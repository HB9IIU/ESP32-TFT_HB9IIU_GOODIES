#ifndef _NOTOSANS_CONDENSED_REGULAR20PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR20PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0xC9, 0x24, 0x92, 0x48, 0x0F, 0x80, 0xCF, 0x2C, 0xB2, 0x48, 0x09,
  0x82, 0x41, 0x90, 0x64, 0x7F, 0xC4, 0xC1, 0x30, 0x48, 0xFF, 0xBF, 0xE3,
  0x20, 0x88, 0x26, 0x09, 0x80, 0x10, 0x10, 0x7E, 0xD2, 0x90, 0xD0, 0xF0,
  0x78, 0x1E, 0x12, 0x13, 0x12, 0xDE, 0xFC, 0x10, 0x10, 0x70, 0xC9, 0x88,
  0x99, 0x89, 0x90, 0x9B, 0x09, 0xA6, 0xDA, 0xF7, 0x69, 0x05, 0x90, 0xD9,
  0x09, 0x90, 0x89, 0x10, 0x93, 0x0E, 0x7C, 0x19, 0x04, 0x41, 0x90, 0x6C,
  0x0E, 0x03, 0x01, 0xE2, 0xCD, 0xB1, 0xE8, 0x73, 0x0C, 0xEF, 0x9F, 0x30,
  0xFF, 0x40, 0x32, 0x64, 0xCC, 0xCC, 0xCC, 0xCC, 0xC4, 0x62, 0x30, 0xC4,
  0x66, 0x23, 0x33, 0x33, 0x33, 0x26, 0x64, 0xC0, 0x10, 0x23, 0x5F, 0xF3,
  0x8D, 0x93, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x7B, 0x48, 0xF0, 0xF8, 0x06, 0x0C, 0x10, 0x60, 0x83, 0x06, 0x08,
  0x30, 0x60, 0x83, 0x04, 0x18, 0x00, 0x7C, 0x66, 0xC6, 0xC2, 0xC2, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC2, 0xC2, 0xC6, 0x6E, 0x3C, 0x19, 0xFA, 0x90, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0xFD, 0x8C, 0x18, 0x30, 0x60, 0xC3, 0x06,
  0x18, 0x61, 0x82, 0x0F, 0xFF, 0xC0, 0xFD, 0x0C, 0x18, 0x30, 0x61, 0x9E,
  0x07, 0x06, 0x04, 0x08, 0x38, 0xFF, 0x80, 0x06, 0x03, 0x02, 0x81, 0x41,
  0x21, 0x90, 0x88, 0xC4, 0x42, 0x7F, 0xFF, 0xE0, 0x40, 0x20, 0x10, 0x7E,
  0x81, 0x06, 0x0C, 0x1F, 0x3F, 0x83, 0x02, 0x04, 0x08, 0x38, 0xFF, 0x80,
  0x3E, 0x60, 0x60, 0xC0, 0xC0, 0xDC, 0xEE, 0xC2, 0xC3, 0xC3, 0xC3, 0xC2,
  0x66, 0x3C, 0xFF, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x30, 0x30, 0x20, 0x60, 0x7C, 0xC6, 0xC2, 0xC2, 0xC6, 0x6C, 0x38, 0x6C,
  0xC6, 0xC3, 0x83, 0xC3, 0xC6, 0x7C, 0x7D, 0x8F, 0x1E, 0x1C, 0x38, 0x71,
  0xBD, 0x32, 0x04, 0x18, 0x29, 0xCF, 0x00, 0x5D, 0x00, 0x00, 0x1F, 0x00,
  0x5D, 0x00, 0x00, 0x2B, 0x69, 0x00, 0x01, 0x07, 0x1C, 0x30, 0xC0, 0xE0,
  0x38, 0x0E, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xC0, 0x70,
  0x1C, 0x07, 0x07, 0x1C, 0x70, 0xC0, 0xFC, 0x98, 0x18, 0x30, 0x41, 0x86,
  0x08, 0x30, 0x60, 0x00, 0x03, 0x06, 0x00, 0x1F, 0xC1, 0x83, 0x18, 0x0C,
  0x80, 0x24, 0xF9, 0x64, 0xCA, 0x66, 0x73, 0x32, 0x99, 0x94, 0xCC, 0xB3,
  0xED, 0x8C, 0xC4, 0x00, 0x30, 0x00, 0xFE, 0x01, 0xE0, 0x0C, 0x03, 0x81,
  0xE0, 0x68, 0x12, 0x0C, 0xC3, 0x30, 0xC4, 0x3F, 0x9F, 0xE6, 0x19, 0x82,
  0xC0, 0xF0, 0x30, 0xFC, 0x86, 0x86, 0x82, 0x86, 0x86, 0xF8, 0x86, 0x83,
  0x83, 0x83, 0x82, 0x8E, 0xFC, 0x04, 0x1F, 0xCC, 0x4C, 0x04, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x08, 0x06, 0x01, 0xC8, 0x7C, 0xFC, 0x47,
  0x20, 0xD0, 0x68, 0x14, 0x0E, 0x07, 0x03, 0x81, 0x41, 0xA0, 0xD0, 0xEF,
  0xE7, 0xC0, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0xFF,
  0xF0, 0xFE, 0x08, 0x20, 0x82, 0x0F, 0xFF, 0x82, 0x08, 0x20, 0x82, 0x00,
  0x1F, 0xCC, 0x26, 0x01, 0x00, 0xC0, 0x30, 0x0C, 0x3F, 0x0F, 0xC0, 0xF0,
  0x36, 0x0D, 0x83, 0x38, 0xC7, 0xF0, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xF6, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x6F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xFE,
  0x87, 0x86, 0x8C, 0x88, 0x98, 0xB0, 0xB0, 0xD0, 0x98, 0x8C, 0x8C, 0x86,
  0x86, 0x83, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xFF,
  0xF0, 0xC0, 0x7E, 0x07, 0xE0, 0x7A, 0x0F, 0xB0, 0xBB, 0x0B, 0x91, 0xB9,
  0x13, 0x99, 0x38, 0xB3, 0x8B, 0x38, 0xE3, 0x8E, 0x38, 0x63, 0xC1, 0xF0,
  0xF8, 0x76, 0x3B, 0x1C, 0xCE, 0x67, 0x13, 0x8D, 0xC2, 0xE1, 0xF0, 0x78,
  0x3C, 0x0C, 0x3F, 0x1C, 0x66, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01,
  0xC0, 0xF0, 0x34, 0x0D, 0x86, 0x33, 0x87, 0xC0, 0xFD, 0x1E, 0x1C, 0x38,
  0x70, 0xE3, 0xFE, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x3F, 0x1C, 0x66,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0xF0, 0x34, 0x0D, 0x86,
  0x33, 0x87, 0xC0, 0x30, 0x0C, 0x01, 0xC0, 0xFC, 0x8E, 0x86, 0x86, 0x86,
  0x86, 0x8C, 0xF8, 0x98, 0x8C, 0x8C, 0x86, 0x86, 0x83, 0x00, 0xFF, 0x0E,
  0x0C, 0x18, 0x18, 0x3C, 0x1C, 0x0C, 0x18, 0x10, 0x79, 0xFF, 0x00, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xD0, 0x6C, 0x37, 0x31, 0xF0, 0xC0, 0xF0, 0x26, 0x19, 0x86, 0x61, 0x08,
  0xC3, 0x30, 0xCC, 0x32, 0x05, 0x81, 0xE0, 0x78, 0x0C, 0x03, 0x00, 0xC1,
  0x83, 0x41, 0x86, 0x43, 0x86, 0x63, 0xC6, 0x62, 0xC4, 0x62, 0xC4, 0x26,
  0x4C, 0x36, 0x4C, 0x34, 0x6C, 0x34, 0x68, 0x14, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x18, 0x30, 0xE1, 0xB1, 0x88, 0xC6, 0xC1, 0x60, 0xE0, 0x30, 0x38,
  0x14, 0x1B, 0x08, 0x8C, 0x66, 0x36, 0x0C, 0xC1, 0xB1, 0x98, 0xC4, 0x43,
  0x61, 0xB0, 0x70, 0x38, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xFE,
  0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x20, 0xC1, 0x06, 0x0F, 0xFF, 0xC0,
  0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xF8, 0xC0,
  0xC1, 0x81, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0xC0,
  0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x0C, 0x0E, 0x05,
  0x86, 0x42, 0x31, 0x09, 0x87, 0x81, 0xFF, 0x80, 0xC6, 0x30, 0x7C, 0xD8,
  0x18, 0x30, 0x6F, 0xF1, 0xC3, 0x87, 0x9D, 0xD8, 0xC0, 0xC0, 0xC0, 0xC0,
  0xDC, 0xFE, 0xE3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0xE6, 0xDE, 0x3D,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x93, 0xC0, 0x03, 0x03, 0x03, 0x03,
  0x3B, 0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0x38,
  0xDB, 0x1E, 0x1C, 0x3F, 0xF0, 0x60, 0xC0, 0xC4, 0xF8, 0x3C, 0xC2, 0x08,
  0x7B, 0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x3B, 0x7F, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0x03, 0x03, 0x02, 0x7E,
  0x78, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xFE, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x74, 0xFF, 0xFF, 0xFC, 0x13, 0x10, 0x33, 0x33,
  0x33, 0x33, 0x33, 0x33, 0x33, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xC6,
  0xCC, 0xD8, 0xD0, 0xF8, 0xE8, 0xCC, 0xC4, 0xC6, 0xC3, 0xFF, 0xFF, 0xFF,
  0xFC, 0xDC, 0xF7, 0xFF, 0xB8, 0xC7, 0x86, 0x3C, 0x21, 0xE1, 0x0F, 0x08,
  0x78, 0x43, 0xC2, 0x1E, 0x10, 0xF0, 0x86, 0xDC, 0xFE, 0xE3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x3C, 0x7E, 0xC2, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0xDC, 0xF6, 0xE3, 0xC3, 0xC3, 0xC1, 0xC1,
  0xC3, 0xE3, 0xE6, 0xDE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3B, 0x7F, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x7B, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xDF, 0xEE, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x00, 0x7B, 0xB8,
  0x30, 0xE1, 0xC1, 0x83, 0x0E, 0x3F, 0x80, 0x21, 0x1F, 0xF6, 0x31, 0x8C,
  0x63, 0x18, 0x63, 0x80, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0x67, 0x7B, 0xC3, 0xC3, 0x43, 0x62, 0x66, 0x26, 0x24, 0x34, 0x3C,
  0x18, 0x18, 0xC3, 0x1E, 0x38, 0xD1, 0xC4, 0xCA, 0x26, 0x5B, 0x36, 0xD8,
  0xB2, 0xC5, 0x14, 0x38, 0xA1, 0xC7, 0x06, 0x38, 0xC3, 0x62, 0x26, 0x34,
  0x1C, 0x18, 0x1C, 0x34, 0x26, 0x62, 0xC3, 0xC3, 0xC3, 0x43, 0x62, 0x66,
  0x26, 0x34, 0x3C, 0x1C, 0x18, 0x18, 0x18, 0x18, 0x30, 0xF0, 0xE0, 0xFB,
  0xE1, 0x84, 0x30, 0x86, 0x10, 0xC2, 0x0F, 0xC0, 0x1C, 0xC3, 0x0C, 0x30,
  0xC2, 0x18, 0xC1, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x1C, 0xFF, 0xFF, 0xF0,
  0xE1, 0x82, 0x08, 0x20, 0x83, 0x0C, 0x0C, 0xC2, 0x08, 0x20, 0x82, 0x18,
  0xC0, 0xF1, 0x9E,
};

const GFXglyph NotoSans_Condensed_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 3, 14, 5, 1, -14 },
  { 7, 6, 5, 8, 1, -14 },
  { 11, 10, 14, 10, 0, -14 },
  { 29, 8, 16, 9, 1, -15 },
  { 45, 12, 14, 14, 1, -14 },
  { 66, 10, 14, 11, 1, -14 },
  { 84, 2, 5, 4, 1, -14 },
  { 86, 4, 17, 6, 1, -14 },
  { 95, 4, 17, 6, 1, -14 },
  { 104, 7, 7, 9, 1, -15 },
  { 111, 8, 10, 9, 1, -12 },
  { 121, 3, 5, 5, 1, -2 },
  { 123, 4, 1, 6, 1, -6 },
  { 124, 3, 2, 5, 1, -2 },
  { 125, 7, 14, 7, 0, -14 },
  { 138, 8, 14, 9, 1, -14 },
  { 152, 5, 14, 9, 1, -14 },
  { 161, 7, 14, 9, 1, -14 },
  { 174, 7, 14, 9, 1, -14 },
  { 187, 9, 14, 9, 0, -14 },
  { 203, 7, 14, 9, 1, -14 },
  { 216, 8, 14, 9, 1, -14 },
  { 230, 8, 14, 9, 1, -14 },
  { 244, 8, 14, 9, 1, -14 },
  { 258, 7, 14, 9, 1, -14 },
  { 271, 3, 11, 5, 1, -11 },
  { 276, 3, 14, 5, 1, -11 },
  { 282, 8, 9, 9, 1, -12 },
  { 291, 8, 6, 9, 1, -10 },
  { 297, 8, 9, 9, 1, -12 },
  { 306, 7, 14, 7, 0, -14 },
  { 319, 13, 16, 15, 1, -14 },
  { 345, 10, 14, 10, 0, -14 },
  { 363, 8, 14, 11, 2, -14 },
  { 377, 9, 15, 10, 1, -15 },
  { 394, 9, 14, 12, 2, -14 },
  { 410, 6, 14, 9, 2, -14 },
  { 421, 6, 14, 8, 2, -14 },
  { 432, 10, 14, 12, 1, -14 },
  { 450, 8, 14, 12, 2, -14 },
  { 464, 4, 14, 6, 1, -14 },
  { 471, 4, 18, 5, -1, -14 },
  { 480, 8, 14, 10, 2, -14 },
  { 494, 6, 14, 8, 2, -14 },
  { 505, 12, 14, 16, 2, -14 },
  { 526, 9, 14, 13, 2, -14 },
  { 542, 10, 14, 12, 1, -14 },
  { 560, 7, 14, 10, 2, -14 },
  { 573, 10, 17, 12, 1, -14 },
  { 595, 8, 14, 10, 2, -14 },
  { 609, 7, 15, 9, 1, -15 },
  { 623, 8, 14, 9, 0, -14 },
  { 637, 9, 14, 12, 1, -14 },
  { 653, 10, 14, 10, 0, -14 },
  { 671, 16, 14, 16, 0, -14 },
  { 699, 9, 14, 9, 0, -14 },
  { 715, 9, 14, 9, 0, -14 },
  { 731, 7, 14, 8, 1, -14 },
  { 744, 5, 17, 6, 1, -14 },
  { 755, 7, 14, 7, 0, -14 },
  { 768, 4, 17, 6, 1, -14 },
  { 777, 9, 8, 10, 0, -14 },
  { 786, 9, 1, 9, 0, 2 },
  { 788, 4, 3, 5, 1, -15 },
  { 790, 7, 11, 9, 1, -11 },
  { 800, 8, 15, 10, 1, -15 },
  { 815, 6, 11, 8, 1, -11 },
  { 824, 8, 15, 10, 1, -15 },
  { 839, 7, 11, 9, 1, -11 },
  { 849, 6, 15, 6, 0, -15 },
  { 861, 8, 16, 10, 1, -11 },
  { 877, 8, 15, 10, 1, -15 },
  { 892, 2, 15, 5, 1, -15 },
  { 896, 4, 20, 5, -1, -15 },
  { 906, 8, 15, 9, 1, -15 },
  { 921, 2, 15, 4, 1, -15 },
  { 925, 13, 11, 15, 1, -11 },
  { 943, 8, 11, 10, 1, -11 },
  { 954, 8, 11, 10, 1, -11 },
  { 965, 8, 16, 10, 1, -11 },
  { 981, 8, 16, 10, 1, -11 },
  { 997, 6, 11, 7, 1, -11 },
  { 1006, 6, 11, 8, 1, -11 },
  { 1015, 5, 13, 6, 0, -13 },
  { 1024, 8, 11, 10, 1, -11 },
  { 1035, 8, 11, 8, 0, -11 },
  { 1046, 13, 11, 13, 0, -11 },
  { 1064, 8, 11, 8, 0, -11 },
  { 1075, 8, 16, 8, 0, -11 },
  { 1091, 6, 11, 7, 1, -11 },
  { 1100, 6, 17, 7, 1, -14 },
  { 1113, 1, 20, 9, 4, -15 },
  { 1116, 6, 17, 7, 1, -14 },
  { 1129, 8, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Regular20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_REGULAR20PT7B_H_
