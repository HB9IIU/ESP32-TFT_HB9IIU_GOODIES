#ifndef _NOTOSANS_CONDENSED_REGULAR39PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x00,
  0x06, 0xFF, 0xFF, 0xF1, 0xFE, 0x3D, 0xC7, 0xB8, 0xF7, 0x1E, 0xE1, 0x9C,
  0x33, 0x86, 0x60, 0xCC, 0x18, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0x60,
  0x0C, 0x18, 0x03, 0x06, 0x00, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x7F,
  0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x18, 0x30, 0x06, 0x1C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x18, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x1C, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x18,
  0x30, 0x06, 0x0C, 0x01, 0x87, 0x00, 0xE1, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x01, 0xFF, 0x87, 0xFF, 0x9F, 0xDF, 0x79, 0x84, 0xE3,
  0x01, 0xC6, 0x03, 0x8C, 0x07, 0x18, 0x0F, 0x30, 0x0F, 0x60, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0C, 0xF0, 0x18, 0xE0, 0x30, 0xE0,
  0x61, 0xC0, 0xC3, 0x81, 0x8E, 0xC3, 0x3D, 0xFF, 0xF3, 0xFF, 0xC1, 0xFE,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x3E, 0x00, 0xE0, 0x7F,
  0x00, 0xC0, 0x77, 0x01, 0xC0, 0xE3, 0x81, 0xC0, 0xE3, 0x83, 0x80, 0xC1,
  0x83, 0x80, 0xC1, 0x83, 0x00, 0xC1, 0x87, 0x00, 0xC1, 0xC7, 0x00, 0xC1,
  0x8E, 0x00, 0xC1, 0x8E, 0x00, 0xC1, 0x8C, 0x78, 0xE3, 0x9C, 0xFC, 0xE3,
  0x9D, 0xEE, 0x77, 0x39, 0xC6, 0x7F, 0x39, 0x87, 0x3E, 0x31, 0x87, 0x00,
  0x73, 0x87, 0x00, 0x63, 0x87, 0x00, 0xE3, 0x87, 0x00, 0xE3, 0x87, 0x01,
  0xC3, 0x87, 0x01, 0xC1, 0x87, 0x01, 0x81, 0x87, 0x03, 0x81, 0xC7, 0x03,
  0x81, 0xCE, 0x07, 0x00, 0xFE, 0x07, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7F,
  0x80, 0x07, 0xDE, 0x00, 0x38, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1E, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xF3, 0xC0, 0x03, 0xBC,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xBC, 0x1C, 0x78, 0xF0, 0xE3, 0xC3, 0xC7, 0x1C, 0x0E, 0x71, 0xE0, 0x7B,
  0x8F, 0x01, 0xFC, 0x78, 0x07, 0xC3, 0xC0, 0x3E, 0x0E, 0x01, 0xF0, 0x78,
  0x1F, 0xC1, 0xFF, 0xEF, 0x0F, 0xFE, 0x78, 0x1F, 0xC1, 0xF0, 0xFF, 0x77,
  0x77, 0x77, 0x66, 0x07, 0x0E, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x3C, 0x1C, 0x1E, 0x0E,
  0x07, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xF0,
  0x70, 0x70, 0x78, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x2E, 0x73, 0x9F, 0xFF, 0xFF, 0xFF, 0x07, 0xC0, 0x0F, 0x80, 0x3B,
  0x80, 0xF3, 0x83, 0xC7, 0x83, 0x86, 0x02, 0x08, 0x00, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0xF3, 0x8E,
  0x79, 0xC7, 0x1C, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x33, 0xFF, 0xF7, 0x00,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFF, 0xC3, 0xC3, 0xC7, 0x03, 0x8E, 0x07, 0xBC, 0x07, 0x78,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x77, 0x00, 0xEE,
  0x01, 0xDE, 0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x78, 0x78, 0x7F, 0xE0, 0x7F,
  0xC0, 0x7E, 0x00, 0x03, 0x83, 0xC3, 0xE3, 0xF3, 0xFF, 0xDF, 0xCE, 0x87,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x0F,
  0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x70, 0x3C, 0x20, 0x1C, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xC1, 0xFF, 0xCF, 0xFF,
  0xB8, 0x1E, 0x40, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x1F, 0xE0, 0x7E, 0x01, 0xFF, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x80, 0x7B, 0xEF, 0xEF, 0xFF, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0E, 0xF0, 0x07,
  0x78, 0x07, 0x3C, 0x03, 0x9E, 0x03, 0x8F, 0x01, 0xC7, 0x81, 0xC3, 0xC0,
  0xE1, 0xE0, 0xE0, 0xF0, 0x70, 0x78, 0x70, 0x3C, 0x38, 0x1E, 0x38, 0x0F,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x7F, 0xF8, 0xFF, 0xF1,
  0xFF, 0xE3, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0xFE, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x80, 0x79, 0xFF, 0xF3, 0xFF, 0xC3, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0xE0, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x82, 0x07, 0x3F, 0x8E,
  0xFF, 0x9F, 0x8F, 0x3E, 0x0F, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xDC, 0x07, 0x38, 0x0E, 0x78, 0x3C,
  0x7F, 0xF0, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x78, 0x0E,
  0x78, 0x0E, 0x70, 0x0E, 0x78, 0x0E, 0x38, 0x0E, 0x38, 0x1E, 0x3C, 0x3C,
  0x1F, 0x78, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x1E, 0x78, 0x3C, 0x3C,
  0x78, 0x1E, 0x70, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F,
  0x70, 0x0F, 0x78, 0x1E, 0x3E, 0x7E, 0x1F, 0xFC, 0x0F, 0xF0, 0x0F, 0xC0,
  0x7F, 0xC1, 0xFF, 0xC3, 0xC3, 0xCF, 0x03, 0x9C, 0x07, 0xB8, 0x07, 0x70,
  0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x00, 0xFE, 0x03, 0xDE, 0x07,
  0x9E, 0x1F, 0x3F, 0xFE, 0x3F, 0xDC, 0x1C, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0xEF, 0xC1, 0xFF,
  0x03, 0xF8, 0x00, 0x73, 0xFE, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x33, 0xFE, 0xF7, 0x00, 0x39, 0xF7, 0xCF, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xCE, 0x39, 0xE7, 0x1C, 0x73,
  0x80, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0x1F,
  0xC7, 0xFF, 0x1F, 0xFC, 0xC0, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x7F, 0x00,
  0x01, 0xFF, 0xC0, 0x03, 0xF1, 0xF0, 0x0F, 0x80, 0x78, 0x0E, 0x00, 0x3C,
  0x1C, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x3F, 0x87,
  0x70, 0x7F, 0x87, 0x60, 0xE1, 0x87, 0xE1, 0xC1, 0x83, 0xE1, 0xC3, 0x83,
  0xE1, 0xC3, 0x83, 0xE1, 0x83, 0x83, 0xE3, 0x83, 0x83, 0xE3, 0x83, 0x83,
  0xE3, 0x83, 0x87, 0xE1, 0x83, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC7, 0xCE,
  0xE0, 0xFE, 0xFE, 0x60, 0xFC, 0xFC, 0x70, 0x10, 0x30, 0x70, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x20, 0x0F, 0x81, 0xC0,
  0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x03, 0xBC, 0x00,
  0x39, 0xC0, 0x03, 0x9C, 0x00, 0x71, 0xC0, 0x07, 0x0E, 0x00, 0x70, 0xE0,
  0x0F, 0x0E, 0x00, 0xE0, 0xF0, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x1F, 0xFF,
  0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xC0, 0x38, 0x3C, 0x03, 0xC3, 0x80,
  0x3C, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0xF0,
  0x00, 0xEF, 0x00, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3E,
  0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x1E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFC, 0xE0, 0x3E,
  0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0,
  0x01, 0xFE, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xE0, 0x63, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1F, 0x01, 0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xC0,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0x81, 0xF8, 0xE0, 0x1E, 0x38,
  0x03, 0xCE, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x00, 0xEE, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0xB8,
  0x01, 0xCE, 0x00, 0xF3, 0x80, 0x78, 0xE0, 0x7E, 0x3F, 0xFF, 0x0F, 0xFF,
  0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF,
  0x7F, 0xFB, 0xFF, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFB,
  0xFF, 0xDF, 0xFE, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0x80, 0x63, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x80,
  0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x80,
  0x0E, 0xF0, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x07, 0x1F, 0x00, 0xE1, 0xFF,
  0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70, 0xFF, 0xFF, 0xCF, 0xC3, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x3F,
  0xFF, 0xF0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFF, 0xFE,
  0xFC, 0xE0, 0x0F, 0x70, 0x07, 0x38, 0x07, 0x9C, 0x07, 0x8E, 0x03, 0x87,
  0x03, 0xC3, 0x83, 0xC1, 0xC1, 0xC0, 0xE1, 0xE0, 0x71, 0xE0, 0x38, 0xE0,
  0x1C, 0xF0, 0x0E, 0xF0, 0x07, 0x7C, 0x03, 0xFE, 0x01, 0xF7, 0x80, 0xF1,
  0xC0, 0x70, 0xF0, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0xC3,
  0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x1E, 0x70, 0x0F, 0x38, 0x03, 0xDC, 0x01,
  0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xEE, 0x00,
  0x3F, 0xEE, 0x00, 0x77, 0xEE, 0x00, 0x77, 0xEF, 0x00, 0x77, 0xE7, 0x00,
  0xE7, 0xE7, 0x00, 0xE7, 0xE7, 0x00, 0xE7, 0xE3, 0x81, 0xC7, 0xE3, 0x81,
  0xC7, 0xE3, 0x81, 0xC7, 0xE1, 0xC3, 0x87, 0xE1, 0xC3, 0x87, 0xE1, 0xC3,
  0x87, 0xE0, 0xE3, 0x07, 0xE0, 0xE7, 0x07, 0xE0, 0xE7, 0x07, 0xE0, 0x77,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0xE0, 0x1F, 0xBC,
  0x07, 0xE7, 0x01, 0xF9, 0xE0, 0x7E, 0x38, 0x1F, 0x8F, 0x07, 0xE1, 0xC1,
  0xF8, 0x78, 0x7E, 0x0E, 0x1F, 0x83, 0xC7, 0xE0, 0x71, 0xF8, 0x1E, 0x7E,
  0x03, 0x9F, 0x80, 0xF7, 0xE0, 0x1D, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xE0, 0x78, 0x3C, 0x03, 0xC7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0F,
  0x70, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x1E, 0x07,
  0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xFF, 0x81, 0xFF, 0xE3,
  0xFF, 0xE7, 0x07, 0xEE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xEE, 0x03, 0xDC, 0x0F, 0xBF, 0xFE,
  0x7F, 0xF8, 0xFF, 0xC1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xE0, 0x7C, 0x3C,
  0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x00, 0x0F, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xE3, 0xC0,
  0x3C, 0x1E, 0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0xFF, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0,
  0xFC, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0,
  0x1E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0xE1, 0xF8, 0xFF, 0xF0, 0xFF,
  0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0xE0,
  0x78, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0,
  0x0F, 0x0F, 0xF0, 0xFF, 0xF7, 0xFF, 0x9E, 0x06, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x80, 0x7B, 0xFF, 0xCF, 0xFF,
  0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1E, 0xE0,
  0x1E, 0x78, 0x0F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xF0, 0x01,
  0xFE, 0x00, 0x3D, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80, 0x3C, 0xF0, 0x07,
  0x8E, 0x00, 0xE1, 0xC0, 0x1C, 0x3C, 0x07, 0x83, 0x80, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x78, 0xF0,
  0x0F, 0x1E, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0xDE, 0x00, 0x3B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0x80, 0x1D, 0xC0, 0x1E, 0x00,
  0x77, 0x00, 0x78, 0x03, 0xDC, 0x01, 0xF0, 0x0F, 0x78, 0x07, 0xC0, 0x39,
  0xE0, 0x3F, 0x00, 0xE3, 0x80, 0xFC, 0x07, 0x8E, 0x03, 0xB8, 0x1E, 0x38,
  0x0E, 0xE0, 0x70, 0xF0, 0x73, 0x81, 0xC1, 0xC1, 0xCE, 0x07, 0x07, 0x07,
  0x38, 0x3C, 0x1C, 0x1C, 0x70, 0xF0, 0x78, 0x71, 0xC3, 0x81, 0xE3, 0x87,
  0x0E, 0x03, 0x8E, 0x1C, 0x38, 0x0E, 0x38, 0x39, 0xE0, 0x38, 0xE0, 0xE7,
  0x00, 0xF7, 0x03, 0x9C, 0x01, 0xDC, 0x0E, 0x70, 0x07, 0x70, 0x1B, 0xC0,
  0x1D, 0xC0, 0x7F, 0x00, 0x77, 0x01, 0xF8, 0x00, 0xD8, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0xF0,
  0x03, 0xC0, 0x78, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0x70, 0xF0, 0x3C, 0x1C,
  0x0E, 0x07, 0x87, 0x80, 0xE1, 0xC0, 0x3C, 0xF0, 0x07, 0x38, 0x01, 0xEE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xDE, 0x00, 0x73, 0x80, 0x3C, 0xF0, 0x0E,
  0x1C, 0x07, 0x87, 0x81, 0xC0, 0xE0, 0xF0, 0x38, 0x38, 0x0F, 0x1E, 0x01,
  0xC7, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xCF,
  0x01, 0xE3, 0x80, 0xF1, 0xE0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1E, 0x1C,
  0x07, 0x1C, 0x03, 0xCE, 0x00, 0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xFF, 0xFF, 0x01, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x1C, 0x70, 0x1C, 0x38, 0x0E,
  0x0E, 0x0E, 0x07, 0x07, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x3B, 0xC0, 0x1D,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xE1, 0xE1,
  0xC1, 0xC1, 0xC0, 0x0F, 0xF0, 0xFF, 0xE1, 0xEF, 0x84, 0x0F, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xFC, 0x3F, 0xF3, 0xFF, 0xDF, 0x07,
  0x78, 0x1D, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xC0, 0xF7, 0x8F,
  0xCF, 0xF3, 0x1F, 0x8C, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xCF, 0xC3, 0xBF,
  0xE7, 0xFF, 0xCF, 0x83, 0xDE, 0x03, 0xBC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3B, 0xE0, 0xF7, 0xF3, 0xCE, 0xFF, 0x98, 0xFC,
  0x00, 0x0F, 0xF1, 0xFF, 0x3F, 0xE7, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3E, 0xF3, 0xFF, 0x0F, 0xE0, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x1F, 0x9C, 0xFF, 0xB9, 0xFF, 0xF7, 0x83, 0xEE, 0x03, 0xFC,
  0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x1E, 0xE0, 0x3D, 0xE0, 0xFB,
  0xE7, 0xF3, 0xFE, 0xE3, 0xF9, 0xC0, 0x0F, 0xE0, 0x7F, 0xC3, 0xEF, 0x9E,
  0x0E, 0x70, 0x3F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xE0, 0x13, 0xF7, 0x87, 0xFE, 0x0F, 0xF8, 0x01, 0xE0, 0x7F, 0x0F, 0xF0,
  0xE0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xFC, 0xFF, 0xCF,
  0xFC, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x0F, 0xCE, 0x7F, 0xDC, 0xFF, 0xFB, 0xC1, 0xF7,
  0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x70, 0x1E,
  0xF0, 0x7D, 0xF3, 0xF9, 0xFF, 0x71, 0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1E, 0x00, 0x39, 0x00, 0xF3, 0xEF, 0xC7, 0xFF, 0x87, 0xFC,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x9F, 0x8E, 0xFF, 0xBF, 0xFE, 0xF8, 0x3F,
  0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0xDF, 0xF4, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0C, 0x1C, 0x38, 0x70, 0x40, 0x00, 0x00,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x7F,
  0xFF, 0xDF, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0xFE, 0x07, 0x38, 0x3C,
  0xE0, 0xE3, 0x87, 0x0E, 0x3C, 0x39, 0xE0, 0xE7, 0x03, 0xB8, 0x0F, 0xF0,
  0x3F, 0xC0, 0xFB, 0x83, 0xCF, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83,
  0xCE, 0x07, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC7, 0xE1, 0xF8, 0xEF,
  0xF3, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x7E, 0x0E, 0xF0, 0x3C, 0x0F, 0xE0,
  0x3C, 0x0F, 0xE0, 0x3C, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0,
  0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x38, 0x07, 0xC7,
  0xE3, 0xBF, 0xEF, 0xFF, 0xBE, 0x0F, 0xF0, 0x3F, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C,
  0x0F, 0xE0, 0x3F, 0xF0, 0xFB, 0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x70, 0x1C, 0xF0, 0x78, 0xFB, 0xE0,
  0xFF, 0xC0, 0xFE, 0x00, 0xC7, 0xE1, 0xDF, 0xF3, 0xFB, 0xE7, 0xC1, 0xEF,
  0x01, 0xDE, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x1D,
  0xF0, 0x7B, 0xFB, 0xE7, 0x7F, 0xCE, 0x7E, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xCE, 0x7F, 0xDC, 0xFF, 0xFB, 0xC1, 0xF7, 0x01, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x70, 0x1E, 0xF0, 0x7D, 0xFB,
  0xF9, 0xFF, 0x71, 0xFC, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xC7, 0xF3,
  0xFE, 0xFB, 0xF0, 0xF8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x00, 0x1F, 0xE3, 0xFF, 0x7C, 0xF7, 0x01, 0xF0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x00, 0x78, 0x07, 0x7B, 0xF7, 0xFE, 0x7F, 0xC0, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x1F, 0xEF, 0xFB, 0xFE, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0xC0, 0xFB, 0x1F, 0xC3, 0xF0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC1, 0xF7, 0xFF, 0xDF, 0xF7, 0x3F, 0x9C, 0xF0, 0x0F, 0x70, 0x0F, 0x70,
  0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0xB8, 0x0F, 0x01, 0xDC, 0x0F, 0x80, 0xEE, 0x07,
  0xC0, 0xF7, 0x83, 0xF0, 0x71, 0xC1, 0xF8, 0x38, 0xE0, 0xDC, 0x1C, 0x70,
  0xE6, 0x1E, 0x3C, 0x73, 0x8E, 0x0E, 0x39, 0xC7, 0x07, 0x18, 0xE3, 0x83,
  0x9C, 0x71, 0xC1, 0xCE, 0x1D, 0xC0, 0xF7, 0x0E, 0xE0, 0x3B, 0x07, 0x70,
  0x1D, 0x83, 0xB8, 0x0F, 0xC0, 0xD8, 0x07, 0xE0, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0xF0, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0xE0, 0x79, 0xE0,
  0xE1, 0xC3, 0xC3, 0xC7, 0x03, 0x9E, 0x07, 0xB8, 0x07, 0xF0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xDC, 0x07, 0x38, 0x1E,
  0x38, 0x38, 0x70, 0xF0, 0x71, 0xC0, 0xE7, 0x80, 0xEE, 0x01, 0xE0, 0xF0,
  0x0F, 0x70, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38,
  0x1C, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x06, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F,
  0xE7, 0xFE, 0x7F, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x07,
  0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x1F, 0x03, 0xF0,
  0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0x7E, 0x00,
  0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x0F, 0xC0, 0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x7C, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x07,
  0xE0, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0x7F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFE,
  0x80, 0x18,
};

const GFXglyph NotoSans_Condensed_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 28, 10, 3, -28 },
  { 15, 11, 10, 15, 2, -28 },
  { 29, 18, 28, 20, 1, -28 },
  { 92, 15, 32, 18, 2, -30 },
  { 152, 24, 28, 28, 2, -28 },
  { 236, 21, 28, 22, 1, -28 },
  { 310, 4, 10, 8, 2, -28 },
  { 315, 8, 34, 11, 2, -28 },
  { 349, 9, 34, 11, 1, -28 },
  { 388, 15, 15, 17, 1, -30 },
  { 417, 16, 18, 18, 1, -23 },
  { 453, 6, 9, 9, 1, -4 },
  { 460, 9, 3, 11, 1, -12 },
  { 464, 5, 5, 9, 2, -5 },
  { 468, 13, 28, 14, 1, -28 },
  { 514, 15, 28, 18, 2, -28 },
  { 567, 9, 28, 18, 3, -28 },
  { 599, 16, 28, 18, 1, -28 },
  { 655, 14, 28, 18, 2, -28 },
  { 704, 17, 28, 18, 1, -28 },
  { 764, 15, 28, 18, 2, -28 },
  { 817, 15, 28, 18, 2, -28 },
  { 870, 16, 28, 18, 1, -28 },
  { 926, 16, 28, 18, 1, -28 },
  { 982, 15, 28, 18, 2, -28 },
  { 1035, 5, 21, 9, 2, -21 },
  { 1049, 6, 26, 9, 1, -21 },
  { 1069, 16, 18, 18, 1, -23 },
  { 1105, 16, 11, 18, 1, -19 },
  { 1127, 16, 18, 18, 1, -23 },
  { 1163, 13, 28, 14, 0, -28 },
  { 1209, 24, 31, 28, 2, -28 },
  { 1302, 20, 28, 20, 0, -28 },
  { 1372, 16, 28, 21, 3, -28 },
  { 1428, 17, 28, 20, 2, -28 },
  { 1488, 18, 28, 23, 3, -28 },
  { 1551, 13, 28, 17, 3, -28 },
  { 1597, 13, 28, 16, 3, -28 },
  { 1643, 19, 28, 23, 2, -28 },
  { 1710, 17, 28, 23, 3, -28 },
  { 1770, 9, 28, 12, 1, -28 },
  { 1802, 8, 35, 9, -2, -28 },
  { 1837, 17, 28, 19, 3, -28 },
  { 1897, 12, 28, 16, 3, -28 },
  { 1939, 24, 28, 30, 3, -28 },
  { 2023, 18, 28, 24, 3, -28 },
  { 2086, 20, 28, 24, 2, -28 },
  { 2156, 15, 28, 19, 3, -28 },
  { 2209, 20, 35, 24, 2, -28 },
  { 2297, 16, 28, 20, 3, -28 },
  { 2353, 14, 28, 18, 2, -28 },
  { 2402, 16, 28, 17, 0, -28 },
  { 2458, 17, 28, 23, 3, -28 },
  { 2518, 19, 28, 19, 0, -28 },
  { 2585, 30, 28, 31, 0, -28 },
  { 2690, 18, 28, 18, 0, -28 },
  { 2753, 17, 28, 17, 0, -28 },
  { 2813, 15, 28, 17, 1, -28 },
  { 2866, 8, 34, 12, 3, -28 },
  { 2900, 13, 28, 14, 1, -28 },
  { 2946, 8, 34, 12, 1, -28 },
  { 2980, 17, 16, 19, 1, -28 },
  { 3014, 17, 3, 17, 0, 3 },
  { 3021, 7, 6, 11, 2, -30 },
  { 3027, 14, 21, 18, 1, -21 },
  { 3064, 15, 30, 20, 3, -30 },
  { 3121, 12, 21, 15, 2, -21 },
  { 3153, 15, 30, 20, 2, -30 },
  { 3210, 14, 21, 18, 2, -21 },
  { 3247, 12, 30, 11, 0, -30 },
  { 3292, 15, 30, 20, 2, -21 },
  { 3349, 14, 30, 20, 3, -30 },
  { 3402, 3, 29, 9, 3, -29 },
  { 3413, 7, 38, 9, -1, -29 },
  { 3447, 14, 30, 17, 3, -30 },
  { 3500, 3, 30, 9, 3, -30 },
  { 3512, 24, 21, 30, 3, -21 },
  { 3575, 14, 21, 20, 3, -21 },
  { 3612, 15, 21, 19, 2, -21 },
  { 3652, 15, 30, 20, 3, -21 },
  { 3709, 15, 30, 20, 2, -21 },
  { 3766, 10, 21, 13, 3, -21 },
  { 3793, 12, 21, 15, 1, -21 },
  { 3825, 10, 26, 11, 1, -26 },
  { 3858, 14, 21, 20, 3, -21 },
  { 3895, 16, 21, 16, 0, -21 },
  { 3937, 25, 21, 26, 0, -21 },
  { 4003, 15, 21, 16, 1, -21 },
  { 4043, 16, 30, 16, 0, -21 },
  { 4103, 12, 21, 14, 1, -21 },
  { 4135, 12, 34, 14, 1, -28 },
  { 4186, 3, 39, 18, 7, -30 },
  { 4201, 12, 34, 14, 1, -28 },
  { 4252, 16, 5, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Regular39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_REGULAR39PT7B_H_
