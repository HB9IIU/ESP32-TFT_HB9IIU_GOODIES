#ifndef _NOTOSANS_CONDENSED_REGULAR52PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7,
  0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xE3, 0x80, 0x00, 0x00,
  0x1E, 0x7F, 0xFF, 0xDF, 0x7C, 0x40, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE,
  0x1F, 0xF8, 0x3D, 0xE0, 0xF7, 0x83, 0xDE, 0x0F, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x9C, 0x0E, 0x70, 0x38, 0x00, 0x70, 0x38, 0x00, 0x38, 0x1C, 0x00,
  0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x03, 0xC0,
  0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xF0, 0x38,
  0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFC, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x38, 0x1C, 0x00, 0x1C,
  0x0E, 0x03, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x01, 0xC0, 0xF0, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x38, 0x00,
  0x38, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x03, 0xC0, 0x03, 0x81, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7,
  0xC7, 0x0C, 0x78, 0x70, 0x07, 0x87, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x00,
  0xF0, 0x70, 0x07, 0x87, 0x00, 0x78, 0x70, 0x07, 0xE7, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x77, 0xE0, 0x07, 0x1F, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0x00,
  0x70, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF8, 0x07, 0x1F, 0xE0, 0x73, 0xEF,
  0xE7, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xE0, 0x0F, 0xF8, 0x00,
  0xE0, 0x07, 0xFE, 0x00, 0xF0, 0x07, 0x8F, 0x00, 0x70, 0x03, 0xC3, 0xC0,
  0x78, 0x01, 0xC1, 0xE0, 0x3C, 0x00, 0xE0, 0xF0, 0x1C, 0x00, 0xF0, 0x38,
  0x1E, 0x00, 0x78, 0x1C, 0x0E, 0x00, 0x3C, 0x0E, 0x0F, 0x00, 0x1E, 0x07,
  0x07, 0x80, 0x0F, 0x03, 0x83, 0x80, 0x07, 0x81, 0xC3, 0xC0, 0x03, 0xC0,
  0xE1, 0xC0, 0x01, 0xE0, 0x71, 0xE1, 0xE0, 0x70, 0x78, 0xF1, 0xFC, 0x38,
  0x3C, 0x71, 0xFF, 0x1E, 0x1E, 0x79, 0xF7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3,
  0xFF, 0x3C, 0x70, 0x71, 0xFF, 0x1E, 0x78, 0x38, 0x7F, 0x1E, 0x3C, 0x1E,
  0x06, 0x0F, 0x1E, 0x0F, 0x00, 0x07, 0x0E, 0x07, 0x80, 0x07, 0x87, 0x03,
  0xC0, 0x03, 0x83, 0x81, 0xE0, 0x03, 0xC1, 0xC0, 0xF0, 0x01, 0xE0, 0xE0,
  0x78, 0x00, 0xE0, 0x70, 0x3C, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x70, 0x1E,
  0x0F, 0x00, 0x78, 0x0F, 0x07, 0x00, 0x3C, 0x03, 0x87, 0x80, 0x1C, 0x01,
  0xE3, 0xC0, 0x1E, 0x00, 0x7F, 0xC0, 0x0E, 0x00, 0x3F, 0xE0, 0x0F, 0x00,
  0x0F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0, 0x00,
  0x78, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1E,
  0x00, 0x03, 0xE7, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x78, 0x7C, 0xF8, 0x0F, 0x1F, 0x0F, 0x83, 0xE3, 0xE0, 0xF8, 0x78, 0xF8,
  0x1F, 0x0F, 0x1F, 0x01, 0xF3, 0xE3, 0xC0, 0x1F, 0x7C, 0x78, 0x01, 0xFF,
  0x0F, 0x00, 0x3F, 0xE1, 0xE0, 0x03, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0,
  0x0F, 0xE0, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0xFF, 0xC1, 0xFE, 0xFF, 0x7C,
  0x1F, 0xFF, 0xC7, 0xC1, 0xFF, 0xF0, 0xFC, 0x1F, 0xF8, 0x0F, 0xC0, 0x30,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBD, 0xEF, 0x73, 0x9C, 0xE7, 0x00, 0x01,
  0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0,
  0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0xC0, 0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x10,
  0x38, 0x17, 0xE7, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFE, 0x00,
  0xF8, 0x00, 0x3B, 0x80, 0x0F, 0x78, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1F,
  0x1F, 0x07, 0xC1, 0xF0, 0x38, 0x38, 0x01, 0x02, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7, 0x9F, 0x3C, 0x78, 0xF1,
  0xC7, 0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xFF, 0xFF,
  0xFD, 0xE1, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xFF,
  0xF8, 0x1F, 0x9F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xC3, 0xC0, 0x3E, 0x7C,
  0x01, 0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x01, 0xE3, 0xC0, 0x3E, 0x3E,
  0x03, 0xC3, 0xF0, 0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFF, 0x00,
  0x3F, 0xC0, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0xFF, 0x1F,
  0xF3, 0xFF, 0x7E, 0xFF, 0xCF, 0xF0, 0xF6, 0x0F, 0x20, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xFE,
  0x1F, 0xC7, 0x80, 0x7C, 0x20, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFC, 0x1F,
  0xC7, 0x00, 0x7C, 0x20, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xEC, 0x00,
  0x7E, 0xFC, 0x3F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0,
  0x07, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x0F, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0,
  0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3D, 0xFC,
  0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x80, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF4, 0x00, 0x7E, 0xC0, 0x1F, 0x9F, 0x0F, 0xF3, 0xFF, 0xFC,
  0x7F, 0xFF, 0x07, 0xFF, 0x80, 0x02, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x0F,
  0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x07, 0xF0, 0x40, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x8F, 0xF0,
  0x79, 0xFF, 0x87, 0xBF, 0xFC, 0x7F, 0xCF, 0xEF, 0xE0, 0x3E, 0xFC, 0x01,
  0xEF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x7C,
  0x01, 0xF3, 0xC0, 0x1F, 0x3E, 0x01, 0xE1, 0xF0, 0x3E, 0x1F, 0xCF, 0xC0,
  0xFF, 0xF8, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF1, 0xF0,
  0x07, 0x8F, 0x80, 0x3E, 0x78, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x7C,
  0xF8, 0x03, 0xC3, 0xC0, 0x1E, 0x1F, 0x01, 0xF0, 0x78, 0x1F, 0x03, 0xF1,
  0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0xFF, 0xF0, 0x0F, 0x8F, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0x7C, 0x78, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0x78, 0x01, 0xF3, 0xE0, 0x1F,
  0x0F, 0xC3, 0xF8, 0x7F, 0xFF, 0x81, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8,
  0x3F, 0x1F, 0x83, 0xE0, 0x7C, 0x7C, 0x03, 0xC7, 0x80, 0x3E, 0x78, 0x01,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7C,
  0x03, 0xF7, 0xE0, 0x7F, 0x3F, 0xBE, 0xF1, 0xFF, 0xEF, 0x0F, 0xFD, 0xF0,
  0x7F, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x30, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xFF,
  0x00, 0x06, 0x00, 0x00, 0x79, 0xFF, 0xFF, 0xFD, 0xF1, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xFF, 0xFF,
  0xDE, 0x10, 0x3C, 0xFD, 0xFB, 0xF7, 0xE7, 0xC2, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E,
  0x78, 0xF3, 0xE7, 0xCF, 0x1E, 0x38, 0xF1, 0xE3, 0x80, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xF0, 0xFF,
  0xFC, 0xFF, 0xFE, 0xF8, 0x7E, 0x60, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x02,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x07, 0xFC, 0x1E, 0x78, 0x0F, 0xFE,
  0x0E, 0x78, 0x1F, 0xFE, 0x0F, 0x70, 0x3E, 0x1E, 0x0F, 0xF0, 0x3C, 0x1E,
  0x0F, 0xF0, 0x78, 0x1E, 0x07, 0xF0, 0x78, 0x1E, 0x07, 0xE0, 0x70, 0x1E,
  0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xE0, 0xF0, 0x1E, 0x07, 0xE0, 0xF0, 0x1E,
  0x07, 0xE0, 0xF0, 0x1E, 0x0F, 0xE0, 0xF0, 0x1C, 0x0F, 0xE0, 0xF0, 0x3C,
  0x0F, 0xE0, 0xF0, 0x3C, 0x0E, 0xE0, 0x70, 0x3C, 0x0E, 0xF0, 0x78, 0x7E,
  0x1E, 0xF0, 0x7C, 0x7E, 0x3C, 0xF0, 0x3F, 0xE7, 0xFC, 0xF0, 0x1F, 0xC7,
  0xF8, 0x78, 0x0F, 0x83, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0x00, 0x07, 0xE0, 0x07, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xC0, 0xFF, 0xFC,
  0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7E, 0x7C,
  0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07,
  0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF3, 0xE0,
  0x0F, 0x9F, 0x03, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xE0, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3E, 0xF8, 0x03,
  0xF7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F,
  0xF0, 0xF8, 0x3F, 0x00, 0x41, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x20, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F,
  0x80, 0xFF, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x1F, 0x3E, 0x00, 0x7E, 0x7C, 0x01, 0xF8, 0xF8, 0x0F, 0xE1, 0xFF,
  0xFF, 0x83, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xC3, 0xF0, 0x7E, 0x00, 0x30, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3C, 0xF8,
  0x00, 0x1E, 0x7E, 0x00, 0x0F, 0x1F, 0x80, 0x07, 0x87, 0xE0, 0x03, 0xC3,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x0C, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7E, 0x1F, 0xFF, 0xEF, 0xF9,
  0xFE, 0x3F, 0x80, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0x78, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x3E, 0x78, 0x00, 0xFB,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0xF8,
  0x03, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x83, 0xE0,
  0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xF7, 0x80, 0x00, 0xFF, 0xF7, 0x80, 0x01, 0xEF,
  0xF7, 0x80, 0x01, 0xEF, 0xF3, 0xC0, 0x01, 0xEF, 0xF3, 0xC0, 0x03, 0xCF,
  0xF3, 0xC0, 0x03, 0xCF, 0xF3, 0xE0, 0x03, 0xCF, 0xF1, 0xE0, 0x07, 0x8F,
  0xF1, 0xE0, 0x07, 0x8F, 0xF1, 0xE0, 0x07, 0x8F, 0xF0, 0xF0, 0x07, 0x0F,
  0xF0, 0xF0, 0x0F, 0x0F, 0xF0, 0xF0, 0x0F, 0x0F, 0xF0, 0x78, 0x0E, 0x0F,
  0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x78, 0x1E, 0x0F, 0xF0, 0x3C, 0x1E, 0x0F,
  0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x3C, 0x3C, 0x0F, 0xF0, 0x1E, 0x3C, 0x0F,
  0xF0, 0x1E, 0x78, 0x0F, 0xF0, 0x1E, 0x78, 0x0F, 0xF0, 0x1F, 0x78, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xF7, 0x80, 0x0F, 0xF7, 0xC0, 0x0F, 0xF3,
  0xC0, 0x0F, 0xF3, 0xE0, 0x0F, 0xF1, 0xE0, 0x0F, 0xF1, 0xF0, 0x0F, 0xF0,
  0xF0, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x3C, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0, 0x1F, 0x0F, 0xF0,
  0x0F, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x0F, 0x8F, 0xF0, 0x07, 0xCF, 0xF0,
  0x07, 0xCF, 0xF0, 0x03, 0xEF, 0xF0, 0x03, 0xEF, 0xF0, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xF3, 0xFC, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07, 0xE0,
  0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xF8, 0x0F, 0xCF, 0x80, 0x7E, 0xF8, 0x03, 0xEF,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xF8, 0x07,
  0xEF, 0x80, 0xFC, 0xF8, 0x7F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF,
  0xC0, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xF3, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF0,
  0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x7C, 0x00,
  0x07, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x1F,
  0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8,
  0x0F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x78, 0xF8, 0x01,
  0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3,
  0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x07, 0xC3, 0xE0,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xF0,
  0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x80, 0xF8, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80,
  0x3E, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x3F,
  0xFF, 0x8F, 0xFF, 0xF3, 0xFD, 0xFC, 0xFC, 0x01, 0x9F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x80, 0x07,
  0xFC, 0x01, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xFF, 0xE0, 0x7F, 0xF8,
  0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3E, 0x00,
  0x7C, 0x7E, 0x01, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xDE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x0F,
  0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0,
  0x78, 0x03, 0xE0, 0x3C, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0xF8,
  0x03, 0xC0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x1F,
  0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE3,
  0xE0, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x7C,
  0x00, 0x7F, 0x00, 0x1E, 0x3C, 0x00, 0x7F, 0x00, 0x1E, 0x3C, 0x00, 0x7F,
  0x00, 0x3E, 0x3E, 0x00, 0xF7, 0x00, 0x3E, 0x3E, 0x00, 0xF7, 0x00, 0x3C,
  0x3E, 0x00, 0xF7, 0x80, 0x3C, 0x1E, 0x00, 0xF7, 0x80, 0x7C, 0x1E, 0x01,
  0xE7, 0x80, 0x7C, 0x1F, 0x01, 0xE7, 0x80, 0x7C, 0x1F, 0x01, 0xE3, 0xC0,
  0x78, 0x0F, 0x01, 0xE3, 0xC0, 0x78, 0x0F, 0x01, 0xE3, 0xC0, 0xF8, 0x0F,
  0x03, 0xC3, 0xC0, 0xF8, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x07, 0x87, 0x81, 0xE1, 0xF0,
  0x07, 0xC7, 0x81, 0xE1, 0xF0, 0x07, 0xC7, 0x80, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0xF1, 0xE0, 0x03, 0xC7, 0x00, 0xF3, 0xE0, 0x03, 0xCF, 0x00, 0xF3,
  0xE0, 0x03, 0xCF, 0x00, 0x73, 0xC0, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x01,
  0xEF, 0x00, 0x7B, 0xC0, 0x01, 0xEE, 0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x3E, 0x7C,
  0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x81, 0xE0,
  0x1E, 0x03, 0xE0, 0x7C, 0x03, 0xC0, 0xF0, 0x07, 0xC3, 0xE0, 0x07, 0x87,
  0x80, 0x0F, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x1F,
  0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x1E, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0x3C, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0xF0, 0x00,
  0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x1F,
  0x07, 0x80, 0x3C, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xC0,
  0x3E, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0xF8, 0x00,
  0xF1, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0xC0, 0x01, 0xE7,
  0x80, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x38, 0x1E,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xEF,
  0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x07, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x78, 0x3E, 0x18, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x03, 0xFF, 0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFC, 0x3D, 0xF8,
  0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x3F, 0x7C, 0x1F, 0xDF, 0xFE, 0x73,
  0xFF, 0x1C, 0x7F, 0x87, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF1, 0xFE, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0xF9, 0xFC, 0xFE,
  0x07, 0xCF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0xC0,
  0x7C, 0xFF, 0x0F, 0xCF, 0x7F, 0xF8, 0xE3, 0xFF, 0x0E, 0x1F, 0xE0, 0x00,
  0x10, 0x00, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xC3, 0xF9, 0xE3, 0xF0,
  0x11, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x7E, 0x01, 0x1F, 0x87, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x3F, 0x8F, 0x87, 0xFF, 0x7C, 0x7F, 0xFD, 0xE3, 0xF1, 0xEF, 0x3E, 0x03,
  0xF9, 0xF0, 0x0F, 0xDF, 0x00, 0x7E, 0xF8, 0x01, 0xF7, 0x80, 0x0F, 0xBC,
  0x00, 0x7D, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0,
  0x03, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x0F, 0xCF, 0x00, 0x7E,
  0x7C, 0x07, 0xF1, 0xF8, 0x77, 0x8F, 0xFF, 0xBC, 0x3F, 0xF9, 0xE0, 0xFF,
  0x0F, 0x00, 0x40, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xF8, 0xFC, 0x3E, 0x03, 0xC3, 0xC0, 0x3E, 0x3C, 0x01, 0xE7, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x06, 0x1F, 0xC3, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x1F, 0xF8, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xF8, 0x3F,
  0xE0, 0xF8, 0x41, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x7F, 0xFC, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF8, 0x78, 0x7F,
  0xF3, 0xC7, 0xFF, 0xDE, 0x3F, 0xBE, 0xF3, 0xE0, 0x3F, 0x9F, 0x00, 0xFD,
  0xF0, 0x07, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01,
  0xF7, 0xC0, 0x0F, 0xBE, 0x00, 0xFC, 0xF0, 0x07, 0xE7, 0xC0, 0x7F, 0x1F,
  0x8F, 0x78, 0xFF, 0xFB, 0xC3, 0xFF, 0xBE, 0x0F, 0xF1, 0xF0, 0x04, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x60, 0x07, 0xC3, 0xF1, 0xFE, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x1F, 0xE1,
  0xE7, 0xFE, 0x3D, 0xFF, 0xE7, 0xFC, 0xFE, 0xFE, 0x07, 0xDF, 0x80, 0x7B,
  0xE0, 0x0F, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0x7F, 0xFF, 0xF7, 0x90, 0x00, 0x00, 0x1E, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBC, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0x78, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7E, 0x7D, 0xFE, 0xFE, 0x7E,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x7D, 0xE0, 0x1F, 0x3C, 0x03,
  0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0x78, 0x7C,
  0x0F, 0x1F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0xBE, 0x00, 0xF7, 0xE0,
  0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7E, 0xF8, 0x0F, 0x8F, 0x81, 0xE1, 0xF0,
  0x3C, 0x1F, 0x07, 0x83, 0xE0, 0xF0, 0x3E, 0x1E, 0x07, 0xC3, 0xC0, 0x7C,
  0x78, 0x0F, 0x8F, 0x00, 0xF9, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x07, 0xF0,
  0xE3, 0xFF, 0x1F, 0xFC, 0xF7, 0xFF, 0x3F, 0xFC, 0xFF, 0x9F, 0xBC, 0xFE,
  0xFC, 0x0F, 0xF0, 0x3E, 0xF8, 0x07, 0xE0, 0x1E, 0xF8, 0x07, 0xE0, 0x1F,
  0xF8, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x0F,
  0xE1, 0xFE, 0x1C, 0x7F, 0xE3, 0xDF, 0xFE, 0x7F, 0xCF, 0xEF, 0xC0, 0x7D,
  0xF8, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0x1F, 0xC3, 0xE0, 0x3E, 0x1F, 0x00, 0xF9, 0xF0,
  0x03, 0xCF, 0x80, 0x1E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xF7,
  0xC0, 0x0F, 0x3E, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x1F, 0x87,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00,
  0xE1, 0xFE, 0x0E, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0xF0, 0xFC, 0xFC, 0x07,
  0xCF, 0xC0, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x3E, 0xFC, 0x03, 0xEF, 0xC0, 0x7C,
  0xFF, 0x0F, 0xCF, 0x7F, 0xF8, 0xF3, 0xFF, 0x0F, 0x1F, 0xE0, 0xF0, 0x30,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x78, 0x7F, 0xF3, 0xC7, 0xFF, 0xDE,
  0x3F, 0x1E, 0xF3, 0xE0, 0x3F, 0x9F, 0x00, 0xFD, 0xF0, 0x07, 0xEF, 0x80,
  0x1F, 0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0xBE,
  0x00, 0xFC, 0xF0, 0x07, 0xE7, 0xC0, 0x7F, 0x1F, 0x8F, 0x78, 0xFF, 0xFB,
  0xC3, 0xFF, 0xBE, 0x0F, 0xF1, 0xF0, 0x04, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xE1, 0xFF, 0x1F, 0xF9, 0xFF, 0xCF, 0xEF, 0xF0, 0x7F, 0x03, 0xF0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00, 0x0F,
  0xFC, 0x3F, 0xFF, 0x7F, 0xFE, 0x7E, 0x3E, 0xF8, 0x04, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xC0, 0x1E, 0xF8,
  0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0, 0x01, 0x00, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7E, 0x21,
  0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x10, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFE, 0x01,
  0xFF, 0xC0, 0x7F, 0x7E, 0x3D, 0xEF, 0xFF, 0xBC, 0xFF, 0xE7, 0x8F, 0xF0,
  0xF0, 0x30, 0x00, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8,
  0x01, 0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x3C,
  0x1E, 0x03, 0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x7C, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x01, 0xEF,
  0x00, 0x07, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0xF8, 0x03, 0xF0,
  0x07, 0xBC, 0x01, 0xF8, 0x03, 0xDF, 0x00, 0xFC, 0x01, 0xE7, 0x80, 0x7F,
  0x01, 0xF3, 0xC0, 0x7F, 0x80, 0xF9, 0xE0, 0x3F, 0xC0, 0x78, 0xF8, 0x1E,
  0xE0, 0x3C, 0x7C, 0x0E, 0x78, 0x1E, 0x1E, 0x07, 0x3C, 0x1F, 0x0F, 0x07,
  0x9E, 0x0F, 0x07, 0x83, 0xCF, 0x07, 0x83, 0xE1, 0xE3, 0x83, 0xC0, 0xF0,
  0xE1, 0xE1, 0xE0, 0x78, 0xF0, 0xF1, 0xE0, 0x3C, 0x78, 0x78, 0xF0, 0x1E,
  0x3C, 0x1C, 0x78, 0x07, 0x9C, 0x0F, 0x3C, 0x03, 0xDE, 0x07, 0xBC, 0x01,
  0xEF, 0x03, 0xDE, 0x00, 0xF7, 0x81, 0xEF, 0x00, 0x7B, 0x80, 0x77, 0x80,
  0x1D, 0xC0, 0x3B, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x03, 0xC3, 0xE0, 0x7C, 0x1E,
  0x07, 0x81, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF9, 0xF0, 0x07, 0x9E, 0x00,
  0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0x9E,
  0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xE0,
  0x7C, 0x3C, 0x03, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF8, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0xF8, 0xF8, 0x07, 0x87, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0,
  0x1F, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x7C, 0x07, 0x83, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x04, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x80,
  0x7F, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x7F, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0x80, 0x00, 0x0E, 0x00, 0x0B, 0xFE, 0x00, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x1F, 0xFA, 0x00, 0x3F, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 38, 13, 3, -37 },
  { 30, 14, 13, 20, 3, -37 },
  { 53, 25, 37, 27, 1, -37 },
  { 169, 20, 43, 25, 2, -40 },
  { 277, 33, 38, 37, 2, -38 },
  { 434, 27, 39, 29, 2, -38 },
  { 566, 5, 13, 11, 3, -37 },
  { 575, 12, 45, 15, 2, -37 },
  { 643, 11, 45, 15, 2, -37 },
  { 705, 19, 20, 23, 2, -40 },
  { 753, 21, 25, 25, 2, -31 },
  { 819, 7, 13, 12, 2, -6 },
  { 831, 11, 4, 15, 2, -16 },
  { 837, 6, 7, 12, 3, -6 },
  { 843, 18, 37, 19, 1, -37 },
  { 927, 20, 39, 25, 2, -38 },
  { 1025, 12, 37, 25, 4, -37 },
  { 1081, 20, 38, 25, 2, -38 },
  { 1176, 20, 39, 25, 2, -38 },
  { 1274, 23, 37, 25, 1, -37 },
  { 1381, 19, 38, 25, 3, -37 },
  { 1472, 20, 39, 25, 2, -38 },
  { 1570, 20, 37, 25, 2, -37 },
  { 1663, 21, 39, 25, 2, -38 },
  { 1766, 20, 39, 25, 2, -38 },
  { 1864, 6, 29, 12, 3, -28 },
  { 1886, 7, 35, 12, 2, -28 },
  { 1917, 21, 24, 25, 2, -31 },
  { 1980, 21, 15, 25, 2, -26 },
  { 2020, 21, 24, 25, 2, -31 },
  { 2083, 16, 39, 18, 1, -38 },
  { 2161, 32, 41, 38, 3, -37 },
  { 2325, 26, 37, 26, 0, -37 },
  { 2446, 21, 37, 28, 4, -37 },
  { 2544, 22, 39, 26, 3, -38 },
  { 2652, 23, 37, 30, 4, -37 },
  { 2759, 17, 37, 23, 4, -37 },
  { 2838, 17, 37, 22, 4, -37 },
  { 2917, 25, 39, 31, 3, -38 },
  { 3039, 23, 37, 31, 4, -37 },
  { 3146, 12, 37, 16, 2, -37 },
  { 3202, 11, 47, 12, -3, -37 },
  { 3267, 22, 37, 26, 4, -37 },
  { 3369, 17, 37, 22, 4, -37 },
  { 3448, 32, 37, 40, 4, -37 },
  { 3596, 24, 37, 33, 4, -37 },
  { 3707, 26, 39, 32, 3, -38 },
  { 3834, 20, 37, 26, 4, -37 },
  { 3927, 26, 47, 32, 3, -38 },
  { 4080, 22, 37, 26, 4, -37 },
  { 4182, 19, 39, 24, 2, -38 },
  { 4275, 21, 37, 23, 1, -37 },
  { 4373, 23, 38, 30, 4, -37 },
  { 4483, 25, 37, 25, 0, -37 },
  { 4599, 40, 37, 41, 0, -37 },
  { 4784, 23, 37, 24, 0, -37 },
  { 4891, 23, 37, 23, 0, -37 },
  { 4998, 19, 37, 22, 2, -37 },
  { 5086, 11, 45, 16, 4, -37 },
  { 5148, 18, 37, 19, 1, -37 },
  { 5232, 11, 45, 16, 2, -37 },
  { 5294, 23, 21, 25, 1, -37 },
  { 5355, 23, 4, 23, 0, 4 },
  { 5367, 10, 8, 14, 2, -40 },
  { 5377, 18, 29, 24, 2, -28 },
  { 5443, 20, 41, 26, 4, -40 },
  { 5546, 17, 29, 20, 2, -28 },
  { 5608, 21, 41, 26, 2, -40 },
  { 5716, 20, 29, 24, 2, -28 },
  { 5789, 15, 40, 15, 1, -40 },
  { 5864, 21, 40, 26, 2, -28 },
  { 5969, 19, 40, 26, 4, -40 },
  { 6064, 5, 38, 12, 3, -38 },
  { 6088, 9, 50, 12, -1, -38 },
  { 6145, 19, 40, 23, 4, -40 },
  { 6240, 4, 40, 12, 4, -40 },
  { 6260, 32, 28, 39, 4, -28 },
  { 6372, 19, 28, 26, 4, -28 },
  { 6439, 21, 29, 26, 2, -28 },
  { 6516, 20, 40, 26, 4, -28 },
  { 6616, 21, 40, 26, 2, -28 },
  { 6721, 13, 28, 18, 4, -28 },
  { 6767, 16, 29, 20, 2, -28 },
  { 6825, 13, 35, 15, 1, -34 },
  { 6882, 19, 29, 26, 4, -28 },
  { 6951, 21, 28, 21, 0, -28 },
  { 7025, 33, 28, 34, 1, -28 },
  { 7141, 20, 28, 22, 1, -28 },
  { 7211, 21, 40, 21, 0, -28 },
  { 7316, 15, 28, 18, 2, -28 },
  { 7369, 15, 45, 19, 2, -37 },
  { 7454, 4, 52, 23, 10, -40 },
  { 7480, 15, 45, 19, 2, -37 },
  { 7565, 21, 7, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Regular52pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular52pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular52pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _NOTOSANS_CONDENSED_REGULAR52PT7B_H_
