#ifndef _NOTOSANS_CONDENSED_REGULAR13PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0x80, 0xB6, 0x80, 0x24, 0xA7, 0xCA, 0x2B, 0xF4, 0x92, 0x50,
  0x23, 0xAD, 0x4A, 0x38, 0xC5, 0xF1, 0x08, 0xC4, 0xA8, 0xA8, 0xB6, 0xD5,
  0x19, 0x29, 0x25, 0x46, 0x78, 0x91, 0x21, 0x87, 0x0B, 0x73, 0x26, 0x7E,
  0xE0, 0x6A, 0xAA, 0xB4, 0xC8, 0x92, 0x49, 0x2B, 0x00, 0x21, 0x7E, 0x65,
  0x80, 0x10, 0x41, 0x3F, 0x10, 0x40, 0x56, 0xE0, 0xC0, 0x18, 0x84, 0x42,
  0x11, 0x08, 0x80, 0xF4, 0xA5, 0x39, 0xCE, 0x52, 0x70, 0x7C, 0x92, 0x49,
  0x20, 0x78, 0x20, 0x82, 0x10, 0x42, 0x10, 0xFC, 0xF8, 0x42, 0x33, 0x84,
  0x21, 0x78, 0x18, 0x62, 0x8A, 0x49, 0x2F, 0xC2, 0x08, 0xF4, 0x21, 0xC1,
  0x08, 0x62, 0xF0, 0x74, 0x21, 0xE9, 0x4E, 0x72, 0x70, 0xFC, 0x20, 0x86,
  0x10, 0x42, 0x08, 0x60, 0x79, 0x24, 0x9E, 0x31, 0x2C, 0x53, 0x78, 0xF4,
  0xA5, 0x3B, 0x28, 0x42, 0xE0, 0xC6, 0x50, 0x15, 0x80, 0x04, 0x62, 0x30,
  0x30, 0x30, 0xFC, 0x0F, 0xC0, 0x81, 0x81, 0x83, 0x33, 0x00, 0xF1, 0x11,
  0x24, 0x04, 0x60, 0x3C, 0x42, 0x99, 0xA9, 0xA9, 0xA9, 0xAE, 0x94, 0xC0,
  0x7C, 0x30, 0x60, 0xA1, 0x44, 0x8F, 0x91, 0x62, 0x86, 0xFC, 0x63, 0x3F,
  0xC6, 0x31, 0xF0, 0x7E, 0x21, 0x08, 0x42, 0x18, 0x78, 0xFA, 0x28, 0xE1,
  0x86, 0x18, 0xE2, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8,
  0x88, 0x80, 0x7F, 0x08, 0x20, 0x9E, 0x18, 0x71, 0x7C, 0x86, 0x18, 0x61,
  0xFE, 0x18, 0x61, 0x84, 0xED, 0xB6, 0xDB, 0xE0, 0x24, 0x92, 0x49, 0x27,
  0xA0, 0x8A, 0x4B, 0x28, 0xE2, 0xC9, 0x26, 0x8C, 0x88, 0x88, 0x88, 0x88,
  0xF0, 0xC3, 0xC3, 0xE3, 0xA5, 0xA5, 0xA5, 0x99, 0x99, 0x99, 0xC7, 0x1A,
  0x69, 0x96, 0x58, 0xE3, 0x84, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x73, 0x78,
  0xF4, 0x63, 0x1F, 0x42, 0x10, 0x80, 0x7A, 0x18, 0x61, 0x86, 0x18, 0x73,
  0x78, 0x20, 0xC0, 0xF4, 0x63, 0x1F, 0x4A, 0x53, 0x88, 0xF8, 0x8C, 0x61,
  0x11, 0xF0, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x20, 0x86, 0x18, 0x61, 0x86,
  0x18, 0xE2, 0x78, 0x87, 0x14, 0xD2, 0x48, 0xA3, 0x0C, 0x30, 0x8C, 0x73,
  0x14, 0xC9, 0x32, 0x52, 0x94, 0xA3, 0x28, 0xCC, 0x31, 0x00, 0xCD, 0x23,
  0x0C, 0x30, 0xC4, 0x92, 0x8C, 0x8D, 0x24, 0x8C, 0x30, 0x82, 0x08, 0x20,
  0xF8, 0xC4, 0x22, 0x11, 0x08, 0xF8, 0xF2, 0x49, 0x24, 0x93, 0x80, 0xC2,
  0x10, 0x42, 0x10, 0x42, 0x18, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x30, 0xC4,
  0x92, 0x84, 0xFC, 0x90, 0x78, 0x42, 0xF4, 0xE5, 0xE0, 0x84, 0x21, 0xE8,
  0xC6, 0x31, 0x8F, 0x80, 0x78, 0x88, 0x88, 0xF0, 0x08, 0x43, 0xD9, 0xC6,
  0x31, 0x9F, 0x40, 0x79, 0x9F, 0x88, 0x70, 0x34, 0x4E, 0x44, 0x44, 0x44,
  0xEC, 0xE3, 0x18, 0xCF, 0xA1, 0x17, 0x80, 0x84, 0x21, 0xE9, 0xC6, 0x31,
  0x8C, 0x40, 0xDF, 0xC0, 0x51, 0x55, 0x55, 0xC0, 0x84, 0x21, 0x3A, 0x53,
  0x94, 0x94, 0xC0, 0xFF, 0xC0, 0xF7, 0x99, 0x91, 0x91, 0x91, 0x91, 0x91,
  0xF4, 0xE3, 0x18, 0xC6, 0x20, 0x74, 0xA3, 0x18, 0xC9, 0xC0, 0xF4, 0x63,
  0x18, 0xC7, 0xD0, 0x84, 0x00, 0xEC, 0xE3, 0x18, 0xCF, 0xA1, 0x08, 0x40,
  0xFA, 0x49, 0x20, 0x7C, 0x43, 0x11, 0xF0, 0x44, 0xE4, 0x44, 0x44, 0x70,
  0x8C, 0x63, 0x18, 0xCF, 0xA0, 0x8E, 0x52, 0xA5, 0x18, 0x80, 0x89, 0xD9,
  0x59, 0x55, 0x56, 0x66, 0x26, 0xCA, 0x8C, 0x43, 0x2B, 0x20, 0x8E, 0x52,
  0xA5, 0x18, 0x84, 0x26, 0x00, 0x71, 0x22, 0x44, 0xF0, 0x32, 0x22, 0x2C,
  0x22, 0x22, 0x30, 0xFF, 0xF8, 0xE2, 0x22, 0x21, 0x22, 0x22, 0xC0, 0xFC,
};

const GFXglyph NotoSans_Condensed_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 3, 3, 5, 1, -9 },
  { 5, 6, 9, 7, 0, -9 },
  { 12, 5, 11, 6, 1, -10 },
  { 19, 8, 9, 9, 1, -9 },
  { 28, 7, 9, 7, 0, -9 },
  { 36, 1, 3, 3, 1, -9 },
  { 37, 2, 11, 4, 1, -9 },
  { 40, 3, 11, 4, 0, -9 },
  { 45, 5, 5, 6, 0, -10 },
  { 49, 6, 6, 6, 0, -8 },
  { 54, 2, 4, 3, 0, -2 },
  { 55, 3, 1, 4, 0, -4 },
  { 56, 1, 2, 3, 1, -2 },
  { 57, 5, 9, 5, 0, -9 },
  { 63, 5, 9, 6, 1, -9 },
  { 69, 3, 9, 6, 1, -9 },
  { 73, 6, 9, 6, 0, -9 },
  { 80, 5, 9, 6, 0, -9 },
  { 86, 6, 9, 6, 0, -9 },
  { 93, 5, 9, 6, 1, -9 },
  { 99, 5, 9, 6, 1, -9 },
  { 105, 6, 9, 6, 0, -9 },
  { 112, 6, 9, 6, 0, -9 },
  { 119, 5, 9, 6, 1, -9 },
  { 125, 1, 7, 3, 1, -7 },
  { 126, 2, 9, 3, 0, -7 },
  { 129, 6, 6, 6, 0, -8 },
  { 134, 6, 3, 6, 0, -6 },
  { 137, 6, 6, 6, 0, -8 },
  { 142, 4, 9, 5, 0, -9 },
  { 147, 8, 10, 9, 1, -9 },
  { 157, 7, 9, 7, 0, -9 },
  { 165, 5, 9, 7, 1, -9 },
  { 171, 5, 9, 7, 1, -9 },
  { 177, 6, 9, 8, 1, -9 },
  { 184, 4, 9, 6, 1, -9 },
  { 189, 4, 9, 5, 1, -9 },
  { 194, 6, 9, 8, 1, -9 },
  { 201, 6, 9, 8, 1, -9 },
  { 208, 3, 9, 4, 0, -9 },
  { 212, 3, 12, 3, -1, -9 },
  { 217, 6, 9, 6, 1, -9 },
  { 224, 4, 9, 5, 1, -9 },
  { 229, 8, 9, 10, 1, -9 },
  { 238, 6, 9, 8, 1, -9 },
  { 245, 6, 9, 8, 1, -9 },
  { 252, 5, 9, 6, 1, -9 },
  { 258, 6, 11, 8, 1, -9 },
  { 267, 5, 9, 7, 1, -9 },
  { 273, 4, 9, 6, 1, -9 },
  { 278, 5, 9, 6, 0, -9 },
  { 284, 6, 9, 8, 1, -9 },
  { 291, 6, 9, 6, 0, -9 },
  { 298, 10, 9, 10, 0, -9 },
  { 310, 6, 9, 6, 0, -9 },
  { 317, 6, 9, 6, 0, -9 },
  { 324, 5, 9, 6, 0, -9 },
  { 330, 3, 11, 4, 1, -9 },
  { 335, 5, 9, 5, 0, -9 },
  { 341, 3, 11, 4, 0, -9 },
  { 346, 6, 5, 6, 0, -9 },
  { 350, 6, 1, 6, 0, 1 },
  { 351, 2, 2, 4, 1, -10 },
  { 352, 5, 7, 6, 0, -7 },
  { 357, 5, 10, 7, 1, -10 },
  { 364, 4, 7, 5, 1, -7 },
  { 368, 5, 10, 7, 1, -10 },
  { 375, 4, 7, 6, 1, -7 },
  { 379, 4, 10, 4, 0, -10 },
  { 384, 5, 10, 7, 1, -7 },
  { 391, 5, 10, 7, 1, -10 },
  { 398, 1, 10, 3, 1, -10 },
  { 400, 2, 13, 3, 0, -10 },
  { 404, 5, 10, 6, 1, -10 },
  { 411, 1, 10, 3, 1, -10 },
  { 413, 8, 7, 10, 1, -7 },
  { 420, 5, 7, 7, 1, -7 },
  { 425, 5, 7, 6, 1, -7 },
  { 430, 5, 10, 7, 1, -7 },
  { 437, 5, 10, 7, 1, -7 },
  { 444, 3, 7, 4, 1, -7 },
  { 447, 4, 7, 5, 0, -7 },
  { 451, 4, 9, 4, 0, -9 },
  { 456, 5, 7, 7, 1, -7 },
  { 461, 5, 7, 5, 0, -7 },
  { 466, 8, 7, 9, 0, -7 },
  { 473, 5, 7, 5, 0, -7 },
  { 478, 5, 10, 5, 0, -7 },
  { 485, 4, 7, 5, 0, -7 },
  { 489, 4, 11, 5, 0, -9 },
  { 495, 1, 13, 6, 2, -10 },
  { 497, 4, 11, 5, 0, -9 },
  { 503, 6, 1, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Regular13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular13pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_CONDENSED_REGULAR13PT7B_H_
