#ifndef _NOTOSANS_CONDENSED_REGULAR49PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x30, 0x00, 0x00, 0x01, 0xE7,
  0xBF, 0xFF, 0xF7, 0x80, 0xF8, 0xFF, 0x83, 0xFC, 0x1F, 0xE0, 0xFF, 0x07,
  0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0x7B, 0x83, 0x9C, 0x1C, 0xE0, 0xE7,
  0x07, 0x00, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x07,
  0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC1, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xE0,
  0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00,
  0x70, 0x38, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x07,
  0x07, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0xE0,
  0x70, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0E,
  0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xF1,
  0xFF, 0x7E, 0x7C, 0xE0, 0x8F, 0x1C, 0x03, 0xC3, 0x80, 0x78, 0x70, 0x0F,
  0x0E, 0x01, 0xE1, 0xC0, 0x1E, 0x38, 0x03, 0xE7, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x39, 0xF0, 0x07, 0x1F, 0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x87, 0x80,
  0x70, 0xF0, 0x0E, 0x1F, 0x01, 0xC7, 0xBC, 0x3B, 0xF7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x07, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x7F, 0x80,
  0x1E, 0x00, 0xFF, 0x80, 0x38, 0x03, 0xC7, 0x00, 0x70, 0x07, 0x0F, 0x01,
  0xE0, 0x0E, 0x0E, 0x03, 0x80, 0x3C, 0x1C, 0x0F, 0x00, 0x78, 0x38, 0x1C,
  0x00, 0xE0, 0x70, 0x78, 0x01, 0xC0, 0xE0, 0xE0, 0x03, 0x81, 0xC1, 0xC0,
  0x07, 0x03, 0x87, 0x80, 0x0E, 0x07, 0x0E, 0x00, 0x1E, 0x0E, 0x3C, 0x10,
  0x3C, 0x1C, 0x70, 0xFC, 0x38, 0x38, 0xE3, 0xFC, 0x70, 0xF3, 0xCF, 0xF8,
  0xF1, 0xC7, 0x1C, 0x78, 0xFF, 0x9E, 0x78, 0x71, 0xFE, 0x38, 0xE0, 0xE1,
  0xF8, 0x71, 0xC1, 0xE0, 0x01, 0xE3, 0x83, 0xC0, 0x03, 0x87, 0x07, 0x80,
  0x0F, 0x0E, 0x0F, 0x00, 0x1C, 0x1C, 0x1E, 0x00, 0x78, 0x38, 0x3C, 0x00,
  0xE0, 0x70, 0x78, 0x01, 0xC0, 0xE0, 0xF0, 0x07, 0x81, 0xC1, 0xE0, 0x0E,
  0x03, 0x83, 0x80, 0x3C, 0x07, 0x87, 0x00, 0x70, 0x07, 0x1E, 0x00, 0xE0,
  0x0F, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xE3, 0xC0, 0x00,
  0xF3, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFE, 0x07, 0xC7, 0xCF, 0x03,
  0xC7, 0xC7, 0xC1, 0xE3, 0xC1, 0xF0, 0xF3, 0xE0, 0x7C, 0x79, 0xE0, 0x1E,
  0x78, 0xF0, 0x0F, 0xBC, 0x78, 0x03, 0xFE, 0x3C, 0x00, 0xFE, 0x1E, 0x00,
  0x7E, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0xC1, 0xF0, 0x1F, 0xF0, 0xFC,
  0x3F, 0xF8, 0x3F, 0xFF, 0x3E, 0x0F, 0xFF, 0x0F, 0x83, 0xFE, 0x03, 0xE0,
  0xFF, 0xBD, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x00, 0x01, 0xC0, 0x78,
  0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0,
  0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0,
  0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x30, 0x70, 0x6F, 0xDC,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0,
  0x0F, 0x38, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0xF8, 0x7C, 0x1C, 0x1C, 0x01,
  0x02, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x3E, 0x7C, 0xF1,
  0xE3, 0xCF, 0x9E, 0x3C, 0x70, 0xE3, 0xC7, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x73, 0xEF, 0xFF, 0xF9, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x8F, 0x83, 0xE0, 0xF8, 0x78, 0x0F,
  0x1F, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F,
  0x7C, 0x01, 0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x03, 0xEF, 0x00, 0x79,
  0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0xC0, 0x7C, 0x78, 0x0F, 0x0F, 0x83, 0xE0,
  0xF8, 0xF8, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x00, 0xF0,
  0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0xF1, 0xFF, 0x3E, 0xFF, 0xCF, 0x78, 0xF3,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x7E, 0x1F,
  0xC7, 0x00, 0xF8, 0x40, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x7E, 0x0F,
  0xC7, 0x00, 0xF8, 0x80, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xA0, 0x03, 0xE7, 0x81, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0x8F, 0x00, 0x3C,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0x80, 0x78, 0x3C, 0x03,
  0xC1, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x20, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF,
  0xFE, 0x18, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE8, 0x01, 0xF3, 0xC1, 0xFC, 0xFF,
  0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F,
  0xFE, 0x07, 0xF0, 0x40, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF1, 0xF8, 0x1E, 0xFF, 0xC7, 0xBF, 0xFC, 0xF7, 0xFF, 0x9F, 0xC0,
  0xFB, 0xF0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x81, 0xF0, 0xF8, 0xFC, 0x0F, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0x7F,
  0xFE, 0x1F, 0x07, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x1E, 0x03, 0xE3, 0xE0,
  0x78, 0x3E, 0x3E, 0x07, 0xEF, 0xC0, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0xFF,
  0x80, 0x3F, 0xF8, 0x0F, 0x9F, 0x83, 0xC0, 0xF8, 0xF8, 0x0F, 0x9E, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xDE, 0x00, 0xF3, 0xF0, 0x7E, 0x3F, 0xFF,
  0x83, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0x8F, 0x87, 0xC0, 0xF8, 0xF0, 0x0F, 0x1E, 0x01, 0xF7, 0xC0,
  0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFB, 0xC0, 0x1F, 0x78, 0x07, 0xEF, 0x81,
  0xFC, 0xFF, 0xF7, 0x9F, 0xFE, 0xF1, 0xFF, 0xBC, 0x0F, 0xC7, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0x07, 0xF0, 0x3F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x31, 0xEF, 0xFF, 0xFD, 0xE3, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0xBF,
  0xFF, 0xE7, 0x80, 0x10, 0x79, 0xFB, 0xF7, 0xEF, 0x8E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x8F, 0x9E,
  0x3C, 0xF9, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0xC0, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x80, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x01, 0x80, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xC3, 0xE4, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x1C, 0x07, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0x38, 0x38, 0x01, 0xC0, 0x78, 0xF0, 0x1F, 0xF0, 0x71, 0xC0, 0xFF, 0xE0,
  0xE3, 0x81, 0xE1, 0xC1, 0xEF, 0x07, 0x83, 0x81, 0xDE, 0x0E, 0x07, 0x03,
  0xB8, 0x3C, 0x0E, 0x07, 0x70, 0x78, 0x1C, 0x0E, 0xE0, 0xE0, 0x38, 0x1D,
  0xC1, 0xC0, 0x70, 0x3B, 0x83, 0x81, 0xE0, 0x7F, 0x07, 0x03, 0xC0, 0xFE,
  0x0E, 0x07, 0x81, 0xDC, 0x1C, 0x0F, 0x07, 0xB8, 0x38, 0x1E, 0x0E, 0x70,
  0x78, 0x3C, 0x1C, 0xE0, 0xF0, 0xDC, 0x79, 0xC0, 0xFF, 0xBF, 0xE3, 0xC1,
  0xFE, 0x3F, 0x87, 0x81, 0xFC, 0x7E, 0x07, 0x00, 0x40, 0x10, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x70, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xE7, 0x80, 0x00, 0xF1, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x1E,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0,
  0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x3E, 0x78, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xE0,
  0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F,
  0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0,
  0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F,
  0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x0F, 0xFE, 0x03, 0xFF, 0xF0,
  0x7F, 0xFF, 0x0F, 0xE1, 0xE1, 0xF8, 0x02, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x01,
  0x0F, 0xF1, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xF0, 0x0F, 0xC3,
  0xC0, 0x1F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xFB, 0xC0,
  0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x0F,
  0x3C, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x8F, 0x00, 0xFC, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0x83, 0xE1, 0xF8, 0x00, 0xC3, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xE0, 0x03, 0xC7, 0xE0, 0x07,
  0x87, 0xF8, 0x3F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xE0,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x8F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1E, 0xCF, 0xDF, 0xF3, 0xFE, 0x7F, 0x00, 0xF0, 0x01,
  0xF7, 0x80, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78,
  0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xE0,
  0x3C, 0x1E, 0x01, 0xE1, 0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xCF,
  0x80, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFB, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x03, 0xC1, 0xF0, 0x1E, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0xF8, 0x78, 0x03, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF0, 0x03,
  0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xEF, 0xF7, 0x80, 0x07, 0xBF, 0xDE, 0x00,
  0x1E, 0xFF, 0x78, 0x00, 0x73, 0xFC, 0xF0, 0x03, 0xCF, 0xF3, 0xC0, 0x0F,
  0x3F, 0xCF, 0x00, 0x38, 0xFF, 0x1C, 0x01, 0xE3, 0xFC, 0x78, 0x07, 0x8F,
  0xF1, 0xE0, 0x1E, 0x3F, 0xC3, 0x80, 0x70, 0xFF, 0x0F, 0x03, 0xC3, 0xFC,
  0x3C, 0x0F, 0x0F, 0xF0, 0x70, 0x38, 0x3F, 0xC1, 0xE1, 0xE0, 0xFF, 0x07,
  0x87, 0x83, 0xFC, 0x1E, 0x1C, 0x0F, 0xF0, 0x3C, 0xF0, 0x3F, 0xC0, 0xF3,
  0xC0, 0xFF, 0x03, 0xCE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x03, 0xF0, 0x0F,
  0xF0, 0x0F, 0xC0, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xC0,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xF7,
  0x80, 0x1F, 0xEF, 0x80, 0x3F, 0xCF, 0x00, 0x7F, 0x9F, 0x00, 0xFF, 0x1E,
  0x01, 0xFE, 0x3E, 0x03, 0xFC, 0x3C, 0x07, 0xF8, 0x7C, 0x0F, 0xF0, 0x78,
  0x1F, 0xE0, 0xF8, 0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xF0, 0xFF, 0x01, 0xE1,
  0xFE, 0x03, 0xE3, 0xFC, 0x03, 0xC7, 0xF8, 0x07, 0xCF, 0xF0, 0x07, 0x9F,
  0xE0, 0x0F, 0xBF, 0xC0, 0x0F, 0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x03, 0xFC, 0x7F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x3F, 0xC7, 0xF0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1E, 0xF0, 0x0F, 0xBC, 0x1F, 0xCF,
  0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03,
  0xFC, 0x7F, 0x03, 0xF0, 0x0F, 0xC1, 0xF0, 0x03, 0xE1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x9E,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x03, 0xE0,
  0x7C, 0x03, 0xF0, 0x3F, 0xC7, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00,
  0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x3F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0xFF, 0xFC, 0x7F, 0xFE, 0x3F, 0x9F, 0x9F, 0x00, 0x67, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x3E, 0xFC, 0x7F, 0x3F,
  0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xF0, 0x0F, 0xC7,
  0xF1, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00,
  0x3E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x03, 0xC3,
  0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xEF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3D,
  0xE0, 0x01, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xC0, 0x07, 0x9E, 0x00, 0x3F,
  0x00, 0x1E, 0x7C, 0x00, 0xFC, 0x00, 0x78, 0xF0, 0x03, 0xF0, 0x01, 0xE3,
  0xC0, 0x0F, 0xE0, 0x0F, 0x8F, 0x00, 0x7F, 0x80, 0x3C, 0x3C, 0x01, 0xEE,
  0x00, 0xF0, 0xF8, 0x07, 0xB8, 0x03, 0xC1, 0xE0, 0x1C, 0xF0, 0x1F, 0x07,
  0x80, 0xF3, 0xC0, 0x78, 0x1E, 0x03, 0xCF, 0x01, 0xE0, 0x7C, 0x0F, 0x1C,
  0x07, 0x80, 0xF0, 0x3C, 0x78, 0x1E, 0x03, 0xC0, 0xE1, 0xE0, 0xF8, 0x0F,
  0x07, 0x87, 0x83, 0xC0, 0x3C, 0x1E, 0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x38,
  0x3C, 0x01, 0xE1, 0xC0, 0xF0, 0xF0, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x1C, 0x78, 0x00, 0xF3, 0x80, 0x79,
  0xE0, 0x03, 0xCE, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x0E, 0xF0, 0x00, 0xF7, 0x80, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0xEF,
  0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x7C, 0xF0, 0x03, 0xE3,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0xF0,
  0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0,
  0x07, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF8, 0x1F,
  0x01, 0xE0, 0x78, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3C, 0x7C, 0x00,
  0xF9, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7D, 0xE0, 0x01,
  0xE7, 0x80, 0x0F, 0x9F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x07, 0xC1,
  0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF8,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x3C, 0x00, 0x3C, 0xF0,
  0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xCF, 0xFF,
  0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x78, 0x00, 0x3D, 0xE0,
  0x00, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x01, 0xC0, 0x1E, 0x0F, 0x00,
  0x38, 0x38, 0x00, 0xF1, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0xBC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x7C, 0x1F,
  0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x83, 0xFF, 0xE1, 0x80, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0xF0, 0xFF, 0xF9, 0xFF, 0xFD,
  0xFC, 0x1E, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x7E, 0xF0, 0x7F, 0x7F, 0xFB, 0x9F,
  0xF9, 0xC7, 0xF0, 0xE0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x78, 0x0F, 0x9F, 0xE0, 0xF3, 0xFF,
  0x0F, 0x7F, 0xF8, 0xFE, 0x07, 0xCF, 0xC0, 0x3C, 0xFC, 0x03, 0xEF, 0x80,
  0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0xC0, 0x3E,
  0xFE, 0x03, 0xCF, 0xF0, 0xFC, 0xF7, 0xFF, 0x8F, 0x3F, 0xF0, 0xF1, 0xFE,
  0x00, 0x00, 0xF8, 0x07, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x02, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x06, 0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x07, 0x83, 0xFC, 0xF1,
  0xFF, 0xDE, 0x3F, 0xFD, 0xCF, 0x83, 0xF9, 0xE0, 0x1F, 0x7C, 0x03, 0xEF,
  0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xE0, 0x1F, 0x3C,
  0x07, 0xE7, 0xE1, 0xFC, 0x7F, 0xFB, 0x87, 0xFE, 0x70, 0x7F, 0x8E, 0x00,
  0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3E, 0x0F, 0x8F, 0x01,
  0xE7, 0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x04, 0x7C, 0x0E, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0,
  0x03, 0xFC, 0x1F, 0xF0, 0xFF, 0x83, 0xE2, 0x0F, 0x00, 0x7C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0xFC, 0xFF, 0xF3, 0xFF,
  0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x1C, 0x7F, 0xF3,
  0x8F, 0xFF, 0x73, 0xE0, 0xFE, 0x78, 0x07, 0xDF, 0x00, 0xFB, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x07, 0xCF, 0x01, 0xF9,
  0xF8, 0x77, 0x1F, 0xFF, 0xE1, 0xFF, 0xBC, 0x1F, 0xE7, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE8,
  0x00, 0x78, 0xC0, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x7F, 0xFC, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x83, 0x83, 0xE7, 0xF8, 0xF3, 0xFF, 0xBD, 0xFF, 0xEF, 0xE0, 0x7F,
  0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8,
  0x03, 0xC0, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0,
  0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E,
  0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87,
  0x83, 0xC1, 0xEF, 0xF7, 0xF3, 0xF1, 0xF0, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x1E, 0xF8, 0x0F,
  0x3E, 0x07, 0xCF, 0x81, 0xE3, 0xE0, 0xF0, 0xF8, 0x7C, 0x3E, 0x3E, 0x0F,
  0x8F, 0x03, 0xE7, 0x80, 0xF3, 0xE0, 0x3C, 0xF0, 0x0F, 0x7E, 0x03, 0xFF,
  0x80, 0xFF, 0xF0, 0x3F, 0x3C, 0x0F, 0x8F, 0x83, 0xE1, 0xE0, 0xF8, 0x7C,
  0x3E, 0x0F, 0x0F, 0x83, 0xE3, 0xE0, 0x78, 0xF8, 0x1F, 0x3E, 0x03, 0xCF,
  0x80, 0xFB, 0xE0, 0x1E, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x78, 0x03, 0xC1, 0xE3,
  0xFC, 0x1F, 0xE3, 0xCF, 0xFC, 0xFF, 0xE7, 0xBF, 0xFD, 0xFF, 0xEF, 0xE0,
  0xFF, 0x07, 0xDF, 0x80, 0xFC, 0x07, 0xBF, 0x01, 0xF8, 0x0F, 0xFC, 0x03,
  0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F,
  0x00, 0x7F, 0xC0, 0x1E, 0x00, 0xFF, 0x80, 0x3C, 0x01, 0xFF, 0x00, 0x78,
  0x03, 0xFE, 0x00, 0xF0, 0x07, 0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x03, 0xC0,
  0x1F, 0xF0, 0x07, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x7F, 0xC0, 0x1E, 0x00,
  0xFF, 0x80, 0x3C, 0x01, 0xFF, 0x00, 0x78, 0x03, 0xFE, 0x00, 0xF0, 0x07,
  0xFC, 0x01, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x1F, 0xF0, 0x07, 0x80, 0x3F,
  0xE0, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x3C, 0x7F, 0xCF, 0x3F, 0xFB, 0xDF,
  0xFE, 0xFE, 0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0xFF, 0x80, 0x3C, 0x00, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xFF, 0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xE7, 0x80,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3E,
  0x3E, 0x03, 0xC1, 0xF0, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x78, 0x0F, 0x1F, 0xE0, 0xF3, 0xFF, 0x8F, 0x7F, 0xF8, 0xFE,
  0x07, 0xCF, 0xC0, 0x3C, 0xFC, 0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01,
  0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0xC0, 0x3E, 0xFE, 0x07, 0xCF, 0xF0,
  0xFC, 0xF7, 0xFF, 0x8F, 0x3F, 0xF0, 0xF9, 0xFE, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0x1C, 0x7F, 0xF3, 0x8F, 0xFF,
  0x73, 0xE0, 0xFE, 0x78, 0x07, 0xDF, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3D, 0xE0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x07, 0xCF, 0x01, 0xF9, 0xF8, 0x77,
  0x1F, 0xFF, 0xE1, 0xFF, 0xBC, 0x1F, 0xC7, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x7F, 0x8F, 0xFC, 0xFF, 0xEF, 0xFF, 0x78, 0xFF, 0x03, 0xF0, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xC0, 0x3F, 0xF8,
  0xFF, 0xFB, 0xFF, 0xEF, 0x80, 0xDE, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x0F, 0xF0, 0x3E, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0x80, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x11, 0xFF, 0x0F, 0xF0, 0x7F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03,
  0xF7, 0xE1, 0xFC, 0xFF, 0xF7, 0x3F, 0xF9, 0xC3, 0xFC, 0x70, 0xF8, 0x00,
  0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xE3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0x78, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0x9E, 0x00, 0x3D, 0xC0,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x78, 0x07, 0xE0, 0x1E, 0x78,
  0x07, 0xE0, 0x1E, 0x78, 0x07, 0xE0, 0x1E, 0x3C, 0x07, 0xF0, 0x1E, 0x3C,
  0x07, 0xF0, 0x3C, 0x3C, 0x0F, 0x70, 0x3C, 0x3C, 0x0F, 0x70, 0x3C, 0x1E,
  0x0E, 0x70, 0x3C, 0x1E, 0x0E, 0x78, 0x3C, 0x1E, 0x1E, 0x78, 0x78, 0x1E,
  0x1E, 0x38, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x0F, 0x1C, 0x3C, 0x78, 0x0F,
  0x3C, 0x3C, 0x70, 0x0F, 0x3C, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x07,
  0x38, 0x1E, 0xF0, 0x07, 0xB8, 0x1E, 0xE0, 0x07, 0xF8, 0x1E, 0xE0, 0x07,
  0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xEF, 0x00, 0xF8, 0xF0, 0x1E, 0x1E, 0x07, 0xC1, 0xE0, 0xF0, 0x3C,
  0x3C, 0x03, 0xC7, 0x80, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x01, 0xE0,
  0xF0, 0x78, 0x1E, 0x0F, 0x01, 0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xDE, 0x00,
  0x7C, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C,
  0x03, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0,
  0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xDE,
  0x00, 0x3D, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x0F, 0xC0,
  0xFE, 0x03, 0xC0, 0x0F, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xFF, 0x01,
  0xFC, 0x03, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x1F, 0xC0, 0xF8,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x01, 0xF0, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x0E, 0x00, 0x00, 0x3F, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xF8, 0x07, 0xFD, 0x00, 0x1E,
  0x00,
};

const GFXglyph NotoSans_Condensed_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 35, 12, 3, -35 },
  { 28, 13, 13, 19, 3, -35 },
  { 50, 23, 35, 25, 1, -35 },
  { 151, 19, 40, 23, 2, -37 },
  { 246, 31, 35, 35, 2, -35 },
  { 382, 25, 35, 27, 2, -35 },
  { 492, 5, 13, 10, 3, -35 },
  { 501, 11, 43, 14, 2, -35 },
  { 561, 11, 43, 14, 1, -35 },
  { 621, 18, 18, 22, 2, -37 },
  { 662, 19, 23, 23, 2, -29 },
  { 717, 7, 12, 12, 2, -6 },
  { 728, 11, 4, 14, 2, -15 },
  { 734, 6, 6, 12, 3, -6 },
  { 739, 17, 35, 18, 1, -35 },
  { 814, 19, 35, 23, 2, -35 },
  { 898, 12, 35, 23, 3, -35 },
  { 951, 19, 35, 23, 2, -35 },
  { 1035, 19, 35, 23, 2, -35 },
  { 1119, 21, 35, 23, 1, -35 },
  { 1211, 18, 35, 23, 3, -35 },
  { 1290, 19, 35, 23, 2, -35 },
  { 1374, 19, 35, 23, 2, -35 },
  { 1458, 19, 35, 23, 2, -35 },
  { 1542, 19, 35, 23, 2, -35 },
  { 1626, 6, 27, 12, 3, -27 },
  { 1647, 7, 33, 12, 2, -27 },
  { 1676, 19, 23, 23, 2, -29 },
  { 1731, 19, 14, 23, 2, -24 },
  { 1765, 19, 23, 23, 2, -29 },
  { 1820, 15, 35, 17, 1, -35 },
  { 1886, 31, 39, 36, 2, -35 },
  { 2038, 25, 35, 25, 0, -35 },
  { 2148, 20, 35, 26, 4, -35 },
  { 2236, 20, 36, 25, 3, -36 },
  { 2326, 22, 35, 28, 4, -35 },
  { 2423, 16, 35, 22, 4, -35 },
  { 2493, 16, 35, 21, 4, -35 },
  { 2563, 23, 35, 29, 3, -35 },
  { 2664, 21, 35, 29, 4, -35 },
  { 2756, 11, 35, 15, 2, -35 },
  { 2805, 11, 44, 12, -3, -35 },
  { 2866, 21, 35, 24, 4, -35 },
  { 2958, 15, 35, 20, 4, -35 },
  { 3024, 30, 35, 38, 4, -35 },
  { 3156, 23, 35, 31, 4, -35 },
  { 3257, 25, 35, 30, 3, -35 },
  { 3367, 18, 35, 24, 4, -35 },
  { 3446, 25, 43, 30, 3, -35 },
  { 3581, 20, 35, 25, 4, -35 },
  { 3669, 18, 36, 22, 2, -36 },
  { 3750, 21, 35, 21, 0, -35 },
  { 3842, 21, 35, 29, 4, -35 },
  { 3934, 24, 35, 24, 0, -35 },
  { 4039, 38, 35, 38, 0, -35 },
  { 4206, 22, 35, 22, 0, -35 },
  { 4303, 22, 35, 22, 0, -35 },
  { 4400, 19, 35, 21, 1, -35 },
  { 4484, 10, 43, 16, 4, -35 },
  { 4538, 17, 35, 18, 1, -35 },
  { 4613, 11, 43, 16, 1, -35 },
  { 4673, 22, 20, 24, 1, -35 },
  { 4728, 22, 3, 22, 0, 4 },
  { 4737, 9, 8, 13, 2, -38 },
  { 4746, 17, 27, 22, 2, -27 },
  { 4804, 20, 37, 25, 3, -37 },
  { 4897, 16, 27, 19, 2, -27 },
  { 4951, 19, 37, 25, 2, -37 },
  { 5039, 18, 27, 23, 2, -27 },
  { 5100, 14, 37, 14, 1, -37 },
  { 5165, 19, 39, 25, 2, -27 },
  { 5258, 18, 37, 25, 3, -37 },
  { 5342, 5, 36, 11, 3, -36 },
  { 5365, 9, 48, 11, -1, -36 },
  { 5419, 18, 37, 22, 3, -37 },
  { 5503, 5, 37, 11, 3, -37 },
  { 5527, 31, 27, 37, 3, -27 },
  { 5632, 18, 27, 25, 3, -27 },
  { 5693, 20, 27, 24, 2, -27 },
  { 5761, 20, 39, 25, 3, -27 },
  { 5859, 19, 39, 25, 2, -27 },
  { 5952, 13, 27, 17, 3, -27 },
  { 5996, 15, 27, 19, 2, -27 },
  { 6047, 12, 32, 14, 1, -32 },
  { 6095, 18, 26, 25, 3, -26 },
  { 6154, 20, 26, 20, 0, -26 },
  { 6219, 32, 26, 32, 0, -26 },
  { 6323, 19, 26, 21, 1, -26 },
  { 6385, 20, 38, 20, 0, -26 },
  { 6480, 15, 26, 17, 1, -26 },
  { 6529, 14, 43, 18, 2, -35 },
  { 6605, 4, 49, 22, 9, -37 },
  { 6630, 14, 43, 18, 2, -35 },
  { 6706, 19, 6, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Regular49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular49pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_CONDENSED_REGULAR49PT7B_H_
