#ifndef _NOTOSANS_CONDENSED_REGULAR50PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE3, 0x8E, 0x38, 0xE0, 0x00, 0x00, 0x07,
  0x9F, 0xFF, 0xFF, 0xDE, 0x10, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xEE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0,
  0xF7, 0x03, 0x80, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xF0,
  0x01, 0xE0, 0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03, 0xC1, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0,
  0x03, 0x83, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x83, 0x80, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x80, 0x07, 0x07, 0x80,
  0x07, 0x07, 0x80, 0x0F, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00,
  0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00,
  0x1E, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x07, 0xFF, 0xF9, 0xFF, 0xFE, 0x7C, 0xE1,
  0xCF, 0x1C, 0x01, 0xC3, 0x80, 0x78, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0,
  0x1E, 0x38, 0x03, 0xC7, 0x00, 0x7E, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0x1F,
  0x00, 0xE1, 0xE0, 0x1C, 0x3C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x1E,
  0x01, 0xC3, 0xF0, 0x38, 0xFF, 0xC7, 0x7E, 0xFF, 0xFF, 0x9F, 0xFF, 0xE0,
  0xFF, 0xF0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x3F, 0xC0, 0x07,
  0x00, 0x3F, 0xE0, 0x07, 0x00, 0x78, 0xE0, 0x0F, 0x00, 0x70, 0xF0, 0x0E,
  0x00, 0x70, 0x70, 0x1E, 0x00, 0xF0, 0x70, 0x1C, 0x00, 0xF0, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x38, 0x00, 0xF0, 0x78, 0x78,
  0x00, 0xF0, 0x78, 0x70, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF0, 0x78, 0xE0,
  0x00, 0xF0, 0x78, 0xE1, 0xE0, 0x70, 0x71, 0xE3, 0xF8, 0x70, 0x71, 0xC7,
  0xFC, 0x70, 0xF3, 0xCF, 0x3C, 0x78, 0xF3, 0x8E, 0x1E, 0x3F, 0xE3, 0x8E,
  0x1E, 0x1F, 0xC7, 0x9E, 0x0E, 0x0F, 0x87, 0x1E, 0x0E, 0x00, 0x0F, 0x1E,
  0x0E, 0x00, 0x0E, 0x1C, 0x0F, 0x00, 0x1E, 0x1C, 0x0F, 0x00, 0x1E, 0x1C,
  0x0F, 0x00, 0x1C, 0x1C, 0x0F, 0x00, 0x3C, 0x1C, 0x0F, 0x00, 0x38, 0x1E,
  0x0E, 0x00, 0x78, 0x1E, 0x0E, 0x00, 0x70, 0x0E, 0x0E, 0x00, 0x70, 0x0E,
  0x1E, 0x00, 0xF0, 0x0F, 0x1C, 0x00, 0xE0, 0x07, 0xFC, 0x01, 0xE0, 0x07,
  0xF8, 0x01, 0xC0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x3C, 0x3E, 0x7C,
  0x0F, 0x1F, 0x0F, 0x87, 0xC7, 0x81, 0xE1, 0xE3, 0xE0, 0x7C, 0x78, 0xF0,
  0x0F, 0xBE, 0x3C, 0x01, 0xFF, 0x0F, 0x00, 0x7F, 0xC3, 0xC0, 0x0F, 0xE0,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x1F,
  0xF0, 0x7F, 0x1F, 0xBE, 0x0F, 0xFF, 0xC7, 0xC1, 0xFF, 0xE1, 0xF8, 0x3F,
  0xE0, 0x3F, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7B, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x3C,
  0x07, 0x80, 0xF8, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x78, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E,
  0x07, 0x81, 0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x20, 0x78, 0x1F, 0x8E, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xB8, 0x03, 0xCF,
  0x01, 0xF1, 0xE0, 0x78, 0x7C, 0x3E, 0x0F, 0x03, 0x03, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3E, 0x7C,
  0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7, 0x0E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xEF, 0xFF, 0xFD, 0xE2, 0x00, 0x00, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF,
  0x83, 0xE0, 0xF8, 0x78, 0x0F, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0xF8, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80, 0x3C,
  0xF8, 0x07, 0x8F, 0x01, 0xF1, 0xF0, 0x3C, 0x1F, 0x9F, 0x83, 0xFF, 0xE0,
  0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E,
  0x0F, 0xF0, 0xFF, 0x8F, 0xBC, 0xF9, 0xEF, 0x9F, 0xF8, 0xF9, 0x87, 0xC8,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0x80, 0xF8, 0x40, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x07, 0xFF,
  0xC1, 0xFF, 0xFC, 0x7F, 0xBF, 0xC7, 0x00, 0xF8, 0x40, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xFC,
  0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF6, 0x00, 0x7E,
  0xF8, 0x3F, 0x9F, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0x18, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x73,
  0xC0, 0x03, 0xCF, 0x00, 0x0E, 0x7C, 0x00, 0x79, 0xF0, 0x03, 0xC7, 0xC0,
  0x0F, 0x1F, 0x00, 0x78, 0x7C, 0x01, 0xE1, 0xF0, 0x0F, 0x07, 0xC0, 0x38,
  0x1F, 0x01, 0xE0, 0x7C, 0x07, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0xE0, 0x1F,
  0x07, 0x80, 0x7C, 0x1C, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00,
  0xFA, 0x00, 0x7E, 0xF0, 0x7F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0,
  0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFD,
  0xC0, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x20,
  0x1E, 0x7F, 0x83, 0xDF, 0xF8, 0xFF, 0xFF, 0x9F, 0xE1, 0xFB, 0xF8, 0x0F,
  0x7E, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x1E,
  0x78, 0x03, 0xCF, 0x00, 0xF1, 0xF0, 0x3E, 0x1F, 0x9F, 0x81, 0xFF, 0xF0,
  0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xF9, 0xFC, 0x3E,
  0x07, 0xC7, 0xC0, 0x3C, 0x78, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x3E, 0x78, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07, 0xC3, 0xE0, 0xF8,
  0x1F, 0x9F, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFE,
  0x01, 0xFB, 0xF0, 0x3E, 0x1F, 0x83, 0xC0, 0x7C, 0x78, 0x03, 0xEF, 0x80,
  0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x0F, 0xC3,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x40, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0x83, 0xE0, 0xF8, 0xF8, 0x0F,
  0x1E, 0x00, 0xF7, 0xC0, 0x1E, 0xF8, 0x03, 0xDF, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x1F,
  0x78, 0x03, 0xEF, 0x80, 0xFD, 0xF8, 0x3F, 0x9F, 0xFE, 0xF1, 0xFF, 0xDE,
  0x1F, 0xF3, 0xC0, 0xF8, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x01, 0xF8, 0x20, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0, 0x00,
  0x40, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x88, 0x3C,
  0xFD, 0xFB, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xCF, 0x9E, 0x3C, 0xF9, 0xF3, 0xC7,
  0x8F, 0x3C, 0x78, 0xE1, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFC, 0x60, 0x3E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x78, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x1F, 0xE0, 0xF3, 0xC0, 0xFF, 0xE0,
  0xE7, 0x03, 0xFF, 0xC1, 0xCE, 0x07, 0x87, 0x83, 0xBC, 0x1E, 0x0F, 0x07,
  0xF8, 0x38, 0x1E, 0x0F, 0xE0, 0xF0, 0x3C, 0x1F, 0xC1, 0xE0, 0x78, 0x3F,
  0x83, 0xC0, 0xF0, 0x7F, 0x07, 0x01, 0xE0, 0xFE, 0x0E, 0x03, 0xC1, 0xFC,
  0x1C, 0x07, 0x03, 0xF8, 0x38, 0x0E, 0x07, 0x70, 0x78, 0x3C, 0x0E, 0xE0,
  0xF0, 0x78, 0x1D, 0xC1, 0xE0, 0xF8, 0x7B, 0x81, 0xE3, 0xF0, 0xE7, 0x83,
  0xFE, 0x7F, 0xCF, 0x03, 0xFC, 0xFF, 0x1E, 0x03, 0xF0, 0xFC, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x10, 0x00, 0xFC, 0x00,
  0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xF0, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x07, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF,
  0x00, 0x7E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC,
  0x03, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x02,
  0x0F, 0xF1, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00,
  0xC0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0xF0, 0x1F, 0xE3, 0xC0, 0x1F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7C,
  0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x07,
  0xCF, 0x00, 0x3E, 0x3C, 0x03, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xC0, 0x1E, 0x1F, 0x80, 0x04, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x1F, 0x80, 0x0F, 0x0F, 0xF8, 0x7F, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x06, 0x00, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xF1, 0xFB, 0xFF,
  0x7F, 0xCF, 0xF0, 0x60, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x00,
  0xF9, 0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x07, 0xC3, 0xC0, 0x3C, 0x1E,
  0x03, 0xE0, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0,
  0x0F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x1E, 0x7C, 0x00, 0xF7,
  0xC0, 0x07, 0xBF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xCF, 0x80,
  0x7C, 0x7C, 0x03, 0xC1, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xF8, 0x78, 0x03, 0xE3,
  0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBC, 0x00,
  0x7D, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x77, 0xFB, 0x80, 0x01, 0xEF, 0xF7,
  0x80, 0x03, 0xDF, 0xEF, 0x00, 0x07, 0x3F, 0xDE, 0x00, 0x1E, 0x7F, 0x9E,
  0x00, 0x3C, 0xFF, 0x3C, 0x00, 0x79, 0xFE, 0x78, 0x01, 0xE3, 0xFC, 0x78,
  0x03, 0xC7, 0xF8, 0xF0, 0x07, 0x8F, 0xF1, 0xE0, 0x0E, 0x1F, 0xE1, 0xE0,
  0x3C, 0x3F, 0xC3, 0xC0, 0x78, 0x7F, 0x87, 0x80, 0xE0, 0xFF, 0x07, 0x03,
  0xC1, 0xFE, 0x0F, 0x07, 0x83, 0xFC, 0x1E, 0x0E, 0x07, 0xF8, 0x1C, 0x3C,
  0x0F, 0xF0, 0x3C, 0x78, 0x1F, 0xE0, 0x78, 0xE0, 0x3F, 0xC0, 0xF3, 0xC0,
  0x7F, 0x80, 0xF7, 0x80, 0xFF, 0x01, 0xEF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F,
  0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0xF0,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x0F, 0xF7,
  0x80, 0x1F, 0xEF, 0x80, 0x3F, 0xCF, 0x00, 0x7F, 0x9F, 0x00, 0xFF, 0x1E,
  0x01, 0xFE, 0x3E, 0x03, 0xFC, 0x3C, 0x07, 0xF8, 0x7C, 0x0F, 0xF0, 0x78,
  0x1F, 0xE0, 0xF8, 0x3F, 0xC0, 0xF0, 0x7F, 0x81, 0xF0, 0xFF, 0x01, 0xE1,
  0xFE, 0x03, 0xE3, 0xFC, 0x03, 0xC7, 0xF8, 0x07, 0xCF, 0xF0, 0x07, 0x9F,
  0xE0, 0x0F, 0xBF, 0xC0, 0x0F, 0x7F, 0x80, 0x1F, 0xFF, 0x00, 0x1E, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3F, 0x01, 0xF8,
  0x0F, 0xF7, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F,
  0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x1F, 0xBC, 0x01, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x03, 0xF3, 0xFF,
  0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3C, 0x00,
  0x07, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xF7,
  0xF8, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x0F, 0x03, 0xF8, 0x78, 0x07, 0xE3, 0xC0, 0x1F, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xE0, 0x07, 0xCF, 0x00,
  0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x0F, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x78, 0x3E,
  0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF8, 0x3C,
  0x07, 0xC1, 0xE0, 0x1F, 0x0F, 0x00, 0xF8, 0x78, 0x03, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0,
  0x01, 0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7,
  0xE0, 0x38, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF6, 0x00, 0x7C, 0xFF, 0x7F, 0x9F, 0xFF, 0xE3, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00,
  0x7B, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7C, 0x3F, 0x8F, 0xE0,
  0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x20, 0x00, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x3E,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1F,
  0x00, 0x78, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x80, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03,
  0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE3, 0xC0, 0x01,
  0xE3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0xE0, 0x03, 0xCF,
  0x80, 0x1F, 0xC0, 0x0F, 0x8F, 0x00, 0x3B, 0x80, 0x1E, 0x1E, 0x00, 0x77,
  0x00, 0x3C, 0x3C, 0x00, 0xEE, 0x00, 0x78, 0x7C, 0x03, 0xDE, 0x01, 0xF0,
  0x78, 0x07, 0xBC, 0x03, 0xE0, 0xF0, 0x0F, 0x78, 0x07, 0x81, 0xE0, 0x1C,
  0x70, 0x0F, 0x03, 0xE0, 0x78, 0xF0, 0x1E, 0x03, 0xC0, 0xF1, 0xE0, 0x7C,
  0x07, 0x81, 0xE3, 0xC0, 0xF0, 0x0F, 0x03, 0xC7, 0x81, 0xE0, 0x1E, 0x07,
  0x07, 0x83, 0xC0, 0x3E, 0x1E, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x1E, 0x1F,
  0x00, 0x78, 0x78, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x38, 0x78, 0x01, 0xE3,
  0xC0, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0xF3, 0xE0, 0x03, 0xCF, 0x01, 0xE7,
  0x80, 0x07, 0x9E, 0x01, 0xCF, 0x00, 0x0F, 0x38, 0x03, 0xDE, 0x00, 0x1E,
  0xF0, 0x07, 0xBC, 0x00, 0x1F, 0xE0, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x78, 0x00,
  0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x01, 0xE0, 0x3E,
  0x03, 0xC0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x8F, 0x80,
  0x0F, 0x1E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x1E, 0x0F,
  0x00, 0x7C, 0x1F, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x7C,
  0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xF7,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0x9F,
  0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF8, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80,
  0x78, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x3C, 0x01, 0xE1, 0xF0,
  0x07, 0x87, 0x80, 0x1F, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x30, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1D, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x1E,
  0x00, 0x70, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x78, 0x07, 0x81,
  0xE0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x01, 0xE7, 0x80,
  0x07, 0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x07, 0x07,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0x78, 0x7E, 0x10, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0xFF, 0xF7, 0xE0, 0x7D, 0xF0, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0xFD, 0xF0, 0xEF, 0x7F, 0xFB, 0xCF, 0xFC, 0xF1, 0xFE, 0x3C,
  0x08, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0xFE, 0x0F, 0x7F, 0xE1, 0xEF, 0xFE, 0x3F,
  0xC7, 0xE7, 0xE0, 0x3E, 0xF8, 0x07, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8,
  0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1E, 0xF8, 0x07, 0xDF, 0x80, 0xFB, 0xF8,
  0x7E, 0x77, 0xFF, 0x8E, 0x7F, 0xF1, 0xC3, 0xF8, 0x00, 0x08, 0x00, 0x03,
  0xFE, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xCE, 0x3E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3F, 0x07, 0x1F,
  0xFF, 0x0F, 0xFF, 0x03, 0xFE, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x7F,
  0x8F, 0x0F, 0xFC, 0xF1, 0xFF, 0xEF, 0x3F, 0x1F, 0xF3, 0xE0, 0x7F, 0x7C,
  0x03, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x78, 0x01,
  0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF3, 0xE0, 0x3F, 0x3F, 0x0F, 0xF1, 0xFF,
  0xEF, 0x0F, 0xFC, 0xF0, 0x7F, 0x8F, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0x87, 0xC3, 0xE0, 0x78, 0x78, 0x07, 0x9E,
  0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x10, 0xFC, 0x0E, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x18, 0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC3, 0xF3, 0x0F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xCF, 0xFF, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x03,
  0xF8, 0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xF9, 0xFF, 0x3E, 0x07, 0xF3,
  0xC0, 0x3F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0x80,
  0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x3E, 0x03, 0xF3, 0xF0, 0xFF, 0x1F,
  0xFE, 0xF0, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x08, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE4, 0x00, 0x3E,
  0x30, 0x07, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC7, 0xF0, 0xF7, 0xFE, 0x3F, 0xFF, 0xCE, 0xF3, 0xFB, 0xF0,
  0x3E, 0xF8, 0x07, 0xBE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF0, 0x77, 0xFF, 0xF7, 0xB8, 0x00, 0x00, 0x1E, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0x80, 0x07, 0x07, 0xC3, 0xE1, 0xF0, 0x78, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC3, 0xE1, 0xF0, 0xF7, 0xFB, 0xFD, 0xFC, 0xF8, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x3E, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x03, 0xE3, 0xC1, 0xF0, 0xF0,
  0x78, 0x3C, 0x3E, 0x0F, 0x1F, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3D, 0xF0,
  0x0F, 0x7C, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x78, 0x0F, 0x9F, 0x03,
  0xC3, 0xC0, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC0, 0xF0, 0xF0,
  0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xFC, 0x0F, 0xE3,
  0x9F, 0xF8, 0xFF, 0xCE, 0xFF, 0xF7, 0xFF, 0xBB, 0xCF, 0xDE, 0x7F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xE0, 0x3F, 0x00, 0xFF, 0x80, 0x7C, 0x03, 0xFC, 0x01,
  0xF0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78,
  0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00,
  0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F,
  0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01, 0xE0, 0x0F, 0xF0,
  0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xFC, 0x01,
  0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00, 0x78,
  0x03, 0xC0, 0xE1, 0xFC, 0x39, 0xFF, 0xCE, 0xFF, 0xF3, 0xBC, 0xFE, 0xFC,
  0x0F, 0xBE, 0x01, 0xEF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3C, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x81, 0xF8,
  0xFC, 0x3E, 0x03, 0xC3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x1F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x1F, 0x7C, 0x01, 0xE3, 0xC0, 0x1E, 0x3E, 0x03,
  0xC1, 0xF0, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x06,
  0x00, 0xE1, 0xFC, 0x1C, 0xFF, 0xC3, 0x9F, 0xFC, 0x77, 0x8F, 0xCF, 0xC0,
  0x7D, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0xBF, 0x01, 0xF7, 0x70, 0xFC, 0xFF, 0xFF,
  0x1E, 0xFF, 0xE3, 0xC7, 0xF0, 0x78, 0x10, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8,
  0xF0, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3, 0xF1, 0xFF, 0x3E, 0x07, 0xF3, 0xC0,
  0x3F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xF7, 0x80, 0x1F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0x80, 0x1F,
  0x78, 0x01, 0xF7, 0xC0, 0x3F, 0x3E, 0x03, 0xF3, 0xF0, 0xFF, 0x1F, 0xFE,
  0xF0, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x08, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0xE1, 0xFE, 0x3F, 0xE7, 0xFE, 0xFF, 0xEE, 0x0F, 0xC0, 0xF8, 0x0F, 0x80,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x7F, 0xFD, 0xFF, 0xFB, 0xE1,
  0xEF, 0x80, 0x5E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F,
  0xF8, 0x3E, 0xFF, 0xFD, 0xFF, 0xF1, 0xFF, 0xC0, 0x10, 0x00, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xFF, 0xDF, 0xFE, 0xFF,
  0xF7, 0xFF, 0x87, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x84, 0x3F,
  0xE1, 0xFF, 0x07, 0xF8, 0x04, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x3E, 0xF0, 0x0F, 0xDF, 0x03,
  0xFB, 0xF0, 0xFF, 0x3F, 0xFD, 0xE3, 0xFF, 0x3C, 0x3F, 0xC7, 0x80, 0x80,
  0x00, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0x80, 0x1E, 0x7C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3, 0xC0, 0x3C, 0x1E, 0x03, 0xC1,
  0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x79, 0xE0, 0x07, 0x9E,
  0x00, 0x3D, 0xE0, 0x03, 0xDC, 0x00, 0x3D, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0xBC, 0x01, 0xF0, 0x07, 0x9E, 0x00, 0xF8, 0x03, 0xCF, 0x00, 0xFE,
  0x01, 0xE7, 0xC0, 0x7F, 0x01, 0xE1, 0xE0, 0x3B, 0x80, 0xF0, 0xF0, 0x1D,
  0xC0, 0x78, 0x78, 0x1E, 0xF0, 0x3C, 0x3E, 0x0F, 0x78, 0x3E, 0x0F, 0x07,
  0xBC, 0x1E, 0x07, 0x83, 0x8E, 0x0F, 0x03, 0xC3, 0xC7, 0x07, 0x81, 0xE1,
  0xE3, 0xC3, 0xC0, 0x78, 0xF1, 0xE3, 0xC0, 0x3C, 0x70, 0x71, 0xE0, 0x1E,
  0x38, 0x38, 0xF0, 0x0F, 0x3C, 0x1E, 0x78, 0x03, 0x9E, 0x0F, 0x38, 0x01,
  0xEE, 0x07, 0xBC, 0x00, 0xF7, 0x01, 0xDE, 0x00, 0x7B, 0x80, 0xEF, 0x00,
  0x3F, 0xC0, 0x77, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xF0,
  0x00, 0xF8, 0x03, 0xEF, 0x00, 0x79, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xE0,
  0xF8, 0x3C, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0xF0, 0x07, 0xBE, 0x00, 0xF7,
  0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0x8F,
  0x01, 0xF1, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0xE1, 0xE0, 0x3C, 0x78, 0x07,
  0xCF, 0x00, 0x7B, 0xC0, 0x0F, 0x80, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x1E, 0x7C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE3,
  0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F,
  0x00, 0x79, 0xE0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x1D,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xFB, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1C, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0xFF, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0xFF, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x7F, 0x01, 0xFC, 0x03,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x17, 0xFC, 0x03, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xE8, 0x03, 0xFC, 0x80, 0x02, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 6, 37, 12, 3, -36 },
  { 29, 13, 13, 19, 3, -36 },
  { 51, 24, 36, 26, 1, -36 },
  { 159, 19, 41, 24, 2, -38 },
  { 257, 32, 36, 36, 2, -36 },
  { 401, 26, 37, 28, 2, -36 },
  { 522, 5, 13, 11, 3, -36 },
  { 531, 11, 44, 15, 2, -36 },
  { 592, 11, 44, 15, 1, -36 },
  { 653, 18, 18, 22, 2, -38 },
  { 694, 20, 24, 24, 2, -30 },
  { 754, 7, 13, 12, 2, -6 },
  { 766, 11, 4, 14, 2, -15 },
  { 772, 6, 7, 12, 3, -6 },
  { 778, 17, 36, 19, 1, -36 },
  { 855, 19, 37, 24, 2, -36 },
  { 943, 13, 36, 24, 3, -36 },
  { 1002, 19, 36, 24, 2, -36 },
  { 1088, 19, 37, 24, 2, -36 },
  { 1176, 22, 36, 24, 1, -36 },
  { 1275, 18, 37, 24, 3, -36 },
  { 1359, 19, 37, 24, 2, -36 },
  { 1447, 20, 36, 24, 2, -36 },
  { 1537, 20, 37, 24, 2, -36 },
  { 1630, 19, 37, 24, 2, -36 },
  { 1718, 6, 28, 12, 3, -27 },
  { 1739, 7, 34, 12, 2, -27 },
  { 1769, 20, 23, 24, 2, -29 },
  { 1827, 20, 14, 24, 2, -25 },
  { 1862, 20, 23, 24, 2, -29 },
  { 1920, 16, 37, 18, 1, -36 },
  { 1994, 31, 40, 36, 3, -36 },
  { 2149, 25, 36, 25, 0, -36 },
  { 2262, 20, 36, 26, 4, -36 },
  { 2352, 21, 37, 25, 3, -36 },
  { 2450, 22, 36, 29, 4, -36 },
  { 2549, 16, 36, 22, 4, -36 },
  { 2621, 16, 36, 21, 4, -36 },
  { 2693, 24, 37, 30, 3, -36 },
  { 2804, 22, 36, 30, 4, -36 },
  { 2903, 11, 36, 15, 2, -36 },
  { 2953, 11, 46, 12, -3, -36 },
  { 3017, 21, 36, 25, 4, -36 },
  { 3112, 16, 36, 21, 4, -36 },
  { 3184, 31, 36, 39, 4, -36 },
  { 3324, 23, 36, 31, 4, -36 },
  { 3428, 25, 37, 31, 3, -36 },
  { 3544, 19, 36, 25, 4, -36 },
  { 3630, 25, 45, 31, 3, -36 },
  { 3771, 21, 36, 25, 4, -36 },
  { 3866, 19, 37, 23, 2, -36 },
  { 3954, 21, 36, 22, 0, -36 },
  { 4049, 22, 37, 29, 4, -36 },
  { 4151, 24, 36, 24, 0, -36 },
  { 4259, 39, 36, 39, 0, -36 },
  { 4435, 23, 36, 23, 0, -36 },
  { 4539, 22, 36, 22, 0, -36 },
  { 4638, 19, 36, 21, 1, -36 },
  { 4724, 10, 44, 16, 4, -36 },
  { 4779, 17, 36, 19, 1, -36 },
  { 4856, 11, 44, 16, 1, -36 },
  { 4917, 22, 20, 24, 1, -36 },
  { 4972, 22, 3, 22, 0, 4 },
  { 4981, 10, 8, 14, 2, -38 },
  { 4991, 18, 28, 23, 2, -27 },
  { 5054, 19, 39, 25, 4, -38 },
  { 5147, 16, 28, 19, 2, -27 },
  { 5203, 20, 39, 25, 2, -38 },
  { 5301, 19, 28, 23, 2, -27 },
  { 5368, 14, 38, 14, 1, -38 },
  { 5435, 20, 39, 25, 2, -27 },
  { 5533, 18, 38, 25, 4, -38 },
  { 5619, 5, 37, 11, 3, -37 },
  { 5643, 9, 49, 11, -1, -37 },
  { 5699, 18, 38, 22, 4, -38 },
  { 5785, 4, 38, 11, 4, -38 },
  { 5804, 30, 27, 38, 4, -27 },
  { 5906, 18, 27, 25, 4, -27 },
  { 5967, 20, 28, 25, 2, -27 },
  { 6037, 19, 39, 25, 4, -27 },
  { 6130, 20, 39, 25, 2, -27 },
  { 6228, 12, 27, 17, 4, -27 },
  { 6269, 15, 28, 19, 2, -27 },
  { 6322, 13, 34, 15, 1, -33 },
  { 6378, 19, 28, 25, 3, -27 },
  { 6445, 20, 27, 21, 0, -27 },
  { 6513, 33, 27, 33, 0, -27 },
  { 6625, 19, 27, 21, 1, -27 },
  { 6690, 20, 39, 21, 0, -27 },
  { 6788, 15, 27, 18, 1, -27 },
  { 6839, 14, 44, 18, 2, -36 },
  { 6916, 4, 50, 22, 9, -38 },
  { 6941, 15, 44, 18, 2, -36 },
  { 7024, 20, 7, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Regular50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_REGULAR50PT7B_H_
