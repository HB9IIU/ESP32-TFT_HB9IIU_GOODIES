#ifndef _NOTOSANS_CONDENSED_REGULAR10PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x32, 0xBE, 0xAF, 0xA9, 0x40, 0x27, 0xAE, 0x33, 0xB6,
  0x20, 0x69, 0x52, 0xD3, 0xD1, 0xA5, 0x49, 0x00, 0x71, 0x46, 0x18, 0x9A,
  0x67, 0xC0, 0xC0, 0x69, 0x49, 0x12, 0x20, 0xD5, 0x55, 0x80, 0x2B, 0x65,
  0x22, 0xF2, 0x20, 0x60, 0xE0, 0x80, 0x32, 0x24, 0x44, 0x80, 0x75, 0x99,
  0x95, 0x70, 0x75, 0x54, 0xF1, 0x12, 0x24, 0xF0, 0xF1, 0x16, 0x11, 0xF0,
  0x31, 0x94, 0xA9, 0x3C, 0x40, 0xF2, 0x32, 0x78, 0x74, 0xAD, 0x95, 0x70,
  0xF1, 0x12, 0x22, 0x40, 0x79, 0x56, 0x99, 0x70, 0x79, 0x97, 0x11, 0x60,
  0x88, 0x40, 0x60, 0x12, 0xC2, 0x10, 0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4,
  0xA4, 0x10, 0x7A, 0x1F, 0x75, 0xD6, 0xA8, 0x1C, 0x22, 0x94, 0xA7, 0x46,
  0x20, 0xE9, 0x9E, 0x99, 0xE0, 0xF8, 0x88, 0x88, 0x70, 0xE9, 0x99, 0x99,
  0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79, 0x20, 0x78, 0x8B, 0x99, 0x70, 0x99,
  0x9F, 0x99, 0x90, 0xE9, 0x24, 0xB8, 0x24, 0x92, 0x49, 0xC0, 0x9A, 0xCC,
  0xAA, 0x90, 0x92, 0x49, 0x38, 0x87, 0x3C, 0xF5, 0xB6, 0xDA, 0x40, 0x9D,
  0xDB, 0xB9, 0x90, 0xF4, 0xA3, 0x18, 0xC9, 0xC0, 0xE9, 0x9E, 0x88, 0x80,
  0xF4, 0xA3, 0x18, 0xC9, 0xC2, 0x10, 0xE9, 0x9E, 0xAA, 0x90, 0x78, 0x42,
  0x11, 0xF0, 0xF2, 0x22, 0x22, 0x20, 0x99, 0x99, 0x99, 0xF0, 0x8C, 0x94,
  0xA5, 0x30, 0x80, 0x91, 0x9A, 0x5A, 0x5A, 0x6A, 0x66, 0x24, 0x92, 0x98,
  0x46, 0x2A, 0x60, 0x95, 0x66, 0x22, 0x20, 0xF2, 0x22, 0x44, 0xF0, 0xEA,
  0xAA, 0xC0, 0x84, 0x44, 0x22, 0x30, 0xD5, 0x55, 0xC0, 0x22, 0x95, 0x10,
  0xF0, 0x90, 0x71, 0x79, 0x70, 0x88, 0xCA, 0x99, 0x9E, 0x78, 0x84, 0x70,
  0x11, 0x35, 0x99, 0x97, 0x79, 0xE4, 0x70, 0x29, 0xE4, 0x92, 0x79, 0x99,
  0x71, 0xF0, 0x93, 0x5B, 0x6D, 0xBE, 0x45, 0x55, 0xC0, 0x92, 0x5D, 0xAD,
  0xFF, 0xFE, 0x9A, 0x69, 0xA4, 0xF6, 0xDA, 0x79, 0x95, 0x70, 0xE9, 0x99,
  0xE8, 0x80, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0xF1, 0x9E, 0x4F, 0x24,
  0x98, 0xB6, 0xDE, 0x99, 0x66, 0x60, 0x97, 0x69, 0xB3, 0x64, 0x80, 0xD6,
  0x66, 0x90, 0x95, 0x66, 0x24, 0xC0, 0xE5, 0x2E, 0x29, 0x2C, 0x92, 0x20,
  0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 4, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 7, 7, 7, 0, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 1, 2, 2, 1, -7 },
  { 27, 3, 9, 3, 0, -7 },
  { 31, 2, 9, 3, 0, -7 },
  { 34, 4, 4, 4, 0, -8 },
  { 36, 4, 5, 5, 0, -6 },
  { 39, 2, 2, 2, 0, -1 },
  { 40, 3, 1, 3, 0, -3 },
  { 41, 1, 1, 2, 1, -1 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 5, 0, -7 },
  { 50, 2, 7, 5, 1, -7 },
  { 52, 4, 7, 5, 0, -7 },
  { 56, 4, 7, 5, 0, -7 },
  { 60, 5, 7, 5, 0, -7 },
  { 65, 3, 7, 5, 1, -7 },
  { 68, 4, 7, 5, 0, -7 },
  { 72, 4, 7, 5, 0, -7 },
  { 76, 4, 7, 5, 0, -7 },
  { 80, 4, 7, 5, 0, -7 },
  { 84, 1, 5, 2, 1, -5 },
  { 85, 2, 6, 2, 0, -5 },
  { 87, 4, 5, 5, 0, -6 },
  { 90, 4, 3, 5, 0, -5 },
  { 92, 4, 5, 5, 0, -6 },
  { 95, 3, 7, 4, 0, -7 },
  { 98, 6, 8, 7, 1, -7 },
  { 104, 5, 7, 5, 0, -7 },
  { 109, 4, 7, 5, 1, -7 },
  { 113, 4, 7, 5, 1, -7 },
  { 117, 4, 7, 6, 1, -7 },
  { 121, 3, 7, 4, 1, -7 },
  { 124, 3, 7, 4, 1, -7 },
  { 127, 4, 7, 6, 1, -7 },
  { 131, 4, 7, 6, 1, -7 },
  { 135, 3, 7, 3, 0, -7 },
  { 138, 3, 9, 2, -1, -7 },
  { 142, 4, 7, 5, 1, -7 },
  { 146, 3, 7, 4, 1, -7 },
  { 149, 6, 7, 8, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 5, 7, 6, 1, -7 },
  { 164, 4, 7, 5, 1, -7 },
  { 168, 5, 9, 6, 1, -7 },
  { 174, 4, 7, 5, 1, -7 },
  { 178, 4, 7, 5, 0, -7 },
  { 182, 4, 7, 4, 0, -7 },
  { 186, 4, 7, 6, 1, -7 },
  { 190, 5, 7, 5, 0, -7 },
  { 195, 8, 7, 8, 0, -7 },
  { 202, 5, 7, 5, 0, -7 },
  { 207, 4, 7, 4, 0, -7 },
  { 211, 4, 7, 4, 0, -7 },
  { 215, 2, 9, 3, 1, -7 },
  { 218, 4, 7, 4, 0, -7 },
  { 222, 2, 9, 3, 0, -7 },
  { 225, 5, 4, 5, 0, -7 },
  { 228, 4, 1, 4, 0, 1 },
  { 229, 2, 2, 3, 0, -8 },
  { 230, 4, 5, 5, 0, -5 },
  { 233, 4, 8, 5, 1, -8 },
  { 237, 4, 5, 4, 0, -5 },
  { 240, 4, 8, 5, 0, -8 },
  { 244, 4, 5, 5, 0, -5 },
  { 247, 3, 8, 3, 0, -8 },
  { 250, 4, 7, 5, 0, -5 },
  { 254, 3, 8, 5, 1, -8 },
  { 257, 1, 7, 2, 1, -7 },
  { 258, 2, 9, 2, 0, -7 },
  { 261, 3, 8, 4, 1, -8 },
  { 264, 1, 8, 2, 1, -8 },
  { 265, 6, 5, 8, 1, -5 },
  { 269, 3, 5, 5, 1, -5 },
  { 271, 4, 5, 5, 0, -5 },
  { 274, 4, 7, 5, 1, -5 },
  { 278, 4, 7, 5, 0, -5 },
  { 282, 2, 5, 3, 1, -5 },
  { 284, 3, 5, 4, 0, -5 },
  { 286, 3, 7, 3, 0, -7 },
  { 289, 3, 5, 5, 1, -5 },
  { 291, 4, 5, 4, 0, -5 },
  { 294, 7, 5, 7, 0, -5 },
  { 299, 4, 5, 4, 0, -5 },
  { 302, 4, 7, 4, 0, -5 },
  { 306, 3, 5, 4, 0, -5 },
  { 308, 3, 9, 4, 0, -7 },
  { 312, 1, 10, 4, 2, -8 },
  { 314, 3, 9, 4, 0, -7 },
  { 318, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Regular10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_REGULAR10PT7B_H_
