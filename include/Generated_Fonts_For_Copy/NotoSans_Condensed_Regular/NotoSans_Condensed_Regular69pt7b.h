#ifndef _NOTOSANS_CONDENSED_REGULAR69PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7C, 0x70, 0xFE, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0x7E, 0x07, 0xEF, 0xC0, 0xFC, 0xF8, 0x0F, 0x9F,
  0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E,
  0x03, 0xE7, 0xC0, 0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x03,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF0, 0x0F,
  0x80, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3E, 0x01,
  0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFB, 0xFC, 0x3F, 0x8F, 0x03, 0x87, 0xE1, 0xE0, 0x10, 0xF8,
  0x3C, 0x00, 0x3F, 0x07, 0x80, 0x07, 0xE0, 0xF0, 0x00, 0xF8, 0x1E, 0x00,
  0x1F, 0x83, 0xC0, 0x03, 0xF0, 0x78, 0x00, 0x7E, 0x0F, 0x00, 0x07, 0xE1,
  0xE0, 0x00, 0xFE, 0x3C, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xF1, 0xFC, 0x00, 0x1E, 0x1F, 0xC0, 0x03, 0xC1, 0xF8, 0x00, 0x78,
  0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x0F, 0xC0,
  0x07, 0x81, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0xD8, 0x03, 0xC3,
  0xFB, 0xE0, 0x78, 0xFE, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x1E, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xC0, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x00,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x7C,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x3C, 0x0F,
  0x80, 0x00, 0xF8, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC1, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x7C, 0x1F, 0xC1, 0xF0, 0x1F, 0x0F, 0x87, 0xFC, 0x1E, 0x03,
  0xE3, 0xE1, 0xFF, 0xC3, 0xC0, 0x78, 0x7C, 0x7F, 0xFC, 0x7C, 0x1F, 0x0F,
  0x0F, 0x8F, 0x87, 0x83, 0xE3, 0xE3, 0xE0, 0xF8, 0xFC, 0xF8, 0x7C, 0x7C,
  0x1F, 0x0F, 0xFF, 0x1F, 0x0F, 0x01, 0xF1, 0xFF, 0xC3, 0xE3, 0xE0, 0x3E,
  0x1F, 0xF0, 0xF8, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xC1, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x07, 0x80, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x00, 0x1E, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x7C, 0x00, 0x3E,
  0x00, 0x78, 0x0F, 0x80, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x7C, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x0F,
  0xC0, 0xFE, 0xFE, 0x00, 0xFC, 0x1F, 0xC7, 0xF0, 0x0F, 0xC1, 0xF8, 0x3F,
  0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0x87, 0xF0, 0x1F, 0xC1, 0xF8, 0x7E,
  0x00, 0xFE, 0x1F, 0x87, 0xE0, 0x07, 0xF1, 0xF0, 0x7E, 0x00, 0x3F, 0x3F,
  0x07, 0xE0, 0x03, 0xFB, 0xF0, 0xFC, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x00,
  0xFF, 0xE0, 0x7C, 0x00, 0x0F, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x7E,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x0F, 0xFC,
  0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0x03, 0xFF, 0xFF,
  0xF3, 0xF8, 0x1F, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xC1, 0xFC, 0x07,
  0xFF, 0xF8, 0x0F, 0xE0, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF7, 0xEF, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x60, 0x3C, 0x03, 0x7E,
  0x1E, 0x1F, 0xBF, 0xEF, 0x7F, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFB, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF0, 0x07, 0x00,
  0xE0, 0x00, 0x80, 0x20, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x8F, 0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7E, 0x7E, 0x3F,
  0x1F, 0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xF0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0x7E, 0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF8, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x87, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x81,
  0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3F, 0xF8, 0x3F,
  0xFC, 0x3F, 0xFE, 0x3F, 0xBF, 0x3F, 0x9F, 0xBF, 0x8F, 0xFF, 0x87, 0xEF,
  0x83, 0xF3, 0x81, 0xF8, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xE0, 0xFF, 0x87, 0xE0, 0x0F, 0xF0, 0xE0, 0x01, 0xFC, 0x10,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0x87,
  0xC0, 0x07, 0xF0, 0xC0, 0x00, 0xFC, 0x20, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFA,
  0x00, 0x01, 0xFE, 0xF0, 0x00, 0xFF, 0x3F, 0xC1, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x01, 0xE7, 0xE0, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x7E,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80,
  0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80,
  0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x30, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xA0, 0x00, 0x3F,
  0x9C, 0x00, 0x7F, 0xCF, 0xF3, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xFC, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0x07, 0xC3, 0xFF, 0x80, 0xF9, 0xFF,
  0xF8, 0x3F, 0x7F, 0xFF, 0x87, 0xEF, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x1F,
  0xF0, 0x07, 0xF3, 0xFC, 0x00, 0x7E, 0x7F, 0x80, 0x07, 0xEF, 0xE0, 0x00,
  0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7E,
  0x0F, 0xE0, 0x1F, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xE3, 0xF0,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xE0, 0x7E, 0x01, 0xFC,
  0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0x1F, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xE0, 0x07, 0xF9, 0xFE, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x00,
  0xFE, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xE7, 0xF0, 0x03, 0xF8, 0x7F, 0xC1, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xB8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x0F, 0xE1,
  0xFC, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xCF, 0xC0, 0x01,
  0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0xCF, 0xE0,
  0x1F, 0xF3, 0xFC, 0x1F, 0xFC, 0x7F, 0xFF, 0xBF, 0x0F, 0xFF, 0xEF, 0xC1,
  0xFF, 0xF3, 0xF0, 0x3F, 0xF0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x0F, 0x1F, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E,
  0x18, 0x1F, 0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x7E, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE1, 0xF8, 0x7E, 0x3F, 0x0F,
  0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x78, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF1, 0xF8, 0x3F, 0xE7, 0x00, 0x3F, 0x88, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x07, 0xFC, 0x03, 0xE1, 0xF0, 0x03, 0xFF, 0xE0, 0x3C, 0x3E,
  0x01, 0xFF, 0xFC, 0x07, 0xCF, 0x80, 0x7F, 0xFF, 0x80, 0xF9, 0xF0, 0x0F,
  0xC1, 0xF0, 0x1F, 0x3E, 0x03, 0xF0, 0x3E, 0x01, 0xE7, 0x80, 0x7C, 0x07,
  0xC0, 0x3D, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xBE, 0x03, 0xE0, 0x1F, 0x00,
  0xFF, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xFE,
  0x03, 0xE0, 0x0F, 0x80, 0x7F, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0xF8, 0x0F,
  0x80, 0x3E, 0x01, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x3E, 0x00,
  0xF8, 0x07, 0xBC, 0x07, 0xC0, 0x1F, 0x00, 0xF7, 0x80, 0xF8, 0x07, 0xE0,
  0x1E, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xDE, 0x03, 0xE0, 0x1F, 0x80, 0xFB,
  0xC0, 0x7C, 0x03, 0xF0, 0x1E, 0x7C, 0x07, 0xC0, 0xFE, 0x07, 0xCF, 0x80,
  0xF8, 0x1D, 0xC0, 0xF9, 0xF0, 0x1F, 0x87, 0xBC, 0x3E, 0x3E, 0x01, 0xFF,
  0xE7, 0xFF, 0xC7, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0, 0x7C, 0x01, 0xFF, 0x07,
  0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xF0, 0x01, 0xFF, 0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFE,
  0xF8, 0x00, 0x1F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0xFE, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x1F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xE3, 0xE0, 0x03, 0xFE, 0x7C, 0x00, 0x1F, 0xEF, 0x80, 0x01, 0xFD, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0xFF, 0x7C, 0x00,
  0x7F, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xC3, 0xF8, 0x1F, 0xE0, 0x03, 0x81, 0xFE, 0x00, 0x04,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x06, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0x80,
  0x07, 0xFC, 0x3E, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x0F, 0xE3, 0xE0, 0x00,
  0x1F, 0xCF, 0x80, 0x00, 0x7F, 0x3E, 0x00, 0x00, 0xFE, 0xF8, 0x00, 0x03,
  0xFB, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0xFE, 0xF8, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x7F, 0x3E, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x1F, 0xE3, 0xE0, 0x00,
  0xFF, 0x0F, 0x80, 0x0F, 0xF8, 0x3E, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFE, 0x0F, 0xF8, 0x1F,
  0xF0, 0x00, 0x78, 0x0F, 0xF0, 0x00, 0x0C, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x03, 0xF0,
  0x7F, 0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x83, 0xFD, 0xFF, 0xF3,
  0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xF7,
  0xC0, 0x00, 0x7F, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x03, 0xF8, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x1F,
  0xC0, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00, 0xFE, 0x01,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xE0,
  0x3F, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xC1, 0xF8,
  0x00, 0x3E, 0x1F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x7C, 0xFE, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x1F, 0x7F, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xEF, 0xC0, 0x01, 0xFE, 0x7F,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xE0, 0x3F, 0x00,
  0x1F, 0x01, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xFE, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x7C, 0x00,
  0x7E, 0x03, 0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7F,
  0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x3F, 0x8F,
  0x80, 0x01, 0xFC, 0x7C, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0xFE, 0xF8, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xDF, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xBE, 0x00, 0x00, 0x3E,
  0xFF, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0xF9, 0xF0, 0x00, 0x07, 0xEF, 0xFE,
  0x7C, 0x00, 0x01, 0xF3, 0xFF, 0x9F, 0x80, 0x00, 0x7C, 0xFF, 0xE3, 0xE0,
  0x00, 0x1F, 0x3F, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0xFE, 0x3F, 0x00, 0x03,
  0xE3, 0xFF, 0x87, 0xC0, 0x00, 0xF8, 0xFF, 0xE1, 0xF0, 0x00, 0x7C, 0x3F,
  0xF8, 0x7E, 0x00, 0x1F, 0x0F, 0xFE, 0x1F, 0x80, 0x07, 0xC3, 0xFF, 0x83,
  0xE0, 0x03, 0xE0, 0xFF, 0xE0, 0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0x3F, 0x00,
  0x3E, 0x0F, 0xFE, 0x07, 0xC0, 0x1F, 0x83, 0xFF, 0x81, 0xF0, 0x07, 0xC0,
  0xFF, 0xE0, 0x7E, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xFE,
  0x03, 0xE0, 0x3E, 0x03, 0xFF, 0x80, 0xFC, 0x0F, 0x80, 0xFF, 0xE0, 0x1F,
  0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0xFE, 0x01, 0xF8, 0x7C,
  0x03, 0xFF, 0x80, 0x7E, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0x8F, 0x80, 0x3F,
  0xF8, 0x03, 0xF3, 0xE0, 0x0F, 0xFE, 0x00, 0xFC, 0xF8, 0x03, 0xFF, 0x80,
  0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x07, 0xDF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFB, 0xF0, 0x00, 0x3F, 0xFB, 0xF0, 0x00, 0x3F, 0xF9, 0xF8, 0x00,
  0x3F, 0xF9, 0xF8, 0x00, 0x3F, 0xF8, 0xFC, 0x00, 0x3F, 0xF8, 0xFC, 0x00,
  0x3F, 0xF8, 0x7E, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x3F, 0xF8, 0x3F, 0x00,
  0x3F, 0xF8, 0x3F, 0x00, 0x3F, 0xF8, 0x1F, 0x80, 0x3F, 0xF8, 0x1F, 0x80,
  0x3F, 0xF8, 0x0F, 0xC0, 0x3F, 0xF8, 0x0F, 0xC0, 0x3F, 0xF8, 0x07, 0xE0,
  0x3F, 0xF8, 0x07, 0xE0, 0x3F, 0xF8, 0x03, 0xF0, 0x3F, 0xF8, 0x03, 0xF0,
  0x3F, 0xF8, 0x01, 0xF8, 0x3F, 0xF8, 0x01, 0xF8, 0x3F, 0xF8, 0x00, 0xFC,
  0x3F, 0xF8, 0x00, 0xFC, 0x3F, 0xF8, 0x00, 0x7E, 0x3F, 0xF8, 0x00, 0x7E,
  0x3F, 0xF8, 0x00, 0x3F, 0x3F, 0xF8, 0x00, 0x3F, 0x3F, 0xF8, 0x00, 0x1F,
  0xBF, 0xF8, 0x00, 0x1F, 0xBF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFE, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0B, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xE7, 0xC0, 0x1F, 0xF3, 0xE0, 0x03, 0xFD, 0xF0, 0x00, 0xFE, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFB, 0xE0, 0x03, 0xFD, 0xF0, 0x03, 0xFC,
  0xF8, 0x1F, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x3F, 0xF8, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0x80, 0x3F, 0xE0,
  0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x00, 0x3F, 0x8F, 0x80,
  0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F,
  0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80,
  0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xFC,
  0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8,
  0x00, 0x7F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x01,
  0xF8, 0xF8, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFC, 0x00, 0xE1, 0xFC, 0x00, 0x08, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE8,
  0x00, 0x03, 0xF3, 0x00, 0x01, 0xFC, 0xF8, 0x01, 0xFE, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x7F, 0x0F, 0xF8, 0x03, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7E, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF7, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xCF, 0x80,
  0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF3, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x0F, 0x8F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x0F,
  0x80, 0x7E, 0x00, 0x3E, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x07,
  0xC0, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x01, 0xF0,
  0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0,
  0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x03, 0xE3, 0xF0, 0x00,
  0x0F, 0xCF, 0x80, 0x07, 0xCF, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0x3E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xE0,
  0x7F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0x81, 0xFE, 0x0C, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x3F, 0xE0, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x07, 0xDF, 0x7F, 0xFF, 0x9F, 0x3F, 0xFF,
  0x9F, 0x1F, 0xFF, 0x1F, 0x0F, 0xFC, 0x0F, 0x01, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x01, 0xC0,
  0x07, 0xE1, 0xFF, 0x80, 0xFC, 0xFF, 0xF8, 0x1F, 0xBF, 0xFF, 0x83, 0xE7,
  0xFF, 0xF8, 0x7D, 0xF8, 0xFF, 0x8F, 0xF8, 0x07, 0xF1, 0xFE, 0x00, 0x7F,
  0x3F, 0xC0, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7F,
  0x00, 0x07, 0xEF, 0xF0, 0x01, 0xF9, 0xFE, 0x00, 0x7F, 0x3F, 0xE0, 0x1F,
  0xC7, 0xDF, 0x07, 0xF8, 0xFB, 0xFF, 0xFE, 0x1F, 0x3F, 0xFF, 0x83, 0xE3,
  0xFF, 0xE0, 0x7C, 0x1F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3F,
  0xE7, 0xE1, 0xFC, 0x01, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x0C, 0x7F, 0xE1, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0x81, 0xF8,
  0x0F, 0xFC, 0x3F, 0x03, 0xFF, 0xE7, 0xE0, 0xFF, 0xFE, 0x7C, 0x3F, 0xFF,
  0xEF, 0x8F, 0xF8, 0xFD, 0xF1, 0xFC, 0x03, 0xFE, 0x7F, 0x00, 0x3F, 0xCF,
  0xC0, 0x07, 0xFB, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x80,
  0x07, 0xF3, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0xC7, 0xF0, 0x0F, 0xF8,
  0xFF, 0x07, 0xDF, 0x0F, 0xFF, 0xFB, 0xE0, 0xFF, 0xFE, 0x7C, 0x0F, 0xFF,
  0x8F, 0x80, 0xFF, 0xC1, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC,
  0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x02, 0x1F, 0xC0, 0x03, 0x03, 0xFE, 0x0F, 0xC0, 0x7F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x3F, 0x86, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x7C, 0x0F,
  0xFF, 0x8F, 0x83, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xBE, 0x3F, 0xE3, 0xF7,
  0xC7, 0xF0, 0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xEF, 0xE0,
  0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03,
  0xF9, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xE3, 0xFE, 0x1F, 0x7C, 0x3F,
  0xFF, 0xCF, 0x83, 0xFF, 0xF9, 0xF0, 0x3F, 0xFE, 0x3E, 0x03, 0xFF, 0x0F,
  0xC0, 0x0F, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF1, 0x00, 0x00, 0xFE, 0x3C, 0x00,
  0x7F, 0x87, 0xFC, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x1C, 0x01, 0xF8, 0x7F, 0xE0,
  0xFC, 0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0x3E, 0xFF, 0xFF, 0x9F, 0x7F, 0x3F,
  0xEF, 0xF8, 0x07, 0xF7, 0xF8, 0x01, 0xFB, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xF0, 0x3C, 0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x9E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF,
  0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB,
  0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xFC,
  0x07, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xFB, 0xFF, 0xDF, 0xFC, 0xFF, 0xE7,
  0xFE, 0x3F, 0xE0, 0x10, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0x7E,
  0x1F, 0xC0, 0x3F, 0x0F, 0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC0, 0x07,
  0xE7, 0xE0, 0x03, 0xE7, 0xF0, 0x01, 0xF7, 0xF8, 0x00, 0xFB, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xEF, 0xC0, 0x1F, 0xE7, 0xE0, 0x0F, 0xE1, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x7E, 0x03, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7F, 0x0F, 0xC0,
  0x1F, 0x87, 0xE0, 0x0F, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0xFC,
  0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x1F, 0x07, 0xFC, 0x01,
  0xFF, 0x83, 0xE3, 0xFF, 0xE0, 0xFF, 0xF8, 0x7C, 0xFF, 0xFE, 0x3F, 0xFF,
  0x8F, 0xBF, 0xFF, 0xCF, 0xFF, 0xF9, 0xF7, 0xE7, 0xFD, 0xF0, 0xFF, 0x3F,
  0xE0, 0x3F, 0xF8, 0x07, 0xF7, 0xF8, 0x03, 0xFE, 0x00, 0x7E, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xDF, 0xC0, 0x07, 0xF0, 0x01, 0xFB, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xEF, 0xC0, 0x03, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xFF,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x03,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0,
  0x01, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0xF8, 0x3E, 0x3F,
  0xFF, 0x1F, 0x3F, 0xFF, 0xCF, 0xBF, 0xFF, 0xE7, 0xDF, 0x8F, 0xFB, 0xFE,
  0x01, 0xFD, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0x0F, 0xF0,
  0x1F, 0xC0, 0x3F, 0x83, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0x80, 0xFF,
  0x9F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0x07, 0xFE, 0x03, 0xE3, 0xFF, 0xE0, 0x7C, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF,
  0xE1, 0xF7, 0xC1, 0xFE, 0x3F, 0xE0, 0x1F, 0xE7, 0xF8, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0x9F, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD, 0xFC, 0x00,
  0x3F, 0xBF, 0xC0, 0x07, 0xE7, 0xF8, 0x01, 0xFC, 0xFF, 0x80, 0x7F, 0x1F,
  0x7E, 0x3F, 0xE3, 0xE7, 0xFF, 0xF8, 0x7C, 0xFF, 0xFE, 0x0F, 0xCF, 0xFF,
  0x81, 0xF8, 0x7F, 0xE0, 0x3F, 0x01, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF0, 0x7C, 0x0F, 0xFF, 0x8F,
  0x83, 0xFF, 0xF9, 0xF0, 0xFF, 0xFF, 0xBE, 0x3F, 0xE3, 0xF7, 0xC7, 0xF0,
  0x0F, 0xF9, 0xFC, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xEF, 0xE0, 0x01, 0xFD,
  0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF9, 0xFC,
  0x00, 0xFF, 0x1F, 0xC0, 0x3F, 0xE3, 0xFE, 0x3F, 0x7C, 0x3F, 0xFF, 0xCF,
  0x83, 0xFF, 0xF9, 0xF0, 0x3F, 0xFE, 0x7E, 0x03, 0xFF, 0x0F, 0xC0, 0x0F,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x7E, 0x0F,
  0xEF, 0x87, 0xFB, 0xE3, 0xFE, 0xF9, 0xFF, 0xBE, 0xFF, 0xEF, 0xBE, 0x03,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F,
  0x81, 0xF3, 0xF8, 0x01, 0x9F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0xE0, 0x07,
  0xF7, 0xE0, 0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0xFF, 0x9F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF8, 0xC1, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x07,
  0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x01, 0xFE, 0xFE, 0x03, 0xFF, 0x7F, 0xCF, 0xEF, 0x9F, 0xFF, 0xE7, 0xCF,
  0xFF, 0xF3, 0xE3, 0xFF, 0xF1, 0xF0, 0x7F, 0xE0, 0xF8, 0x03, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xF8, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x01,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00,
  0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0,
  0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x7F, 0xC0,
  0x07, 0xE7, 0xE0, 0x07, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0xC0, 0x07,
  0xC7, 0xE0, 0x07, 0xBE, 0x00, 0xFC, 0x3E, 0x00, 0x7B, 0xE0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xBE, 0x00, 0xFC, 0x3F, 0x00, 0xF9, 0xE0, 0x0F, 0x83, 0xF0,
  0x0F, 0x9F, 0x00, 0xF8, 0x1F, 0x00, 0xF9, 0xF0, 0x1F, 0x81, 0xF0, 0x1F,
  0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF1, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0x0F, 0x81, 0xF0, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x0F, 0x83,
  0xF0, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x0F, 0xC3, 0xE0,
  0x0F, 0xC3, 0xE0, 0x7C, 0x3E, 0x00, 0x7C, 0x7C, 0x07, 0xC7, 0xE0, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x00, 0x7E, 0x7C, 0x07, 0xC7, 0xC0, 0x07, 0xE7,
  0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80,
  0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x03, 0xEF, 0x80, 0x3E,
  0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xEF, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xC1,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x03,
  0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x00,
  0x3F, 0x87, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07,
  0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xFF,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x11, 0xFF, 0x80, 0x01, 0x3F, 0xFE, 0x00, 0x37, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xEC, 0x00,
  0x1F, 0xFC, 0x80, 0x00, 0x7F, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 7, 50, 17, 5, -49 },
  { 45, 19, 18, 27, 4, -49 },
  { 88, 33, 49, 36, 1, -49 },
  { 291, 27, 56, 33, 3, -52 },
  { 480, 43, 51, 49, 3, -50 },
  { 755, 36, 51, 38, 2, -50 },
  { 985, 7, 18, 15, 4, -49 },
  { 1001, 15, 61, 20, 3, -50 },
  { 1116, 15, 61, 20, 2, -50 },
  { 1231, 25, 26, 31, 3, -53 },
  { 1313, 28, 33, 33, 2, -41 },
  { 1429, 9, 17, 16, 3, -8 },
  { 1449, 16, 5, 20, 2, -21 },
  { 1459, 8, 9, 16, 4, -8 },
  { 1468, 24, 49, 26, 1, -49 },
  { 1615, 27, 51, 33, 3, -50 },
  { 1788, 17, 49, 33, 5, -49 },
  { 1893, 26, 50, 33, 3, -50 },
  { 2056, 26, 51, 33, 3, -50 },
  { 2222, 30, 50, 33, 1, -50 },
  { 2410, 25, 50, 33, 4, -49 },
  { 2567, 27, 51, 33, 3, -50 },
  { 2740, 28, 49, 33, 2, -49 },
  { 2912, 27, 51, 33, 3, -50 },
  { 3085, 26, 51, 33, 3, -50 },
  { 3251, 8, 38, 17, 4, -37 },
  { 3289, 10, 46, 17, 2, -37 },
  { 3347, 28, 32, 33, 2, -41 },
  { 3459, 27, 19, 33, 3, -34 },
  { 3524, 28, 32, 33, 2, -41 },
  { 3636, 22, 51, 24, 1, -50 },
  { 3777, 43, 56, 50, 4, -50 },
  { 4078, 35, 49, 35, 0, -49 },
  { 4293, 27, 49, 37, 6, -49 },
  { 4459, 29, 51, 35, 4, -50 },
  { 4644, 30, 49, 40, 6, -49 },
  { 4828, 22, 49, 31, 6, -49 },
  { 4963, 22, 49, 29, 6, -49 },
  { 5098, 33, 51, 41, 4, -50 },
  { 5309, 30, 49, 41, 6, -49 },
  { 5493, 16, 49, 21, 2, -49 },
  { 5591, 15, 62, 16, -4, -49 },
  { 5708, 29, 49, 34, 6, -49 },
  { 5886, 21, 49, 29, 6, -49 },
  { 6015, 42, 49, 53, 6, -49 },
  { 6273, 32, 49, 43, 6, -49 },
  { 6469, 35, 51, 43, 4, -50 },
  { 6693, 25, 49, 34, 6, -49 },
  { 6847, 35, 62, 43, 4, -50 },
  { 7119, 28, 49, 35, 6, -49 },
  { 7291, 26, 51, 31, 3, -50 },
  { 7457, 28, 49, 30, 1, -49 },
  { 7629, 30, 50, 40, 5, -49 },
  { 7817, 34, 49, 34, 0, -49 },
  { 8026, 54, 49, 54, 0, -49 },
  { 8357, 31, 49, 31, 0, -49 },
  { 8547, 31, 49, 31, 0, -49 },
  { 8737, 26, 49, 29, 2, -49 },
  { 8897, 15, 61, 22, 5, -50 },
  { 9012, 24, 49, 26, 1, -49 },
  { 9159, 15, 61, 22, 2, -50 },
  { 9274, 30, 27, 33, 2, -49 },
  { 9376, 30, 4, 30, 0, 6 },
  { 9391, 13, 11, 19, 3, -53 },
  { 9409, 24, 39, 32, 3, -38 },
  { 9526, 27, 53, 35, 5, -52 },
  { 9705, 22, 39, 27, 3, -38 },
  { 9813, 27, 53, 35, 3, -52 },
  { 9992, 26, 39, 32, 3, -38 },
  { 10119, 20, 53, 19, 1, -53 },
  { 10252, 27, 55, 35, 3, -38 },
  { 10438, 25, 52, 35, 5, -52 },
  { 10601, 7, 51, 16, 4, -51 },
  { 10646, 13, 68, 16, -2, -51 },
  { 10757, 25, 52, 30, 5, -52 },
  { 10920, 6, 52, 15, 5, -52 },
  { 10959, 43, 38, 52, 5, -38 },
  { 11164, 25, 38, 35, 5, -38 },
  { 11283, 28, 39, 34, 3, -38 },
  { 11420, 27, 55, 35, 5, -38 },
  { 11606, 27, 55, 35, 3, -38 },
  { 11792, 18, 38, 23, 5, -38 },
  { 11878, 21, 39, 26, 3, -38 },
  { 11981, 18, 46, 20, 1, -45 },
  { 12085, 25, 38, 35, 5, -37 },
  { 12204, 28, 37, 28, 0, -37 },
  { 12334, 44, 37, 45, 1, -37 },
  { 12538, 27, 37, 29, 1, -37 },
  { 12663, 28, 54, 28, 0, -37 },
  { 12852, 21, 37, 24, 2, -37 },
  { 12950, 20, 60, 25, 3, -49 },
  { 13100, 5, 69, 31, 13, -53 },
  { 13144, 20, 60, 25, 3, -49 },
  { 13294, 28, 9, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_Regular69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_REGULAR69PT7B_H_
