#ifndef _NOTOSANS_CONDENSED_REGULAR33PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF7, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F,
  0xFF, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8D, 0xC6, 0x63, 0x00,
  0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x63, 0x81, 0xC6, 0x03,
  0x0C, 0x3F, 0xFF, 0x7F, 0xFE, 0x18, 0x60, 0x30, 0xC0, 0x63, 0x81, 0xC6,
  0x03, 0x0C, 0x06, 0x18, 0x7F, 0xFF, 0xFF, 0xFE, 0x30, 0xC0, 0x63, 0x81,
  0xC6, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x03, 0xFF, 0x7F, 0xEF, 0x66, 0xC6, 0x0C, 0x60, 0xC6, 0x0C, 0x60,
  0xE6, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x6F, 0x06, 0x70, 0x63,
  0x06, 0x70, 0x67, 0xC6, 0xEF, 0xFE, 0xFF, 0x80, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x1C, 0x03, 0x81, 0xF0, 0x18, 0x1D, 0xC0, 0xC0, 0xC6, 0x0C,
  0x06, 0x30, 0x60, 0x71, 0xC7, 0x03, 0x8E, 0x30, 0x1C, 0x71, 0x80, 0xE3,
  0x98, 0x03, 0x1C, 0xC0, 0x18, 0xCE, 0x78, 0xC6, 0x67, 0xE7, 0x77, 0x73,
  0x9F, 0x33, 0x0C, 0x71, 0x98, 0x60, 0x1C, 0xC3, 0x00, 0xC6, 0x18, 0x0E,
  0x30, 0xC0, 0x61, 0x86, 0x03, 0x0C, 0x30, 0x30, 0x61, 0x81, 0x81, 0x98,
  0x1C, 0x0F, 0xC0, 0xC0, 0x3C, 0x07, 0x80, 0x0F, 0xE0, 0x07, 0x78, 0x07,
  0x1C, 0x03, 0x86, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x1C, 0xC0,
  0x0E, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xDC, 0x39, 0xC7,
  0x1C, 0xE1, 0xCE, 0xE0, 0xFE, 0x70, 0x3F, 0x38, 0x0F, 0x1C, 0x07, 0x87,
  0x07, 0xE3, 0xC7, 0xF0, 0xFF, 0x9C, 0x3F, 0x8F, 0xFF, 0xFF, 0xFF, 0x60,
  0x0E, 0x38, 0x61, 0xC3, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x86, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x87, 0x0E, 0x1C, 0x18, 0x38, 0x70, 0x70, 0xE0,
  0xE0, 0xE0, 0xE0, 0xC1, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x0C, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38,
  0x70, 0xC3, 0x8E, 0x00, 0x07, 0x00, 0x70, 0x06, 0x08, 0x61, 0x76, 0xFF,
  0xFF, 0x07, 0x00, 0xF8, 0x1D, 0x81, 0x9C, 0x38, 0xE1, 0x08, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x39,
  0xDC, 0xE7, 0x31, 0x9C, 0xFF, 0xFC, 0x6F, 0xFF, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0x01, 0xC0, 0x38, 0x06, 0x00, 0x07, 0x80, 0xFE, 0x0F, 0xF8, 0x70, 0xE7,
  0x07, 0x38, 0x19, 0xC0, 0xEE, 0x07, 0x60, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xEC, 0x07, 0x60, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0xE3, 0x87, 0x1E, 0x70, 0x7F, 0x81, 0xF8, 0x03, 0x07, 0x0F, 0x1F,
  0x7B, 0xF3, 0x63, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x0F, 0x81, 0xFE, 0x3F,
  0xF8, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0x83, 0xFF, 0x3F, 0xF8, 0xC0, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x3F, 0x01, 0xFC, 0x00, 0xF8, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x70, 0x7B, 0xFF,
  0x8F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x60, 0x0D,
  0x80, 0x66, 0x03, 0x98, 0x0C, 0x60, 0x71, 0x81, 0x86, 0x0E, 0x18, 0x30,
  0x61, 0xC1, 0x86, 0x06, 0x38, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE6, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0x8F, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x80, 0xEC, 0x1E, 0xFF, 0xCF, 0xF0, 0x07, 0xE0, 0xFE, 0x3F,
  0xE3, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x78, 0xDF,
  0xCD, 0xFE, 0xF0, 0xEE, 0x07, 0xE0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0x70, 0xE7, 0x9E, 0x3F, 0xC1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x0F,
  0x80, 0xFF, 0x0F, 0x7C, 0xE0, 0xE7, 0x03, 0xB8, 0x1D, 0xC0, 0xEE, 0x06,
  0x30, 0x71, 0xE7, 0x07, 0xF0, 0x1F, 0x01, 0xFC, 0x1E, 0xF1, 0xC1, 0xCE,
  0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x77, 0x03, 0xBC, 0x38, 0xFF,
  0xC3, 0xF8, 0x0F, 0x80, 0xFE, 0x0F, 0xF8, 0xE0, 0xE7, 0x07, 0x30, 0x1B,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0xF7, 0x8F, 0x9F,
  0xFC, 0x7E, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E,
  0x21, 0xE0, 0xFE, 0x07, 0xE0, 0x6F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x6F, 0xFF, 0x33, 0xDE, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7,
  0x73, 0x9C, 0xC6, 0x70, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x70, 0x02, 0x00, 0x00, 0x1F, 0x1F, 0xF1,
  0xFF, 0x20, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xE0, 0x0F,
  0x8F, 0x81, 0xE0, 0x1C, 0x38, 0x00, 0xC3, 0x00, 0x0E, 0x70, 0x00, 0x66,
  0x0F, 0xC7, 0x61, 0xFC, 0x3E, 0x38, 0xC3, 0xC3, 0x0C, 0x3C, 0x70, 0xC3,
  0xC7, 0x0C, 0x3C, 0x70, 0xC3, 0xC7, 0x0C, 0x3C, 0x70, 0xC3, 0xC7, 0x1C,
  0x3C, 0x31, 0x46, 0xC3, 0xF7, 0xEE, 0x1E, 0x3C, 0x60, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x0E, 0x00, 0xFF, 0xE0, 0x01,
  0xF8, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x36,
  0x00, 0x3B, 0x00, 0x1D, 0xC0, 0x0C, 0xE0, 0x0E, 0x30, 0x07, 0x1C, 0x03,
  0x8E, 0x01, 0x87, 0x01, 0xC1, 0x80, 0xE0, 0xE0, 0x7F, 0xF0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x1C, 0x07, 0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x73, 0x80,
  0x3B, 0x80, 0x1D, 0xC0, 0x07, 0xFC, 0x07, 0xFE, 0x3F, 0xF9, 0x81, 0xEC,
  0x07, 0x60, 0x3B, 0x00, 0xD8, 0x0E, 0xC0, 0x76, 0x03, 0xBF, 0xF9, 0xFF,
  0x0F, 0xFE, 0x60, 0x7B, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x07, 0x61, 0xFB, 0xFF, 0x9F, 0xF0, 0x03, 0xF0, 0x3F, 0xF1,
  0xFF, 0x8F, 0x02, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF8, 0x61, 0xFF,
  0x81, 0xFE, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x30, 0x3C, 0xC0, 0x7B, 0x00,
  0xEC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xB0,
  0x1E, 0xC0, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x01, 0xF8, 0x0F, 0xFF,
  0x1F, 0xFE, 0x3C, 0x06, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7F, 0xE0, 0x7F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x07,
  0x3C, 0x07, 0x3E, 0x0F, 0x0F, 0xFF, 0x07, 0xFE, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x1C, 0x3C, 0xFF, 0xDF, 0x00, 0xC0, 0x3B, 0x01, 0xEC, 0x07, 0x30, 0x38,
  0xC1, 0xE3, 0x07, 0x0C, 0x38, 0x30, 0xE0, 0xC7, 0x03, 0x38, 0x0C, 0xE0,
  0x37, 0x80, 0xFE, 0x03, 0xDC, 0x0E, 0x70, 0x30, 0xE0, 0xC3, 0x83, 0x07,
  0x0C, 0x1E, 0x30, 0x38, 0xC0, 0xF3, 0x01, 0xCC, 0x03, 0xB0, 0x0F, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFD, 0x80, 0x3F, 0xDC, 0x03, 0x7D, 0xC0,
  0x37, 0xCC, 0x07, 0x7C, 0xE0, 0x77, 0xCE, 0x06, 0x7C, 0x60, 0xE7, 0xC6,
  0x0E, 0x7C, 0x70, 0xC7, 0xC3, 0x1C, 0x7C, 0x31, 0xC7, 0xC3, 0x98, 0x7C,
  0x39, 0x87, 0xC1, 0xB8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x07,
  0xC0, 0xE0, 0x7C, 0x0E, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFB, 0x81, 0xF7, 0x03, 0xE7, 0x07, 0xCE, 0x0F, 0x8E, 0x1F,
  0x1C, 0x3E, 0x18, 0x7C, 0x38, 0xF8, 0x31, 0xF0, 0x73, 0xE0, 0xE7, 0xC0,
  0xEF, 0x81, 0xDF, 0x01, 0xFE, 0x03, 0xBC, 0x03, 0xF8, 0x07, 0xF0, 0x07,
  0xE0, 0x0F, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07, 0x03, 0xC7, 0x00,
  0xE3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0E,
  0xE0, 0x07, 0x70, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x81, 0xE1, 0xF1,
  0xE0, 0x7F, 0xE0, 0x0F, 0xE0, 0xF8, 0x0F, 0xF8, 0xFF, 0xCC, 0x1E, 0xC0,
  0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xFC, 0x1E, 0xFF,
  0xCF, 0xF8, 0xFE, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0x07,
  0x03, 0xC7, 0x00, 0xE3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3,
  0x81, 0xE1, 0xF1, 0xE0, 0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x78, 0xF8, 0x07, 0xFC,
  0x3F, 0xF9, 0x83, 0xCC, 0x0F, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0, 0x76,
  0x03, 0xB0, 0x39, 0x83, 0xCF, 0xFC, 0x7F, 0x83, 0x0E, 0x18, 0x70, 0xC1,
  0xC6, 0x0E, 0x30, 0x39, 0x81, 0xCC, 0x07, 0x60, 0x3B, 0x01, 0xF8, 0x07,
  0x07, 0xC0, 0xFF, 0x8F, 0xFC, 0xF0, 0x27, 0x00, 0x38, 0x01, 0x80, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE8, 0x07, 0x78, 0xFB,
  0xFF, 0x8F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0x80, 0x3B, 0x80, 0xE7, 0x01,
  0xC7, 0x8F, 0x8F, 0xFE, 0x07, 0xF0, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x1C, 0x1C, 0x18, 0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x38, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1C, 0x01, 0xF8, 0x07, 0x00,
  0xE7, 0x01, 0xE0, 0x39, 0xC0, 0x78, 0x0E, 0x70, 0x1E, 0x03, 0x9C, 0x0F,
  0x80, 0xC3, 0x03, 0xF0, 0x70, 0xE0, 0xDC, 0x1C, 0x38, 0x33, 0x07, 0x0E,
  0x1C, 0xC1, 0xC3, 0x87, 0x38, 0x60, 0x61, 0xCE, 0x38, 0x1C, 0x61, 0x8E,
  0x07, 0x18, 0x63, 0x81, 0xCE, 0x1C, 0xC0, 0x33, 0x87, 0x70, 0x0E, 0xC1,
  0xDC, 0x03, 0xB0, 0x37, 0x00, 0xFC, 0x0D, 0xC0, 0x1F, 0x03, 0x60, 0x07,
  0x80, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x01, 0xC0,
  0x70, 0x1E, 0xE0, 0x38, 0xE0, 0x71, 0xC1, 0xC1, 0xC3, 0x83, 0x8E, 0x03,
  0x1C, 0x07, 0x70, 0x06, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0xF8, 0x01, 0xB0, 0x07, 0x70, 0x0E, 0x60, 0x38, 0xE0, 0x71, 0xC1,
  0xC1, 0xC3, 0x83, 0x8E, 0x03, 0x9C, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0xC0,
  0x39, 0xC0, 0x73, 0x81, 0xC3, 0x83, 0x87, 0x07, 0x0E, 0x1C, 0x0E, 0x38,
  0x1C, 0x60, 0x1D, 0xC0, 0x3B, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xC0,
  0x1C, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0xFF, 0xFF, 0xF8, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x03, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xE0, 0x0D, 0xC0, 0x33, 0x01, 0xCE, 0x06, 0x18,
  0x38, 0x70, 0xC0, 0xC7, 0x03, 0x98, 0x06, 0xE0, 0x1F, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x0F, 0x83, 0xFE, 0x38,
  0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x3F, 0x1F, 0xF7, 0xC7, 0x70,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xF7, 0x1F, 0x7F, 0xB3, 0xF3, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xF8,
  0xEF, 0xE7, 0xEF, 0xBC, 0x1D, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x3B, 0xE1,
  0xDD, 0xFC, 0xE7, 0xC0, 0x0F, 0x8F, 0xF7, 0xD9, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xE1,
  0x3F, 0xC7, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x31, 0xF3, 0x3F, 0xB7, 0xBF, 0xF0, 0xFE, 0x07, 0xE0, 0x7E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x07,
  0x70, 0xF7, 0xFB, 0x3F, 0x30, 0x1F, 0x03, 0xFC, 0x79, 0xC6, 0x0E, 0xE0,
  0x6E, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x07, 0x86, 0x3F, 0xE1, 0xFE, 0x07, 0xC3, 0xF1, 0xC4,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xFE, 0xFF, 0xBF, 0xE1, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x00, 0x1F, 0x33, 0xFB, 0x79, 0xFF, 0x0F, 0xE0, 0x7E,
  0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7E,
  0x07, 0xE0, 0x77, 0x0F, 0x7F, 0xB3, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x07, 0x80, 0xF7, 0xBE, 0x7F, 0xC3, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x7C, 0xEF, 0xEF, 0xDF, 0xF0, 0x7F,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x71, 0xC0, 0x00, 0x01, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1F, 0xFF, 0xBC, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38,
  0xE7, 0x0E, 0x60, 0xEE, 0x0F, 0xE0, 0xFF, 0x0F, 0x30, 0xE3, 0x8E, 0x18,
  0xE1, 0xCE, 0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE7, 0xC3, 0xC7, 0x7F, 0x7F, 0xBF,
  0x7B, 0xBD, 0xE0, 0xF0, 0xEF, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0,
  0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x1C, 0x0F, 0xC0,
  0xE0, 0x7E, 0x07, 0x03, 0xF0, 0x38, 0x1F, 0x81, 0xC0, 0xFC, 0x0E, 0x07,
  0xE0, 0x70, 0x3F, 0x03, 0x81, 0xC0, 0xE7, 0xCE, 0xFE, 0xFC, 0xFF, 0x07,
  0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x1F, 0x81, 0xFE,
  0x1E, 0x78, 0xE0, 0xEE, 0x07, 0x70, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0x70, 0x3B, 0x81, 0xCE, 0x1C, 0x3F,
  0xE0, 0xFC, 0x00, 0xE7, 0xC7, 0x7F, 0x3F, 0x3D, 0xE0, 0xEF, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF8, 0x1F, 0xC1, 0xDF, 0x1E, 0xEF, 0xE7, 0x3E, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x1F, 0x33,
  0xFB, 0x7B, 0xFF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0F, 0x7F, 0xB3,
  0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0xE7, 0xF7, 0xFF, 0xDF, 0x0F, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00, 0x1F, 0x9F,
  0xF7, 0x1F, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0x00, 0xC0, 0x30, 0x1F, 0x07, 0xFF, 0x9F, 0xC0, 0x30, 0x30, 0x30,
  0x30, 0x7F, 0xFF, 0xFF, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x70, 0x38, 0x3F, 0x1F, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0F, 0x7F, 0xB3, 0xF3, 0xE0, 0x1F,
  0x80, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x70, 0xC1, 0xC3, 0x87, 0x0E, 0x18,
  0x38, 0xE0, 0x63, 0x81, 0xCE, 0x07, 0x30, 0x0D, 0xC0, 0x37, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x70, 0x1B, 0x03, 0xC1, 0xDC,
  0x1E, 0x0E, 0xE0, 0xF0, 0x77, 0x0F, 0x83, 0x18, 0x6E, 0x18, 0xC3, 0x71,
  0xC7, 0x19, 0x8E, 0x39, 0xCC, 0x71, 0xCE, 0x73, 0x06, 0x63, 0xB8, 0x3B,
  0x0D, 0xC1, 0xD8, 0x6E, 0x0F, 0xC3, 0x60, 0x3C, 0x1F, 0x01, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x1C, 0x00, 0x70, 0x3B, 0x81, 0xCE, 0x1C, 0x70,
  0xC1, 0xCE, 0x06, 0x60, 0x3F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1F, 0x81, 0xCC, 0x0E, 0x70, 0xE1, 0xC7, 0x0E, 0x70, 0x3F, 0x81, 0xC0,
  0xE0, 0x1F, 0x80, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x70, 0xC1, 0xC3, 0x87,
  0x0E, 0x18, 0x18, 0xE0, 0x73, 0x81, 0xCE, 0x03, 0x30, 0x0D, 0xC0, 0x3F,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0xF0,
  0x7C, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x0F, 0x0F, 0x03, 0xE0, 0x1C, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0xF0, 0x1F, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC0,
  0x3E, 0x0F, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0E, 0x03, 0xC0, 0x3C, 0x1F, 0x0E, 0x03, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x03, 0xC3, 0xE0, 0xF0, 0x00,
  0x38, 0x0B, 0xF8, 0x7F, 0xFF, 0x07, 0xF8, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 9, 9, 13, 2, -24 },
  { 24, 15, 24, 17, 1, -24 },
  { 69, 12, 27, 16, 2, -25 },
  { 110, 21, 24, 24, 1, -24 },
  { 173, 17, 24, 18, 1, -24 },
  { 224, 3, 9, 7, 2, -24 },
  { 228, 7, 29, 10, 2, -24 },
  { 254, 7, 29, 10, 1, -24 },
  { 280, 12, 12, 15, 1, -25 },
  { 298, 13, 15, 16, 1, -19 },
  { 323, 5, 8, 8, 1, -4 },
  { 328, 7, 2, 10, 1, -10 },
  { 330, 4, 4, 8, 2, -4 },
  { 332, 11, 24, 12, 1, -24 },
  { 365, 13, 24, 16, 1, -24 },
  { 404, 8, 24, 16, 2, -24 },
  { 428, 13, 24, 16, 1, -24 },
  { 467, 13, 24, 16, 1, -24 },
  { 506, 14, 24, 16, 1, -24 },
  { 548, 12, 24, 16, 2, -24 },
  { 584, 12, 24, 16, 2, -24 },
  { 620, 13, 24, 16, 1, -24 },
  { 659, 13, 24, 16, 1, -24 },
  { 698, 13, 24, 16, 1, -24 },
  { 737, 4, 18, 8, 2, -18 },
  { 746, 5, 22, 8, 1, -18 },
  { 760, 13, 15, 16, 1, -19 },
  { 785, 13, 9, 16, 1, -16 },
  { 800, 13, 15, 16, 1, -19 },
  { 825, 11, 24, 12, 0, -24 },
  { 858, 20, 27, 24, 2, -24 },
  { 926, 17, 24, 17, 0, -24 },
  { 977, 13, 24, 17, 3, -24 },
  { 1016, 14, 24, 17, 2, -24 },
  { 1058, 14, 24, 19, 3, -24 },
  { 1100, 10, 24, 15, 3, -24 },
  { 1130, 10, 24, 14, 3, -24 },
  { 1160, 16, 24, 20, 2, -24 },
  { 1208, 14, 24, 20, 3, -24 },
  { 1250, 8, 24, 10, 1, -24 },
  { 1274, 7, 30, 8, -2, -24 },
  { 1301, 14, 24, 16, 3, -24 },
  { 1343, 10, 24, 14, 3, -24 },
  { 1373, 20, 24, 26, 3, -24 },
  { 1433, 15, 24, 21, 3, -24 },
  { 1478, 17, 24, 20, 2, -24 },
  { 1529, 12, 24, 16, 3, -24 },
  { 1565, 17, 30, 20, 2, -24 },
  { 1629, 13, 24, 17, 3, -24 },
  { 1668, 13, 24, 15, 1, -24 },
  { 1707, 14, 24, 14, 0, -24 },
  { 1749, 15, 24, 19, 2, -24 },
  { 1794, 16, 24, 16, 0, -24 },
  { 1842, 26, 24, 26, 0, -24 },
  { 1920, 15, 24, 15, 0, -24 },
  { 1965, 15, 24, 15, 0, -24 },
  { 2010, 12, 24, 14, 1, -24 },
  { 2046, 8, 29, 10, 2, -24 },
  { 2075, 11, 24, 12, 1, -24 },
  { 2108, 7, 29, 10, 1, -24 },
  { 2134, 14, 14, 16, 1, -24 },
  { 2159, 15, 2, 14, 0, 3 },
  { 2163, 7, 5, 9, 1, -25 },
  { 2168, 12, 18, 15, 1, -18 },
  { 2195, 13, 25, 17, 2, -25 },
  { 2236, 10, 18, 13, 2, -18 },
  { 2259, 12, 25, 17, 2, -25 },
  { 2297, 12, 18, 15, 2, -18 },
  { 2324, 10, 25, 9, 0, -25 },
  { 2356, 12, 26, 17, 2, -18 },
  { 2395, 12, 25, 17, 2, -25 },
  { 2433, 3, 24, 7, 2, -24 },
  { 2442, 6, 32, 7, -1, -24 },
  { 2466, 12, 25, 14, 2, -25 },
  { 2504, 3, 25, 7, 2, -25 },
  { 2514, 21, 18, 25, 2, -18 },
  { 2562, 12, 18, 17, 2, -18 },
  { 2589, 13, 18, 16, 2, -18 },
  { 2619, 13, 26, 17, 2, -18 },
  { 2662, 12, 26, 17, 2, -18 },
  { 2701, 9, 18, 11, 2, -18 },
  { 2722, 10, 18, 13, 1, -18 },
  { 2745, 8, 22, 10, 1, -22 },
  { 2767, 12, 18, 17, 2, -18 },
  { 2794, 14, 18, 14, 0, -18 },
  { 2826, 21, 18, 22, 0, -18 },
  { 2874, 13, 18, 14, 0, -18 },
  { 2904, 14, 26, 14, 0, -18 },
  { 2950, 10, 18, 12, 1, -18 },
  { 2973, 10, 29, 12, 1, -24 },
  { 3010, 3, 33, 15, 6, -25 },
  { 3023, 10, 29, 12, 1, -24 },
  { 3060, 13, 5, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Regular33pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular33pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular33pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _NOTOSANS_CONDENSED_REGULAR33PT7B_H_
