#ifndef _NOTOSANS_CONDENSED_REGULAR29PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xB6, 0x90, 0x03, 0xFE, 0xC7, 0xC6, 0xC6,
  0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x18, 0xC0,
  0xC6, 0x06, 0x33, 0xFF, 0xFF, 0xFF, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x31,
  0x81, 0x8C, 0x7F, 0xFF, 0xFF, 0xE6, 0x30, 0x31, 0x81, 0x8C, 0x0C, 0x60,
  0x63, 0x02, 0x18, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x1F, 0xF7, 0xFE, 0xCC,
  0x39, 0x87, 0x30, 0xE6, 0x0E, 0xC0, 0xF8, 0x0F, 0xC0, 0x7C, 0x0D, 0xC1,
  0x98, 0x33, 0x06, 0x70, 0xDF, 0xFF, 0x7F, 0xC0, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x3C, 0x0E, 0x1F, 0x03, 0x06, 0x60, 0xC3, 0x18, 0x60, 0xC6, 0x18,
  0x31, 0xCC, 0x0C, 0x33, 0x03, 0x1C, 0xC0, 0xC6, 0x63, 0x11, 0x9B, 0xE6,
  0x6C, 0xCD, 0xF3, 0x63, 0x3C, 0xD8, 0xC0, 0x66, 0x30, 0x19, 0x8C, 0x0C,
  0x63, 0x03, 0x18, 0xC1, 0xC6, 0x30, 0x60, 0xCC, 0x18, 0x3F, 0x0C, 0x07,
  0x80, 0x0F, 0x00, 0x3F, 0x00, 0xE7, 0x01, 0x8E, 0x03, 0x1C, 0x06, 0x38,
  0x0C, 0x60, 0x1D, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xF8, 0x67,
  0x39, 0xDC, 0x73, 0xB8, 0x76, 0x70, 0x7C, 0xE0, 0x71, 0xC0, 0xE1, 0xC7,
  0xE3, 0xFE, 0xE3, 0xF0, 0xE0, 0xFF, 0xFF, 0x0E, 0x18, 0x61, 0xC3, 0x06,
  0x1C, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0xC1, 0x83,
  0x83, 0x06, 0x0E, 0x0C, 0x0C, 0x1C, 0xC1, 0x87, 0x0C, 0x38, 0xE1, 0x87,
  0x1C, 0x70, 0xC3, 0x0C, 0x30, 0xC3, 0x1C, 0x71, 0x86, 0x38, 0xC3, 0x18,
  0x63, 0x00, 0x0E, 0x01, 0xC0, 0x30, 0x62, 0x2F, 0xFE, 0xFF, 0x87, 0x80,
  0xD8, 0x3B, 0x8E, 0x38, 0x44, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x77, 0x76, 0x6C, 0xC0, 0xFF, 0xF0, 0xFF, 0x80, 0x00,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80,
  0xE0, 0x00, 0x0F, 0x07, 0xF0, 0xE7, 0x38, 0x66, 0x0E, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1B, 0x03,
  0x60, 0xEE, 0x1D, 0xC7, 0x1F, 0xC1, 0xF0, 0x06, 0x1C, 0x7B, 0xBE, 0x68,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0x1F, 0x0F, 0xF3, 0xC7, 0x20, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x0E, 0x01, 0x80, 0x7F, 0xFF, 0xFE, 0x1F, 0x0F, 0xF3, 0x87, 0x20,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC3, 0xE0, 0x7C, 0x03, 0xE0,
  0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1E, 0x07, 0x7F, 0xEF, 0xF0,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0xDC, 0x0D, 0xC1, 0x9C,
  0x19, 0xC3, 0x1C, 0x31, 0xC6, 0x1C, 0x61, 0xCC, 0x1C, 0xFF, 0xFF, 0xFF,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0xBF, 0xEF, 0xFB,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFC, 0x3F, 0xCC, 0x78, 0x07, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x78, 0x3B, 0xFC, 0xFE, 0x00, 0x07,
  0xC1, 0xF8, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x6F, 0x9F,
  0xFB, 0xC3, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1B, 0x03, 0x60, 0x6E, 0x1C,
  0xE3, 0x9F, 0xE1, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x00,
  0x1F, 0x03, 0xFC, 0x71, 0xE6, 0x0E, 0x60, 0x66, 0x06, 0x60, 0xE7, 0x0C,
  0x39, 0xC1, 0xF8, 0x1F, 0x03, 0xBC, 0x71, 0xC6, 0x0E, 0xE0, 0x6E, 0x07,
  0xE0, 0x7E, 0x06, 0x70, 0xE7, 0xFC, 0x3F, 0x80, 0x1F, 0x07, 0xF1, 0xC7,
  0x30, 0x6E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x1D, 0xC3, 0xBF,
  0xB3, 0xF6, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x0E, 0x3F, 0x87,
  0xE0, 0x5F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x27, 0x77, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x76, 0x66, 0xCC, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E,
  0x07, 0x80, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x00, 0xC0, 0x00, 0x3E, 0x3F, 0xE6,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x30,
  0x1C, 0x06, 0x01, 0x80, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x38, 0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x18,
  0x60, 0x01, 0x8C, 0x3E, 0x33, 0x0F, 0xC6, 0x63, 0x18, 0x4C, 0x63, 0x0D,
  0x9C, 0x61, 0xE3, 0x0C, 0x3C, 0x61, 0x8D, 0x8C, 0x31, 0x99, 0xC6, 0x33,
  0x19, 0xE6, 0x63, 0xEF, 0x8C, 0x18, 0xE1, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0x80, 0x00, 0x1E, 0x38, 0x01, 0xFF, 0x00, 0x03, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x6C, 0x01, 0xD8, 0x03, 0x38, 0x06, 0x70, 0x0C, 0x60,
  0x38, 0xC0, 0x61, 0xC0, 0xC1, 0x83, 0xFF, 0x07, 0xFF, 0x0F, 0xFE, 0x18,
  0x0C, 0x70, 0x18, 0xE0, 0x39, 0x80, 0x77, 0x00, 0x6E, 0x00, 0xE0, 0xFF,
  0x0F, 0xFC, 0xE3, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x6E, 0x06, 0xE0,
  0xEF, 0xFC, 0xFF, 0x8E, 0x1E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0x80, 0x07, 0xC1, 0xFF, 0x3C, 0x67,
  0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x23,
  0xFE, 0x0F, 0xE0, 0xFE, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x03, 0xB8, 0x79, 0xFF, 0x8F,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3F, 0xEF, 0xFB, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFB, 0xFE, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0xE3,
  0xC3, 0x9E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x07,
  0x60, 0x1D, 0xC0, 0x73, 0x81, 0xC7, 0xFF, 0x0F, 0xF8, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0x80, 0xFF, 0xFC, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE7, 0xEF, 0xE0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86,
  0xFD, 0xF1, 0x80, 0xE0, 0x77, 0x03, 0x38, 0x39, 0xC3, 0x8E, 0x18, 0x71,
  0xC3, 0x8C, 0x1C, 0xC0, 0xEE, 0x07, 0x60, 0x3F, 0x81, 0xEC, 0x0E, 0x70,
  0x71, 0x83, 0x8E, 0x1C, 0x38, 0xE1, 0xC7, 0x07, 0x38, 0x39, 0xC0, 0xEE,
  0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF8, 0x06, 0xFF, 0x01, 0xBE, 0xC0, 0x6F, 0xB0, 0x3B, 0xEC,
  0x0C, 0xF9, 0x83, 0x3E, 0x61, 0xCF, 0x98, 0x63, 0xE7, 0x18, 0xF8, 0xCE,
  0x3E, 0x33, 0x0F, 0x8E, 0xC3, 0xE1, 0xB0, 0xF8, 0x78, 0x3E, 0x1E, 0x0F,
  0x83, 0x83, 0xE0, 0xC0, 0xC0, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03,
  0xD8, 0x0F, 0xF0, 0x3E, 0xC0, 0xFB, 0x83, 0xE6, 0x0F, 0x9C, 0x3E, 0x30,
  0xF8, 0xE3, 0xE1, 0x8F, 0x87, 0x3E, 0x0C, 0xF8, 0x3B, 0xE0, 0x6F, 0x81,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1C, 0x0F, 0xC0, 0xFF, 0x83, 0x8F, 0x1C,
  0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0, 0x1D,
  0xC0, 0xE7, 0x87, 0x0F, 0xFC, 0x0F, 0xC0, 0xFC, 0x1F, 0xF3, 0x9F, 0x70,
  0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0xFC, 0x1F, 0x8F, 0x7F, 0xCF,
  0xE1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00,
  0x0F, 0xC0, 0xFF, 0x83, 0x8F, 0x1C, 0x0E, 0xE0, 0x1B, 0x80, 0x7E, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xE7, 0x87, 0x8F, 0xFC, 0x0F,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0xFE, 0x0F,
  0xF8, 0xFF, 0xCE, 0x0E, 0xE0, 0xEE, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0xEE,
  0x1C, 0xFF, 0xCF, 0xF0, 0xE3, 0x0E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE,
  0x0E, 0xE0, 0xEE, 0x07, 0xE0, 0x70, 0x1F, 0x87, 0xFD, 0xE3, 0x30, 0x0E,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0x07, 0x7F, 0xCF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x01,
  0x9C, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0xE0, 0x0F, 0x80, 0x76, 0x01, 0xD8,
  0x06, 0x70, 0x39, 0xC0, 0xE3, 0x03, 0x0C, 0x0C, 0x38, 0x70, 0x61, 0xC1,
  0x86, 0x07, 0x18, 0x1C, 0xE0, 0x33, 0x80, 0xCC, 0x03, 0xB0, 0x0F, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xC0, 0x70,
  0x19, 0x80, 0xE0, 0x73, 0x03, 0xC0, 0xE7, 0x07, 0x81, 0xCE, 0x0D, 0x83,
  0x0C, 0x1B, 0x06, 0x18, 0x76, 0x1C, 0x30, 0xCC, 0x38, 0x71, 0x9C, 0x60,
  0xE3, 0x18, 0xC0, 0xC6, 0x31, 0x81, 0x9C, 0x67, 0x03, 0xB0, 0xEE, 0x07,
  0x60, 0xD8, 0x06, 0xC1, 0xB0, 0x0D, 0x83, 0x60, 0x1E, 0x07, 0xC0, 0x3C,
  0x0F, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x60, 0x3B, 0x81, 0x8C,
  0x1C, 0x70, 0xC1, 0x8E, 0x0E, 0x60, 0x37, 0x01, 0xB0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0F, 0x00, 0xF8, 0x06, 0xE0, 0x73, 0x03, 0x1C, 0x38, 0xE1,
  0x83, 0x1C, 0x1C, 0xC0, 0x6E, 0x03, 0x80, 0xE0, 0x3F, 0x01, 0x98, 0x1C,
  0xE0, 0xE3, 0x06, 0x1C, 0x70, 0x63, 0x03, 0x38, 0x1D, 0xC0, 0x6C, 0x03,
  0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x00, 0xE0,
  0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0,
  0x70, 0x0E, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0xE0, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x06, 0x00, 0x60, 0x0F, 0x00, 0xF0,
  0x19, 0x81, 0x98, 0x31, 0xC3, 0x0C, 0x60, 0xE6, 0x06, 0xE0, 0x7C, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x87, 0x1F, 0x1F, 0xE3, 0x1C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0xFF, 0x7C, 0xD8, 0x3E, 0x0F, 0x83, 0xE1, 0xF8,
  0x77, 0xFC, 0xFB, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x31,
  0xC6, 0xFE, 0xF9, 0xDC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xF8, 0x6D, 0xFD, 0x9F, 0x00, 0x0F, 0xC7,
  0xE3, 0x89, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0x80, 0x70, 0x1C, 0x13, 0xF8, 0x7E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0E, 0x73, 0xFF, 0x79, 0xF7, 0x0F, 0x60, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x60, 0x77, 0x0F,
  0x3F, 0xF1, 0xF3, 0x0F, 0x07, 0xF0, 0xE7, 0x38, 0x76, 0x0E, 0xC0, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x4F, 0xF8,
  0xFE, 0x0F, 0x8F, 0xC6, 0x03, 0x03, 0x81, 0xC0, 0xFD, 0xFE, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x0E, 0x33, 0xFB, 0x39, 0xF7, 0x0F, 0x60, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x60, 0x77, 0x0F, 0x3F,
  0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x61, 0xE7, 0xFC, 0x3F,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x31, 0xC6, 0xFE,
  0xF9, 0xDC, 0x1B, 0x83, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xC0, 0xFF, 0x01, 0xB6, 0xDB,
  0x6D, 0xB6, 0xDB, 0x6C, 0x1C, 0x71, 0x80, 0x00, 0x61, 0x86, 0x18, 0x61,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0xEF,
  0xBC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x36, 0x0C,
  0xC3, 0x98, 0xE3, 0x18, 0x67, 0x0D, 0xC1, 0xB8, 0x3F, 0x87, 0x30, 0xC7,
  0x18, 0x63, 0x0E, 0x60, 0xCC, 0x1D, 0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xCF, 0x0F, 0x37, 0xE7, 0xEF, 0x3F, 0x3F, 0x87, 0x87, 0xE0,
  0xE1, 0xF8, 0x30, 0x3E, 0x0C, 0x0F, 0x83, 0x03, 0xC0, 0xC0, 0xF0, 0x30,
  0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F,
  0x03, 0x03, 0xC7, 0x1B, 0xFB, 0xE7, 0x70, 0x6E, 0x0F, 0xC1, 0xF8, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x0F, 0x03, 0xFC, 0x39, 0xE7, 0x06, 0x60, 0x66, 0x07, 0xE0, 0x7E, 0x03,
  0xE0, 0x3E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0x67, 0x0E, 0x3F, 0xC1, 0xF8,
  0xC7, 0x1B, 0xFB, 0xC7, 0x70, 0x7E, 0x0F, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xE1, 0xB7, 0xF6, 0x7C, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x33, 0xFB, 0x39,
  0xF7, 0x0F, 0x60, 0x76, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x76, 0x07, 0x60, 0x77, 0x0F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xC7, 0xBF, 0x7F, 0x8E, 0x1C,
  0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x1E, 0x3F, 0xF8,
  0x5C, 0x0C, 0x07, 0x01, 0xC0, 0x78, 0x1F, 0x03, 0x80, 0xE0, 0x30, 0x1C,
  0x1F, 0xFD, 0xFC, 0x18, 0x18, 0x38, 0x3F, 0xFF, 0x38, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1F, 0x1F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7E, 0x0F, 0xC3, 0xDF, 0xF9, 0xF3, 0xE0, 0x7E, 0x07, 0x60,
  0x66, 0x06, 0x70, 0xE3, 0x0C, 0x30, 0xC3, 0x1C, 0x39, 0xC1, 0x98, 0x19,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0xE0, 0xE0, 0xEC, 0x1C,
  0x1D, 0x83, 0x83, 0x30, 0xD8, 0x67, 0x1B, 0x0C, 0xE3, 0x63, 0x8C, 0x6C,
  0x61, 0x8D, 0xCC, 0x3B, 0x19, 0x87, 0x63, 0x70, 0x6C, 0x6C, 0x0D, 0x8D,
  0x81, 0xA0, 0xF0, 0x3C, 0x1E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x60, 0x77,
  0x0E, 0x30, 0xC3, 0x9C, 0x19, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x81, 0x98, 0x39, 0xC3, 0x0C, 0x70, 0xEE, 0x07, 0xE0, 0x7E,
  0x07, 0x60, 0x66, 0x06, 0x70, 0xE3, 0x0C, 0x30, 0xC3, 0x9C, 0x19, 0xC1,
  0x98, 0x19, 0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x0F, 0x80, 0xF0, 0x00, 0xFF, 0xFF, 0x03,
  0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xFF,
  0xFF, 0x03, 0x87, 0xC3, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x06, 0x07, 0x0F, 0x07, 0x80, 0xE0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x1E, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xC0, 0x78, 0x0E, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0x78, 0x3C, 0x30, 0x38,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0xF0, 0xF0, 0x60, 0x00,
  0x7C, 0x1F, 0xF7, 0x87, 0xE8, 0x1C,
};

const GFXglyph NotoSans_Condensed_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 8, 8, 11, 2, -21 },
  { 17, 13, 21, 15, 1, -21 },
  { 52, 11, 24, 14, 1, -22 },
  { 85, 18, 21, 21, 1, -21 },
  { 133, 15, 21, 16, 1, -21 },
  { 173, 2, 8, 6, 2, -21 },
  { 175, 7, 26, 9, 1, -21 },
  { 198, 6, 26, 9, 1, -21 },
  { 218, 11, 11, 13, 1, -22 },
  { 234, 12, 14, 14, 1, -17 },
  { 255, 4, 7, 7, 1, -3 },
  { 259, 6, 2, 8, 1, -9 },
  { 261, 3, 3, 7, 2, -3 },
  { 263, 10, 21, 11, 0, -21 },
  { 290, 11, 21, 14, 1, -21 },
  { 319, 7, 21, 14, 2, -21 },
  { 338, 11, 21, 14, 1, -21 },
  { 367, 11, 21, 14, 1, -21 },
  { 396, 12, 21, 14, 1, -21 },
  { 428, 10, 21, 14, 2, -21 },
  { 455, 11, 21, 14, 1, -21 },
  { 484, 12, 21, 14, 1, -21 },
  { 516, 12, 21, 14, 1, -21 },
  { 548, 11, 21, 14, 1, -21 },
  { 577, 3, 16, 7, 2, -16 },
  { 583, 4, 20, 7, 1, -16 },
  { 593, 12, 13, 14, 1, -17 },
  { 613, 12, 8, 14, 1, -14 },
  { 625, 12, 13, 14, 1, -17 },
  { 645, 10, 21, 10, 0, -21 },
  { 672, 19, 23, 21, 1, -21 },
  { 727, 15, 21, 15, 0, -21 },
  { 767, 12, 21, 15, 2, -21 },
  { 799, 12, 21, 15, 2, -21 },
  { 831, 13, 21, 17, 2, -21 },
  { 866, 10, 21, 13, 2, -21 },
  { 893, 10, 21, 12, 2, -21 },
  { 920, 14, 21, 17, 2, -21 },
  { 957, 13, 21, 17, 2, -21 },
  { 992, 7, 21, 9, 1, -21 },
  { 1011, 7, 27, 7, -2, -21 },
  { 1035, 13, 21, 14, 2, -21 },
  { 1070, 10, 21, 12, 2, -21 },
  { 1097, 18, 21, 22, 2, -21 },
  { 1145, 14, 21, 18, 2, -21 },
  { 1182, 14, 21, 18, 2, -21 },
  { 1219, 11, 21, 14, 2, -21 },
  { 1248, 14, 26, 18, 2, -21 },
  { 1294, 12, 21, 15, 2, -21 },
  { 1326, 11, 21, 13, 1, -21 },
  { 1355, 12, 21, 13, 0, -21 },
  { 1387, 13, 21, 17, 2, -21 },
  { 1422, 14, 21, 14, 0, -21 },
  { 1459, 23, 21, 23, 0, -21 },
  { 1520, 13, 21, 13, 0, -21 },
  { 1555, 13, 21, 13, 0, -21 },
  { 1590, 11, 21, 12, 1, -21 },
  { 1619, 6, 26, 9, 2, -21 },
  { 1639, 10, 21, 11, 0, -21 },
  { 1666, 6, 26, 9, 1, -21 },
  { 1686, 12, 12, 14, 1, -21 },
  { 1704, 13, 2, 13, 0, 2 },
  { 1708, 6, 4, 8, 1, -22 },
  { 1711, 10, 16, 13, 1, -16 },
  { 1731, 11, 22, 15, 2, -22 },
  { 1762, 10, 16, 11, 1, -16 },
  { 1782, 12, 22, 15, 1, -22 },
  { 1815, 11, 16, 13, 1, -16 },
  { 1837, 9, 22, 8, 0, -22 },
  { 1862, 12, 23, 15, 1, -16 },
  { 1897, 11, 22, 15, 2, -22 },
  { 1928, 3, 21, 7, 2, -21 },
  { 1936, 6, 28, 7, -1, -21 },
  { 1957, 11, 22, 13, 2, -22 },
  { 1988, 2, 22, 7, 2, -22 },
  { 1994, 18, 16, 22, 2, -16 },
  { 2030, 11, 16, 15, 2, -16 },
  { 2052, 12, 16, 14, 1, -16 },
  { 2076, 11, 23, 15, 2, -16 },
  { 2108, 12, 23, 15, 1, -16 },
  { 2143, 7, 16, 10, 2, -16 },
  { 2157, 9, 16, 11, 1, -16 },
  { 2175, 8, 19, 8, 0, -19 },
  { 2194, 11, 16, 15, 2, -16 },
  { 2216, 12, 16, 12, 0, -16 },
  { 2240, 19, 16, 19, 0, -16 },
  { 2278, 12, 16, 12, 0, -16 },
  { 2302, 12, 23, 12, 0, -16 },
  { 2337, 8, 16, 10, 1, -16 },
  { 2353, 9, 26, 11, 1, -21 },
  { 2383, 3, 29, 13, 5, -22 },
  { 2394, 9, 26, 11, 1, -21 },
  { 2424, 12, 4, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Regular29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_REGULAR29PT7B_H_
