#ifndef _NOTOSANS_CONDENSED_REGULAR35PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x66, 0x00, 0x07,
  0xFF, 0x70, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x1F, 0x0D, 0x86, 0xC3, 0x61,
  0x80, 0x07, 0x0C, 0x07, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x06, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x38, 0x0C, 0x38, 0x0C,
  0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x18,
  0x70, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x18, 0x60, 0x38, 0x60, 0x38,
  0xE0, 0x30, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x03, 0xFF, 0x3F,
  0xFB, 0xD8, 0xDC, 0xC0, 0xC6, 0x06, 0x30, 0x39, 0x81, 0xCC, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x06, 0xF0, 0x31, 0xC1, 0x8E, 0x0C, 0x70,
  0x63, 0xC3, 0x1F, 0xDF, 0xDF, 0xFC, 0x7F, 0x80, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x00, 0x3E, 0x01, 0xC0, 0x7E, 0x03, 0x01, 0xCE, 0x0E, 0x03,
  0x1C, 0x18, 0x06, 0x18, 0x30, 0x0C, 0x30, 0xE0, 0x18, 0x61, 0x80, 0x70,
  0xC7, 0x00, 0x61, 0x8C, 0x00, 0xC3, 0x38, 0x01, 0x86, 0x73, 0xC3, 0x1C,
  0xCF, 0xC7, 0x3B, 0xB9, 0xC7, 0xE6, 0x61, 0x87, 0x9C, 0xC3, 0x00, 0x31,
  0x86, 0x00, 0x63, 0x0C, 0x01, 0xC6, 0x1C, 0x03, 0x0C, 0x30, 0x0E, 0x18,
  0x60, 0x18, 0x30, 0xC0, 0x30, 0x61, 0x80, 0xE0, 0xE7, 0x01, 0x80, 0xFC,
  0x07, 0x00, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x01, 0xCF, 0x00, 0xE1, 0xC0,
  0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0xE7, 0x9C,
  0x39, 0xC3, 0x8E, 0xF0, 0xF7, 0x38, 0x1F, 0xCE, 0x03, 0xF3, 0x80, 0x78,
  0xF0, 0x1E, 0x1C, 0x0F, 0xC7, 0xCF, 0xF0, 0xFF, 0xCE, 0x1F, 0xC3, 0xC0,
  0xFF, 0xFF, 0xDB, 0x60, 0x0E, 0x38, 0x71, 0xC3, 0x8E, 0x1C, 0x38, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C,
  0x38, 0x70, 0x70, 0xE0, 0xC1, 0xC1, 0xC1, 0x80, 0xE0, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x38,
  0x70, 0x60, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x04, 0x31, 0xBF,
  0xFF, 0xFF, 0xE0, 0xE0, 0x0F, 0x80, 0xEE, 0x07, 0x38, 0x71, 0xE1, 0x84,
  0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x39, 0xCE, 0xE7, 0x39, 0x8C,
  0xE0, 0xFF, 0xFF, 0xFF, 0x7F, 0xF7, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x83,
  0xCF, 0x0E, 0x1E, 0x78, 0x39, 0xC0, 0xE7, 0x01, 0x9C, 0x07, 0x70, 0x1D,
  0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07,
  0x70, 0x1D, 0xC0, 0x77, 0x03, 0x9C, 0x0E, 0x70, 0x38, 0xE1, 0xE3, 0xCF,
  0x07, 0xF8, 0x0F, 0xC0, 0x03, 0x83, 0xC3, 0xE3, 0xF7, 0xBF, 0x9D, 0x8E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x1F, 0xC1, 0xFF,
  0xCF, 0x8F, 0x08, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xC1, 0xFF, 0xCF, 0x8F, 0x18, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3A, 0x01, 0xEF, 0x0F, 0x3F, 0xFC, 0x7F,
  0xC0, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x6E,
  0x01, 0xDC, 0x03, 0x38, 0x0E, 0x70, 0x18, 0xE0, 0x71, 0xC0, 0xC3, 0x83,
  0x87, 0x06, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x71, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x7F, 0xE3, 0xFF, 0x1F, 0xF8, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x3F, 0xF1, 0xFF, 0xC4, 0x1F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x40, 0x7B,
  0x87, 0x9F, 0xF8, 0xFF, 0x80, 0x07, 0xF0, 0xFF, 0x8F, 0x84, 0x70, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x1C, 0x3B, 0xF9, 0xFF,
  0xEF, 0x07, 0x70, 0x3B, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x77, 0x03, 0xB8, 0x39, 0xE7, 0xC7, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xC7, 0x9C,
  0x0E, 0x70, 0x39, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x38, 0x38, 0xF1, 0xC1,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0xC3, 0x87, 0x9C, 0x0E, 0x70, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x87, 0x8F, 0xFC,
  0x1F, 0xE0, 0x0F, 0xC0, 0x7F, 0x83, 0xCF, 0x1E, 0x1E, 0x70, 0x39, 0xC0,
  0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x03, 0xDC, 0x0F, 0x78,
  0x7C, 0xFF, 0x71, 0xFD, 0xC3, 0xC6, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x70, 0x03, 0xC2, 0x3E, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0xFF,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x70, 0x3B, 0xDE, 0xF1, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x3B, 0xDC, 0xE7, 0x33, 0x98, 0x00,
  0x04, 0x00, 0x30, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xC0, 0x03, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80,
  0x03, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1C, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x00, 0x30, 0x00, 0x80, 0x00, 0x3F, 0x8F, 0xFC, 0x71, 0xE4, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0xF8, 0x3C, 0x07, 0x80, 0x38, 0x1C, 0x00, 0x70, 0xE0, 0x00, 0xC7,
  0x00, 0x03, 0x9C, 0x3F, 0x86, 0x61, 0xFE, 0x1B, 0x87, 0x18, 0x6E, 0x38,
  0x61, 0xF0, 0xC1, 0x87, 0xC3, 0x06, 0x1F, 0x0C, 0x18, 0x7C, 0x30, 0x61,
  0xF0, 0xC3, 0x86, 0xC3, 0x0E, 0x1B, 0x0C, 0x38, 0x6C, 0x39, 0xB3, 0xB8,
  0x7E, 0xFC, 0xE0, 0xF1, 0xE1, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7C, 0x1C, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0x70, 0x00,
  0xDC, 0x00, 0x73, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0x8E, 0x00, 0xE1,
  0xC0, 0x38, 0x70, 0x0C, 0x1C, 0x07, 0x07, 0x01, 0xFF, 0xE0, 0x7F, 0xF8,
  0x3F, 0xFE, 0x0E, 0x03, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x70, 0x07, 0x1C,
  0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x0E, 0xE0, 0x03, 0xC0, 0xFF, 0x83, 0xFF,
  0xCF, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0,
  0x3B, 0x81, 0xEE, 0x1F, 0x3F, 0xF0, 0xFF, 0xE3, 0x83, 0xEE, 0x03, 0xB8,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xEF,
  0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0x07, 0xFC, 0x1F, 0xFC, 0x7C, 0x71, 0xE0,
  0x23, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xE7,
  0x07, 0xFE, 0x07, 0xFC, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x03, 0xCE,
  0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xEE, 0x03, 0xDC, 0x0F, 0x3F, 0xFC, 0x7F,
  0xF0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x7F, 0xEF, 0xFD, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFD, 0xFF, 0xB8, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC7, 0xE3, 0xC7, 0x80, 0x23, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x03, 0xFF, 0x01, 0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x39, 0xE0, 0x1C,
  0x7E, 0x3E, 0x1F, 0xFF, 0x07, 0xFF, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E, 0xFF, 0xFF, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E,
  0xFE, 0xFC, 0x70, 0xE0, 0x1D, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0x8E, 0x0E,
  0x1C, 0x3C, 0x38, 0x70, 0x71, 0xC0, 0xE7, 0x81, 0xCE, 0x03, 0xB8, 0x07,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3D, 0xE0, 0x71, 0xC0, 0xE1, 0xC1, 0xC3,
  0x83, 0x83, 0x87, 0x07, 0x8E, 0x07, 0x1C, 0x0F, 0x38, 0x0E, 0x70, 0x1E,
  0xE0, 0x1E, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFD,
  0xC0, 0x0D, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFD, 0x80, 0x37, 0xEE, 0x03,
  0xBF, 0x70, 0x1D, 0xF9, 0x80, 0xCF, 0xCE, 0x0E, 0x7E, 0x70, 0x73, 0xF1,
  0x83, 0x1F, 0x8E, 0x38, 0xFC, 0x71, 0xC7, 0xE1, 0x8C, 0x3F, 0x0E, 0x61,
  0xF8, 0x77, 0x0F, 0xC3, 0xB8, 0x7E, 0x0F, 0x83, 0xF0, 0x7C, 0x1F, 0x83,
  0xE0, 0xFC, 0x0E, 0x07, 0xE0, 0x70, 0x38, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x07, 0xDC, 0x07, 0xFE, 0x07, 0xEE, 0x07, 0xEF,
  0x07, 0xE7, 0x07, 0xE7, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE1, 0xC7, 0xE1,
  0xE7, 0xE0, 0xE7, 0xE0, 0xF7, 0xE0, 0x77, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0x07, 0xF8, 0x07,
  0xFF, 0x03, 0xF3, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x1C, 0x01, 0xE7, 0x00,
  0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x07, 0x0F, 0x03, 0xC1, 0xF3,
  0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1,
  0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC1, 0xEE, 0x3F, 0x7F, 0xF3, 0xFE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x07,
  0xF8, 0x07, 0xFF, 0x03, 0xF3, 0xE0, 0xF0, 0x3C, 0x78, 0x07, 0x1C, 0x01,
  0xE7, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x78, 0x07, 0x0F, 0x03,
  0xC1, 0xF3, 0xE0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0xFF, 0x83, 0xFF,
  0x8F, 0xFF, 0x38, 0x3C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0,
  0x3B, 0x81, 0xEE, 0x07, 0x38, 0x3C, 0xFF, 0xE3, 0xFE, 0x0F, 0xF8, 0x38,
  0xF0, 0xE1, 0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE,
  0x03, 0xB8, 0x0F, 0xE0, 0x1C, 0x0F, 0xF0, 0xFF, 0xCF, 0xBE, 0xF0, 0x17,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0xC0, 0x3F, 0xE7, 0xDF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xDE, 0x07, 0x9F, 0x1E, 0x1F, 0xFC, 0x1F, 0xE0, 0xE0, 0x03, 0xF8, 0x01,
  0xDC, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x38, 0x70,
  0x1C, 0x38, 0x0E, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x06, 0x38, 0x03, 0xB8, 0x01, 0xDC,
  0x00, 0xEE, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xC0, 0x00, 0xE0, 0x0E, 0x00, 0xEE, 0x01, 0xC0, 0x1D, 0xC0, 0x3C, 0x03,
  0xB8, 0x0F, 0x80, 0xE7, 0x01, 0xF0, 0x1C, 0xE0, 0x36, 0x03, 0x8E, 0x06,
  0xE0, 0x71, 0xC1, 0xDC, 0x1E, 0x38, 0x3B, 0x83, 0x87, 0x07, 0x30, 0x70,
  0x70, 0xC7, 0x0E, 0x0E, 0x18, 0xE1, 0xC1, 0xC7, 0x1C, 0x70, 0x38, 0xE1,
  0x8E, 0x07, 0x1C, 0x31, 0xC0, 0x73, 0x07, 0x38, 0x0E, 0xE0, 0xE7, 0x01,
  0xDC, 0x1D, 0xC0, 0x3B, 0x81, 0xB8, 0x03, 0x60, 0x37, 0x00, 0x6C, 0x07,
  0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03,
  0x80, 0x3C, 0x00, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x3C, 0x1C, 0x1C,
  0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70,
  0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0x70, 0x0E, 0x70, 0x1E, 0x78,
  0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0E,
  0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0F, 0xFF, 0xFF, 0x80, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF,
  0xFF, 0x03, 0x00, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xEC, 0x01, 0x9C,
  0x07, 0x18, 0x0C, 0x38, 0x38, 0x30, 0x70, 0x71, 0xC0, 0x63, 0x80, 0xEE,
  0x00, 0xDC, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0, 0xE0,
  0xC0, 0xC0, 0x0F, 0xC1, 0xFF, 0x0E, 0x3C, 0x40, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x0F, 0xF9, 0xFF, 0xDE, 0x0E, 0xE0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xFE, 0x0F, 0x70, 0xFB, 0xFD, 0xCF, 0xCE, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE3,
  0xE3, 0xBF, 0xCE, 0xEF, 0xBE, 0x0E, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x03, 0xFE, 0x0E, 0xFC, 0x7B, 0xBF, 0xCE, 0x7E, 0x00, 0x0F, 0xE7, 0xF9,
  0xF7, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x47, 0xF8, 0x7F, 0x00,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x1F, 0x39, 0xFF, 0xDF, 0x76, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFE, 0x0F, 0x78, 0xF9, 0xFE, 0xC7, 0xE6, 0x0F, 0x81, 0xFE, 0x1E,
  0x78, 0xE0, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x7C, 0x31,
  0xFF, 0x87, 0xF8, 0x03, 0xC1, 0xFC, 0x3F, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3F, 0x9F, 0xF3, 0xFE, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x1F, 0x19, 0xFE, 0xDF, 0x76, 0xE0, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xEE, 0x0F, 0x78, 0xD9, 0xFF, 0xC7, 0xEE,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x60, 0xF3, 0xFF, 0x1F,
  0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE3, 0xE7, 0x7F, 0xBB, 0xBF, 0xF0, 0x7F, 0x03, 0xF8, 0x1F,
  0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0x6F, 0xF6, 0x00,
  0x0E, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x0C, 0x3C,
  0x78, 0x60, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0xFD, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC3, 0x8E,
  0x1C, 0x71, 0xC3, 0x9C, 0x1D, 0xC0, 0xEF, 0x07, 0xF8, 0x3E, 0xE1, 0xE7,
  0x0E, 0x1C, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0x77, 0x03, 0xB8, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE7,
  0xC1, 0xF3, 0xBF, 0xDF, 0xEF, 0xDF, 0x77, 0xBE, 0x1F, 0x07, 0xF0, 0x38,
  0x1F, 0xC0, 0xE0, 0x7F, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F,
  0x80, 0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80,
  0xE0, 0x7E, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0, 0x38, 0x1F, 0x80, 0xE0,
  0x7E, 0x03, 0x81, 0xC0, 0xE7, 0xE7, 0x7F, 0xBF, 0xBF, 0xF0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0x0F,
  0xC0, 0xFF, 0x87, 0xDF, 0x1C, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xEE,
  0x03, 0x9C, 0x1E, 0x78, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0xE7, 0xE3, 0xBF,
  0xCE, 0xCF, 0xBE, 0x0E, 0xF0, 0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE,
  0x0E, 0xFC, 0x7B, 0xBF, 0xCE, 0x7E, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x1F, 0x19, 0xFE,
  0xDF, 0x76, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0x78,
  0xD9, 0xFF, 0xC7, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0xE3, 0xF3, 0xFB, 0xFF, 0x8F, 0x87, 0x83,
  0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x00, 0x1F, 0xC7, 0xFD, 0xE7, 0x70, 0x0E, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C,
  0x07, 0xE1, 0xFF, 0xF9, 0xFE, 0x00, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xF7,
  0xFB, 0xFC, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x89, 0xFC, 0x7E, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0xC0, 0xEE, 0x0F, 0x78, 0xF9,
  0xFE, 0xC7, 0xE6, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDC, 0x0E, 0x70, 0x38,
  0xE0, 0xE3, 0x83, 0x0E, 0x1C, 0x38, 0x70, 0x71, 0xC1, 0xC6, 0x07, 0x38,
  0x0C, 0xE0, 0x3B, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x00, 0xE0, 0x38, 0x0E, 0xE0, 0x70, 0x19, 0xC1, 0xF0, 0x73, 0x83, 0x60,
  0xE7, 0x06, 0xC1, 0xC6, 0x0D, 0x83, 0x0E, 0x3B, 0x8E, 0x1C, 0x77, 0x1C,
  0x38, 0xE6, 0x38, 0x71, 0x8C, 0x70, 0x77, 0x1C, 0xC0, 0xEE, 0x3B, 0x81,
  0xDC, 0x77, 0x03, 0xB0, 0x6E, 0x03, 0x60, 0xD8, 0x06, 0xC1, 0xB0, 0x0F,
  0x83, 0xE0, 0x1E, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x3F, 0x83, 0x9C,
  0x1C, 0x71, 0xC3, 0x8E, 0x0E, 0xE0, 0x77, 0x01, 0xF0, 0x0F, 0x80, 0x38,
  0x03, 0xE0, 0x1F, 0x01, 0xDC, 0x1C, 0xE0, 0xE3, 0x8E, 0x1C, 0x70, 0x77,
  0x03, 0xB8, 0x0E, 0xE0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x70, 0x38,
  0xE0, 0xE3, 0x83, 0x0E, 0x1C, 0x18, 0x70, 0x71, 0xC1, 0xCE, 0x03, 0x38,
  0x0E, 0xE0, 0x3B, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x03, 0xF0,
  0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x3F, 0xFF, 0xFC, 0x01, 0xC1, 0xF0, 0x7C, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x0F, 0x83, 0xC0, 0x7C,
  0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x1F, 0x01, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xF8,
  0x0F, 0x07, 0xC1, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x0F, 0xC1, 0xF0, 0x20, 0x00, 0x18, 0x05,
  0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0x80, 0x70,
};

const GFXglyph NotoSans_Condensed_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 25, 9, 2, -25 },
  { 14, 9, 9, 14, 2, -25 },
  { 25, 16, 25, 18, 1, -25 },
  { 75, 13, 29, 17, 2, -27 },
  { 123, 23, 25, 25, 1, -25 },
  { 195, 18, 25, 19, 1, -25 },
  { 252, 3, 9, 7, 2, -25 },
  { 256, 7, 31, 10, 2, -25 },
  { 284, 8, 31, 10, 1, -25 },
  { 315, 13, 13, 16, 1, -27 },
  { 337, 14, 17, 17, 1, -21 },
  { 367, 5, 9, 8, 1, -4 },
  { 373, 8, 3, 10, 1, -11 },
  { 376, 4, 4, 8, 2, -4 },
  { 378, 12, 25, 13, 1, -25 },
  { 416, 14, 25, 17, 1, -25 },
  { 460, 9, 25, 17, 2, -25 },
  { 489, 14, 25, 17, 1, -25 },
  { 533, 14, 25, 17, 1, -25 },
  { 577, 15, 25, 17, 1, -25 },
  { 624, 13, 25, 17, 2, -25 },
  { 665, 13, 25, 17, 2, -25 },
  { 706, 14, 25, 17, 1, -25 },
  { 750, 14, 25, 17, 1, -25 },
  { 794, 14, 25, 17, 1, -25 },
  { 838, 4, 19, 8, 2, -19 },
  { 848, 5, 24, 8, 1, -19 },
  { 863, 14, 17, 17, 1, -21 },
  { 893, 14, 10, 17, 1, -17 },
  { 911, 14, 17, 17, 1, -21 },
  { 941, 12, 25, 12, 0, -25 },
  { 979, 22, 28, 25, 2, -25 },
  { 1056, 18, 25, 18, 0, -25 },
  { 1113, 14, 25, 19, 3, -25 },
  { 1157, 15, 25, 18, 2, -25 },
  { 1204, 15, 25, 20, 3, -25 },
  { 1251, 11, 25, 16, 3, -25 },
  { 1286, 11, 25, 15, 3, -25 },
  { 1321, 17, 25, 21, 2, -25 },
  { 1375, 15, 25, 21, 3, -25 },
  { 1422, 8, 25, 11, 1, -25 },
  { 1447, 8, 32, 8, -2, -25 },
  { 1479, 15, 25, 17, 3, -25 },
  { 1526, 11, 25, 15, 3, -25 },
  { 1561, 21, 25, 27, 3, -25 },
  { 1627, 16, 25, 22, 3, -25 },
  { 1677, 18, 25, 22, 2, -25 },
  { 1734, 13, 25, 17, 3, -25 },
  { 1775, 18, 31, 22, 2, -25 },
  { 1845, 14, 25, 18, 3, -25 },
  { 1889, 13, 25, 16, 1, -25 },
  { 1930, 15, 25, 15, 0, -25 },
  { 1977, 15, 25, 20, 3, -25 },
  { 2024, 17, 25, 17, 0, -25 },
  { 2078, 27, 25, 27, 0, -25 },
  { 2163, 16, 25, 16, 0, -25 },
  { 2213, 16, 25, 16, 0, -25 },
  { 2263, 13, 25, 15, 1, -25 },
  { 2304, 7, 31, 11, 3, -25 },
  { 2332, 12, 25, 13, 1, -25 },
  { 2370, 8, 31, 11, 1, -25 },
  { 2401, 15, 14, 17, 1, -25 },
  { 2428, 15, 2, 15, 0, 3 },
  { 2432, 7, 6, 9, 1, -27 },
  { 2438, 13, 19, 16, 1, -19 },
  { 2469, 14, 27, 18, 2, -27 },
  { 2517, 11, 19, 14, 2, -19 },
  { 2544, 13, 27, 18, 2, -27 },
  { 2588, 13, 19, 16, 2, -19 },
  { 2619, 11, 27, 10, 0, -27 },
  { 2657, 13, 27, 18, 2, -19 },
  { 2701, 13, 27, 18, 2, -27 },
  { 2745, 4, 26, 8, 2, -26 },
  { 2758, 7, 34, 8, -1, -26 },
  { 2788, 13, 27, 15, 2, -27 },
  { 2832, 3, 27, 8, 2, -27 },
  { 2843, 22, 19, 27, 2, -19 },
  { 2896, 13, 19, 18, 2, -19 },
  { 2927, 14, 19, 17, 2, -19 },
  { 2961, 14, 27, 18, 2, -19 },
  { 3009, 13, 27, 18, 2, -19 },
  { 3053, 9, 19, 12, 2, -19 },
  { 3075, 11, 19, 13, 1, -19 },
  { 3102, 9, 23, 10, 1, -23 },
  { 3128, 13, 19, 18, 2, -19 },
  { 3159, 14, 19, 14, 0, -19 },
  { 3193, 23, 19, 23, 0, -19 },
  { 3248, 13, 19, 15, 1, -19 },
  { 3279, 14, 27, 14, 0, -19 },
  { 3327, 10, 19, 12, 1, -19 },
  { 3351, 10, 31, 13, 1, -25 },
  { 3390, 2, 35, 16, 7, -27 },
  { 3399, 11, 31, 13, 1, -25 },
  { 3442, 14, 5, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Regular35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular35pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_CONDENSED_REGULAR35PT7B_H_
