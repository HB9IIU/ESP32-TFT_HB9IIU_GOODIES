#ifndef _NOTOSANS_CONDENSED_REGULAR65PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular65pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x18,
  0xFC, 0x1F, 0xFE, 0x0F, 0xFF, 0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0,
  0x7F, 0xF0, 0x3F, 0xF8, 0x1F, 0x78, 0x0F, 0xBC, 0x07, 0xDE, 0x03, 0xEF,
  0x01, 0xF7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78,
  0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01,
  0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xC7, 0x07, 0x8F, 0xC3, 0x80, 0x8F, 0xC1,
  0xC0, 0x07, 0xC0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xF0, 0x38, 0x00, 0xF8,
  0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x3F, 0x07, 0x00, 0x0F, 0x83, 0x80, 0x07,
  0xE1, 0xC0, 0x03, 0xFC, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xE7, 0xF0, 0x00, 0x70, 0xFC, 0x00, 0x38,
  0x3E, 0x00, 0x1C, 0x1F, 0x80, 0x0E, 0x07, 0xC0, 0x07, 0x03, 0xE0, 0x03,
  0x81, 0xF0, 0x01, 0xC0, 0xF8, 0x00, 0xE0, 0xFA, 0x00, 0x70, 0x7D, 0xC0,
  0x38, 0x7E, 0xFC, 0x1D, 0xFE, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x00, 0x07, 0x80, 0x07, 0xFF,
  0x80, 0x07, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x03,
  0xE0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x00, 0x78, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x07,
  0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x1F, 0x00, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x1E, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x07,
  0x83, 0xC0, 0x00, 0x3C, 0x07, 0xC3, 0xE0, 0x20, 0x1E, 0x03, 0xE1, 0xE0,
  0xFE, 0x0F, 0x81, 0xF1, 0xF0, 0xFF, 0x87, 0xC0, 0xF0, 0xF0, 0xFF, 0xE1,
  0xE0, 0x78, 0xF8, 0xFD, 0xF8, 0xF8, 0x7C, 0x7C, 0x78, 0x7C, 0x3C, 0x7C,
  0x3C, 0x7C, 0x1F, 0x1F, 0xFE, 0x3E, 0x3E, 0x0F, 0x87, 0xFE, 0x1E, 0x1E,
  0x03, 0xC1, 0xFE, 0x1F, 0x0F, 0x01, 0xE0, 0x7E, 0x0F, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x87, 0xC0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x3E, 0x00, 0x03,
  0xC1, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0x01, 0xE0, 0x7C,
  0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x01, 0xF0,
  0x00, 0x78, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xC0, 0x78, 0x00, 0x3C,
  0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x00, 0xF0, 0x1E, 0x00, 0x1F, 0x00, 0x78,
  0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xEF, 0xC0, 0x07, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xC0,
  0x00, 0x7F, 0xC0, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF0, 0x0F, 0xC1, 0xFC, 0xFC, 0x03, 0xF0, 0xFE, 0x1F, 0x80, 0xF8,
  0x3F, 0x03, 0xF0, 0x3E, 0x1F, 0x80, 0xFE, 0x1F, 0x87, 0xE0, 0x1F, 0x87,
  0xE1, 0xF0, 0x03, 0xF1, 0xF0, 0x7C, 0x00, 0xFE, 0xFC, 0x3F, 0x00, 0x1F,
  0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0x83, 0xF0, 0x00, 0x7F, 0xE0, 0xFC, 0x00,
  0x1F, 0xF0, 0x3F, 0x00, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0x03,
  0xFE, 0x3F, 0xEF, 0xE0, 0x7F, 0xFF, 0xF1, 0xF8, 0x1F, 0xFF, 0xF8, 0x7F,
  0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F, 0xFC, 0x01, 0xFC, 0x00, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x01, 0x78, 0x3C, 0x0F, 0x7F, 0x3C, 0x7F,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE3, 0xE0, 0x07, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0xC1, 0xFC,
  0x07, 0x80, 0xF0, 0x03, 0x80, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x18, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFE, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xF8, 0x3E, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x03,
  0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x1F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00,
  0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xF8, 0xFE, 0x01, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xF8, 0x1F, 0xF0, 0x7F, 0xE1,
  0xFF, 0xC7, 0xFF, 0x9F, 0xDF, 0x7F, 0x3F, 0xFC, 0x7F, 0xE0, 0xFB, 0x81,
  0xF2, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F,
  0x83, 0xC0, 0x07, 0xE0, 0x60, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFE, 0x01, 0xFC, 0x78, 0x00, 0xFE, 0x20,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x80, 0x00, 0xFE, 0xE0, 0x01, 0xFE, 0xFC, 0x07, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x02,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xBE, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x78, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3C, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x08,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x70, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF9, 0x00, 0x01, 0xFC, 0xE0, 0x01,
  0xFC, 0x7E, 0x03, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x0F, 0xF0, 0x1F, 0x9F, 0xFE, 0x0F, 0xDF,
  0xFF, 0x87, 0xEF, 0xFF, 0xE3, 0xEF, 0xDF, 0xF9, 0xFF, 0x01, 0xFC, 0xFF,
  0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xDF, 0x80, 0x03, 0xEF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x7F, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xF0, 0x1F, 0xC3, 0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x00,
  0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x0F, 0xC0, 0x1F, 0xCF,
  0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x01, 0xFD, 0xFE, 0x00, 0xFE, 0x1F, 0xC0,
  0x7E, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xE3, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xC1, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xEF, 0x80, 0x03,
  0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF, 0xC0,
  0x03, 0xFF, 0xE0, 0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x3F,
  0x81, 0xFF, 0x1F, 0xFF, 0xEF, 0x87, 0xFF, 0xF7, 0xC1, 0xFF, 0xF3, 0xE0,
  0x7F, 0xE1, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0C, 0x0F, 0xF8, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF8, 0xC0, 0x1F, 0x07,
  0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE1, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xE1,
  0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x87, 0xC1, 0xF0,
  0x7C, 0x1E, 0x0F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF,
  0xF0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0x80, 0xFE, 0x60,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0xF8, 0x01, 0xFF, 0x00, 0xF0, 0x78, 0x03, 0xFF, 0xE0,
  0x7C, 0x7C, 0x03, 0xFF, 0xF0, 0x3E, 0x3E, 0x03, 0xFF, 0xF8, 0x0F, 0x1E,
  0x01, 0xF0, 0x3C, 0x07, 0x9F, 0x01, 0xF0, 0x1E, 0x03, 0xEF, 0x80, 0xF0,
  0x0F, 0x01, 0xF7, 0xC0, 0xF8, 0x0F, 0x80, 0xFB, 0xC0, 0x7C, 0x07, 0xC0,
  0x3D, 0xE0, 0x3C, 0x03, 0xE0, 0x1E, 0xF0, 0x3E, 0x01, 0xF0, 0x0F, 0xF8,
  0x1F, 0x00, 0xF8, 0x07, 0xFC, 0x0F, 0x80, 0x7C, 0x03, 0xFE, 0x07, 0xC0,
  0x3E, 0x03, 0xFF, 0x03, 0xE0, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x0F, 0x80,
  0xFF, 0xC0, 0xF8, 0x07, 0xC0, 0x7B, 0xE0, 0x7C, 0x03, 0xE0, 0x3D, 0xF0,
  0x3E, 0x03, 0xF0, 0x1E, 0xF8, 0x0F, 0x01, 0xF8, 0x1F, 0x3C, 0x07, 0xC0,
  0xFC, 0x0F, 0x1E, 0x03, 0xE0, 0xEF, 0x0F, 0x8F, 0x00, 0xFC, 0xF7, 0xCF,
  0x87, 0xC0, 0x7F, 0xF9, 0xFF, 0xC3, 0xE0, 0x1F, 0xF8, 0xFF, 0xC0, 0xF0,
  0x07, 0xF8, 0x3F, 0xC0, 0x7C, 0x00, 0xE0, 0x03, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x08, 0x00, 0x07, 0xF8, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xC3, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xFC,
  0x1F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xF7, 0xE0, 0x00,
  0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xC0, 0x7F, 0xF1, 0xF8, 0x00, 0xFE, 0x3F, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF3,
  0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9, 0xF8, 0x00,
  0x1F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x1F,
  0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0xFC,
  0x01, 0xFF, 0x1F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x07, 0xF7, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x9F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0, 0x3E, 0x07,
  0xF8, 0x00, 0x40, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x06, 0x03, 0xFF, 0x8F, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1E, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7E, 0x00, 0x7F, 0xC3,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x0F, 0xF0, 0xFC, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x1C, 0x07, 0xF0, 0x00, 0x04, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x7C,
  0x00, 0x1F, 0xFF, 0x7C, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x1F, 0x07,
  0xFC, 0x00, 0x1F, 0x03, 0xFF, 0x83, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xDF, 0xFF, 0x3F, 0xFE,
  0x7F, 0xF8, 0xFF, 0xE1, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC1,
  0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7C, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFD, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xBF, 0x00, 0x0F, 0xF3, 0xF0,
  0x00, 0xFF, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFB,
  0xE0, 0x00, 0x03, 0xFF, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0xFB, 0xE0, 0x00,
  0x07, 0xDF, 0xF9, 0xF0, 0x00, 0x07, 0xDF, 0xF9, 0xF0, 0x00, 0x0F, 0x9F,
  0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0xF9, 0xF8, 0x00, 0x0F, 0x9F, 0xF8, 0xF8,
  0x00, 0x1F, 0x1F, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0xF8, 0xF8, 0x00, 0x1F,
  0x1F, 0xF8, 0x7C, 0x00, 0x1E, 0x1F, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0xF8, 0x3E, 0x00, 0x3C, 0x1F, 0xF8, 0x3E, 0x00,
  0x7C, 0x1F, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0xF8, 0x1F, 0x00, 0x7C, 0x1F,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0xF8, 0x0F,
  0x80, 0xF8, 0x1F, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0xF8, 0x0F, 0x81, 0xF0,
  0x1F, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0xF8, 0x03, 0xE3,
  0xC0, 0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0xF8, 0x03, 0xE7, 0xC0, 0x1F,
  0xF8, 0x01, 0xF7, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xE0, 0x00,
  0x7F, 0xF7, 0xE0, 0x00, 0xFF, 0xEF, 0xC0, 0x01, 0xFF, 0xCF, 0xC0, 0x03,
  0xFF, 0x9F, 0x80, 0x07, 0xFF, 0x1F, 0x80, 0x0F, 0xFE, 0x3F, 0x00, 0x1F,
  0xFC, 0x3F, 0x00, 0x3F, 0xF8, 0x7E, 0x00, 0x7F, 0xF0, 0x7E, 0x00, 0xFF,
  0xE0, 0xFC, 0x01, 0xFF, 0xC0, 0xFC, 0x03, 0xFF, 0x81, 0xF8, 0x07, 0xFF,
  0x01, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x03, 0xF0, 0x3F, 0xF8,
  0x07, 0xE0, 0x7F, 0xF0, 0x07, 0xE0, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF, 0xC0,
  0x0F, 0xC3, 0xFF, 0x80, 0x1F, 0x87, 0xFF, 0x00, 0x1F, 0x8F, 0xFE, 0x00,
  0x3F, 0x1F, 0xFC, 0x00, 0x3F, 0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xF0, 0x00,
  0x7E, 0xFF, 0xE0, 0x00, 0xFD, 0xFF, 0xC0, 0x00, 0xFD, 0xFF, 0x80, 0x01,
  0xFB, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0B, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0xC3, 0xFF, 0xC7, 0xE0, 0x0F, 0xF3, 0xF0, 0x03, 0xF9, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF,
  0x80, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0xEF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xF3, 0xF0, 0x1F,
  0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x1F,
  0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3F,
  0x7C, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xC1, 0xF8, 0x03, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x07, 0xF8, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x1F,
  0x80, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x03,
  0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F,
  0xC0, 0xFC, 0x7F, 0x00, 0x0C, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x80, 0x00, 0xFE, 0xF0,
  0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xC3, 0xFF, 0x1F, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x1F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xEF, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xBE, 0x00, 0x3F,
  0x03, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x7C, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x1F, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x0F,
  0x80, 0xFC, 0x01, 0xF8, 0x0F, 0x83, 0xE0, 0x3F, 0x00, 0x3E, 0x07, 0xC0,
  0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0x80, 0x7C, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0x80, 0x3E, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xF7, 0x80, 0x07, 0xDF, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3D, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x7E, 0x7E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3F,
  0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0xFC, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80,
  0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xF8, 0x1F, 0xC0, 0x80,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0x80, 0xF9, 0xFC, 0x01, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x0F, 0xEF, 0xC0, 0x3F, 0xDF, 0xC0,
  0xF7, 0x9F, 0xFF, 0xCF, 0x1F, 0xFF, 0x9E, 0x3F, 0xFE, 0x3C, 0x1F, 0xF0,
  0x78, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE1, 0xFF, 0x01, 0xF1, 0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0x7D, 0xFF, 0xFE,
  0x3F, 0xF0, 0xFF, 0x1F, 0xE0, 0x1F, 0xCF, 0xE0, 0x07, 0xE7, 0xF0, 0x01,
  0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x3F,
  0x7F, 0x00, 0x1F, 0xBF, 0x80, 0x1F, 0x9F, 0xE0, 0x1F, 0xCF, 0xFC, 0x1F,
  0xC7, 0xDF, 0xFF, 0xE3, 0xCF, 0xFF, 0xE1, 0xE3, 0xFF, 0xE0, 0xF0, 0x7F,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x00, 0xFF,
  0xFE, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xF8, 0xF0, 0x7E, 0x00, 0x87,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x43, 0xFC, 0x0E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0xC0, 0x7C, 0x07, 0xFC, 0x3E, 0x0F, 0xFF, 0x1F, 0x0F, 0xFF, 0xCF,
  0x8F, 0xFF, 0xF7, 0xC7, 0xF8, 0x7F, 0xE7, 0xF0, 0x0F, 0xF3, 0xF0, 0x03,
  0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xF0, 0x0F,
  0xF1, 0xFC, 0x0F, 0xF8, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0x9E, 0x0F, 0xFF,
  0x8F, 0x01, 0xFF, 0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x1F,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C,
  0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x06, 0x1F, 0xE0, 0x3E, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x0F,
  0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xE0, 0x81, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xF8, 0xFF, 0xFF,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0x83, 0xC1, 0xFF, 0xE1, 0xE1, 0xFF, 0xF8, 0xF1, 0xFF, 0xFE, 0xF8, 0xFF,
  0x1F, 0xFC, 0xFE, 0x01, 0xFE, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x3F, 0x83, 0xFF, 0x1F,
  0xFF, 0xEF, 0x87, 0xFF, 0xE7, 0xC1, 0xFF, 0xE3, 0xE0, 0x3F, 0xE1, 0xF0,
  0x03, 0x80, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE2, 0x00, 0x03, 0xF1, 0x80, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0xF0, 0x7C, 0x7F, 0xF8,
  0xF9, 0xFF, 0xF9, 0xF7, 0xFF, 0xFB, 0xFF, 0x8F, 0xF7, 0xF8, 0x07, 0xEF,
  0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x39,
  0xFF, 0xFF, 0xFD, 0xF7, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D,
  0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x00,
  0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03,
  0xF0, 0x3F, 0x87, 0xEF, 0xFE, 0xFF, 0xCF, 0xFC, 0xFF, 0x03, 0x80, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFC, 0x00, 0x7C, 0xF8, 0x01, 0xF9,
  0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x0F, 0x80, 0xFC, 0x1F,
  0x03, 0xF0, 0x3E, 0x07, 0xC0, 0x7C, 0x1F, 0x80, 0xF8, 0x7E, 0x01, 0xF0,
  0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x80, 0x1F, 0x7F,
  0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0x7E, 0x01, 0xFC, 0xFC,
  0x03, 0xF8, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xF0,
  0x3E, 0x03, 0xF0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x9F, 0x00, 0x3F, 0x3E,
  0x00, 0x3F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x04, 0x00, 0x06, 0x00, 0xF0, 0x7F, 0xC0, 0x3F,
  0xE0, 0xF1, 0xFF, 0xE0, 0xFF, 0xF8, 0xF3, 0xFF, 0xF1, 0xFF, 0xFC, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0xFF, 0xC3, 0xFB, 0xE1, 0xFE, 0xFF, 0x01, 0xFF,
  0x80, 0x7E, 0xFE, 0x00, 0xFF, 0x00, 0x7E, 0xFC, 0x00, 0xFF, 0x00, 0x3E,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C,
  0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x04, 0x01, 0xE0, 0xFF, 0xC3, 0xC3, 0xFF, 0xC7,
  0x8F, 0xFF, 0xCF, 0x3F, 0xFF, 0xDF, 0xF8, 0x7F, 0xBF, 0xC0, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x0C, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0xFC, 0x00,
  0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x83, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x0C, 0x00, 0x78, 0x3F, 0xE0, 0x3C, 0x3F, 0xFC, 0x1E, 0x3F, 0xFF,
  0x0F, 0xBF, 0xFF, 0xC7, 0xFE, 0x0F, 0xE3, 0xFC, 0x03, 0xF9, 0xFC, 0x00,
  0xFC, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x80,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xDF, 0x80, 0x07, 0xEF, 0xE0, 0x03, 0xF7, 0xF0, 0x03, 0xF3, 0xFC, 0x03,
  0xF9, 0xFF, 0x83, 0xF8, 0xFB, 0xFF, 0xFC, 0x7D, 0xFF, 0xFC, 0x3E, 0x3F,
  0xFC, 0x1F, 0x0F, 0xFC, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0xFF,
  0x83, 0xC1, 0xFF, 0xE1, 0xE1, 0xFF, 0xF8, 0xF1, 0xFF, 0xFE, 0xF8, 0xFF,
  0x0F, 0xFC, 0xFE, 0x01, 0xFE, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xEF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0,
  0x01, 0xF9, 0xF8, 0x01, 0xFC, 0xFE, 0x01, 0xFE, 0x3F, 0x83, 0xFF, 0x1F,
  0xFF, 0xEF, 0x87, 0xFF, 0xE7, 0xC1, 0xFF, 0xE3, 0xE0, 0x7F, 0xE1, 0xF0,
  0x03, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x0C, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xFF,
  0xF3, 0xFF, 0xF7, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x3F, 0xFF, 0xE7, 0xF0, 0x3E, 0x7E, 0x00, 0x47, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x60, 0x03, 0xF7, 0xC0, 0xFE, 0x7F, 0xFF,
  0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF0, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x82, 0x0F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0x00, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7E, 0x00, 0x7F,
  0x7F, 0x00, 0xFF, 0x3F, 0x83, 0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F,
  0x0F, 0xFF, 0x0F, 0x07, 0xFE, 0x0F, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x83,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x1E, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF,
  0x80, 0x0F, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xFC, 0x00, 0xF9, 0xF8, 0x03, 0xDE, 0x00, 0xFC, 0xFC, 0x01, 0xEF, 0x00,
  0x7E, 0x3E, 0x01, 0xF7, 0x80, 0x3E, 0x1F, 0x00, 0xFB, 0xE0, 0x1F, 0x0F,
  0x80, 0x7D, 0xF0, 0x0F, 0x87, 0xE0, 0x3C, 0xF8, 0x0F, 0xC1, 0xF0, 0x3E,
  0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x8F, 0x81,
  0xF0, 0x3F, 0x07, 0x87, 0xC1, 0xF8, 0x1F, 0x83, 0xC1, 0xE0, 0xF8, 0x07,
  0xC3, 0xE0, 0xF8, 0x7C, 0x03, 0xE1, 0xF0, 0x7C, 0x3E, 0x01, 0xF0, 0xF8,
  0x3E, 0x1F, 0x00, 0xF8, 0x78, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x07, 0x8F,
  0x80, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x07,
  0xCF, 0x00, 0xF9, 0xE0, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x00, 0xFF, 0xC0,
  0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xBF,
  0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x83, 0xF0, 0x07, 0xE1, 0xF0,
  0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xE7, 0xC0, 0x03,
  0xE3, 0xF0, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x7C,
  0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F,
  0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x01, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF,
  0xF7, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x20, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xC0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x17, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x9F, 0xFD, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFC,
  0x00, 0x7F, 0xFA, 0x00, 0x03, 0xF8,
};

const GFXglyph NotoSans_Condensed_Regular65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 8, 47, 16, 4, -46 },
  { 48, 17, 16, 25, 4, -46 },
  { 82, 31, 46, 34, 1, -46 },
  { 261, 25, 53, 31, 3, -49 },
  { 427, 41, 48, 46, 3, -47 },
  { 673, 34, 48, 36, 2, -47 },
  { 877, 6, 16, 14, 4, -46 },
  { 889, 14, 57, 19, 3, -47 },
  { 989, 14, 57, 19, 2, -47 },
  { 1089, 24, 23, 29, 2, -49 },
  { 1158, 26, 30, 31, 2, -38 },
  { 1256, 10, 16, 16, 2, -7 },
  { 1276, 15, 5, 19, 2, -20 },
  { 1286, 7, 9, 16, 4, -8 },
  { 1294, 22, 47, 24, 1, -47 },
  { 1424, 25, 48, 31, 3, -47 },
  { 1574, 15, 46, 31, 5, -46 },
  { 1661, 26, 47, 31, 2, -47 },
  { 1814, 24, 48, 31, 3, -47 },
  { 1958, 29, 47, 31, 1, -47 },
  { 2129, 25, 47, 31, 3, -46 },
  { 2276, 25, 48, 31, 3, -47 },
  { 2426, 26, 46, 31, 2, -46 },
  { 2576, 26, 48, 31, 2, -47 },
  { 2732, 25, 48, 31, 3, -47 },
  { 2882, 7, 36, 16, 4, -35 },
  { 2914, 10, 44, 16, 2, -35 },
  { 2969, 26, 30, 31, 2, -38 },
  { 3067, 26, 18, 31, 2, -32 },
  { 3126, 26, 30, 31, 2, -38 },
  { 3224, 20, 48, 23, 1, -47 },
  { 3344, 41, 53, 47, 3, -47 },
  { 3616, 33, 46, 33, 0, -46 },
  { 3806, 27, 46, 34, 5, -46 },
  { 3962, 28, 48, 33, 3, -47 },
  { 4130, 29, 46, 38, 5, -46 },
  { 4297, 21, 46, 29, 5, -46 },
  { 4418, 21, 46, 27, 5, -46 },
  { 4539, 32, 48, 39, 3, -47 },
  { 4731, 29, 46, 39, 5, -46 },
  { 4898, 15, 46, 20, 2, -46 },
  { 4985, 15, 58, 16, -4, -46 },
  { 5094, 28, 46, 32, 5, -46 },
  { 5255, 21, 46, 27, 5, -46 },
  { 5376, 40, 46, 50, 5, -46 },
  { 5606, 31, 46, 41, 5, -46 },
  { 5785, 34, 48, 40, 3, -47 },
  { 5989, 25, 46, 32, 5, -46 },
  { 6133, 34, 58, 40, 3, -47 },
  { 6380, 27, 46, 33, 5, -46 },
  { 6536, 24, 48, 30, 3, -47 },
  { 6680, 26, 46, 28, 1, -46 },
  { 6830, 28, 47, 38, 5, -46 },
  { 6995, 32, 46, 32, 0, -46 },
  { 7179, 50, 46, 51, 0, -46 },
  { 7467, 29, 46, 30, 0, -46 },
  { 7634, 29, 46, 29, 0, -46 },
  { 7801, 24, 46, 28, 2, -46 },
  { 7939, 14, 57, 21, 5, -47 },
  { 8039, 22, 47, 24, 1, -47 },
  { 8169, 14, 57, 21, 2, -47 },
  { 8269, 29, 26, 31, 1, -46 },
  { 8364, 29, 4, 29, 0, 6 },
  { 8379, 12, 11, 18, 3, -50 },
  { 8396, 23, 36, 30, 2, -35 },
  { 8500, 25, 50, 33, 5, -49 },
  { 8657, 21, 37, 25, 3, -36 },
  { 8755, 25, 50, 33, 3, -49 },
  { 8912, 24, 36, 30, 3, -35 },
  { 9020, 19, 50, 18, 1, -50 },
  { 9139, 25, 52, 33, 3, -36 },
  { 9302, 23, 49, 33, 5, -49 },
  { 9443, 6, 48, 15, 4, -48 },
  { 9479, 12, 64, 15, -2, -48 },
  { 9575, 23, 49, 29, 5, -49 },
  { 9716, 5, 49, 15, 5, -49 },
  { 9747, 40, 36, 49, 5, -36 },
  { 9927, 23, 36, 33, 5, -36 },
  { 10031, 26, 37, 32, 3, -36 },
  { 10152, 25, 52, 33, 5, -36 },
  { 10315, 25, 52, 33, 3, -36 },
  { 10478, 16, 36, 22, 5, -36 },
  { 10550, 20, 37, 25, 2, -36 },
  { 10643, 17, 44, 19, 1, -43 },
  { 10737, 24, 36, 33, 4, -35 },
  { 10845, 27, 35, 27, 0, -35 },
  { 10964, 41, 35, 43, 1, -35 },
  { 11144, 25, 35, 27, 1, -35 },
  { 11254, 27, 51, 27, 0, -35 },
  { 11427, 19, 35, 23, 2, -35 },
  { 11511, 19, 57, 24, 2, -47 },
  { 11647, 5, 65, 29, 12, -50 },
  { 11688, 19, 57, 24, 2, -47 },
  { 11824, 26, 8, 31, 2, -27 },
};

const GFXfont NotoSans_Condensed_Regular65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_REGULAR65PT7B_H_
