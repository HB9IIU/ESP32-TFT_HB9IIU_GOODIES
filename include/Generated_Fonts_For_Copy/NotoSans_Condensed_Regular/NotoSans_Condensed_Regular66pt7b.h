#ifndef _NOTOSANS_CONDENSED_REGULAR66PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E,
  0x18, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0xFB, 0xF0, 0x3E, 0xFC, 0x0F,
  0xBF, 0x03, 0xEF, 0xC0, 0xFB, 0xF0, 0x3E, 0x7C, 0x0F, 0x9F, 0x03, 0xE7,
  0x80, 0xF9, 0xE0, 0x3E, 0x78, 0x0F, 0x9E, 0x03, 0xE7, 0x80, 0xF9, 0xE0,
  0x1E, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xE0,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00,
  0x00, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xF7, 0x1F, 0x8F, 0xC3,
  0x80, 0xC7, 0xC1, 0xC0, 0x07, 0xE0, 0xE0, 0x03, 0xE0, 0x70, 0x01, 0xF0,
  0x38, 0x00, 0xF8, 0x1C, 0x00, 0x7C, 0x0E, 0x00, 0x3F, 0x07, 0x00, 0x1F,
  0x83, 0x80, 0x07, 0xE1, 0xC0, 0x03, 0xF8, 0xE0, 0x00, 0xFF, 0x70, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xEF, 0xF0, 0x00, 0x71,
  0xFC, 0x00, 0x38, 0x7F, 0x00, 0x1C, 0x1F, 0x80, 0x0E, 0x07, 0xC0, 0x07,
  0x03, 0xE0, 0x03, 0x81, 0xF0, 0x01, 0xC0, 0xF8, 0x00, 0xE0, 0x7C, 0x00,
  0x70, 0x3F, 0x00, 0x38, 0x3E, 0xE0, 0x1C, 0x3F, 0x7F, 0x0E, 0xFF, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x07,
  0xFE, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xC0, 0x03, 0xE7, 0xE0,
  0x03, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x00, 0x7C,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x3E, 0x00, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0x07, 0x80, 0x78, 0x0F, 0x00,
  0x03, 0xC0, 0x3C, 0x0F, 0x80, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x83, 0xE0, 0x00, 0x3C, 0x03, 0xC1,
  0xE0, 0x00, 0x1F, 0x01, 0xE1, 0xF0, 0x7E, 0x0F, 0x81, 0xF0, 0xF0, 0x7F,
  0x87, 0xC0, 0xF8, 0xF8, 0x7F, 0xE1, 0xE0, 0x7C, 0x7C, 0x7F, 0xF8, 0xF0,
  0x3C, 0x3C, 0x7E, 0x7C, 0x7C, 0x3E, 0x3E, 0x3E, 0x1F, 0x1F, 0x3F, 0x1E,
  0x1E, 0x07, 0x8F, 0xFF, 0x1F, 0x1F, 0x03, 0xE3, 0xFF, 0x0F, 0x8F, 0x81,
  0xF0, 0xFF, 0x07, 0x87, 0xC0, 0xF8, 0x1E, 0x07, 0xC3, 0xC0, 0x3C, 0x00,
  0x03, 0xC1, 0xE0, 0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x0F, 0x00, 0x01, 0xF0,
  0x78, 0x07, 0x80, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x00, 0xF8, 0x1E, 0x01,
  0xE0, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0x1E, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x03,
  0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0xBF, 0x00, 0x7C, 0x0F,
  0xC3, 0xF0, 0x0F, 0x83, 0xF8, 0x7F, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E,
  0x1F, 0x80, 0x7E, 0x0F, 0x83, 0xF0, 0x0F, 0xE1, 0xF0, 0x7C, 0x00, 0xFE,
  0x7E, 0x0F, 0x80, 0x0F, 0xCF, 0x83, 0xF0, 0x00, 0xFF, 0xF0, 0x7E, 0x00,
  0x1F, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0x81, 0xF8, 0x00, 0x1F, 0xF0, 0x1F,
  0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x1F, 0xF8,
  0x0F, 0xE0, 0x07, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0xF1, 0xFF,
  0x7F, 0x01, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0x01, 0xFF,
  0xFC, 0x07, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E,
  0x78, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x3C, 0x06, 0x7E, 0x1E,
  0x3F, 0x3F, 0xEE, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x03, 0xC0, 0x03, 0x00, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x87, 0xF1,
  0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x18, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x1F,
  0xE0, 0x7E, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00,
  0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x01, 0xF3, 0xE0,
  0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xE7, 0xC0,
  0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x03, 0xFC, 0x7F, 0x80,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x3F, 0xBF, 0x7F, 0x3F, 0xFE, 0x3F,
  0xFC, 0x3F, 0x78, 0x3F, 0x30, 0x3F, 0x20, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x1F, 0xE0, 0xFF, 0x83, 0xE0, 0x0F,
  0xF0, 0x60, 0x00, 0xFC, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xE1, 0xE0, 0x03, 0xF8,
  0x60, 0x00, 0xFC, 0x20, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x40, 0x00,
  0x3F, 0x38, 0x00, 0x7F, 0x9F, 0x80, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xBF, 0x00, 0x00, 0x7D, 0xF8,
  0x00, 0x03, 0xCF, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x01, 0xE3, 0xF0, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x78,
  0x3F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7E,
  0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0xFC, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0,
  0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x7F, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x30, 0x07, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x80, 0x00, 0xFE, 0x70,
  0x00, 0xFF, 0x3F, 0x83, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xE0, 0x30, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0x8F, 0xFC, 0x0F,
  0xCF, 0xFF, 0x87, 0xEF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF9, 0xFF, 0xC3, 0xFC,
  0xFF, 0x80, 0x7F, 0x7F, 0x80, 0x1F, 0xBF, 0x80, 0x07, 0xDF, 0xC0, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x1F, 0x81,
  0xFE, 0x3F, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x83, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0,
  0x3F, 0x87, 0xE0, 0x0F, 0xF7, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0xFE,
  0x7F, 0x80, 0x7F, 0x0F, 0xF0, 0x3F, 0x00, 0xFE, 0x1F, 0x80, 0x1F, 0xC7,
  0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF1, 0xFE, 0x03, 0xFC, 0x3F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x1F, 0xE0, 0xFC, 0x03, 0xF0,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFD, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0x9F, 0xE1, 0xFF, 0xC7,
  0xFF, 0xF7, 0xE3, 0xFF, 0xFB, 0xF0, 0xFF, 0xF9, 0xF8, 0x1F, 0xF0, 0xF8,
  0x00, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFC, 0x06, 0x07, 0xFC, 0x03, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E,
  0x18, 0x0F, 0x07, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0x7E, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x87, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xE3, 0xF0, 0xFC, 0x3F, 0x0F,
  0x83, 0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0x0F, 0xF9, 0xC0, 0x1F, 0xC8, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x78, 0x1F, 0x00, 0x02, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xFE,
  0x03, 0xC1, 0xE0, 0x0F, 0xFF, 0xC0, 0xF0, 0xF8, 0x07, 0xFF, 0xF0, 0x3E,
  0x3E, 0x03, 0xF8, 0xFC, 0x0F, 0x8F, 0x00, 0xF8, 0x1F, 0x01, 0xE7, 0xC0,
  0x7C, 0x07, 0xC0, 0x79, 0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x7C, 0x0F, 0x80,
  0x7C, 0x07, 0x9E, 0x03, 0xE0, 0x1F, 0x01, 0xF7, 0x80, 0xF8, 0x07, 0xC0,
  0x7D, 0xE0, 0x3C, 0x01, 0xF0, 0x1F, 0xF8, 0x1F, 0x00, 0x78, 0x07, 0xFE,
  0x07, 0xC0, 0x1E, 0x01, 0xFF, 0x81, 0xF0, 0x07, 0x80, 0x7B, 0xE0, 0x7C,
  0x03, 0xE0, 0x1E, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xBE, 0x07, 0xC0, 0x3E,
  0x01, 0xEF, 0x81, 0xF0, 0x0F, 0x80, 0x7B, 0xE0, 0x3C, 0x03, 0xE0, 0x3E,
  0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x1E, 0x03, 0xE0, 0x7F, 0x07, 0xC7, 0x80,
  0xFC, 0x3D, 0xC1, 0xF1, 0xF0, 0x1F, 0xDE, 0x7D, 0xF8, 0x7C, 0x07, 0xFF,
  0x9F, 0xFC, 0x1F, 0x00, 0xFF, 0xC3, 0xFE, 0x03, 0xE0, 0x1F, 0xE0, 0x7F,
  0x00, 0xF8, 0x00, 0xC0, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x20, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x0F, 0xCF, 0x80,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x01,
  0xFF, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xDF,
  0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x7F,
  0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x1F, 0x80, 0x0F, 0xF3, 0xF0, 0x00, 0xFE,
  0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xDF,
  0x80, 0x0F, 0xF3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xF0, 0x7E, 0x07, 0xFC, 0x00, 0xE0, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x60, 0x3F, 0xFD, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xC0,
  0x07, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x83, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFE, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x78, 0x0F, 0xF0,
  0x00, 0x08, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xBE, 0x00, 0x0F, 0xFF, 0xDF, 0x00, 0x07, 0xFF, 0xEF, 0xC0, 0x03, 0xFF,
  0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x0F, 0xC0, 0xFF,
  0x00, 0x07, 0xE0, 0x7F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xE0, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x83, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0xB9, 0xFE, 0x7F, 0xFC, 0xFF, 0xF1, 0xFF,
  0xC3, 0xFF, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0xFD, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFB, 0xF0, 0x00,
  0xFF, 0x1F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0xFB,
  0xE0, 0x00, 0x03, 0xEF, 0xFD, 0xF0, 0x00, 0x01, 0xF7, 0xFE, 0x7C, 0x00,
  0x01, 0xF3, 0xFF, 0x3E, 0x00, 0x00, 0xFB, 0xFF, 0xDF, 0x00, 0x00, 0x7D,
  0xFF, 0xE7, 0xC0, 0x00, 0x7C, 0xFF, 0xF3, 0xE0, 0x00, 0x3E, 0x7F, 0xF9,
  0xF0, 0x00, 0x1F, 0x3F, 0xFC, 0xFC, 0x00, 0x0F, 0x1F, 0xFE, 0x3E, 0x00,
  0x0F, 0x8F, 0xFF, 0x1F, 0x00, 0x07, 0xC7, 0xFF, 0x8F, 0xC0, 0x03, 0xE3,
  0xFF, 0xC3, 0xE0, 0x03, 0xE1, 0xFF, 0xE1, 0xF0, 0x01, 0xF0, 0xFF, 0xF0,
  0xF8, 0x00, 0xF8, 0x7F, 0xF8, 0x3E, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x00,
  0x7C, 0x1F, 0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0xFF, 0x03, 0xE0, 0x3E, 0x07,
  0xFF, 0x81, 0xF0, 0x1F, 0x03, 0xFF, 0xC0, 0xF8, 0x0F, 0x81, 0xFF, 0xE0,
  0x3E, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0x83,
  0xE0, 0x3F, 0xFC, 0x07, 0xE1, 0xE0, 0x1F, 0xFE, 0x01, 0xF1, 0xF0, 0x0F,
  0xFF, 0x00, 0xF8, 0xF8, 0x07, 0xFF, 0x80, 0x7E, 0x7C, 0x03, 0xFF, 0xC0,
  0x1F, 0x7C, 0x01, 0xFF, 0xE0, 0x0F, 0xBE, 0x00, 0xFF, 0xF0, 0x07, 0xFF,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80,
  0x0F, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xF7, 0xE0, 0x00, 0x7F, 0xEF, 0xC0,
  0x00, 0xFF, 0xCF, 0xC0, 0x01, 0xFF, 0x9F, 0x80, 0x03, 0xFF, 0x1F, 0x80,
  0x07, 0xFF, 0x3F, 0x00, 0x0F, 0xFE, 0x3F, 0x00, 0x1F, 0xFC, 0x7E, 0x00,
  0x3F, 0xF8, 0x7E, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0xFC, 0x01,
  0xFF, 0xC1, 0xF8, 0x03, 0xFF, 0x81, 0xF8, 0x07, 0xFF, 0x03, 0xF0, 0x0F,
  0xFE, 0x03, 0xF0, 0x1F, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x7F,
  0xF0, 0x0F, 0xC0, 0xFF, 0xE0, 0x0F, 0xC1, 0xFF, 0xC0, 0x1F, 0x83, 0xFF,
  0x80, 0x1F, 0x87, 0xFF, 0x00, 0x3F, 0x0F, 0xFE, 0x00, 0x3F, 0x1F, 0xFC,
  0x00, 0x7E, 0x3F, 0xF8, 0x00, 0x7E, 0x7F, 0xF0, 0x00, 0xFC, 0xFF, 0xE0,
  0x00, 0xFD, 0xFF, 0xC0, 0x01, 0xFB, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F,
  0xC0, 0x0F, 0xFC, 0x7F, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xF3, 0xF0, 0x03,
  0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xFB,
  0xF0, 0x07, 0xF9, 0xF8, 0x1F, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x87, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xFC, 0x7F,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0,
  0x3F, 0xE0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFB, 0xFE, 0x7F, 0x80, 0x1C, 0x7F,
  0x00, 0x04, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x80, 0x00, 0xFE, 0xF0, 0x01, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xFE, 0x7F, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFF, 0xC0,
  0x03, 0xF0, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xDF,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xF9, 0xE0, 0x01, 0xF0, 0x3F, 0x00, 0x1F,
  0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0xF8, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x1F, 0x00, 0x3F, 0x01, 0xF8,
  0x03, 0xE1, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x87, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x1F,
  0x00, 0x1F, 0x01, 0xF0, 0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x07, 0xC0,
  0xFC, 0x00, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0xC0,
  0x3E, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x3E,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x79, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x78, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8,
  0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF9, 0xF8,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3E, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFE, 0xFF, 0x81, 0xC0, 0x3F, 0x82,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x7F, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFB, 0xFC, 0x03, 0xF7, 0xE0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F, 0xFF,
  0x03, 0xDF, 0x7F, 0xFF, 0xBE, 0x7F, 0xFE, 0x7C, 0x7F, 0xF8, 0xF8, 0x7F,
  0xC0, 0xF0, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x81, 0xF8, 0x03, 0xE1, 0xFF, 0x80, 0xF9, 0xFF, 0xF8,
  0x3E, 0xFF, 0xFF, 0x0F, 0xBF, 0xFF, 0xC3, 0xFE, 0x03, 0xF8, 0xFF, 0x00,
  0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x3E,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xCF, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x7E, 0x3F, 0xF0, 0x7F, 0x8F, 0xBF,
  0xFF, 0xC3, 0xC7, 0xFF, 0xE0, 0xF0, 0xFF, 0xF0, 0x3C, 0x1F, 0xF8, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xE0, 0x30, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x23, 0xFC, 0x0E, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03,
  0xFF, 0xC0, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0xFC, 0x0F, 0xFE, 0x3F, 0x07, 0xFF, 0xCF,
  0xC3, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0x7C, 0x7F, 0x03, 0xFF, 0x3F, 0x80,
  0x3F, 0xCF, 0xC0, 0x0F, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E,
  0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x01,
  0xFC, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xC7, 0xF0, 0x3D, 0xF1, 0xFF,
  0xFF, 0x7C, 0x3F, 0xFF, 0x9F, 0x07, 0xFF, 0xC7, 0xC0, 0x7F, 0xC1, 0xF0,
  0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x00, 0xFF, 0x7F, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x18, 0x3F, 0xC0, 0x7C, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0x8C, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xFF,
  0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFF, 0xE1, 0xF0, 0x7F, 0xFC, 0x7C, 0x3F, 0xFF, 0x9F, 0x1F,
  0xFF, 0xF7, 0xC7, 0xF0, 0x3F, 0xF3, 0xF8, 0x07, 0xFC, 0xFC, 0x00, 0xFF,
  0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x00, 0xFD, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xF3,
  0xF8, 0x07, 0xFC, 0x7F, 0x03, 0xDF, 0x1F, 0xFF, 0xF7, 0xC3, 0xFF, 0xF9,
  0xF0, 0x7F, 0xFC, 0xFC, 0x07, 0xFC, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x8C, 0x00, 0x1F, 0xC3, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0xF8, 0xFF, 0xF0, 0xF9,
  0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xFF, 0x80, 0xFE, 0xFF,
  0x00, 0x7E, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x38, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF,
  0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3,
  0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C,
  0x00, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x07, 0xC0,
  0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFD,
  0x0F, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF, 0x1F, 0xF0, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x02, 0xF8, 0x00, 0xFC, 0xF8, 0x01,
  0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07,
  0xE0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8,
  0x00, 0xFB, 0xF8, 0x00, 0xFB, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0x7E, 0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x1F,
  0x80, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07,
  0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xF0, 0xFF, 0xE0, 0x3F, 0xF8, 0xF1, 0xFF,
  0xF0, 0xFF, 0xFC, 0xFB, 0xFF, 0xF9, 0xFF, 0xFE, 0xFB, 0xFF, 0xF9, 0xFF,
  0xFE, 0xFF, 0x81, 0xFF, 0xC0, 0x7E, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0xF0, 0xFF, 0xF0, 0xF1, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC,
  0xFB, 0xFF, 0xFC, 0xFF, 0x80, 0xFE, 0xFF, 0x00, 0x7E, 0xFE, 0x00, 0x7E,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF1, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF8,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0xC0, 0xFF, 0x07, 0xF0,
  0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x3C, 0x1F, 0xFC, 0x0F,
  0x1F, 0xFF, 0x83, 0xEF, 0xFF, 0xF0, 0xFB, 0xFF, 0xFE, 0x3F, 0xE0, 0x3F,
  0x8F, 0xF0, 0x07, 0xF3, 0xF8, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7C,
  0xFE, 0x00, 0x3F, 0x3F, 0xC0, 0x1F, 0xCF, 0xF0, 0x07, 0xE3, 0xFF, 0x07,
  0xF8, 0xFB, 0xFF, 0xFC, 0x3E, 0x7F, 0xFE, 0x0F, 0x8F, 0xFF, 0x03, 0xE1,
  0xFF, 0x80, 0xF8, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xE1,
  0xF0, 0x7F, 0xFC, 0x7C, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0xF7, 0xC7, 0xF0,
  0x3F, 0xF3, 0xF8, 0x03, 0xFC, 0xFC, 0x00, 0xFF, 0x7E, 0x00, 0x1F, 0xDF,
  0x80, 0x07, 0xF7, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x7F, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xF3, 0xF8, 0x07, 0xFC, 0x7F,
  0x87, 0xDF, 0x1F, 0xFF, 0xE7, 0xC3, 0xFF, 0xFB, 0xF0, 0x7F, 0xFC, 0xFC,
  0x07, 0xFC, 0x3F, 0x00, 0x78, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xF8, 0x3F, 0xBC,
  0x3F, 0xDE, 0x3F, 0xEF, 0x3F, 0xF7, 0xDF, 0x9B, 0xFE, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xEF, 0xE0, 0x1C, 0xFC, 0x00, 0x4F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x3E, 0xC0, 0x07, 0xEF, 0x81, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x82, 0x0F, 0xFF, 0x07, 0xFF,
  0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x07, 0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xBE, 0x00, 0x1F, 0xDF, 0x00, 0x0F, 0xEF, 0xC0, 0x0F, 0xF7, 0xE0,
  0x07, 0xFB, 0xF8, 0x07, 0xFC, 0xFF, 0x0F, 0xBE, 0x7F, 0xFF, 0x9F, 0x1F,
  0xFF, 0xCF, 0x87, 0xFF, 0xC7, 0xC1, 0xFF, 0x83, 0xE0, 0x0E, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7E, 0x00,
  0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01,
  0xF0, 0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x1F,
  0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xEF, 0xC0, 0x07,
  0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xFE, 0x00, 0x3E, 0x7C, 0x00, 0x7F, 0x80,
  0x1F, 0x9F, 0x80, 0x3F, 0xE0, 0x07, 0xE7, 0xE0, 0x0F, 0xF8, 0x01, 0xF1,
  0xF8, 0x03, 0xDF, 0x00, 0x7C, 0x3E, 0x00, 0xF7, 0xC0, 0x3F, 0x0F, 0x80,
  0x7D, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x3C, 0x03, 0xE0, 0xFC, 0x07, 0xCF,
  0x80, 0xF8, 0x1F, 0x01, 0xE3, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0xF8, 0x1F,
  0x81, 0xF0, 0x3E, 0x1E, 0x07, 0xC0, 0x7E, 0x0F, 0x87, 0xC1, 0xF0, 0x0F,
  0x83, 0xC1, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x7C, 0x3F, 0x00, 0xF8, 0x7C,
  0x1F, 0x0F, 0x80, 0x3F, 0x1F, 0x03, 0xC3, 0xE0, 0x0F, 0xC7, 0xC0, 0xF8,
  0xF8, 0x01, 0xF1, 0xE0, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x0F, 0x9F, 0x00,
  0x1F, 0x3E, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x7D, 0xF0, 0x00, 0xFB,
  0xC0, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x07, 0xDF, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xF8,
  0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x3F, 0x00, 0xFC,
  0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE1, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x1F, 0x80, 0x07, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x07, 0xC0,
  0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x80,
  0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83,
  0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x7F,
  0xC0, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x10, 0x00, 0x00, 0x01, 0x00, 0x00, 0x23, 0xFE,
  0x00, 0x04, 0xFF, 0xF0, 0x01, 0xBF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xF6, 0x00, 0x1F, 0xFC, 0x80, 0x00,
  0x7C, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 48, 16, 4, -47 },
  { 49, 18, 17, 26, 4, -47 },
  { 88, 32, 47, 34, 1, -47 },
  { 276, 25, 54, 31, 3, -50 },
  { 445, 41, 49, 47, 3, -48 },
  { 697, 35, 49, 37, 2, -48 },
  { 912, 6, 17, 14, 4, -47 },
  { 925, 14, 57, 19, 3, -47 },
  { 1025, 14, 57, 19, 2, -47 },
  { 1125, 25, 24, 29, 2, -50 },
  { 1200, 27, 31, 31, 2, -39 },
  { 1305, 10, 17, 16, 2, -8 },
  { 1327, 15, 5, 19, 2, -20 },
  { 1337, 8, 9, 16, 4, -8 },
  { 1346, 23, 47, 24, 1, -47 },
  { 1482, 25, 49, 31, 3, -48 },
  { 1636, 16, 47, 31, 5, -47 },
  { 1730, 26, 48, 31, 2, -48 },
  { 1886, 25, 49, 31, 3, -48 },
  { 2040, 29, 47, 31, 1, -47 },
  { 2211, 25, 48, 31, 3, -47 },
  { 2361, 25, 49, 31, 3, -48 },
  { 2515, 27, 47, 31, 2, -47 },
  { 2674, 26, 49, 31, 3, -48 },
  { 2834, 25, 49, 31, 3, -48 },
  { 2988, 8, 37, 16, 4, -36 },
  { 3025, 10, 45, 16, 2, -36 },
  { 3082, 27, 31, 31, 2, -39 },
  { 3187, 26, 18, 31, 3, -32 },
  { 3246, 27, 31, 31, 2, -39 },
  { 3351, 21, 49, 23, 1, -48 },
  { 3480, 42, 53, 48, 3, -47 },
  { 3759, 33, 47, 33, 0, -47 },
  { 3953, 27, 47, 35, 5, -47 },
  { 4112, 28, 49, 33, 3, -48 },
  { 4284, 30, 47, 38, 5, -47 },
  { 4461, 21, 47, 30, 5, -47 },
  { 4585, 21, 47, 28, 5, -47 },
  { 4709, 33, 49, 40, 3, -48 },
  { 4912, 29, 47, 39, 5, -47 },
  { 5083, 15, 47, 20, 2, -47 },
  { 5172, 15, 60, 16, -4, -47 },
  { 5285, 28, 47, 33, 5, -47 },
  { 5450, 21, 47, 28, 5, -47 },
  { 5574, 41, 47, 51, 5, -47 },
  { 5815, 31, 47, 41, 5, -47 },
  { 5998, 34, 49, 41, 3, -48 },
  { 6207, 25, 47, 32, 5, -47 },
  { 6354, 34, 59, 41, 3, -48 },
  { 6605, 28, 47, 34, 5, -47 },
  { 6770, 24, 49, 30, 3, -48 },
  { 6917, 27, 47, 29, 1, -47 },
  { 7076, 29, 48, 39, 5, -47 },
  { 7250, 32, 47, 32, 0, -47 },
  { 7438, 51, 47, 52, 0, -47 },
  { 7738, 30, 47, 30, 0, -47 },
  { 7915, 29, 47, 29, 0, -47 },
  { 8086, 24, 47, 28, 2, -47 },
  { 8227, 14, 58, 21, 5, -47 },
  { 8329, 23, 47, 24, 1, -47 },
  { 8465, 14, 58, 21, 2, -47 },
  { 8567, 29, 26, 32, 1, -47 },
  { 8662, 29, 4, 29, 0, 6 },
  { 8677, 12, 11, 18, 3, -51 },
  { 8694, 23, 37, 30, 3, -36 },
  { 8801, 26, 51, 34, 5, -50 },
  { 8967, 21, 37, 26, 3, -36 },
  { 9065, 26, 51, 34, 3, -50 },
  { 9231, 25, 37, 30, 3, -36 },
  { 9347, 19, 50, 18, 1, -50 },
  { 9466, 26, 52, 34, 3, -36 },
  { 9635, 24, 50, 33, 5, -50 },
  { 9785, 7, 49, 15, 4, -49 },
  { 9828, 13, 65, 15, -2, -49 },
  { 9934, 24, 50, 29, 5, -50 },
  { 10084, 5, 50, 15, 5, -50 },
  { 10116, 40, 36, 50, 5, -36 },
  { 10296, 24, 36, 33, 5, -36 },
  { 10404, 27, 37, 33, 3, -36 },
  { 10529, 26, 52, 34, 5, -36 },
  { 10698, 26, 52, 34, 3, -36 },
  { 10867, 17, 36, 22, 5, -36 },
  { 10944, 20, 37, 25, 3, -36 },
  { 11037, 17, 44, 19, 1, -43 },
  { 11131, 25, 36, 33, 4, -35 },
  { 11244, 27, 35, 27, 0, -35 },
  { 11363, 42, 35, 44, 1, -35 },
  { 11547, 26, 35, 28, 1, -35 },
  { 11661, 27, 51, 27, 0, -35 },
  { 11834, 20, 35, 23, 2, -35 },
  { 11922, 20, 58, 24, 2, -47 },
  { 12067, 5, 66, 30, 12, -50 },
  { 12109, 19, 58, 24, 3, -47 },
  { 12247, 27, 9, 31, 2, -28 },
};

const GFXfont NotoSans_Condensed_Regular66pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular66pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular66pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _NOTOSANS_CONDENSED_REGULAR66PT7B_H_
