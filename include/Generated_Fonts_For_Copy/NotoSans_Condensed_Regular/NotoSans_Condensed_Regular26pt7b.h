#ifndef _NOTOSANS_CONDENSED_REGULAR26PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0x80, 0xDF, 0x00, 0xCF, 0x9B, 0x36,
  0x6C, 0xD9, 0xB3, 0x00, 0x0C, 0xC0, 0x8C, 0x08, 0xC1, 0x8C, 0x18, 0xC1,
  0x88, 0xFF, 0xF1, 0x98, 0x11, 0x81, 0x18, 0x31, 0x83, 0x18, 0xFF, 0xE3,
  0x10, 0x33, 0x02, 0x30, 0x23, 0x06, 0x30, 0x63, 0x00, 0x0C, 0x03, 0x00,
  0xC0, 0xFF, 0x7D, 0xB3, 0x0C, 0xC3, 0x30, 0x6C, 0x1F, 0x03, 0xE0, 0x3E,
  0x0D, 0xC3, 0x30, 0xCC, 0x33, 0xCD, 0xBF, 0xE1, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0x38, 0x18, 0x7C, 0x18, 0x4C, 0x30, 0xC4, 0x30, 0xC6, 0x60, 0xC6,
  0x60, 0xC6, 0x40, 0xC6, 0xC0, 0xC4, 0xDE, 0x4D, 0x93, 0x7D, 0xB3, 0x39,
  0x31, 0x03, 0x31, 0x03, 0x31, 0x06, 0x31, 0x06, 0x31, 0x04, 0x33, 0x0C,
  0x1B, 0x0C, 0x1E, 0x0C, 0x01, 0xF8, 0x0C, 0xC0, 0xE3, 0x07, 0x18, 0x19,
  0xC0, 0xCC, 0x07, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x8E, 0xCE, 0x6C, 0x33,
  0x60, 0xFB, 0x07, 0x98, 0x1C, 0xE1, 0xE3, 0xFD, 0x8F, 0x8E, 0xFF, 0xFC,
  0x0C, 0x63, 0x8C, 0x31, 0x86, 0x18, 0xE3, 0x0C, 0x30, 0xC3, 0x0E, 0x18,
  0x61, 0x87, 0x0C, 0x30, 0x61, 0xC0, 0xC7, 0x18, 0xE3, 0x18, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x19, 0xCC, 0x66, 0x33, 0x00, 0x0C, 0x03, 0x00,
  0xC3, 0x36, 0xFF, 0x87, 0x11, 0xE0, 0xDC, 0x73, 0x08, 0x80, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x76, 0x66, 0xCC, 0xFF, 0xF0, 0xDF, 0x00, 0x01, 0x80, 0xC0, 0xE0,
  0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0xC0,
  0xC0, 0x60, 0x60, 0x30, 0x38, 0x00, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0x61,
  0xF8, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E,
  0x1D, 0x86, 0x71, 0x8F, 0xE1, 0xF0, 0x0C, 0x73, 0xDF, 0xED, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x1E, 0x1F, 0xCE,
  0x39, 0x06, 0x01, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x38,
  0x0C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x1E, 0x1F, 0xCE,
  0x38, 0x06, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x3F, 0x0F, 0x80, 0xF8, 0x06,
  0x01, 0xC0, 0x30, 0x0C, 0x07, 0x81, 0xBF, 0xEF, 0xF0, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x2C, 0x06, 0xC0, 0x4C, 0x0C, 0xC1, 0x8C, 0x18, 0xC3, 0x0C,
  0x30, 0xC6, 0x0C, 0x60, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x7F, 0x1D, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x83, 0xBF,
  0xE7, 0xE0, 0x07, 0x87, 0xE3, 0x80, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x98,
  0xDF, 0xBC, 0x6E, 0x1F, 0x83, 0xC0, 0xF8, 0x36, 0x0D, 0x83, 0x71, 0x8F,
  0xE1, 0xF0, 0xFF, 0xFF, 0xF0, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E,
  0x03, 0x00, 0x1E, 0x0F, 0xE7, 0x19, 0x87, 0xE0, 0xD8, 0x36, 0x19, 0xCE,
  0x3F, 0x07, 0x83, 0xF1, 0x86, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xDF,
  0xE3, 0xF0, 0x1E, 0x0F, 0xC7, 0x3B, 0x86, 0xC1, 0xF0, 0x3C, 0x0F, 0x03,
  0xE1, 0xD8, 0x77, 0xEC, 0xFB, 0x00, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x1F,
  0xC7, 0xC0, 0xDF, 0x00, 0x00, 0x00, 0x6F, 0x80, 0x67, 0x60, 0x00, 0x00,
  0x00, 0x07, 0x66, 0x6C, 0xC0, 0x00, 0x40, 0x70, 0x78, 0x78, 0x78, 0x38,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0C, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x70, 0x3C, 0x3C, 0x3C, 0x3C, 0x0C, 0x02, 0x00, 0x3C, 0x7F, 0x91, 0xC0,
  0x60, 0x38, 0x1C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0,
  0x00, 0x00, 0x18, 0x1C, 0x06, 0x00, 0x01, 0xE0, 0x03, 0xFC, 0x07, 0x03,
  0x03, 0x00, 0xC3, 0x00, 0x23, 0x07, 0x19, 0x8F, 0xCC, 0xCE, 0x62, 0x46,
  0x31, 0xE3, 0x18, 0xF1, 0x8C, 0x78, 0x86, 0x2C, 0x63, 0x16, 0x33, 0x99,
  0x1F, 0x7C, 0xC7, 0x3C, 0x60, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0xCE,
  0x00, 0x7F, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1B, 0x00, 0xD8, 0x06,
  0xC0, 0x37, 0x03, 0x18, 0x18, 0xC0, 0xC6, 0x0E, 0x18, 0x7F, 0xC3, 0xFE,
  0x18, 0x39, 0xC0, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xF0, 0x06, 0xF8, 0x1F,
  0xF3, 0x0F, 0x60, 0xEC, 0x0D, 0x81, 0xB0, 0x36, 0x0E, 0xFF, 0x9F, 0xE3,
  0x0F, 0x60, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC1, 0xDF, 0xF3, 0xFC,
  0x00, 0x07, 0xC3, 0xFC, 0xF1, 0x9C, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0xFC, 0x3F, 0x80, 0xFC, 0x0F, 0xF0, 0xC7, 0xCC, 0x1C, 0xC0, 0xEC,
  0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x06, 0xC0, 0xEC, 0x0C, 0xC1, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x03,
  0xE0, 0x7F, 0xC7, 0x0C, 0x70, 0x07, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x07, 0xF8, 0x3F, 0xC0, 0x36, 0x01, 0xB0, 0x0D, 0xC0, 0x66,
  0x03, 0x38, 0x18, 0xFF, 0xC3, 0xFE, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0xFF, 0xF3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0xEF, 0xC0,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x7F, 0xBC, 0xC0, 0xF8, 0x1B, 0x06, 0x61, 0xCC,
  0x31, 0x8C, 0x33, 0x86, 0x60, 0xD8, 0x1F, 0x83, 0xF0, 0x77, 0x0C, 0x61,
  0x86, 0x30, 0xE6, 0x0C, 0xC1, 0xD8, 0x1B, 0x03, 0x80, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xD8, 0x0F, 0xD8, 0x1B, 0xD8, 0x1B, 0xD8, 0x1B, 0xCC, 0x33, 0xCC, 0x33,
  0xCC, 0x33, 0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC1, 0x83, 0xC1, 0x83, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03,
  0xF8, 0x3D, 0x83, 0xDC, 0x3C, 0xC3, 0xCE, 0x3C, 0x63, 0xC7, 0x3C, 0x33,
  0xC3, 0xBC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x70, 0x07,
  0x80, 0x7F, 0x83, 0x8F, 0x0C, 0x0C, 0x70, 0x39, 0x80, 0x66, 0x01, 0xB8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x1D, 0x80, 0x66,
  0x01, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x3F, 0xCC,
  0x7B, 0x06, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xB1, 0xEF, 0xF3, 0xF0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x07, 0x80, 0x7F,
  0x83, 0x8F, 0x0C, 0x0E, 0x70, 0x39, 0x80, 0x66, 0x01, 0xB8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0x60, 0x1D, 0x80, 0x66, 0x01, 0x9C,
  0x0E, 0x38, 0x70, 0x7F, 0x80, 0xFC, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0xF8, 0x1F, 0xE3, 0x3E, 0x60, 0xCC, 0x1D, 0x81, 0xB0, 0x76,
  0x0E, 0xC1, 0x9F, 0xE3, 0xF8, 0x63, 0x0C, 0x71, 0x86, 0x30, 0xE6, 0x0C,
  0xC1, 0xD8, 0x1B, 0x03, 0x80, 0x1F, 0x0F, 0xF7, 0x1B, 0x80, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x83, 0xBF, 0xEF, 0xE0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0x60, 0xEF, 0xF8, 0xFE, 0x00, 0xC0,
  0x3F, 0x01, 0x98, 0x0C, 0xC0, 0x66, 0x07, 0x38, 0x30, 0xC1, 0x86, 0x1C,
  0x30, 0xC1, 0xC6, 0x06, 0x30, 0x33, 0x81, 0x98, 0x06, 0xC0, 0x36, 0x01,
  0xF0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0xC0, 0x60, 0x3E, 0x06, 0x03, 0x60,
  0x70, 0x76, 0x0F, 0x07, 0x60, 0xF0, 0x67, 0x0F, 0x06, 0x30, 0xD8, 0x63,
  0x19, 0x8E, 0x31, 0x98, 0xC3, 0x19, 0x8C, 0x39, 0x8C, 0xC1, 0x98, 0xDC,
  0x1B, 0x0D, 0xC1, 0xB0, 0xD8, 0x1B, 0x0D, 0x80, 0xF0, 0x78, 0x0E, 0x07,
  0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x60, 0x66, 0x06, 0x30, 0xC3, 0x0C,
  0x39, 0xC1, 0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0x60, 0x0F, 0x00, 0xF0,
  0x1B, 0x81, 0x98, 0x39, 0xC3, 0x0C, 0x70, 0xE6, 0x06, 0xE0, 0x70, 0xC0,
  0x7E, 0x06, 0x60, 0xE7, 0x0C, 0x30, 0xC3, 0x18, 0x39, 0x81, 0xB8, 0x1F,
  0x00, 0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x7F,
  0xFF, 0xE0, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x7F, 0xE0, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80,
  0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03,
  0x00, 0xC0, 0x60, 0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x38, 0x0F, 0x01,
  0x30, 0x66, 0x0C, 0x63, 0x0C, 0x60, 0xD8, 0x1B, 0x01, 0x80, 0xFF, 0xFF,
  0xFC, 0xE3, 0x0C, 0x30, 0x3F, 0x3F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0xFE,
  0xE3, 0xE1, 0xE0, 0xF0, 0x7C, 0x7F, 0xFB, 0xEC, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0D, 0xF3, 0xFE, 0xE1, 0xB0, 0x7C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF8, 0x6F, 0xFB, 0x7C, 0x1F, 0x3F, 0x70,
  0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x3F, 0x1F, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x33, 0xED, 0xFF, 0x61, 0xD8, 0x3E,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0x60, 0xD8, 0x77, 0xFC, 0xF9,
  0x1F, 0x0F, 0xE6, 0x19, 0x87, 0xE0, 0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x38,
  0x06, 0x01, 0xC1, 0x3F, 0x87, 0xE0, 0x0F, 0x1F, 0x38, 0x30, 0x30, 0x30,
  0x7E, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x3E, 0x4F, 0xF6, 0x1D, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF8, 0x36, 0x0D, 0x87, 0x7F, 0xCF, 0xB0, 0x0C, 0x03, 0x00, 0xD0,
  0x77, 0xF9, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x7D, 0xFF,
  0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x30, 0xFC, 0x3F, 0xFF, 0xFF, 0xFC, 0x18, 0xC6, 0x00, 0x0C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7F, 0xF0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0x86, 0xC6, 0x66, 0x37, 0x1B,
  0x0F, 0x87, 0x63, 0x31, 0x8C, 0xC6, 0x61, 0xB0, 0xF8, 0x30, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0x3E, 0xFF, 0x7E, 0xE3, 0xC7, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1,
  0x83, 0xC1, 0x83, 0xC1, 0x83, 0xC1, 0x83, 0xDF, 0x7F, 0xF8, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C, 0x1F,
  0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFC,
  0x19, 0x83, 0x30, 0xE3, 0xF8, 0x3E, 0x00, 0xDF, 0x3F, 0xEE, 0x1B, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x86, 0xFF, 0xB7,
  0xCC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x3E, 0x5F, 0xF6, 0x1D,
  0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x36, 0x0D, 0x87, 0x7F,
  0xCF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xDF, 0xFF, 0x38,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x3E, 0x7F, 0xC0, 0xC0,
  0xC0, 0x70, 0x7C, 0x1E, 0x07, 0x03, 0x03, 0x83, 0xFE, 0xFC, 0x10, 0x60,
  0xC3, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F,
  0x1E, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x7F, 0xFB, 0xEC, 0xC0, 0xFC, 0x19, 0x83, 0x30, 0xE7, 0x18,
  0x63, 0x0C, 0x61, 0x98, 0x1B, 0x03, 0x60, 0x6C, 0x0F, 0x00, 0xE0, 0x1C,
  0x00, 0xE1, 0xC1, 0xB0, 0xE1, 0xD8, 0x70, 0xCC, 0x2C, 0x66, 0x36, 0x31,
  0x9B, 0x18, 0xCD, 0x98, 0x64, 0x6C, 0x36, 0x36, 0x1B, 0x1B, 0x07, 0x8F,
  0x03, 0xC3, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x60, 0xCE, 0x38, 0xC6, 0x1D,
  0xC1, 0xB0, 0x1C, 0x03, 0x80, 0x70, 0x1F, 0x03, 0x60, 0xCE, 0x18, 0xC6,
  0x1D, 0xC1, 0xC0, 0xC0, 0xEC, 0x19, 0x83, 0x30, 0xE7, 0x18, 0x63, 0x0C,
  0x61, 0x98, 0x1B, 0x03, 0x60, 0x6C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00,
  0x60, 0x0C, 0x03, 0x03, 0xE0, 0x78, 0x00, 0xFE, 0xFE, 0x06, 0x0C, 0x0C,
  0x18, 0x18, 0x30, 0x30, 0x70, 0x60, 0xE0, 0xFF, 0xFF, 0x01, 0x0F, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0xE0, 0xF0, 0x38, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0xF0, 0x30, 0x38, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x1C, 0x07, 0x0F, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38,
  0xF0, 0xE0, 0x70, 0x7F, 0xB8, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 19, 6, 2, -19 },
  { 9, 7, 7, 10, 2, -19 },
  { 16, 12, 19, 13, 1, -19 },
  { 45, 10, 22, 12, 1, -20 },
  { 73, 16, 19, 19, 1, -19 },
  { 111, 13, 19, 14, 1, -19 },
  { 142, 2, 7, 6, 2, -19 },
  { 144, 6, 23, 8, 1, -19 },
  { 162, 5, 23, 8, 1, -19 },
  { 177, 10, 10, 12, 1, -20 },
  { 190, 10, 12, 12, 1, -15 },
  { 205, 4, 6, 6, 1, -3 },
  { 208, 6, 2, 7, 1, -8 },
  { 210, 3, 3, 6, 2, -3 },
  { 212, 9, 19, 10, 0, -19 },
  { 234, 10, 19, 12, 1, -19 },
  { 258, 6, 19, 12, 2, -19 },
  { 273, 10, 19, 12, 1, -19 },
  { 297, 10, 19, 12, 1, -19 },
  { 321, 12, 19, 12, 0, -19 },
  { 350, 10, 19, 12, 1, -19 },
  { 374, 10, 19, 12, 1, -19 },
  { 398, 10, 19, 12, 1, -19 },
  { 422, 10, 19, 12, 1, -19 },
  { 446, 10, 19, 12, 1, -19 },
  { 470, 3, 14, 6, 2, -14 },
  { 476, 4, 17, 6, 1, -14 },
  { 485, 10, 12, 12, 1, -15 },
  { 500, 10, 7, 12, 1, -13 },
  { 509, 10, 12, 12, 1, -15 },
  { 524, 9, 19, 9, 0, -19 },
  { 546, 17, 21, 19, 1, -19 },
  { 591, 13, 19, 13, 0, -19 },
  { 622, 11, 19, 14, 2, -19 },
  { 649, 11, 19, 13, 1, -19 },
  { 676, 12, 19, 15, 2, -19 },
  { 705, 8, 19, 12, 2, -19 },
  { 724, 8, 19, 11, 2, -19 },
  { 743, 13, 19, 16, 1, -19 },
  { 774, 11, 19, 15, 2, -19 },
  { 801, 6, 19, 8, 1, -19 },
  { 816, 6, 24, 6, -2, -19 },
  { 834, 11, 19, 13, 2, -19 },
  { 861, 8, 19, 11, 2, -19 },
  { 880, 16, 19, 20, 2, -19 },
  { 918, 12, 19, 16, 2, -19 },
  { 947, 14, 19, 16, 1, -19 },
  { 981, 10, 19, 13, 2, -19 },
  { 1005, 14, 23, 16, 1, -19 },
  { 1046, 11, 19, 13, 2, -19 },
  { 1073, 10, 19, 12, 1, -19 },
  { 1097, 11, 19, 11, 0, -19 },
  { 1124, 11, 19, 15, 2, -19 },
  { 1151, 13, 19, 13, 0, -19 },
  { 1182, 20, 19, 20, 0, -19 },
  { 1230, 12, 19, 12, 0, -19 },
  { 1259, 12, 19, 12, 0, -19 },
  { 1288, 9, 19, 11, 1, -19 },
  { 1310, 5, 23, 8, 2, -19 },
  { 1325, 9, 19, 10, 0, -19 },
  { 1347, 5, 23, 8, 1, -19 },
  { 1362, 11, 11, 13, 1, -19 },
  { 1378, 11, 2, 11, 0, 2 },
  { 1381, 5, 4, 7, 1, -20 },
  { 1384, 9, 14, 12, 1, -14 },
  { 1400, 10, 20, 13, 2, -20 },
  { 1425, 8, 14, 10, 1, -14 },
  { 1439, 10, 20, 13, 1, -20 },
  { 1464, 10, 14, 12, 1, -14 },
  { 1482, 8, 20, 7, 0, -20 },
  { 1502, 10, 20, 13, 1, -14 },
  { 1527, 9, 20, 13, 2, -20 },
  { 1550, 2, 19, 6, 2, -19 },
  { 1555, 5, 25, 6, -1, -19 },
  { 1571, 9, 20, 11, 2, -20 },
  { 1594, 2, 20, 6, 2, -20 },
  { 1599, 16, 14, 20, 2, -14 },
  { 1627, 9, 14, 13, 2, -14 },
  { 1643, 11, 14, 13, 1, -14 },
  { 1663, 10, 20, 13, 2, -14 },
  { 1688, 10, 20, 13, 1, -14 },
  { 1713, 6, 14, 9, 2, -14 },
  { 1724, 8, 14, 10, 1, -14 },
  { 1738, 7, 17, 8, 0, -17 },
  { 1753, 9, 14, 13, 2, -14 },
  { 1769, 11, 14, 11, 0, -14 },
  { 1789, 17, 14, 17, 0, -14 },
  { 1819, 11, 14, 11, 0, -14 },
  { 1839, 11, 20, 11, 0, -14 },
  { 1867, 8, 14, 9, 1, -14 },
  { 1881, 8, 23, 10, 1, -19 },
  { 1904, 2, 26, 12, 5, -20 },
  { 1911, 8, 23, 10, 1, -19 },
  { 1934, 10, 4, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_Regular26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_REGULAR26PT7B_H_
