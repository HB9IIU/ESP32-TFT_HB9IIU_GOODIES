#ifndef _NOTOSANS_CONDENSED_REGULAR25PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0xE6, 0xCD, 0x9B, 0x36, 0x6C, 0xD1,
  0x80, 0x08, 0xC3, 0x18, 0x62, 0x0C, 0x41, 0x89, 0xFF, 0xFF, 0xF8, 0x8C,
  0x11, 0x86, 0x20, 0xC4, 0x7F, 0xFF, 0xFE, 0x46, 0x08, 0xC3, 0x18, 0x62,
  0x0C, 0x40, 0x0C, 0x03, 0x01, 0xF1, 0xFE, 0x6C, 0xB3, 0x0C, 0xC3, 0x30,
  0x7C, 0x0F, 0x00, 0xF0, 0x3E, 0x0C, 0xC3, 0x30, 0xCF, 0x36, 0xFF, 0x0F,
  0x00, 0xC0, 0x30, 0x38, 0x10, 0x7C, 0x30, 0xCC, 0x30, 0xCC, 0x60, 0xC4,
  0x60, 0xC4, 0x40, 0xC4, 0xC0, 0xCC, 0x9C, 0xCD, 0xBE, 0x7D, 0xB2, 0x3B,
  0x23, 0x03, 0x23, 0x02, 0x63, 0x06, 0x23, 0x06, 0x23, 0x0C, 0x22, 0x0C,
  0x36, 0x18, 0x1C, 0x1E, 0x01, 0xF8, 0x1C, 0xC0, 0xC6, 0x07, 0x30, 0x19,
  0x80, 0xDC, 0x03, 0xC0, 0x1C, 0x03, 0xE1, 0x99, 0x8D, 0x8E, 0x6C, 0x3E,
  0x60, 0xF3, 0x03, 0x1C, 0x3C, 0x7F, 0x71, 0xF1, 0xC0, 0xED, 0xB6, 0xD0,
  0x1C, 0x63, 0x0C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x30, 0xC3, 0x0E, 0x18,
  0x61, 0x83, 0x0C, 0x18, 0x70, 0xC3, 0x18, 0x63, 0x18, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x31, 0x8C, 0xC6, 0x60, 0x1C, 0x04, 0x02, 0x1D, 0x7F,
  0xF8, 0xE0, 0xD8, 0xEE, 0x22, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x6D, 0xBD, 0x80,
  0xFF, 0xC0, 0xFC, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x18,
  0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x00,
  0x1E, 0x0F, 0xC6, 0x39, 0x86, 0xE1, 0xB0, 0x6C, 0x1F, 0x07, 0xC0, 0xF0,
  0x3C, 0x1F, 0x07, 0xC1, 0xB8, 0x66, 0x19, 0x8E, 0x3F, 0x0F, 0x80, 0x0C,
  0x77, 0xFB, 0xCC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0x3E, 0x3F, 0xC4, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03,
  0x01, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x01, 0x80, 0xFF, 0xFF, 0xF0,
  0x3E, 0x3F, 0xC4, 0x38, 0x06, 0x01, 0x80, 0x60, 0x38, 0x1C, 0x3C, 0x0F,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1A, 0x0E, 0xFF, 0x3F, 0x80, 0x01,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x58, 0x1B, 0x02, 0x60, 0xCC, 0x11, 0x86,
  0x31, 0x86, 0x30, 0xCF, 0xFF, 0xFF, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xF8, 0x7F, 0x00,
  0xE0, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1A, 0x0E, 0xFF, 0x3F, 0x80, 0x0F,
  0x87, 0xE3, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x7C, 0xFF, 0xB8, 0x6E,
  0x1F, 0x03, 0xC0, 0xF8, 0x36, 0x19, 0x86, 0x3F, 0x87, 0xC0, 0xFF, 0xFF,
  0xF0, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80, 0xE0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x00, 0x3E, 0x1F, 0xE6,
  0x1B, 0x86, 0xE1, 0x98, 0x66, 0x38, 0xFC, 0x1E, 0x0F, 0xC6, 0x3B, 0x86,
  0xC0, 0xF0, 0x3C, 0x0F, 0x86, 0x7F, 0x8F, 0xC0, 0x3E, 0x1F, 0xC6, 0x3B,
  0x86, 0xC1, 0xB0, 0x6C, 0x1F, 0x07, 0xE1, 0xDD, 0xF3, 0xF8, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x7E, 0x1F, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x4D,
  0xB0, 0x00, 0x00, 0x36, 0xFE, 0xC0, 0x00, 0x40, 0x30, 0x38, 0x38, 0x3C,
  0x3C, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80, 0x30, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1C, 0x1E, 0x1E, 0x1E, 0x0E, 0x02, 0x00, 0x7E, 0xFF, 0x43,
  0x03, 0x03, 0x03, 0x03, 0x06, 0x0C, 0x1C, 0x18, 0x18, 0x10, 0x00, 0x00,
  0x18, 0x38, 0x38, 0x03, 0xE0, 0x0F, 0xF8, 0x18, 0x0C, 0x30, 0x06, 0x30,
  0x06, 0x63, 0xE2, 0x67, 0x23, 0x46, 0x23, 0xC4, 0x23, 0xCC, 0x63, 0xCC,
  0x63, 0xCC, 0x63, 0xC4, 0x62, 0xC6, 0xF6, 0x63, 0x9C, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x1E, 0x70, 0x07, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1A, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x03, 0x18, 0x18, 0xC1, 0xC6, 0x0F,
  0xF0, 0x7F, 0xC3, 0x06, 0x38, 0x31, 0x81, 0xCC, 0x06, 0xE0, 0x36, 0x01,
  0xC0, 0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC1, 0xF0, 0x7C, 0x1B, 0x0E, 0xFE,
  0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0xC0,
  0x0F, 0xC3, 0xFC, 0xE1, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1F, 0xC1,
  0xF8, 0xFE, 0x1F, 0xF3, 0x0E, 0x60, 0xEC, 0x0F, 0x81, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x36, 0x1C, 0xFF,
  0x9F, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x07, 0xE0, 0xFF, 0x8E, 0x04, 0x60, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF8, 0x0E, 0xC0, 0x76, 0x03, 0xB0,
  0x1D, 0xC0, 0xE7, 0x07, 0x1F, 0xF8, 0x7F, 0x80, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0C, 0xFF, 0xE3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x7B, 0xF0, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x33,
  0xFB, 0x80, 0xC0, 0xD8, 0x33, 0x0E, 0x61, 0x8C, 0x61, 0x9C, 0x33, 0x06,
  0xC0, 0xF8, 0x1F, 0x83, 0xB0, 0x63, 0x0C, 0x71, 0x86, 0x30, 0xE6, 0x0C,
  0xC1, 0xD8, 0x1C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x01, 0xFB, 0x03, 0xF6, 0x0D, 0xEC, 0x1B,
  0xCC, 0x37, 0x98, 0xCF, 0x31, 0x9E, 0x33, 0x3C, 0x6C, 0x78, 0xD8, 0xF0,
  0xF1, 0xE1, 0xC3, 0xC3, 0x87, 0x83, 0x0C, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x03, 0xF8, 0x3D, 0x83, 0xDC, 0x3C, 0xC3, 0xCE, 0x3C, 0x63, 0xC7, 0x3C,
  0x33, 0xC3, 0xBC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0x0F, 0x80,
  0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x01, 0xB0, 0x1D, 0xC0, 0xC6, 0x0E,
  0x3F, 0xE0, 0x7E, 0x00, 0xFC, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC3, 0xFF, 0xBF, 0x98, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xB0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x36, 0x01, 0xB0, 0x1D,
  0xC0, 0xC6, 0x0E, 0x3F, 0xE0, 0x7E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x3C, 0xFC, 0x3F, 0xCC, 0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC7,
  0x3F, 0x8F, 0xE3, 0x18, 0xC7, 0x30, 0xCC, 0x3B, 0x06, 0xC1, 0xF0, 0x30,
  0x3F, 0x3F, 0xD8, 0x3C, 0x0C, 0x06, 0x03, 0x80, 0xE0, 0x3C, 0x0F, 0x81,
  0xE0, 0x30, 0x18, 0x0C, 0x07, 0x07, 0xFF, 0x7F, 0x00, 0xFF, 0xFF, 0xFC,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x37, 0x06, 0x7F, 0xC7, 0xE0, 0xC0,
  0x3E, 0x03, 0x60, 0x76, 0x06, 0x60, 0x67, 0x06, 0x30, 0xC3, 0x0C, 0x30,
  0xC1, 0x9C, 0x19, 0x81, 0x98, 0x19, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x60, 0xC0, 0x60, 0x7C, 0x1C, 0x0D, 0x83, 0x81, 0xB0, 0x78, 0x76,
  0x0F, 0x0C, 0xE3, 0x61, 0x8C, 0x6C, 0x31, 0x8C, 0xC6, 0x31, 0x99, 0xC6,
  0x33, 0x30, 0xEC, 0x66, 0x0D, 0x84, 0xC1, 0xB0, 0xD8, 0x36, 0x1E, 0x06,
  0x83, 0xC0, 0x70, 0x78, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x60, 0x6C, 0x18,
  0xC3, 0x18, 0xC1, 0x98, 0x37, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x3C,
  0x0D, 0x81, 0x98, 0x63, 0x0C, 0x73, 0x86, 0x60, 0xFC, 0x0C, 0xC0, 0x6C,
  0x1D, 0x83, 0x38, 0x63, 0x18, 0x63, 0x06, 0xE0, 0xD8, 0x1F, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0xFF,
  0xFF, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06,
  0x03, 0x03, 0x01, 0x81, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xE0, 0x30,
  0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x06, 0x03, 0x00, 0xC0,
  0x60, 0x30, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0xFF, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0xFC, 0x0C, 0x01, 0x80,
  0x78, 0x0F, 0x03, 0x30, 0x66, 0x18, 0x63, 0x0C, 0xC0, 0xD8, 0x1C, 0xFF,
  0xFF, 0xFC, 0xE3, 0x0C, 0x30, 0x0C, 0x3F, 0x88, 0xC0, 0x30, 0x18, 0x0C,
  0xFE, 0xF3, 0xE1, 0xE0, 0xF0, 0xF8, 0x7F, 0xFB, 0xEC, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x33, 0x0F, 0xF3, 0x8E, 0xC1, 0xB0, 0x6C, 0x1B, 0x07,
  0xC1, 0xF0, 0x7C, 0x1B, 0x06, 0xE1, 0xBF, 0xCD, 0xE0, 0x0E, 0x3F, 0x71,
  0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x7F, 0x3F, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC2, 0x33, 0xED, 0xCF, 0x61, 0xF8, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0x61, 0xDF, 0xF3, 0xEC, 0x0C,
  0x1F, 0x9C, 0xEC, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC0, 0x60, 0x18, 0x0C,
  0x03, 0xF8, 0xFC, 0x1F, 0x1E, 0x30, 0x30, 0x30, 0x30, 0xFE, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x08, 0x0F,
  0xB7, 0x3D, 0x87, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0D,
  0x87, 0x7F, 0xCF, 0xB0, 0x0C, 0x03, 0x00, 0xD0, 0x67, 0xF8, 0xF8, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x63, 0xFD, 0xC7, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x18, 0xC0, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8F, 0xDE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07,
  0x0D, 0x8C, 0xCC, 0x66, 0x36, 0x1F, 0x0F, 0x86, 0x63, 0x39, 0x8C, 0xC7,
  0x61, 0xB0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x19, 0xFE, 0xFB,
  0x8F, 0x3E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3,
  0x87, 0x87, 0x0F, 0x0E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70, 0xC0, 0x0C,
  0x7F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0C, 0x0E, 0x0F, 0xC7, 0x39, 0x87, 0xE0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x36, 0x0D, 0x86, 0x3F, 0x87, 0xC0, 0x0C, 0x3F, 0xCE,
  0x3B, 0x06, 0xC1, 0xB0, 0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x6C, 0x1B, 0x86,
  0xFF, 0x37, 0x8C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1C, 0x0F,
  0xB7, 0x3D, 0x87, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0D,
  0x87, 0x7F, 0xCF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F,
  0x7F, 0x78, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x00, 0x18, 0x7F,
  0xE2, 0xC0, 0xC0, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x87, 0xFE, 0xFC,
  0x30, 0x60, 0xC7, 0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0F, 0x8F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE1, 0xF0, 0xFF, 0xF7, 0xD8, 0xC0, 0xD8, 0x36, 0x19, 0x86, 0x31, 0x8C,
  0xE3, 0x30, 0xCC, 0x1B, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x00, 0xE1, 0xC3,
  0x61, 0xC3, 0x63, 0xC3, 0x63, 0x46, 0x63, 0x66, 0x32, 0x66, 0x36, 0x66,
  0x36, 0x6C, 0x36, 0x2C, 0x16, 0x3C, 0x1C, 0x3C, 0x1C, 0x38, 0x1C, 0x18,
  0x61, 0xCC, 0x63, 0x30, 0x6C, 0x1E, 0x03, 0x80, 0xE0, 0x78, 0x1B, 0x0C,
  0xC3, 0x19, 0x86, 0xE0, 0xC0, 0xE0, 0xD8, 0x36, 0x19, 0x86, 0x31, 0x8C,
  0xE3, 0x30, 0xCC, 0x1B, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0,
  0x70, 0x18, 0x3E, 0x0F, 0x00, 0xFE, 0x0C, 0x30, 0x61, 0x83, 0x0C, 0x18,
  0x60, 0xC3, 0x07, 0xFF, 0xE0, 0x06, 0x3C, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x63, 0xC7, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xE0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC1, 0xE0, 0xC1, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x38, 0x71, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0xE1, 0x8F, 0x1C, 0x00, 0xFC, 0x77, 0xF8, 0x30,
};

const GFXglyph NotoSans_Condensed_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 18, 6, 2, -18 },
  { 6, 7, 7, 10, 1, -18 },
  { 13, 11, 18, 13, 1, -18 },
  { 38, 10, 20, 12, 1, -19 },
  { 63, 16, 18, 18, 1, -18 },
  { 99, 13, 18, 14, 1, -18 },
  { 129, 3, 7, 5, 1, -18 },
  { 132, 6, 22, 7, 1, -18 },
  { 149, 5, 22, 7, 1, -18 },
  { 163, 9, 9, 11, 1, -19 },
  { 174, 10, 12, 12, 1, -15 },
  { 189, 3, 6, 6, 1, -3 },
  { 192, 5, 2, 7, 1, -8 },
  { 194, 2, 3, 6, 2, -3 },
  { 195, 9, 18, 9, 0, -18 },
  { 216, 10, 18, 12, 1, -18 },
  { 239, 6, 18, 12, 2, -18 },
  { 253, 10, 18, 12, 1, -18 },
  { 276, 10, 18, 12, 1, -18 },
  { 299, 11, 18, 12, 0, -18 },
  { 324, 10, 18, 12, 1, -18 },
  { 347, 10, 18, 12, 1, -18 },
  { 370, 10, 18, 12, 1, -18 },
  { 393, 10, 18, 12, 1, -18 },
  { 416, 10, 18, 12, 1, -18 },
  { 439, 2, 14, 6, 2, -14 },
  { 443, 3, 17, 6, 1, -14 },
  { 450, 10, 12, 12, 1, -15 },
  { 465, 10, 7, 12, 1, -12 },
  { 474, 10, 12, 12, 1, -15 },
  { 489, 8, 18, 9, 0, -18 },
  { 507, 16, 20, 18, 1, -18 },
  { 547, 13, 18, 13, 0, -18 },
  { 577, 10, 18, 13, 2, -18 },
  { 600, 11, 18, 13, 1, -18 },
  { 625, 11, 18, 15, 2, -18 },
  { 650, 8, 18, 11, 2, -18 },
  { 668, 8, 18, 11, 2, -18 },
  { 686, 13, 18, 15, 1, -18 },
  { 716, 11, 18, 15, 2, -18 },
  { 741, 6, 18, 8, 1, -18 },
  { 755, 5, 23, 6, -1, -18 },
  { 770, 11, 18, 12, 2, -18 },
  { 795, 8, 18, 10, 2, -18 },
  { 813, 15, 18, 19, 2, -18 },
  { 847, 12, 18, 16, 2, -18 },
  { 874, 13, 18, 15, 1, -18 },
  { 904, 9, 18, 12, 2, -18 },
  { 925, 13, 22, 15, 1, -18 },
  { 961, 10, 18, 13, 2, -18 },
  { 984, 9, 18, 11, 1, -18 },
  { 1005, 11, 18, 11, 0, -18 },
  { 1030, 11, 18, 15, 2, -18 },
  { 1055, 12, 18, 12, 0, -18 },
  { 1082, 19, 18, 20, 0, -18 },
  { 1125, 11, 18, 11, 0, -18 },
  { 1150, 11, 18, 11, 0, -18 },
  { 1175, 9, 18, 11, 1, -18 },
  { 1196, 5, 22, 8, 2, -18 },
  { 1210, 9, 18, 9, 0, -18 },
  { 1231, 5, 22, 8, 1, -18 },
  { 1245, 11, 10, 12, 1, -18 },
  { 1259, 11, 2, 11, 0, 2 },
  { 1262, 5, 4, 7, 1, -19 },
  { 1265, 9, 14, 11, 1, -14 },
  { 1281, 10, 19, 13, 2, -19 },
  { 1305, 8, 14, 10, 1, -14 },
  { 1319, 10, 19, 13, 1, -19 },
  { 1343, 9, 14, 12, 1, -14 },
  { 1359, 8, 19, 7, 0, -19 },
  { 1378, 10, 20, 13, 1, -14 },
  { 1403, 9, 19, 13, 2, -19 },
  { 1425, 2, 18, 6, 2, -18 },
  { 1430, 5, 24, 6, -1, -18 },
  { 1445, 9, 19, 11, 2, -19 },
  { 1467, 2, 19, 6, 2, -19 },
  { 1472, 15, 14, 19, 2, -14 },
  { 1499, 9, 14, 13, 2, -14 },
  { 1515, 10, 14, 12, 1, -14 },
  { 1533, 10, 20, 13, 2, -14 },
  { 1558, 10, 20, 13, 1, -14 },
  { 1583, 6, 14, 8, 2, -14 },
  { 1594, 8, 14, 10, 1, -14 },
  { 1608, 7, 16, 7, 0, -16 },
  { 1622, 9, 13, 13, 2, -13 },
  { 1637, 10, 13, 10, 0, -13 },
  { 1654, 16, 13, 16, 0, -13 },
  { 1680, 10, 13, 11, 0, -13 },
  { 1697, 10, 19, 10, 0, -13 },
  { 1721, 7, 13, 9, 1, -13 },
  { 1733, 7, 22, 9, 1, -18 },
  { 1753, 2, 25, 11, 5, -19 },
  { 1760, 7, 22, 9, 1, -18 },
  { 1780, 10, 3, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_Regular25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_REGULAR25PT7B_H_
