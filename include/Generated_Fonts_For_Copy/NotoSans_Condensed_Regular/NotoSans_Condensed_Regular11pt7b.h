#ifndef _NOTOSANS_CONDENSED_REGULAR11PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xB6, 0x80, 0x29, 0x5E, 0xA5, 0x7D, 0x4A, 0x4F, 0xCC, 0x65,
  0xE4, 0x40, 0x65, 0x52, 0xA5, 0x77, 0x63, 0x49, 0x93, 0x71, 0x45, 0x08,
  0x66, 0x68, 0x9D, 0xE0, 0x29, 0x29, 0x12, 0x44, 0x89, 0x12, 0x4A, 0x50,
  0x2F, 0x55, 0x21, 0x3E, 0x42, 0x00, 0x70, 0xE0, 0x80, 0x11, 0x22, 0x44,
  0x48, 0x72, 0x93, 0x18, 0xA5, 0x4E, 0x75, 0x55, 0xF0, 0x84, 0x21, 0x11,
  0x1F, 0xF0, 0x84, 0xE1, 0x04, 0x3E, 0x11, 0x8C, 0xA5, 0x7C, 0x42, 0xE8,
  0x8E, 0x21, 0x1E, 0x68, 0x8E, 0x99, 0x9E, 0xF8, 0x44, 0x22, 0x10, 0x88,
  0x72, 0x52, 0xE5, 0x46, 0x2E, 0x72, 0xA2, 0x97, 0x84, 0x4C, 0x84, 0x40,
  0x1C, 0x1B, 0x30, 0x60, 0x80, 0xF8, 0x3E, 0xC1, 0x86, 0xC8, 0x00, 0xE1,
  0x12, 0x44, 0x04, 0x7A, 0x1B, 0x73, 0xD7, 0x5A, 0xE0, 0x78, 0x20, 0xC3,
  0x14, 0x49, 0xE8, 0xA3, 0xE9, 0x9F, 0x99, 0x9F, 0x78, 0x88, 0x88, 0x87,
  0xE4, 0xA3, 0x18, 0xC6, 0x5C, 0xF2, 0x79, 0x27, 0xF2, 0x4F, 0x24, 0x7C,
  0x21, 0x09, 0xC6, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xE9, 0x24, 0x97,
  0x24, 0x92, 0x49, 0x38, 0x95, 0xA9, 0x8A, 0x52, 0x53, 0x92, 0x49, 0x27,
  0x87, 0x8F, 0x2E, 0x5A, 0xB5, 0x6C, 0xC9, 0x8E, 0x73, 0x5A, 0xCE, 0x71,
  0x74, 0x63, 0x18, 0xC6, 0x2E, 0xE9, 0x99, 0xE8, 0x88, 0x74, 0x63, 0x18,
  0xC6, 0x2E, 0x10, 0xC0, 0xE9, 0x99, 0xEA, 0x99, 0x72, 0x10, 0xC3, 0x04,
  0x5E, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6, 0x5E, 0x8C,
  0x52, 0xA5, 0x28, 0xC4, 0x89, 0xC4, 0x96, 0x4A, 0xA5, 0x52, 0xB0, 0x98,
  0x44, 0x8A, 0x94, 0x42, 0x29, 0x51, 0x8A, 0x94, 0xA2, 0x10, 0x84, 0xF1,
  0x12, 0x24, 0x4F, 0xEA, 0xAA, 0xB0, 0x84, 0x44, 0x22, 0x21, 0xE4, 0x92,
  0x49, 0x3C, 0x21, 0x94, 0x98, 0x80, 0xF8, 0xE0, 0x71, 0x35, 0x97, 0x88,
  0xE9, 0x99, 0x9E, 0xF2, 0x49, 0xC0, 0x08, 0x5E, 0x98, 0xC5, 0x2F, 0xEA,
  0xF8, 0x8E, 0x6B, 0xA4, 0x92, 0x7A, 0x63, 0x14, 0xBC, 0x33, 0x60, 0x88,
  0xE9, 0x99, 0x99, 0xBF, 0x45, 0x55, 0x58, 0x88, 0xBA, 0xCC, 0xA9, 0xFF,
  0xED, 0x26, 0x4C, 0x99, 0x32, 0x40, 0xE9, 0x99, 0x99, 0x72, 0x63, 0x14,
  0xB8, 0xE9, 0x99, 0x9E, 0x88, 0x80, 0x7A, 0x63, 0x14, 0xBC, 0x21, 0x08,
  0xF2, 0x49, 0x00, 0x78, 0x43, 0x1E, 0x5D, 0x24, 0x98, 0x99, 0x99, 0x9F,
  0x9C, 0x94, 0xA6, 0x10, 0x93, 0x25, 0xAB, 0x66, 0xCC, 0x80, 0x95, 0x26,
  0x59, 0x9C, 0x94, 0xA6, 0x10, 0x88, 0x80, 0xF2, 0x24, 0x4F, 0x32, 0x22,
  0xC4, 0x22, 0x23, 0xFF, 0xE0, 0xC4, 0x44, 0x32, 0x44, 0x4C, 0x4D, 0xC0,
};

const GFXglyph NotoSans_Condensed_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 3, 1, -8 },
  { 2, 3, 3, 4, 1, -8 },
  { 4, 5, 8, 6, 0, -8 },
  { 9, 4, 9, 5, 1, -8 },
  { 14, 7, 8, 8, 0, -8 },
  { 21, 6, 8, 6, 0, -8 },
  { 27, 1, 3, 2, 1, -8 },
  { 28, 3, 10, 3, 0, -8 },
  { 32, 3, 10, 3, 0, -8 },
  { 36, 4, 4, 5, 0, -8 },
  { 38, 5, 5, 5, 0, -6 },
  { 42, 2, 2, 3, 0, -1 },
  { 43, 3, 1, 3, 0, -3 },
  { 44, 1, 1, 3, 1, -1 },
  { 45, 4, 8, 4, 0, -8 },
  { 49, 5, 8, 5, 0, -8 },
  { 54, 2, 8, 5, 1, -8 },
  { 56, 5, 8, 5, 0, -8 },
  { 61, 5, 8, 5, 0, -8 },
  { 66, 5, 8, 5, 0, -8 },
  { 71, 4, 8, 5, 1, -8 },
  { 75, 4, 8, 5, 1, -8 },
  { 79, 5, 8, 5, 0, -8 },
  { 84, 5, 8, 5, 0, -8 },
  { 89, 5, 8, 5, 0, -8 },
  { 94, 1, 6, 3, 1, -6 },
  { 95, 2, 7, 3, 0, -6 },
  { 97, 5, 5, 5, 0, -6 },
  { 101, 5, 3, 5, 0, -5 },
  { 103, 5, 5, 5, 0, -6 },
  { 107, 4, 8, 4, 0, -8 },
  { 111, 6, 9, 8, 1, -8 },
  { 118, 6, 8, 6, 0, -8 },
  { 124, 4, 8, 6, 1, -8 },
  { 128, 4, 8, 6, 1, -8 },
  { 132, 5, 8, 6, 1, -8 },
  { 137, 3, 8, 5, 1, -8 },
  { 140, 3, 8, 5, 1, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 5, 8, 7, 1, -8 },
  { 153, 3, 8, 3, 0, -8 },
  { 156, 3, 10, 3, -1, -8 },
  { 160, 5, 8, 5, 1, -8 },
  { 165, 3, 8, 5, 1, -8 },
  { 168, 7, 8, 9, 1, -8 },
  { 175, 5, 8, 7, 1, -8 },
  { 180, 5, 8, 7, 1, -8 },
  { 185, 4, 8, 5, 1, -8 },
  { 189, 5, 10, 7, 1, -8 },
  { 196, 4, 8, 6, 1, -8 },
  { 200, 5, 8, 5, 0, -8 },
  { 205, 5, 8, 5, 0, -8 },
  { 210, 5, 8, 6, 1, -8 },
  { 215, 5, 8, 5, 0, -8 },
  { 220, 9, 8, 9, 0, -8 },
  { 229, 5, 8, 5, 0, -8 },
  { 234, 5, 8, 5, 0, -8 },
  { 239, 4, 8, 5, 0, -8 },
  { 243, 2, 10, 3, 1, -8 },
  { 246, 4, 8, 4, 0, -8 },
  { 250, 3, 10, 3, 0, -8 },
  { 254, 5, 5, 5, 0, -8 },
  { 258, 5, 1, 5, 0, 1 },
  { 259, 3, 1, 3, 0, -8 },
  { 260, 4, 6, 5, 0, -6 },
  { 263, 4, 8, 6, 1, -8 },
  { 267, 3, 6, 4, 1, -6 },
  { 270, 5, 8, 6, 0, -8 },
  { 275, 4, 6, 5, 1, -6 },
  { 278, 3, 8, 3, 0, -8 },
  { 281, 5, 9, 6, 0, -6 },
  { 287, 4, 8, 6, 1, -8 },
  { 291, 1, 8, 2, 1, -8 },
  { 292, 2, 11, 2, 0, -8 },
  { 295, 4, 8, 5, 1, -8 },
  { 299, 1, 8, 2, 1, -8 },
  { 300, 7, 6, 8, 1, -6 },
  { 306, 4, 6, 6, 1, -6 },
  { 309, 5, 6, 5, 0, -6 },
  { 313, 4, 9, 6, 1, -6 },
  { 318, 5, 9, 6, 0, -6 },
  { 324, 3, 6, 4, 1, -6 },
  { 327, 4, 6, 4, 0, -6 },
  { 330, 3, 7, 3, 0, -7 },
  { 333, 4, 6, 6, 1, -6 },
  { 336, 5, 6, 5, 0, -6 },
  { 340, 7, 6, 7, 0, -6 },
  { 346, 4, 6, 5, 0, -6 },
  { 349, 5, 9, 5, 0, -6 },
  { 355, 4, 6, 4, 0, -6 },
  { 358, 4, 10, 4, 0, -8 },
  { 363, 1, 11, 5, 2, -8 },
  { 365, 4, 10, 4, 0, -8 },
  { 370, 5, 2, 5, 0, -5 },
};

const GFXfont NotoSans_Condensed_Regular11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_REGULAR11PT7B_H_
