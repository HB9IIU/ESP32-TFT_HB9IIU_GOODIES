#ifndef _NOTOSANS_CONDENSED_REGULAR23PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xEE, 0x89, 0x12, 0x24, 0x48, 0x80, 0x0C,
  0xC1, 0x98, 0x22, 0x04, 0x47, 0xFE, 0xFF, 0xC6, 0x60, 0xCC, 0x19, 0x82,
  0x23, 0xFF, 0x88, 0x83, 0x10, 0x66, 0x0C, 0xC1, 0x98, 0x08, 0x06, 0x1F,
  0xDD, 0x2C, 0x86, 0x43, 0x20, 0xF0, 0x3C, 0x07, 0x82, 0xE1, 0x30, 0x9C,
  0x5F, 0xFC, 0xF8, 0x08, 0x04, 0x00, 0x30, 0x01, 0xE1, 0x8C, 0x86, 0x33,
  0x10, 0xCC, 0xC3, 0x32, 0x0C, 0xD8, 0x33, 0x6E, 0xC9, 0x6D, 0xED, 0x13,
  0x24, 0x41, 0x91, 0x04, 0x44, 0x31, 0x10, 0xC4, 0x42, 0x1B, 0x18, 0x38,
  0x1C, 0x03, 0xE0, 0x66, 0x06, 0x30, 0x63, 0x06, 0x60, 0x36, 0x03, 0xC0,
  0x38, 0x06, 0xC6, 0xC6, 0x6C, 0x74, 0xC3, 0xCC, 0x1C, 0xC3, 0xCF, 0xFE,
  0x7E, 0x70, 0xE9, 0x24, 0x80, 0x18, 0x8C, 0x46, 0x31, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x0C, 0x63, 0x0C, 0x21, 0x80, 0x86, 0x18, 0xC3, 0x18, 0xC6,
  0x18, 0xC6, 0x31, 0x88, 0xC6, 0x33, 0x19, 0x8C, 0x00, 0x18, 0x18, 0x18,
  0xDB, 0xFF, 0x18, 0x3C, 0x66, 0x24, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87,
  0xFF, 0xFE, 0x10, 0x08, 0x04, 0x02, 0x00, 0x6D, 0xED, 0x80, 0xFF, 0xC0,
  0x7D, 0x80, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x1C, 0x1F, 0x18, 0xCC, 0x6C, 0x16,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x19, 0x8C, 0xFE,
  0x3E, 0x00, 0x1B, 0xFF, 0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0x3F, 0x31, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x06, 0x07, 0x03,
  0x03, 0x03, 0x03, 0x81, 0x81, 0xFF, 0xFF, 0x80, 0x1C, 0x7F, 0x30, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x1C, 0x3C, 0x07, 0x80, 0xC0, 0x30, 0x18, 0x0C,
  0x0D, 0xDE, 0xFE, 0x00, 0x03, 0x80, 0xE0, 0x78, 0x16, 0x0D, 0x82, 0x61,
  0x98, 0x46, 0x31, 0x88, 0x66, 0x19, 0x06, 0xFF, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x7F, 0x30, 0x18, 0x08, 0x04, 0x02, 0x03, 0xF8, 0xFE, 0x03,
  0x00, 0xC0, 0x60, 0x30, 0x38, 0x1B, 0xBD, 0xF8, 0x07, 0x0F, 0x8C, 0x0C,
  0x06, 0x02, 0x03, 0x01, 0xBC, 0xF3, 0x70, 0xF0, 0x78, 0x3C, 0x1E, 0x0D,
  0x8C, 0xFE, 0x3E, 0x00, 0xFF, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18,
  0x0C, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x1C, 0x3F,
  0x98, 0xD8, 0x3C, 0x1E, 0x19, 0x8C, 0x7C, 0x1C, 0x3B, 0x18, 0xD8, 0x3C,
  0x1E, 0x0F, 0x06, 0xCE, 0x3E, 0x00, 0x18, 0x3F, 0x19, 0xD8, 0x6C, 0x16,
  0x0F, 0x07, 0x83, 0xE3, 0xBE, 0xCE, 0x60, 0x20, 0x30, 0x18, 0x18, 0xBC,
  0x7C, 0x00, 0x7D, 0x00, 0x00, 0x0F, 0xB0, 0xFD, 0x00, 0x00, 0x0D, 0xBD,
  0xA0, 0x00, 0x80, 0xC1, 0xE3, 0xC7, 0x87, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x20, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x60, 0x3C,
  0x07, 0x80, 0xE0, 0x1C, 0x0E, 0x1C, 0x78, 0x70, 0x20, 0x00, 0x38, 0xFE,
  0x46, 0x03, 0x03, 0x02, 0x06, 0x0E, 0x1C, 0x18, 0x10, 0x10, 0x00, 0x00,
  0x10, 0x38, 0x38, 0x01, 0x00, 0x1F, 0xC0, 0x60, 0xC1, 0x80, 0xC6, 0x00,
  0xCC, 0x78, 0x91, 0x91, 0x66, 0x22, 0xCC, 0x47, 0x98, 0x8F, 0x31, 0x16,
  0x66, 0x2C, 0xCC, 0xD8, 0xF7, 0x10, 0x00, 0x30, 0x00, 0x30, 0x00, 0x39,
  0xC0, 0x3F, 0x00, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xB0, 0x1B, 0x01, 0x98,
  0x19, 0x83, 0x18, 0x30, 0x83, 0xFC, 0x3F, 0xC6, 0x0C, 0x60, 0x66, 0x06,
  0xC0, 0x6C, 0x07, 0xFE, 0x63, 0xB0, 0xF8, 0x3C, 0x1E, 0x1B, 0x1D, 0xFC,
  0xC3, 0x60, 0xF0, 0x78, 0x3C, 0x1E, 0x1F, 0xFD, 0xFC, 0x07, 0x07, 0xF3,
  0x89, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x80,
  0x60, 0x18, 0x03, 0x00, 0xFE, 0x1F, 0x80, 0xFE, 0x31, 0xCC, 0x1B, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xB0,
  0xEF, 0xF3, 0xF0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F,
  0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x07, 0x83, 0xFC, 0xE1, 0xB8,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x00, 0xC1, 0xF8, 0x3F, 0x01, 0xF0, 0x36,
  0x06, 0xC0, 0xCC, 0x19, 0xFF, 0x0F, 0xE0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xFB, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0xDF, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xED, 0xE0, 0xC1, 0xB0, 0xCC, 0x63, 0x18, 0xCC, 0x36, 0x0D, 0x83, 0xE0,
  0xF8, 0x33, 0x0C, 0xE3, 0x18, 0xC7, 0x30, 0xCC, 0x3B, 0x07, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF,
  0xE0, 0x1F, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xF0, 0x2F, 0x61, 0xBD, 0x86,
  0xF6, 0x13, 0xC8, 0xCF, 0x33, 0x3C, 0xC8, 0xF1, 0x63, 0xC7, 0x8F, 0x1E,
  0x3C, 0x30, 0xF0, 0xC3, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8, 0x3D, 0x87, 0xB0,
  0xF3, 0x1E, 0x63, 0xC6, 0x78, 0xCF, 0x0D, 0xE1, 0xBC, 0x1F, 0x83, 0xF0,
  0x7E, 0x07, 0x07, 0x01, 0xFC, 0x38, 0xC6, 0x06, 0x60, 0x66, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x36, 0x06, 0x70,
  0xE3, 0xFC, 0x1F, 0x80, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7,
  0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x07, 0x01, 0xFC, 0x38,
  0xE6, 0x06, 0x60, 0x66, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x60, 0x36, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0xFE, 0x63, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D,
  0xFC, 0xFC, 0x66, 0x31, 0x98, 0xCC, 0x36, 0x1B, 0x0F, 0x83, 0x1C, 0x3F,
  0x98, 0x58, 0x0C, 0x06, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x00, 0xC0, 0x60,
  0x18, 0x1A, 0x0D, 0xFE, 0xFC, 0x00, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x67, 0xF8, 0xFC, 0xC0, 0x6C,
  0x0D, 0x83, 0x30, 0x66, 0x0C, 0x61, 0x8C, 0x61, 0x8C, 0x31, 0x83, 0x20,
  0x6C, 0x0D, 0x80, 0xB0, 0x1C, 0x03, 0x80, 0x70, 0xC0, 0xC0, 0xD8, 0x30,
  0x66, 0x1E, 0x19, 0x87, 0x86, 0x61, 0xE1, 0x98, 0x48, 0x63, 0x33, 0x30,
  0xCC, 0xCC, 0x33, 0x33, 0x0C, 0xCC, 0xC1, 0x21, 0x60, 0x78, 0x78, 0x1E,
  0x1E, 0x07, 0x87, 0x80, 0xC0, 0xE0, 0x30, 0x30, 0x60, 0xD8, 0x63, 0x18,
  0xCC, 0x1B, 0x07, 0x80, 0xE0, 0x30, 0x0E, 0x07, 0x81, 0xB0, 0xCC, 0x31,
  0x98, 0x66, 0x0F, 0x03, 0xC0, 0xD8, 0x66, 0x18, 0xC6, 0x33, 0x0C, 0xC1,
  0xE0, 0x78, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0xFF, 0x03, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x38, 0x30, 0x30, 0x60,
  0x60, 0xC0, 0xFF, 0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x31, 0xFF, 0x80, 0xE0, 0x60, 0x60, 0x30, 0x30, 0x10,
  0x18, 0x18, 0x08, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80,
  0x0C, 0x01, 0xC0, 0x28, 0x0D, 0x81, 0x10, 0x63, 0x08, 0x23, 0x06, 0xC0,
  0x60, 0xFF, 0xC0, 0xC6, 0x63, 0x18, 0x7E, 0x47, 0x03, 0x03, 0x03, 0x7F,
  0xE3, 0xC3, 0xC3, 0xC3, 0xEF, 0x7B, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x87,
  0xF3, 0x9D, 0x86, 0xC3, 0x60, 0xF0, 0x78, 0x3C, 0x1E, 0x1B, 0x0D, 0x4E,
  0xBE, 0x00, 0x0C, 0x7D, 0x8B, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x83,
  0x93, 0xE0, 0x01, 0x80, 0xC0, 0x60, 0x31, 0x99, 0xFD, 0x8F, 0xC3, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0x86, 0xEF, 0x3D, 0x80, 0x08, 0x1F,
  0x18, 0xC8, 0x6C, 0x1E, 0x0F, 0xFF, 0x80, 0xC0, 0x60, 0x18, 0x0E, 0x63,
  0xF0, 0x0C, 0x3C, 0xC1, 0x83, 0x06, 0x3F, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x18, 0x1F, 0xD8, 0xFC, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xD8, 0x6E, 0xF3, 0xD8, 0x0C, 0x06, 0x03, 0x43,
  0x3F, 0x82, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC8, 0xFE, 0xE7, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7D, 0x00, 0xDB, 0x6D,
  0xB6, 0xDB, 0x60, 0x19, 0xC4, 0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0xC6, 0x33, 0x79, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xC1, 0xC6,
  0xCC, 0xCC, 0xD8, 0xF0, 0xB8, 0xD8, 0xCC, 0xCC, 0xC6, 0xC6, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x22, 0xFB, 0xEE, 0x79, 0xF0, 0xC3, 0xC3,
  0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0,
  0xC3, 0xC3, 0x0C, 0x08, 0xBE, 0xE7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x0C, 0x1F, 0x98, 0xCC, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xD8, 0x6E, 0xE3, 0xE0, 0x08, 0x5F, 0x38, 0xD8, 0x6C,
  0x36, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xB0, 0xD6, 0xEF, 0xE6, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x00, 0x18, 0x1F, 0xD8, 0xFC, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xD8, 0x6E, 0xF3, 0xD8, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x0E, 0xEA, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x18, 0xFF, 0x16, 0x0C, 0x1C, 0x1E, 0x0E, 0x06, 0x0C, 0x1E, 0x7F,
  0xC0, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xD1,
  0xC0, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC7, 0xEF,
  0x7B, 0xC1, 0xB0, 0xD8, 0x6C, 0x66, 0x31, 0x98, 0xC8, 0x6C, 0x16, 0x0F,
  0x07, 0x03, 0x80, 0xC3, 0x86, 0xC7, 0x0D, 0x8A, 0x33, 0x16, 0x66, 0x6C,
  0xC4, 0xD9, 0x8D, 0x92, 0x1A, 0x2C, 0x34, 0x78, 0x38, 0xF0, 0x71, 0xC0,
  0xC1, 0x80, 0x61, 0x99, 0x8C, 0xC3, 0xC1, 0xE0, 0x60, 0x70, 0x3C, 0x36,
  0x19, 0x98, 0xFC, 0x30, 0xC1, 0xB0, 0xD8, 0x6C, 0x62, 0x31, 0x98, 0xC8,
  0x6C, 0x1E, 0x0F, 0x07, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0xF0, 0x20,
  0x00, 0xFC, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x61, 0x83, 0xFF, 0xF0,
  0x1E, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x31, 0x81, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x30, 0x78, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x18, 0x1C, 0x61, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x63, 0x84, 0x00, 0x60, 0xFE, 0x63, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 16, 6, 2, -16 },
  { 5, 7, 6, 9, 1, -16 },
  { 11, 11, 16, 12, 0, -16 },
  { 33, 9, 18, 11, 1, -17 },
  { 54, 14, 17, 16, 1, -17 },
  { 84, 12, 17, 13, 1, -17 },
  { 110, 3, 6, 5, 1, -16 },
  { 113, 5, 21, 7, 1, -17 },
  { 127, 5, 21, 7, 1, -17 },
  { 141, 8, 9, 10, 1, -18 },
  { 150, 9, 11, 11, 1, -14 },
  { 163, 3, 6, 6, 1, -3 },
  { 166, 5, 2, 7, 1, -7 },
  { 168, 3, 3, 6, 1, -3 },
  { 170, 8, 16, 9, 0, -16 },
  { 186, 9, 17, 11, 1, -17 },
  { 206, 5, 16, 11, 2, -16 },
  { 216, 9, 17, 11, 1, -17 },
  { 236, 9, 17, 11, 1, -17 },
  { 256, 10, 17, 11, 0, -17 },
  { 278, 9, 16, 11, 1, -16 },
  { 296, 9, 17, 11, 1, -17 },
  { 316, 9, 16, 11, 1, -16 },
  { 334, 9, 17, 11, 1, -17 },
  { 354, 9, 17, 11, 1, -17 },
  { 374, 3, 12, 6, 1, -12 },
  { 379, 3, 15, 6, 1, -12 },
  { 385, 9, 11, 11, 1, -14 },
  { 398, 9, 6, 11, 1, -11 },
  { 405, 9, 11, 11, 1, -14 },
  { 418, 8, 17, 8, 0, -17 },
  { 435, 15, 19, 17, 1, -17 },
  { 471, 12, 16, 12, 0, -16 },
  { 495, 9, 16, 12, 2, -16 },
  { 513, 10, 17, 12, 1, -17 },
  { 535, 10, 16, 13, 2, -16 },
  { 555, 7, 16, 10, 2, -16 },
  { 569, 7, 16, 10, 2, -16 },
  { 583, 11, 17, 14, 1, -17 },
  { 607, 10, 16, 14, 2, -16 },
  { 627, 5, 16, 7, 1, -16 },
  { 637, 5, 20, 6, -1, -16 },
  { 650, 10, 16, 11, 2, -16 },
  { 670, 7, 16, 10, 2, -16 },
  { 684, 14, 16, 18, 2, -16 },
  { 712, 11, 16, 14, 2, -16 },
  { 734, 12, 17, 14, 1, -17 },
  { 760, 8, 16, 11, 2, -16 },
  { 776, 12, 21, 14, 1, -17 },
  { 808, 9, 16, 12, 2, -16 },
  { 826, 9, 17, 10, 1, -17 },
  { 846, 10, 16, 10, 0, -16 },
  { 866, 10, 16, 13, 2, -16 },
  { 886, 11, 16, 11, 0, -16 },
  { 908, 18, 16, 18, 0, -16 },
  { 944, 10, 16, 10, 0, -16 },
  { 964, 10, 16, 10, 0, -16 },
  { 984, 8, 16, 10, 1, -16 },
  { 1000, 5, 21, 7, 2, -17 },
  { 1014, 8, 16, 9, 0, -16 },
  { 1030, 5, 21, 7, 1, -17 },
  { 1044, 11, 9, 11, 0, -16 },
  { 1057, 10, 1, 10, 0, 2 },
  { 1059, 4, 4, 6, 1, -18 },
  { 1061, 8, 13, 11, 1, -13 },
  { 1074, 9, 17, 12, 2, -17 },
  { 1094, 7, 13, 9, 1, -13 },
  { 1106, 9, 17, 12, 1, -17 },
  { 1126, 9, 13, 11, 1, -13 },
  { 1141, 7, 18, 6, 0, -18 },
  { 1157, 9, 19, 12, 1, -13 },
  { 1179, 8, 17, 12, 2, -17 },
  { 1196, 3, 17, 5, 1, -17 },
  { 1203, 5, 23, 5, -1, -17 },
  { 1218, 8, 17, 10, 2, -17 },
  { 1235, 2, 17, 5, 2, -17 },
  { 1240, 14, 13, 17, 2, -13 },
  { 1263, 8, 13, 12, 2, -13 },
  { 1276, 9, 13, 11, 1, -13 },
  { 1291, 9, 19, 12, 2, -13 },
  { 1313, 9, 19, 12, 1, -13 },
  { 1335, 6, 13, 8, 2, -13 },
  { 1345, 7, 13, 9, 1, -13 },
  { 1357, 6, 15, 7, 0, -15 },
  { 1369, 8, 12, 12, 2, -12 },
  { 1381, 9, 12, 9, 0, -12 },
  { 1395, 15, 12, 15, 0, -12 },
  { 1418, 9, 12, 10, 0, -12 },
  { 1432, 9, 18, 9, 0, -12 },
  { 1453, 7, 12, 8, 1, -12 },
  { 1464, 7, 20, 8, 1, -16 },
  { 1482, 2, 23, 10, 4, -18 },
  { 1488, 7, 20, 8, 1, -16 },
  { 1506, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Regular23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_REGULAR23PT7B_H_
