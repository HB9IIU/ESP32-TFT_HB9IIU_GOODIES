#ifndef _NOTOSANS_CONDENSED_REGULAR55PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xFB, 0xEF, 0xBE, 0xF9, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC7, 0x1C, 0x00, 0x00,
  0x00, 0x23, 0xEF, 0xFF, 0xFF, 0xFF, 0x88, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0,
  0xFB, 0xC1, 0xF7, 0x83, 0xEF, 0x07, 0xDE, 0x0F, 0xBC, 0x1F, 0x78, 0x3C,
  0xF0, 0x39, 0xE0, 0x73, 0xC0, 0xE7, 0x81, 0xCF, 0x03, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x07, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x70, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0, 0xF0,
  0x00, 0xF0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07,
  0x81, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x3C, 0x00, 0x1C, 0x0F, 0x00,
  0x07, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0E,
  0x00, 0x0F, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xF8, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x70, 0x00,
  0x78, 0x1C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x03, 0xC0, 0x01, 0xC0, 0xF0,
  0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xC7,
  0xFF, 0xFC, 0x7F, 0xFF, 0xE3, 0xE7, 0x07, 0x3E, 0x38, 0x09, 0xE1, 0xC0,
  0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x1E, 0x1C, 0x00, 0xF0,
  0xE0, 0x07, 0xC7, 0x00, 0x1F, 0xB8, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07,
  0x3F, 0x00, 0x38, 0x7C, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x7C,
  0x03, 0x83, 0xE0, 0x1C, 0x1E, 0x00, 0xE0, 0xF4, 0x07, 0x0F, 0xB8, 0x39,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x10, 0x03, 0xFC, 0x00, 0x3C,
  0x00, 0x7F, 0xC0, 0x07, 0x80, 0x1F, 0xF8, 0x00, 0xE0, 0x03, 0x87, 0x80,
  0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x1E, 0x0F, 0x01, 0xE0, 0x03, 0x81,
  0xE0, 0x3C, 0x00, 0x70, 0x3C, 0x07, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x03,
  0xC0, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x0F, 0x00, 0x0F, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0x78, 0x38, 0x00, 0x3C, 0x0F, 0x0F, 0x00, 0x07, 0x81, 0xE1,
  0xE0, 0x00, 0x70, 0x3C, 0x78, 0x7E, 0x0E, 0x07, 0x8F, 0x1F, 0xE1, 0xE0,
  0xF3, 0xC7, 0xFE, 0x3C, 0x3C, 0x78, 0xF3, 0xC3, 0x87, 0x8E, 0x3C, 0x3C,
  0x7F, 0xE3, 0xC7, 0x87, 0x87, 0xFC, 0x78, 0xE0, 0x70, 0x7F, 0x1E, 0x3C,
  0x0F, 0x07, 0x83, 0xC7, 0x81, 0xE0, 0x00, 0x70, 0xF0, 0x3C, 0x00, 0x1E,
  0x1E, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x1E, 0x00,
  0x1E, 0x0F, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x0F,
  0x00, 0x1E, 0x07, 0x81, 0xE0, 0x07, 0x80, 0x70, 0x38, 0x00, 0xF0, 0x0E,
  0x0F, 0x00, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x80, 0x3C, 0x7C, 0x00, 0xE0,
  0x03, 0xFF, 0x00, 0x3C, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01,
  0xF0, 0x3C, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x3E, 0x3F, 0x3E, 0x03,
  0xC3, 0xE1, 0xF0, 0x3C, 0x7C, 0x1F, 0x87, 0xC7, 0xC0, 0xF8, 0x7C, 0xF8,
  0x07, 0xC7, 0x8F, 0x80, 0x3E, 0xF8, 0xF8, 0x03, 0xFF, 0x8F, 0x80, 0x1F,
  0xF0, 0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xE0, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0xE0, 0x7C, 0x01, 0xFF, 0x07, 0xE0, 0x3F, 0xF8, 0x3F, 0xFF,
  0xEF, 0xC3, 0xFF, 0xFC, 0x7E, 0x1F, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0x3F,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBC, 0x01, 0xF0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0,
  0x1E, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x40, 0xF0, 0x37, 0xC7, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0x9E, 0x00, 0xF9, 0xF0, 0x0F, 0x0F, 0x81, 0xF0, 0xFC, 0x3E, 0x07,
  0x80, 0x60, 0x60, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x78,
  0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0xF9,
  0xFF, 0xFF, 0xEF, 0x9F, 0x08, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xFF,
  0xF0, 0x1F, 0xCF, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x1E, 0x0F, 0x80, 0x7C,
  0x3C, 0x01, 0xF1, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x7C,
  0x00, 0xF9, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00,
  0x7B, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0xF8, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3C, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xE0, 0x3E, 0x07, 0xC1, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0xFE,
  0x0F, 0xF0, 0xFF, 0x8F, 0xBC, 0xF9, 0xEF, 0x8F, 0xF8, 0x7B, 0x83, 0xC8,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xF1, 0xFE,
  0x3C, 0x01, 0xF0, 0xC0, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xE0, 0xFE, 0x3C, 0x01, 0xF8,
  0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xA0, 0x00, 0xFD, 0xC0, 0x0F, 0xEF, 0xF7, 0xFE, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1D, 0xF0, 0x00, 0x3D, 0xF0, 0x00,
  0x3D, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xF0, 0x00,
  0xF1, 0xF0, 0x01, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xC1, 0xF0, 0x07,
  0x81, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x1E,
  0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0x78, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x3F, 0xFF, 0xC3, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC2, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE8, 0x00, 0x7E, 0xE0, 0x0F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x10, 0x00,
  0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0xFF,
  0x04, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x0F, 0x80, 0xF1, 0xFF, 0x07, 0x9F, 0xFC, 0x3D,
  0xFF, 0xF1, 0xFF, 0x1F, 0xCF, 0xE0, 0x3E, 0x7E, 0x00, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x30, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x87, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF0,
  0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x07, 0xC0, 0xF8, 0x0F, 0xCF, 0xC0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE,
  0x01, 0xF8, 0xFE, 0x0F, 0xC1, 0xF8, 0x3E, 0x01, 0xF1, 0xF0, 0x03, 0xE7,
  0x80, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xE7, 0xC0, 0x0F,
  0x9F, 0x80, 0x7E, 0x3F, 0xCF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xF8, 0xFC, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0x8F,
  0x80, 0x3E, 0x7C, 0x00, 0xF3, 0xC0, 0x07, 0xBE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00, 0x7E, 0xF8, 0x03, 0xF3, 0xE0, 0x3F,
  0x9F, 0xEF, 0xBC, 0x7F, 0xFD, 0xE1, 0xFF, 0xCF, 0x07, 0xF8, 0xF8, 0x02,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x03, 0xDF, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFE, 0x00, 0x02, 0x00, 0x00, 0x73, 0xEF, 0xFF, 0xFF, 0xEF, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0xFB,
  0xFF, 0xFF, 0xFB, 0xE2, 0x00, 0x1C, 0x3E, 0x3F, 0x7F, 0x3F, 0x3E, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C,
  0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x70,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x38, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x9F, 0xFF, 0xEF, 0xC7, 0xF3, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x03, 0xF0,
  0x1E, 0x3C, 0x07, 0xFF, 0x07, 0x9E, 0x03, 0xFF, 0xC0, 0xE7, 0x81, 0xF9,
  0xF0, 0x3D, 0xE0, 0x78, 0x3C, 0x0F, 0x70, 0x3C, 0x0F, 0x03, 0xFC, 0x0F,
  0x03, 0xC0, 0xFF, 0x03, 0xC0, 0xF0, 0x3F, 0xC1, 0xE0, 0x3C, 0x0F, 0xF0,
  0x78, 0x0F, 0x03, 0xFC, 0x1E, 0x03, 0xC0, 0xFF, 0x07, 0x80, 0xF0, 0x3F,
  0xC1, 0xE0, 0x3C, 0x0F, 0xF0, 0x78, 0x0F, 0x03, 0xFC, 0x1E, 0x03, 0xC0,
  0xFF, 0x07, 0x81, 0xF0, 0x3F, 0xC1, 0xE0, 0x7C, 0x0E, 0xF0, 0x7C, 0x1F,
  0x07, 0xBC, 0x0F, 0x0E, 0xE1, 0xEF, 0x03, 0xFF, 0xBF, 0xF1, 0xC0, 0x7F,
  0xCF, 0xF8, 0x78, 0x0F, 0xE1, 0xFC, 0x1E, 0x01, 0xF0, 0x3E, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x00,
  0x07, 0xF0, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xD0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0xF8,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0xE7, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xC7, 0xC1, 0xFC,
  0x01, 0x87, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x60, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x02, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0x7F, 0x87, 0xC0, 0x0F,
  0xE3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0xFC, 0x7C, 0x01, 0xFC, 0x3E, 0x03, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF,
  0xFF, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xE3, 0xF8, 0x1F, 0xC0, 0x07,
  0x03, 0xF0, 0x00, 0x20, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0xF9, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x7C, 0x7F,
  0x00, 0x0F, 0x87, 0xF8, 0x01, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0x40, 0x00, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x81, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xEF, 0xFE, 0xFF, 0xCF, 0xF8, 0xFF, 0x01, 0x00, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01,
  0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x3E,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0,
  0x00, 0xFB, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0x7C, 0x00, 0xFE, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3F,
  0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01,
  0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x07, 0xBF, 0xFF, 0x00, 0x01, 0xEF, 0xFB, 0xC0, 0x00,
  0x7B, 0xFE, 0xF0, 0x00, 0x3E, 0xFF, 0xBE, 0x00, 0x0F, 0x3F, 0xE7, 0x80,
  0x03, 0xCF, 0xF9, 0xE0, 0x01, 0xF3, 0xFE, 0x78, 0x00, 0x78, 0xFF, 0x8F,
  0x00, 0x1E, 0x3F, 0xE3, 0xC0, 0x0F, 0x8F, 0xF8, 0xF0, 0x03, 0xC3, 0xFE,
  0x3E, 0x00, 0xF0, 0xFF, 0x87, 0x80, 0x3C, 0x3F, 0xE1, 0xE0, 0x1E, 0x0F,
  0xF8, 0x7C, 0x07, 0x83, 0xFE, 0x0F, 0x01, 0xE0, 0xFF, 0x83, 0xC0, 0xF0,
  0x3F, 0xE0, 0xF8, 0x3C, 0x0F, 0xF8, 0x1E, 0x0F, 0x03, 0xFE, 0x07, 0x87,
  0xC0, 0xFF, 0x81, 0xF1, 0xE0, 0x3F, 0xE0, 0x3C, 0x78, 0x0F, 0xF8, 0x0F,
  0x3E, 0x03, 0xFE, 0x03, 0xEF, 0x00, 0xFF, 0x80, 0xFB, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFF,
  0x80, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xF0, 0x03,
  0xFE, 0x00, 0x7C, 0x00, 0xFF, 0x80, 0x1E, 0x00, 0x3C, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFE, 0xF8, 0x00, 0xFF, 0xBE, 0x00, 0x3F, 0xE7, 0xC0, 0x0F,
  0xF9, 0xF0, 0x03, 0xFE, 0x3E, 0x00, 0xFF, 0x8F, 0x80, 0x3F, 0xE1, 0xF0,
  0x0F, 0xF8, 0x7C, 0x03, 0xFE, 0x0F, 0x80, 0xFF, 0x83, 0xE0, 0x3F, 0xE0,
  0x7C, 0x0F, 0xF8, 0x1F, 0x03, 0xFE, 0x03, 0xE0, 0xFF, 0x80, 0xF8, 0x3F,
  0xE0, 0x1F, 0x0F, 0xF8, 0x07, 0xC3, 0xFE, 0x00, 0xF8, 0xFF, 0x80, 0x3E,
  0x3F, 0xE0, 0x07, 0xCF, 0xF8, 0x01, 0xF3, 0xFE, 0x00, 0x3E, 0xFF, 0x80,
  0x0F, 0xBF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFD, 0xFF, 0x01, 0xFC, 0x03,
  0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x02, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xCF, 0x80, 0xFE, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xF7, 0xC0, 0x1F, 0xBE, 0x01, 0xF9, 0xF0, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xFC, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFD, 0xFF, 0x01, 0xFC, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x0F, 0x80, 0xFF, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x0F, 0xC3, 0xE0, 0xFF, 0x87, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xEF, 0x80,
  0x07, 0xDF, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0x80, 0x31,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xA0, 0x00, 0xFD, 0xE0, 0x0F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xE3,
  0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x80, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xF8, 0x00, 0x7C, 0x78,
  0x00, 0x7F, 0x00, 0x0F, 0x0F, 0x80, 0x0E, 0xE0, 0x03, 0xE1, 0xF0, 0x03,
  0xDE, 0x00, 0x7C, 0x3E, 0x00, 0x7B, 0xC0, 0x0F, 0x83, 0xC0, 0x0F, 0x78,
  0x01, 0xF0, 0x78, 0x01, 0xEF, 0x00, 0x3C, 0x0F, 0x80, 0x7D, 0xE0, 0x0F,
  0x81, 0xF0, 0x0F, 0x1E, 0x01, 0xF0, 0x3E, 0x01, 0xE3, 0xC0, 0x3E, 0x03,
  0xC0, 0x3C, 0x78, 0x07, 0x80, 0x7C, 0x07, 0x8F, 0x01, 0xF0, 0x0F, 0x81,
  0xF1, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x1E, 0x07, 0xC0, 0x1E, 0x07, 0x83,
  0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x00, 0x7C, 0x3E, 0x0F, 0x87,
  0xC0, 0x0F, 0x87, 0x80, 0xF0, 0xF8, 0x01, 0xF0, 0xF0, 0x1E, 0x1F, 0x00,
  0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x78, 0xF8, 0x00, 0x7C,
  0xF8, 0x0F, 0x9F, 0x00, 0x0F, 0x9E, 0x00, 0xF3, 0xE0, 0x00, 0xF3, 0xC0,
  0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x03, 0xCF, 0x00, 0x79,
  0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x0F, 0x81, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x78,
  0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF1, 0xF0, 0x00,
  0xF8, 0xF8, 0x00, 0x78, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x07, 0x80,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E,
  0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xF3, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xE3,
  0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0,
  0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x80,
  0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x0C, 0x07, 0xE0, 0x80,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0x1F, 0xFF, 0xF3,
  0xFF, 0xDF, 0x7F, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x07,
  0xF7, 0xC0, 0x7F, 0x7E, 0x1F, 0xF3, 0xFF, 0xCF, 0x3F, 0xF8, 0xF0, 0xFF,
  0x0F, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x07, 0xE0, 0x78, 0xFF, 0xC3, 0xCF, 0xFF, 0x1E, 0xFF, 0xFC, 0xFF, 0x07,
  0xE7, 0xF0, 0x1F, 0xBF, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0x7F, 0x01, 0xFB, 0xDF, 0x3F, 0x9E, 0xFF,
  0xF8, 0xF3, 0xFF, 0x87, 0x87, 0xF8, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x03,
  0xFF, 0xC3, 0xFF, 0xC3, 0xFF, 0xE3, 0xF0, 0x33, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x4F, 0xF7, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F,
  0xF8, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x3F,
  0x0F, 0x87, 0xFE, 0x7C, 0x7F, 0xF9, 0xE7, 0xFF, 0xEF, 0x3F, 0x07, 0xFB,
  0xF0, 0x1F, 0xDF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8,
  0x03, 0xF7, 0xC0, 0x1F, 0xBF, 0x01, 0xFC, 0xFE, 0x3D, 0xE3, 0xFF, 0xEF,
  0x0F, 0xFE, 0x78, 0x3F, 0xC3, 0xC0, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x3E, 0x07, 0xC7, 0xC0, 0x3C, 0x7C,
  0x03, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x06, 0x1F, 0xC7, 0xE1, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x10, 0x00, 0x00, 0xFE, 0x03, 0xFF, 0x07, 0xFE, 0x07, 0xFE, 0x0F, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0xFC, 0x7F, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x03, 0xF0, 0x78, 0x7F, 0xE3, 0xC7, 0xFF, 0x9E, 0x7F, 0xFE,
  0xF3, 0xF0, 0x7F, 0xBF, 0x01, 0xFD, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xEF, 0x00, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0xCF, 0xE3,
  0xDE, 0x3F, 0xFE, 0xF0, 0xFF, 0xE7, 0x83, 0xFC, 0x3C, 0x01, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x20, 0x01, 0xF9, 0xC0, 0x1F, 0x8F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x7E, 0x0F, 0x1F, 0xF8, 0xF3, 0xFF, 0xCF, 0x7F, 0xFE, 0xFF,
  0x07, 0xEF, 0xE0, 0x3E, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0x27, 0xBF, 0xFF, 0xF9, 0x80, 0x00, 0x01, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF0, 0x01, 0x01, 0xE0, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x83, 0xEF, 0xFB, 0xFC, 0xFE,
  0x3F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xEF, 0x00,
  0x7E, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0,
  0x3E, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F,
  0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x7E, 0x00, 0xF7, 0xF0, 0x0F, 0xFF, 0x00,
  0xFE, 0xF8, 0x0F, 0xC7, 0x80, 0xF8, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x00,
  0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xF8,
  0x3C, 0x7F, 0xC1, 0xFF, 0x8F, 0x3F, 0xF8, 0xFF, 0xF3, 0xDF, 0xFF, 0x7F,
  0xFE, 0xFF, 0x0F, 0xDC, 0x1F, 0xBF, 0x01, 0xFE, 0x03, 0xEF, 0xC0, 0x3F,
  0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x00,
  0x78, 0x01, 0xFF, 0x80, 0x1E, 0x00, 0x7F, 0xE0, 0x07, 0x80, 0x1F, 0xF8,
  0x01, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x7F,
  0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x01,
  0xFF, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x01, 0xE0,
  0x07, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x07,
  0x80, 0x1F, 0xF0, 0x01, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00,
  0x1E, 0x00, 0x7F, 0xC0, 0x07, 0x80, 0x1F, 0xF0, 0x01, 0xE0, 0x07, 0xFC,
  0x00, 0x78, 0x01, 0xF0, 0xF0, 0x7E, 0x0F, 0x1F, 0xF8, 0xF3, 0xFF, 0xCF,
  0x7F, 0xFE, 0xFF, 0x07, 0xEF, 0xE0, 0x3E, 0xFC, 0x01, 0xFF, 0x80, 0x1F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x01, 0xFC, 0x00, 0x1F, 0xFC,
  0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x07, 0xE1, 0xF8, 0x07, 0xC7,
  0xC0, 0x1F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00,
  0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x0F, 0x83, 0xFD, 0xFE, 0x07, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x7E, 0x07,
  0x8F, 0xFC, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0xF0, 0x7E, 0x7F, 0x00,
  0xFB, 0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3E,
  0xFC, 0x01, 0xF7, 0xF0, 0x1F, 0x3D, 0xF7, 0xF9, 0xEF, 0xFF, 0x8F, 0x3F,
  0xF8, 0x78, 0x7F, 0x83, 0xC0, 0x40, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xF0, 0x78, 0x7F, 0xE3, 0xC7, 0xFF, 0x9E, 0x7F, 0xFE,
  0xF3, 0xF0, 0x7F, 0xBF, 0x01, 0xFD, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xEF, 0x80, 0x3F, 0x7C, 0x01, 0xFB, 0xF0, 0x1F, 0xCF, 0xE7,
  0xDE, 0x3F, 0xFC, 0xF0, 0xFF, 0xC7, 0x83, 0xFC, 0x7C, 0x01, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0xF0, 0x7F, 0xC7, 0xFF, 0x3F,
  0xFD, 0xFE, 0xF7, 0xFB, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xEF, 0xFF, 0xE7, 0xC0, 0x77, 0xC0,
  0x0B, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xBF, 0x3F, 0xDF, 0xFF, 0xCF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x04, 0x00, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xCC, 0x3F, 0xF0, 0x7F, 0xC0, 0xFF, 0x00, 0x40, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x07, 0xF7, 0xC0, 0xFF, 0x7F, 0xFE, 0xF3, 0xFF, 0xCF, 0x3F, 0xFC, 0xF0,
  0xFF, 0x0F, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xE0,
  0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80,
  0x3E, 0x1F, 0x00, 0x78, 0x3E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF0,
  0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1F, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF7, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xF0, 0x03,
  0xFE, 0x00, 0x7E, 0x00, 0x7F, 0xE0, 0x0F, 0xC0, 0x0F, 0x7C, 0x01, 0xF8,
  0x01, 0xEF, 0x80, 0x3F, 0x80, 0x7C, 0xF0, 0x0F, 0xF0, 0x0F, 0x9E, 0x01,
  0xFE, 0x01, 0xE3, 0xE0, 0x3D, 0xC0, 0x3C, 0x7C, 0x07, 0xBC, 0x0F, 0x87,
  0x81, 0xE7, 0x81, 0xF0, 0xF0, 0x3C, 0xF0, 0x3C, 0x1F, 0x07, 0x9E, 0x07,
  0x83, 0xE0, 0xF1, 0xC0, 0xF0, 0x3C, 0x3C, 0x3C, 0x3E, 0x07, 0x87, 0x87,
  0x87, 0x80, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0x1E, 0x1E, 0x1E, 0x03, 0xE3,
  0xC1, 0xE7, 0xC0, 0x3C, 0xF0, 0x3C, 0xF0, 0x07, 0x9E, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0xF3, 0xC0, 0x1F, 0x78, 0x0E, 0x78, 0x01, 0xEE, 0x01, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFB, 0xE0,
  0x0F, 0x9F, 0x00, 0x7C, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x0F, 0x83, 0xE0,
  0x7C, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0x8F, 0x80, 0x3E, 0xF8, 0x00, 0xF7,
  0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBE,
  0x00, 0x7C, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1E, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xE7, 0x80, 0x0F,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3,
  0xE0, 0x03, 0xE7, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x78, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x00, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xF0, 0x03, 0xC1,
  0xE0, 0x07, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFE, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0xFF, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0xFF, 0x80, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x00,
  0x7F, 0x01, 0xFF, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x80, 0xFF, 0x80, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x1F,
  0x80, 0x05, 0xFF, 0x80, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x00, 0xFF, 0xE8, 0x00, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 40, 13, 4, -39 },
  { 31, 15, 14, 21, 3, -39 },
  { 58, 26, 39, 28, 1, -39 },
  { 185, 21, 45, 26, 3, -42 },
  { 304, 35, 41, 39, 2, -40 },
  { 484, 28, 41, 30, 2, -40 },
  { 628, 5, 14, 12, 3, -39 },
  { 637, 12, 48, 16, 3, -39 },
  { 709, 12, 48, 16, 2, -39 },
  { 781, 20, 20, 24, 2, -42 },
  { 831, 22, 26, 26, 2, -32 },
  { 903, 8, 13, 13, 2, -6 },
  { 916, 12, 4, 16, 2, -17 },
  { 922, 7, 8, 13, 3, -7 },
  { 929, 19, 39, 20, 1, -39 },
  { 1022, 22, 41, 26, 2, -40 },
  { 1135, 13, 39, 26, 4, -39 },
  { 1199, 21, 40, 26, 2, -40 },
  { 1304, 21, 41, 26, 2, -40 },
  { 1412, 24, 40, 26, 1, -40 },
  { 1532, 20, 40, 26, 3, -39 },
  { 1632, 21, 41, 26, 3, -40 },
  { 1740, 22, 39, 26, 2, -39 },
  { 1848, 22, 41, 26, 2, -40 },
  { 1961, 21, 41, 26, 2, -40 },
  { 2069, 6, 31, 13, 4, -30 },
  { 2093, 8, 37, 13, 2, -30 },
  { 2130, 22, 25, 26, 2, -32 },
  { 2199, 22, 15, 26, 2, -27 },
  { 2241, 22, 25, 26, 2, -32 },
  { 2310, 17, 41, 19, 1, -40 },
  { 2398, 34, 45, 40, 3, -40 },
  { 2590, 28, 39, 28, 0, -39 },
  { 2727, 23, 39, 29, 4, -39 },
  { 2840, 23, 41, 28, 3, -40 },
  { 2958, 25, 39, 32, 4, -39 },
  { 3080, 18, 39, 25, 4, -39 },
  { 3168, 18, 39, 23, 4, -39 },
  { 3256, 27, 41, 33, 3, -40 },
  { 3395, 24, 39, 33, 4, -39 },
  { 3512, 12, 39, 17, 2, -39 },
  { 3571, 12, 50, 13, -3, -39 },
  { 3646, 24, 39, 27, 4, -39 },
  { 3763, 18, 39, 23, 4, -39 },
  { 3851, 34, 39, 43, 4, -39 },
  { 4017, 26, 39, 34, 4, -39 },
  { 4144, 28, 41, 34, 3, -40 },
  { 4288, 21, 39, 27, 4, -39 },
  { 4391, 28, 49, 34, 3, -40 },
  { 4563, 23, 39, 28, 4, -39 },
  { 4676, 21, 41, 25, 2, -40 },
  { 4784, 22, 39, 24, 1, -39 },
  { 4892, 24, 40, 32, 4, -39 },
  { 5012, 27, 39, 27, 0, -39 },
  { 5144, 43, 39, 43, 0, -39 },
  { 5354, 25, 39, 25, 0, -39 },
  { 5476, 24, 39, 24, 0, -39 },
  { 5593, 20, 39, 23, 2, -39 },
  { 5691, 12, 48, 17, 4, -39 },
  { 5763, 19, 39, 20, 1, -39 },
  { 5856, 11, 48, 17, 2, -39 },
  { 5922, 24, 22, 26, 1, -39 },
  { 5988, 24, 3, 24, 0, 5 },
  { 5997, 11, 9, 15, 2, -42 },
  { 6010, 20, 31, 25, 2, -30 },
  { 6088, 21, 43, 28, 4, -42 },
  { 6201, 17, 31, 21, 3, -30 },
  { 6267, 21, 43, 28, 3, -42 },
  { 6380, 20, 31, 25, 3, -30 },
  { 6458, 16, 42, 15, 1, -42 },
  { 6542, 21, 43, 28, 3, -30 },
  { 6655, 20, 42, 28, 4, -42 },
  { 6760, 5, 41, 12, 4, -41 },
  { 6786, 10, 54, 12, -1, -41 },
  { 6854, 20, 42, 24, 4, -42 },
  { 6959, 4, 42, 12, 4, -42 },
  { 6980, 34, 30, 42, 4, -30 },
  { 7108, 20, 30, 28, 4, -30 },
  { 7183, 22, 31, 27, 3, -30 },
  { 7269, 21, 43, 28, 4, -30 },
  { 7382, 21, 43, 28, 3, -30 },
  { 7495, 14, 30, 19, 4, -30 },
  { 7548, 17, 31, 21, 2, -30 },
  { 7614, 14, 37, 16, 1, -36 },
  { 7679, 20, 31, 28, 4, -30 },
  { 7757, 23, 30, 23, 0, -30 },
  { 7844, 35, 30, 36, 1, -30 },
  { 7976, 21, 30, 23, 1, -30 },
  { 8055, 23, 43, 23, 0, -30 },
  { 8179, 16, 30, 19, 2, -30 },
  { 8239, 16, 48, 20, 2, -39 },
  { 8335, 4, 55, 25, 10, -42 },
  { 8363, 16, 48, 20, 2, -39 },
  { 8459, 22, 7, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Regular55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_REGULAR55PT7B_H_
