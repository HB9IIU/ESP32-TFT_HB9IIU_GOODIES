#ifndef _NOTOSANS_CONDENSED_REGULAR44PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x00, 0x3D, 0xFF, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x80, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x03, 0x83, 0x00,
  0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0x83,
  0x83, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x06, 0x0E, 0x00, 0x70, 0x70, 0x03,
  0x83, 0x80, 0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70,
  0x01, 0x83, 0x81, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x38,
  0x38, 0x01, 0xC1, 0x80, 0x0E, 0x1C, 0x00, 0x60, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x60, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7E, 0x01, 0xFF, 0xE1, 0xFF, 0xF9,
  0xFF, 0xFC, 0xF3, 0x84, 0xF1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x38,
  0x0F, 0x1C, 0x03, 0xCE, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x1C, 0xF0, 0x0E, 0x3C, 0x07, 0x1E,
  0x03, 0x8F, 0x01, 0xC7, 0x80, 0xE3, 0xB0, 0x73, 0xDF, 0xBF, 0xCF, 0xFF,
  0xC7, 0xFF, 0xC0, 0x1F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x04, 0x03, 0xF8, 0x03, 0x80, 0x7F,
  0x80, 0x38, 0x07, 0x1C, 0x07, 0x00, 0x71, 0xC0, 0x70, 0x0E, 0x0E, 0x07,
  0x00, 0xE0, 0xE0, 0xE0, 0x0E, 0x0E, 0x0E, 0x00, 0xE0, 0xE1, 0xC0, 0x0E,
  0x0E, 0x1C, 0x00, 0xE0, 0xE1, 0xC0, 0x0E, 0x0E, 0x38, 0x00, 0xE0, 0xE3,
  0x80, 0x0E, 0x0E, 0x71, 0xF8, 0xE0, 0xE7, 0x3F, 0xC7, 0x1C, 0xF3, 0xFC,
  0x71, 0xCE, 0x70, 0xE7, 0xF8, 0xE7, 0x0E, 0x3F, 0x9C, 0x70, 0xE0, 0xE1,
  0xC7, 0x0E, 0x00, 0x38, 0x70, 0xE0, 0x03, 0x8F, 0x0F, 0x00, 0x38, 0xF0,
  0xF0, 0x07, 0x0F, 0x0F, 0x00, 0x70, 0x70, 0xE0, 0x0E, 0x07, 0x0E, 0x00,
  0xE0, 0x70, 0xE0, 0x0E, 0x07, 0x0E, 0x01, 0xC0, 0x70, 0xE0, 0x1C, 0x03,
  0x9C, 0x03, 0x80, 0x3F, 0xC0, 0x38, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x80, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x70,
  0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0xF0, 0x01,
  0xC3, 0xC0, 0x07, 0x9E, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x81, 0xE7, 0xCF, 0x07,
  0x9E, 0x1E, 0x1C, 0xF0, 0x7C, 0x73, 0xC0, 0xF3, 0xCE, 0x01, 0xEF, 0x38,
  0x07, 0xF8, 0xE0, 0x0F, 0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x03,
  0xF8, 0xF8, 0x3F, 0xF1, 0xFF, 0xF3, 0xC3, 0xFF, 0x87, 0x87, 0xFC, 0x1F,
  0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xE0, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x0E,
  0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x1C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0xF0, 0x1C, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80,
  0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0E,
  0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x83, 0x82, 0xFB, 0x9E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xC0, 0x07, 0xE0, 0x0E, 0xE0, 0x1E, 0x70, 0x1C, 0x78, 0x3C, 0x3C,
  0x18, 0x38, 0x08, 0x20, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x3D, 0xF7, 0x9E, 0x79, 0xC7, 0x3C, 0xE3, 0x8E, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xEF, 0x83, 0xC1, 0xE3, 0xC0, 0xF1, 0xE0, 0x3C, 0xF0, 0x1E,
  0x70, 0x0F, 0x78, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1D, 0xE0, 0x0E, 0x70, 0x0F,
  0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x83, 0xC3, 0xC3, 0xE1, 0xFF, 0xE0, 0x7F,
  0xE0, 0x0F, 0xE0, 0x01, 0xE0, 0xFC, 0x3F, 0x8F, 0xF3, 0xFE, 0xFB, 0xFE,
  0x7B, 0x8F, 0x21, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0xC0,
  0x1F, 0xFC, 0x1F, 0xFF, 0x1F, 0xDF, 0xC7, 0x01, 0xE2, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF,
  0x1F, 0x9F, 0xC6, 0x01, 0xE2, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x7F, 0xC0, 0x3F, 0x80, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0xD0, 0x03, 0xEC, 0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xE0,
  0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xCE, 0x00,
  0x39, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03,
  0x83, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x38,
  0x07, 0x07, 0x00, 0xE1, 0xC0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF,
  0x8F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xE1,
  0xFF, 0xF8, 0x40, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0xA0, 0x07, 0xDC, 0x07, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0,
  0x00, 0x7E, 0x01, 0xFF, 0x01, 0xFF, 0x81, 0xF8, 0xC1, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x0F, 0x07, 0x9F, 0xE3, 0xDF, 0xF9, 0xFE, 0xFC, 0xFC, 0x0F,
  0x7C, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0x70, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xC7, 0x81, 0xE3,
  0xE1, 0xE0, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x87, 0xC7, 0xC7, 0x81,
  0xF3, 0xC0, 0x79, 0xC0, 0x3C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x07, 0x9E,
  0x03, 0xCF, 0x03, 0xC3, 0xE3, 0xE0, 0xFB, 0xE0, 0x3F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0x0F, 0x8F, 0x03, 0xEF, 0x00, 0xF7, 0x80,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xE7, 0x81, 0xF3, 0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xF0, 0x03, 0xC0,
  0x07, 0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE3, 0xC0, 0xF3, 0xC0,
  0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xDE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3E, 0xF0, 0x3F, 0x7C, 0x3F, 0x9F, 0xFB,
  0x8F, 0xFD, 0xC1, 0xF8, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x0F, 0x83,
  0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x77, 0xFF, 0xFF, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFE, 0x39, 0xF7, 0xDF,
  0x78, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x7D, 0xE7, 0x9E, 0x73, 0xCF, 0x38, 0xE3, 0x00, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xE0, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10,
  0x00, 0x00, 0x1F, 0x81, 0xFF, 0x8F, 0xFF, 0x3F, 0xFE, 0x40, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x0E, 0x00, 0x03, 0x81, 0xC0,
  0x00, 0x1C, 0x3C, 0x00, 0x01, 0xC3, 0x80, 0xFE, 0x0E, 0x38, 0x3F, 0xF0,
  0xE7, 0x03, 0xFF, 0x0E, 0x70, 0x70, 0x70, 0xE7, 0x0F, 0x07, 0x07, 0x70,
  0xE0, 0x70, 0x7E, 0x0E, 0x07, 0x07, 0xE0, 0xE0, 0xF0, 0x7E, 0x0E, 0x0F,
  0x07, 0xE0, 0xE0, 0xF0, 0x7E, 0x0E, 0x0F, 0x07, 0xE0, 0xE0, 0xF0, 0xEE,
  0x0E, 0x0F, 0x0E, 0xE0, 0xE0, 0xF0, 0xEF, 0x0F, 0x1B, 0x1C, 0x70, 0x7F,
  0xBF, 0xC7, 0x07, 0xF3, 0xF8, 0x70, 0x1E, 0x1F, 0x07, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x80, 0x07, 0xC0, 0x38, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x0E, 0x00, 0x70, 0x3C, 0x03, 0xC0, 0xF0,
  0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF0, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9C, 0x03, 0xEE, 0x00, 0xF7, 0x00, 0x7B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xB8, 0x03, 0xDC, 0x01, 0xEE, 0x03, 0xE7, 0xFF, 0xE3,
  0xFF, 0xC1, 0xFF, 0xF8, 0xE0, 0x3F, 0x70, 0x07, 0xB8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x03, 0xDC, 0x07, 0xEF, 0xFF, 0xE7, 0xFF, 0xE3, 0xFF, 0xC0,
  0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xF8, 0x04,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x0C, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFC, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x70,
  0x1F, 0x8E, 0x00, 0xF9, 0xC0, 0x0F, 0x38, 0x01, 0xF7, 0x00, 0x1E, 0xE0,
  0x03, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00,
  0x1E, 0xE0, 0x07, 0x9C, 0x01, 0xF3, 0x80, 0x7C, 0x70, 0x7F, 0x0F, 0xFF,
  0xC1, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xFF, 0xEE, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xFE, 0xFE, 0x0F, 0x80, 0x30, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0xC0,
  0x0F, 0x0F, 0xC0, 0x3C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFC,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x78, 0xFF, 0xFF, 0xF1, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x7F, 0x3F, 0xFF, 0xFC, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1E, 0xFF, 0xBF, 0xCF, 0xE0, 0xE0, 0x07, 0xF8, 0x03, 0xCE, 0x00,
  0xF3, 0x80, 0x78, 0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x07, 0x83, 0x83, 0xC0,
  0xE0, 0xF0, 0x38, 0x78, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xE7, 0x80, 0x3B,
  0xC0, 0x0E, 0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3E, 0xF8, 0x0F, 0x1E,
  0x03, 0x83, 0xC0, 0xE0, 0xF0, 0x38, 0x1E, 0x0E, 0x07, 0x83, 0x80, 0xF0,
  0xE0, 0x3C, 0x38, 0x07, 0x8E, 0x01, 0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0xB8,
  0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFB, 0x80, 0x07, 0x7F, 0x70, 0x00, 0xEF, 0xEF, 0x00,
  0x3D, 0xFC, 0xE0, 0x07, 0x3F, 0x9C, 0x00, 0xE7, 0xF3, 0xC0, 0x3C, 0xFE,
  0x38, 0x07, 0x1F, 0xC7, 0x00, 0xE3, 0xF8, 0xF0, 0x3C, 0x7F, 0x1E, 0x07,
  0x0F, 0xE1, 0xC0, 0xE1, 0xFC, 0x3C, 0x1C, 0x3F, 0x87, 0x87, 0x87, 0xF0,
  0x70, 0xE0, 0xFE, 0x0E, 0x1C, 0x1F, 0xC1, 0xE7, 0x83, 0xF8, 0x1C, 0xE0,
  0x7F, 0x03, 0x9C, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x3C, 0x03,
  0xF8, 0x07, 0x80, 0x78, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xEE, 0x00, 0xFE, 0xF0, 0x0F,
  0xE7, 0x00, 0xFE, 0x78, 0x0F, 0xE3, 0x80, 0xFE, 0x3C, 0x0F, 0xE3, 0xC0,
  0xFE, 0x1E, 0x0F, 0xE1, 0xE0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x07,
  0x8F, 0xE0, 0x78, 0xFE, 0x03, 0xCF, 0xE0, 0x3C, 0x7E, 0x01, 0xE7, 0xE0,
  0x1E, 0x7E, 0x00, 0xF7, 0xE0, 0x0F, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1F,
  0x07, 0xC0, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x07, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x78, 0x00,
  0xF0, 0xF8, 0x01, 0xE0, 0xF0, 0x07, 0x81, 0xF8, 0x3F, 0x01, 0xFF, 0xFC,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xE0, 0x7E, 0xE0, 0x1E, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1E, 0xE0, 0x3E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x1F, 0x07, 0xC0,
  0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x07, 0xDE,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0xF0, 0xF8,
  0x01, 0xE0, 0xF0, 0x07, 0x81, 0xF8, 0x3F, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0x81, 0xF8, 0xE0, 0x1E,
  0x38, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x03, 0xCE,
  0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x1E, 0x38, 0x0F, 0x8E, 0x0F, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0E, 0x0F, 0x03, 0x83, 0xC0, 0xE0, 0x78,
  0x38, 0x1E, 0x0E, 0x03, 0xC3, 0x80, 0xF0, 0xE0, 0x3E, 0x38, 0x07, 0x8E,
  0x01, 0xF3, 0x80, 0x3C, 0xE0, 0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x7C, 0x03,
  0xF0, 0x0F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFE, 0x7C, 0x06, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1E, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xF0, 0x0F, 0x1F, 0x03, 0xE3,
  0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x80, 0xF0, 0x00, 0x7D, 0xC0, 0x01,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0,
  0x1E, 0x07, 0x80, 0xF0, 0x0E, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x38,
  0x03, 0xC1, 0xE0, 0x07, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x78, 0x70, 0x01,
  0xE3, 0xC0, 0x03, 0x8F, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0xE0, 0x00, 0x77,
  0x80, 0x01, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xDE, 0x00, 0x78, 0x00, 0xF7, 0x80, 0x1F, 0x00, 0x3D, 0xE0, 0x0F,
  0xC0, 0x1E, 0x78, 0x03, 0xF0, 0x07, 0x8E, 0x00, 0xFC, 0x01, 0xE3, 0xC0,
  0x3F, 0x80, 0x78, 0xF0, 0x0E, 0xE0, 0x1C, 0x3C, 0x07, 0xB8, 0x0F, 0x0F,
  0x01, 0xCE, 0x03, 0xC1, 0xC0, 0x73, 0xC0, 0xF0, 0x78, 0x1C, 0xF0, 0x3C,
  0x1E, 0x0F, 0x1C, 0x1E, 0x07, 0x83, 0xC7, 0x07, 0x80, 0xE0, 0xE1, 0xC1,
  0xE0, 0x3C, 0x38, 0x78, 0x78, 0x0F, 0x1E, 0x0E, 0x1C, 0x03, 0xC7, 0x83,
  0x8F, 0x00, 0x71, 0xC0, 0xE3, 0xC0, 0x1C, 0x70, 0x3C, 0xF0, 0x07, 0x9C,
  0x0F, 0x38, 0x01, 0xEF, 0x01, 0xCE, 0x00, 0x7B, 0xC0, 0x77, 0x80, 0x0E,
  0xE0, 0x1D, 0xE0, 0x03, 0xB8, 0x07, 0xF8, 0x00, 0xEE, 0x00, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xF0,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE3,
  0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0x78,
  0x0F, 0x0F, 0x00, 0x70, 0xF0, 0x07, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xDC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x39, 0xE0, 0x07,
  0x9E, 0x00, 0x78, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x0E,
  0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x07, 0x9C, 0x00,
  0x3B, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xC7, 0x00, 0x38, 0xE0,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x78,
  0x70, 0x07, 0x1E, 0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x07, 0xF0, 0x7F, 0xF0, 0xFF, 0xF1, 0xC1, 0xE2, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x1F, 0xF8, 0xFF, 0xF7,
  0xF8, 0xEF, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x81, 0xFF, 0x07, 0xEF, 0xFD, 0xDF, 0xF3, 0x9F, 0xC7, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0xF8, 0x3D, 0xFF, 0x1F, 0xFF, 0xCF,
  0xE3, 0xF7, 0xC0, 0x7B, 0xE0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0xF7,
  0xE0, 0xFB, 0xBF, 0xF9, 0xCF, 0xF8, 0xE3, 0xF8, 0x00, 0x03, 0xF8, 0x3F,
  0xF1, 0xFF, 0x8F, 0x86, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x04, 0xFF, 0xF1,
  0xFF, 0xC1, 0xFE, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x83, 0xE1,
  0xC7, 0xFC, 0xE7, 0xFF, 0x73, 0xE3, 0xFB, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xDC, 0x01,
  0xEF, 0x00, 0xF7, 0x80, 0xF9, 0xE0, 0xFC, 0xFF, 0xEE, 0x3F, 0xE7, 0x0F,
  0xE3, 0x80, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3C, 0x3E, 0x38, 0x1E,
  0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x02, 0x1F, 0xFE, 0x0F, 0xFE,
  0x07, 0xFC, 0x00, 0x60, 0x0F, 0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xFF, 0x1F, 0xFC, 0xFF,
  0xF0, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x07, 0xC3, 0x8F, 0xF9, 0xC7, 0xFE, 0xE7, 0xC7, 0xF7, 0xC0,
  0xFB, 0xC0, 0x7D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xB8, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF3, 0xC1, 0xF9, 0xFF,
  0xDC, 0x7F, 0xCE, 0x1F, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x79, 0x80, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC,
  0x1F, 0xFC, 0x00, 0x40, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1,
  0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFE, 0x3E, 0xFC, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0xFE, 0xFE, 0xFC, 0x20, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xC0, 0xF3, 0xC0, 0xF7, 0x80,
  0xF7, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xF9, 0xE0, 0xF9, 0xE0, 0xF0, 0xF0,
  0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C, 0xF0, 0x1E,
  0xF0, 0x1E, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xF0, 0x3F,
  0x1C, 0xFF, 0x8F, 0xF3, 0xBF, 0xF3, 0xFF, 0x7F, 0x1F, 0xE1, 0xFF, 0x81,
  0xF8, 0x1F, 0xF0, 0x1E, 0x03, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x78, 0x07,
  0xF0, 0x0F, 0x00, 0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x3C, 0x03, 0xF8, 0x07,
  0x80, 0x7F, 0x00, 0xF0, 0x0F, 0xE0, 0x1E, 0x01, 0xFC, 0x03, 0xC0, 0x3F,
  0x80, 0x78, 0x07, 0xF0, 0x0F, 0x00, 0xFE, 0x01, 0xE0, 0x1F, 0xC0, 0x3C,
  0x03, 0xF8, 0x07, 0x80, 0x7F, 0x00, 0xF0, 0x0F, 0xE0, 0x1E, 0x01, 0xFC,
  0x03, 0xC0, 0x3F, 0x80, 0x78, 0x07, 0xE1, 0xF8, 0xE7, 0xFC, 0xEF, 0xFE,
  0xFE, 0x1E, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF8, 0x7C, 0x7C, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x1E,
  0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x03, 0x9C, 0x01, 0xE7, 0x80,
  0x79, 0xE0, 0x3C, 0x3C, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0xE0,
  0xE1, 0xF0, 0x73, 0xFE, 0x3B, 0xFF, 0x9F, 0xC3, 0xEF, 0x80, 0xF7, 0xC0,
  0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x01, 0xEF, 0xC1, 0xF7, 0xFF, 0xF3, 0xDF,
  0xF1, 0xE7, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xE3, 0x8F, 0xF9, 0xCF, 0xFE, 0xE7, 0xC7, 0xF7,
  0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xB8, 0x03, 0xDE, 0x01, 0xEF, 0x01, 0xF3, 0xC1, 0xF9,
  0xFF, 0xDC, 0x7F, 0xCE, 0x1F, 0xC7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0xE1, 0xFC, 0x7F, 0x9F, 0xF7, 0xFE,
  0xC1, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x0F, 0xE1, 0xFF, 0xDF, 0xFF, 0xF0, 0x6F, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0xFC,
  0x0F, 0xFF, 0xFB, 0xFF, 0x8F, 0xF8, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x7F, 0x8F, 0xF0, 0xFE, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0x78, 0x3F, 0x7F, 0xF7, 0x3F, 0xE7, 0x1F, 0xC7, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x8E, 0x01, 0xE3,
  0xC0, 0x70, 0xF0, 0x3C, 0x3C, 0x0F, 0x07, 0x03, 0x81, 0xE1, 0xE0, 0x78,
  0x78, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0x38,
  0x01, 0xCE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0x7B, 0x80, 0x7C, 0x03, 0x9E,
  0x03, 0xE0, 0x3C, 0xF0, 0x1F, 0x01, 0xE7, 0x80, 0xDC, 0x0F, 0x1C, 0x0E,
  0xE0, 0x70, 0xE0, 0x77, 0x03, 0x87, 0x83, 0xB8, 0x3C, 0x3C, 0x1D, 0xC1,
  0xE0, 0xE1, 0xEF, 0x0E, 0x07, 0x0E, 0x38, 0x70, 0x3C, 0x71, 0xC7, 0x81,
  0xE3, 0x8E, 0x3C, 0x0F, 0x3C, 0x79, 0xC0, 0x39, 0xC1, 0xCE, 0x01, 0xCE,
  0x0E, 0x70, 0x0F, 0x70, 0x77, 0x80, 0x7B, 0x83, 0xBC, 0x01, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80,
  0x0F, 0x00, 0xF8, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0xBC, 0x07, 0x9E,
  0x03, 0x87, 0x83, 0xC3, 0xC1, 0xC0, 0xF1, 0xE0, 0x78, 0xE0, 0x1E, 0xF0,
  0x0F, 0x70, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x1E, 0xE0, 0x0E, 0x78, 0x0F, 0x1C, 0x07, 0x0F, 0x07,
  0x83, 0x83, 0x81, 0xE3, 0xC0, 0x73, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x80, 0x39, 0xE0, 0x1E, 0x78, 0x07, 0x8E, 0x01, 0xE3,
  0xC0, 0x70, 0xF0, 0x3C, 0x1C, 0x0F, 0x07, 0x83, 0x81, 0xE1, 0xE0, 0x38,
  0x78, 0x0E, 0x1C, 0x03, 0xC7, 0x00, 0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0x38,
  0x01, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x03, 0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x10, 0x0F, 0x03,
  0xF0, 0x7F, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0xFC,
  0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x3F, 0x01, 0xFC, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xFE,
  0x01, 0xF0, 0x1F, 0x83, 0xF0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x03, 0x80, 0x00, 0x7F, 0x00, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 11, 11, 17, 3, -31 },
  { 37, 21, 31, 23, 1, -31 },
  { 119, 17, 36, 21, 2, -33 },
  { 196, 28, 32, 31, 2, -32 },
  { 308, 22, 32, 24, 2, -32 },
  { 396, 4, 11, 9, 3, -31 },
  { 402, 10, 39, 13, 2, -32 },
  { 451, 10, 39, 13, 1, -32 },
  { 500, 16, 16, 19, 2, -33 },
  { 532, 17, 21, 21, 2, -26 },
  { 577, 6, 11, 11, 2, -5 },
  { 586, 10, 4, 13, 1, -14 },
  { 591, 5, 5, 11, 3, -5 },
  { 595, 15, 32, 16, 1, -32 },
  { 655, 17, 32, 21, 2, -32 },
  { 723, 11, 31, 21, 3, -31 },
  { 766, 17, 32, 21, 2, -32 },
  { 834, 17, 32, 21, 2, -32 },
  { 902, 19, 32, 21, 1, -32 },
  { 978, 17, 31, 21, 2, -31 },
  { 1044, 17, 32, 21, 2, -32 },
  { 1112, 17, 31, 21, 2, -31 },
  { 1178, 17, 32, 21, 2, -32 },
  { 1246, 17, 32, 21, 2, -32 },
  { 1314, 5, 24, 11, 3, -24 },
  { 1329, 6, 30, 11, 2, -24 },
  { 1352, 17, 20, 21, 2, -26 },
  { 1395, 17, 13, 21, 2, -22 },
  { 1423, 17, 20, 21, 2, -26 },
  { 1466, 14, 32, 16, 1, -32 },
  { 1522, 28, 36, 32, 2, -32 },
  { 1648, 22, 31, 22, 0, -31 },
  { 1734, 17, 31, 23, 4, -31 },
  { 1800, 19, 32, 22, 2, -32 },
  { 1876, 19, 31, 26, 4, -31 },
  { 1950, 14, 31, 20, 4, -31 },
  { 2005, 14, 31, 19, 4, -31 },
  { 2060, 22, 32, 26, 2, -32 },
  { 2148, 19, 31, 26, 4, -31 },
  { 2222, 10, 31, 13, 2, -31 },
  { 2261, 10, 39, 11, -3, -31 },
  { 2310, 18, 31, 22, 4, -31 },
  { 2380, 13, 31, 18, 4, -31 },
  { 2431, 27, 31, 34, 4, -31 },
  { 2536, 20, 31, 28, 4, -31 },
  { 2614, 23, 32, 27, 2, -32 },
  { 2706, 16, 31, 22, 4, -31 },
  { 2768, 23, 39, 27, 2, -32 },
  { 2881, 18, 31, 22, 4, -31 },
  { 2951, 16, 32, 20, 2, -32 },
  { 3015, 19, 31, 19, 0, -31 },
  { 3089, 19, 31, 26, 3, -31 },
  { 3163, 22, 31, 22, 0, -31 },
  { 3249, 34, 31, 34, 0, -31 },
  { 3381, 20, 31, 20, 0, -31 },
  { 3459, 20, 31, 20, 0, -31 },
  { 3537, 17, 31, 19, 1, -31 },
  { 3603, 10, 39, 14, 3, -32 },
  { 3652, 15, 32, 16, 1, -32 },
  { 3712, 10, 39, 14, 1, -32 },
  { 3761, 19, 17, 21, 1, -31 },
  { 3802, 19, 3, 19, 0, 4 },
  { 3810, 8, 7, 12, 2, -34 },
  { 3817, 15, 24, 20, 2, -24 },
  { 3862, 17, 33, 22, 3, -33 },
  { 3933, 14, 24, 17, 2, -24 },
  { 3975, 17, 33, 22, 2, -33 },
  { 4046, 16, 24, 20, 2, -24 },
  { 4094, 14, 34, 12, 0, -34 },
  { 4154, 17, 35, 22, 2, -24 },
  { 4229, 16, 33, 22, 3, -33 },
  { 4295, 4, 32, 10, 3, -32 },
  { 4311, 8, 43, 10, -1, -32 },
  { 4354, 16, 33, 19, 3, -33 },
  { 4420, 4, 33, 10, 3, -33 },
  { 4437, 27, 24, 33, 3, -24 },
  { 4518, 16, 24, 22, 3, -24 },
  { 4566, 18, 24, 22, 2, -24 },
  { 4620, 17, 35, 22, 3, -24 },
  { 4695, 17, 35, 22, 2, -24 },
  { 4770, 11, 24, 15, 3, -24 },
  { 4803, 13, 24, 17, 2, -24 },
  { 4842, 11, 29, 13, 1, -29 },
  { 4882, 16, 24, 22, 3, -24 },
  { 4930, 18, 24, 18, 0, -24 },
  { 4984, 29, 24, 29, 0, -24 },
  { 5071, 17, 24, 18, 1, -24 },
  { 5122, 18, 35, 18, 0, -24 },
  { 5201, 13, 24, 16, 1, -24 },
  { 5240, 12, 39, 16, 2, -32 },
  { 5299, 4, 44, 20, 8, -34 },
  { 5321, 13, 39, 16, 2, -32 },
  { 5385, 17, 5, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_Regular44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_REGULAR44PT7B_H_
