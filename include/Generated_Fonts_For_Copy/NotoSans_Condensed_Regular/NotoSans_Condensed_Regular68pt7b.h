#ifndef _NOTOSANS_CONDENSED_REGULAR68PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F,
  0x7F, 0x7E, 0x18, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F,
  0xFC, 0x0F, 0xFF, 0x03, 0xF7, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F, 0xDF,
  0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x1F, 0x7C, 0x07, 0xDF, 0x01, 0xE7, 0xC0,
  0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x03,
  0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFE, 0x78, 0x7C, 0x7E, 0x1E,
  0x03, 0x1F, 0x07, 0x80, 0x0F, 0xC1, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0xF8,
  0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03, 0xF0, 0x78, 0x00,
  0x7C, 0x1E, 0x00, 0x1F, 0x87, 0x80, 0x07, 0xF1, 0xE0, 0x00, 0xFF, 0x78,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0,
  0x00, 0x79, 0xFE, 0x00, 0x1E, 0x3F, 0x80, 0x07, 0x83, 0xF0, 0x01, 0xE0,
  0xFC, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xF0, 0x01,
  0xE0, 0x7C, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x0F, 0xF0, 0x07, 0x87, 0xEF,
  0x01, 0xE3, 0xFB, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3E,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xC0,
  0x78, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x3C, 0x00, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x7C,
  0x00, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x00, 0xF8,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x78, 0x0F, 0x80, 0xF8, 0x78,
  0x3F, 0xC1, 0xF0, 0x1E, 0x1F, 0x0F, 0xFC, 0x1E, 0x03, 0xC3, 0xE3, 0xFF,
  0xC3, 0xE0, 0xF8, 0xF8, 0xFC, 0xFC, 0x7C, 0x1F, 0x1F, 0x1F, 0x0F, 0x87,
  0xC7, 0xC3, 0xC3, 0xC0, 0xF0, 0xFF, 0xF8, 0xF8, 0xF8, 0x1F, 0x0F, 0xFE,
  0x1E, 0x1F, 0x03, 0xE0, 0xFF, 0x87, 0xC3, 0xE0, 0x3C, 0x0F, 0xE0, 0xF8,
  0x78, 0x07, 0x80, 0x00, 0x1E, 0x0F, 0x00, 0xF8, 0x00, 0x07, 0xC1, 0xE0,
  0x1F, 0x00, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0x80, 0x7C,
  0x00, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x00,
  0x3E, 0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3E,
  0x03, 0xC0, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x00, 0x78, 0x1F,
  0x00, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xF9, 0xFC, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x0F, 0x81, 0xFC, 0x7E, 0x01, 0xF8, 0x1F, 0x87, 0xF0, 0x1F,
  0x83, 0xF0, 0x3F, 0x81, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0x07, 0xE0, 0x0F,
  0xC1, 0xF0, 0x7E, 0x00, 0xFE, 0x3F, 0x07, 0xE0, 0x07, 0xF3, 0xF0, 0x7C,
  0x00, 0x3F, 0x7E, 0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xFC,
  0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x7F,
  0x00, 0x1F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x7F,
  0x01, 0xFF, 0xFF, 0xE3, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0x7F, 0xFF,
  0x00, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDE, 0x79,
  0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0xF0, 0x3C, 0x0F, 0x7F, 0x1E, 0x3F, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x84, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xC0, 0x7E, 0x07, 0xF0, 0x1E,
  0x01, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x8F,
  0xCF, 0xE7, 0xF3, 0xF1, 0xF8, 0xFC, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87,
  0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xF8, 0x07, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF8, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xDF, 0x3F, 0x9F, 0x7F,
  0x9F, 0xFE, 0x1F, 0xFC, 0x1F, 0x78, 0x1F, 0x30, 0x1F, 0x20, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0xC0, 0x7F, 0x87, 0xC0, 0x0F, 0xE0, 0xC0, 0x01, 0xFC, 0x10, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x7F, 0x87, 0x80, 0x07, 0xF0, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE8, 0x00, 0x07, 0xF3, 0x80, 0x03, 0xFC, 0xFF, 0x07,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x03,
  0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xBF, 0xC0,
  0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x38, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x20, 0x00, 0x3F,
  0x9C, 0x00, 0x7F, 0x8F, 0xE3, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x03, 0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x40, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x70,
  0x01, 0xF0, 0xFF, 0xC0, 0x7C, 0x7F, 0xF8, 0x3F, 0x3F, 0xFF, 0x0F, 0xDF,
  0xFF, 0xE3, 0xFF, 0xC7, 0xFC, 0xFF, 0xC0, 0x7F, 0x3F, 0xC0, 0x0F, 0xEF,
  0xF0, 0x01, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x8F, 0xE0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xFB,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x00, 0xFE,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0x7F, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xDF, 0xE0, 0x0F,
  0xE1, 0xFF, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x0F,
  0xE3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x0F, 0xF0,
  0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F,
  0x03, 0xF0, 0x0F, 0xE1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x1F, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xF7, 0xE0, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0x7F,
  0x00, 0x7F, 0xCF, 0xE0, 0x7F, 0xF3, 0xFF, 0xFE, 0xFC, 0x7F, 0xFF, 0xBE,
  0x0F, 0xFF, 0xCF, 0x81, 0xFF, 0xE3, 0xE0, 0x1F, 0xE0, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x38, 0x7F, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0x7E, 0x18, 0x0F, 0x07, 0xE1, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xFC, 0x7E,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF1, 0xFC, 0x7F, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x3F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xF0, 0x78, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3E, 0x03, 0xF9, 0xC0, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0xFF, 0x01,
  0xF0, 0xF8, 0x03, 0xFF, 0xF0, 0x3E, 0x3E, 0x00, 0xFF, 0xFE, 0x07, 0xC7,
  0xC0, 0x3F, 0x8F, 0xC0, 0x78, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x1E, 0x01,
  0xF0, 0x1F, 0x01, 0xF7, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xDF, 0x03, 0xE0, 0x0F, 0x80, 0xFB, 0xC0, 0x7C, 0x01, 0xF0,
  0x1F, 0x78, 0x0F, 0x80, 0x3E, 0x03, 0xEF, 0x01, 0xF0, 0x07, 0x80, 0x7D,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xFF, 0x80,
  0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xFE, 0x03, 0xE0,
  0x1F, 0x00, 0xFF, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x78, 0x0F, 0x80, 0x7C,
  0x03, 0xCF, 0x01, 0xF0, 0x1F, 0x80, 0xF9, 0xE0, 0x3E, 0x03, 0xF0, 0x1F,
  0x3E, 0x03, 0xE0, 0x7F, 0x07, 0xC7, 0xC0, 0x7E, 0x1E, 0xF0, 0xF8, 0xF8,
  0x07, 0xFF, 0x9F, 0xFE, 0x1F, 0x00, 0xFF, 0xF3, 0xFF, 0x81, 0xF0, 0x0F,
  0xFC, 0x3F, 0xE0, 0x3E, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03,
  0xF0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0x7F, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFC, 0x00, 0xFF, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF,
  0xC0, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x7F, 0xE0, 0x3E, 0x07, 0xF8, 0x00, 0x60, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x0E, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x0F, 0xF0, 0xFC,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0xC3, 0xF0,
  0x01, 0xFF, 0x07, 0xE0, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x07, 0xF0, 0x1F, 0xF0, 0x00,
  0x78, 0x1F, 0xE0, 0x00, 0x08, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x0F, 0xC3, 0xFC, 0x00, 0x07, 0xE0, 0xFF, 0x80, 0x03, 0xF0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFE, 0xC3, 0xFD, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0x8F, 0xFE, 0x1F,
  0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00,
  0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x1F, 0xBF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x7F,
  0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00,
  0x01, 0xF7, 0xFF, 0xFC, 0x00, 0x00, 0x7D, 0xFF, 0xDF, 0x00, 0x00, 0x1F,
  0x7F, 0xF7, 0xC0, 0x00, 0x0F, 0xDF, 0xFD, 0xF8, 0x00, 0x03, 0xE7, 0xFF,
  0x3E, 0x00, 0x00, 0xF9, 0xFF, 0xCF, 0x80, 0x00, 0x7E, 0x7F, 0xF3, 0xF0,
  0x00, 0x1F, 0x1F, 0xFC, 0x7C, 0x00, 0x07, 0xC7, 0xFF, 0x1F, 0x00, 0x01,
  0xF1, 0xFF, 0xC7, 0xC0, 0x00, 0xF8, 0x7F, 0xF1, 0xF8, 0x00, 0x3E, 0x1F,
  0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xFF, 0x0F, 0x80, 0x07, 0xC1, 0xFF, 0xC3,
  0xF0, 0x01, 0xF0, 0x7F, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0xFC, 0x1F, 0x00,
  0x3E, 0x07, 0xFF, 0x07, 0xE0, 0x0F, 0x81, 0xFF, 0xC0, 0xF8, 0x03, 0xE0,
  0x7F, 0xF0, 0x3E, 0x01, 0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xFF,
  0x01, 0xF0, 0x1F, 0x01, 0xFF, 0xC0, 0x7C, 0x0F, 0xC0, 0x7F, 0xF0, 0x1F,
  0x83, 0xE0, 0x1F, 0xFC, 0x03, 0xE0, 0xF8, 0x07, 0xFF, 0x00, 0xF8, 0x3E,
  0x01, 0xFF, 0xC0, 0x3E, 0x1F, 0x00, 0x7F, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F,
  0xFC, 0x01, 0xF1, 0xF0, 0x07, 0xFF, 0x00, 0x7C, 0xF8, 0x01, 0xFF, 0xC0,
  0x1F, 0xBE, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFD, 0xF8, 0x00, 0x1F, 0xFD, 0xF8, 0x00,
  0x1F, 0xFC, 0xFC, 0x00, 0x1F, 0xFC, 0xFC, 0x00, 0x1F, 0xFC, 0x7E, 0x00,
  0x1F, 0xFC, 0x7E, 0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x1F, 0xFC, 0x3F, 0x00,
  0x1F, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x1F, 0x80, 0x1F, 0xFC, 0x0F, 0xC0,
  0x1F, 0xFC, 0x0F, 0xC0, 0x1F, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x07, 0xE0,
  0x1F, 0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x03, 0xF0, 0x1F, 0xFC, 0x01, 0xF8,
  0x1F, 0xFC, 0x01, 0xF8, 0x1F, 0xFC, 0x00, 0xFC, 0x1F, 0xFC, 0x00, 0xFC,
  0x1F, 0xFC, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0x3F,
  0x1F, 0xFC, 0x00, 0x3F, 0x1F, 0xFC, 0x00, 0x1F, 0x9F, 0xFC, 0x00, 0x1F,
  0x9F, 0xFC, 0x00, 0x0F, 0xDF, 0xFC, 0x00, 0x0F, 0xDF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F,
  0xF8, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x03,
  0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F,
  0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x03, 0xFC, 0xFC, 0x03,
  0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xF0, 0x03, 0xFC,
  0x1F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xFC, 0x1F, 0x80,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF1, 0xFF, 0x03, 0xF1, 0xFE, 0x00, 0x38, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xB0, 0x00, 0x1F, 0xDF,
  0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x07, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F,
  0xC0, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1E,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xBE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x8F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE3,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x80, 0x1F,
  0x80, 0x7C, 0x1F, 0x00, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x1F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x3E,
  0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x00, 0x3F,
  0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00,
  0x07, 0xC7, 0xC0, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x01, 0xF9, 0xF0, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x0E, 0x00, 0xFC, 0x08, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE0, 0x3F, 0x7F,
  0x80, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x7F,
  0x07, 0xDF, 0x7F, 0xFF, 0x9F, 0x3F, 0xFF, 0x1F, 0x1F, 0xFE, 0x1F, 0x0F,
  0xFC, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0xF8, 0x7F, 0xF0,
  0x3E, 0x3F, 0xFE, 0x0F, 0x9F, 0xFF, 0xC3, 0xEF, 0xFF, 0xF8, 0xFF, 0xC0,
  0xFF, 0x3F, 0xC0, 0x0F, 0xCF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0xC0, 0x0F, 0xEF, 0xF8,
  0x07, 0xF3, 0xEF, 0x87, 0xFC, 0xFB, 0xFF, 0xFE, 0x3E, 0x7F, 0xFF, 0x0F,
  0x8F, 0xFF, 0x83, 0xC0, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0xE0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8,
  0x7F, 0x80, 0xC1, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x02, 0x1F, 0xF0, 0x78, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07, 0xF8,
  0x3F, 0x03, 0xFF, 0xC7, 0xE0, 0xFF, 0xFC, 0xFC, 0x3F, 0xFF, 0xDF, 0x8F,
  0xFF, 0xFF, 0xF1, 0xFC, 0x07, 0xFE, 0x7F, 0x00, 0x7F, 0xCF, 0xC0, 0x07,
  0xFB, 0xF8, 0x00, 0xFF, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8,
  0x00, 0x3F, 0xBE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF3,
  0xF0, 0x01, 0xFE, 0x7E, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF8, 0xFF, 0x07,
  0xFF, 0x0F, 0xFF, 0xF3, 0xE1, 0xFF, 0xFE, 0x7C, 0x0F, 0xFF, 0x0F, 0x80,
  0xFF, 0xC1, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFE, 0x07,
  0xF0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3F, 0x00,
  0x0F, 0xDF, 0x80, 0x07, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x04, 0x3F, 0x80, 0x06, 0x0F, 0xF0,
  0x3F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0x02, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0x03, 0xE0, 0x7F, 0xF8, 0x7C, 0x1F, 0xFF,
  0x8F, 0x87, 0xFF, 0xF9, 0xF1, 0xFF, 0xFF, 0xBE, 0x3F, 0x81, 0xFF, 0xCF,
  0xE0, 0x0F, 0xF9, 0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xEF, 0xC0, 0x01,
  0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x07, 0xF9,
  0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0xFF, 0xE1, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF,
  0x9F, 0x81, 0xFF, 0xE3, 0xF0, 0x1F, 0xF8, 0x7E, 0x00, 0x70, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x0C, 0x00, 0x0F, 0xE1, 0xE0, 0x03, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x3F, 0xC0, 0xF8, 0x7F, 0xF8, 0x7C, 0x7F, 0xFE, 0x3E, 0x7F,
  0xFF, 0x1F, 0x7F, 0xFF, 0xCF, 0xFC, 0x0F, 0xF7, 0xFC, 0x03, 0xFB, 0xFC,
  0x00, 0xFD, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x3C, 0xFF, 0xFF,
  0xFF, 0xEF, 0xDF, 0x08, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F, 0x3E, 0x7C,
  0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0xFE, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x7F, 0xFB, 0xFF, 0x9F,
  0xFC, 0xFF, 0xC7, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x7E, 0x3E, 0x00, 0x7F, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x07, 0xC0,
  0x3F, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x1F, 0x80, 0xF8, 0x1F, 0x80, 0x7C,
  0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x0F, 0x8F, 0xC0, 0x07,
  0xC7, 0xE0, 0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xF8, 0x00, 0xFB, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xE7, 0xE0, 0x0F, 0xE3, 0xF8,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x0F,
  0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0x7E, 0x0F, 0x80,
  0x3F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xF1, 0xF0, 0x01, 0xF8, 0xF8,
  0x00, 0xFE, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xDF, 0x00, 0x07, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3F, 0xC0,
  0x0F, 0xF0, 0x3E, 0x1F, 0xFC, 0x0F, 0xFF, 0x0F, 0x9F, 0xFF, 0x87, 0xFF,
  0xE3, 0xE7, 0xFF, 0xF3, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F,
  0xE0, 0x7F, 0xFC, 0x0F, 0xEF, 0xF0, 0x0F, 0xFC, 0x01, 0xFB, 0xF8, 0x01,
  0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x00, 0x0F, 0xE0,
  0x03, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0,
  0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0xF0, 0x1F, 0xE0, 0x7C, 0x3F, 0xFC, 0x3E, 0x3F, 0xFF, 0x1F, 0x3F, 0xFF,
  0xCF, 0xBF, 0xFF, 0xE7, 0xFE, 0x07, 0xFB, 0xFC, 0x01, 0xFD, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0x3F, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x1F, 0x8F, 0xE0, 0x07, 0xE0, 0xFE, 0x01, 0xFC, 0x0F, 0xF0, 0xFF, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x1F, 0xE0, 0x3E, 0x1F, 0xFC, 0x0F,
  0x8F, 0xFF, 0xC3, 0xE7, 0xFF, 0xF8, 0xFB, 0xFF, 0xFE, 0x3F, 0xF0, 0x1F,
  0xCF, 0xF0, 0x03, 0xF3, 0xFC, 0x00, 0xFE, 0xFE, 0x00, 0x1F, 0xBF, 0x80,
  0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xF0, 0x03, 0xF3, 0xFE, 0x01,
  0xFC, 0xFB, 0xE1, 0xFF, 0x3E, 0xFF, 0xFF, 0x8F, 0x9F, 0xFF, 0xC3, 0xE3,
  0xFF, 0xE0, 0xF8, 0x3F, 0xF0, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x03, 0xE0, 0x7F, 0xF8, 0x7C, 0x1F, 0xFF, 0x8F, 0x87, 0xFF, 0xF9, 0xF1,
  0xFF, 0xFF, 0xBE, 0x3F, 0x80, 0xFF, 0xCF, 0xE0, 0x0F, 0xF9, 0xF8, 0x00,
  0xFF, 0x3F, 0x00, 0x1F, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00, 0x3F, 0xBF,
  0x00, 0x07, 0xF7, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE,
  0x7E, 0x00, 0x3F, 0xCF, 0xC0, 0x07, 0xF9, 0xFC, 0x01, 0xFF, 0x1F, 0xE1,
  0xFF, 0xE1, 0xFF, 0xFE, 0xFC, 0x3F, 0xFF, 0x9F, 0x81, 0xFF, 0xE3, 0xF0,
  0x1F, 0xF8, 0x7E, 0x00, 0x70, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFE, 0x3F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xDF, 0xDB, 0xEF, 0x01,
  0xFF, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xF3,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xE0, 0x1E, 0xFC, 0x00, 0x4F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x7F,
  0xFC, 0x1F, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x3F, 0xFE,
  0x00, 0x7E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x8F,
  0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x83, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0xC1,
  0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0x80, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFE,
  0xFC, 0x03, 0xFF, 0x7F, 0x87, 0xFF, 0x9F, 0xFF, 0xEF, 0xCF, 0xFF, 0xE3,
  0xE3, 0xFF, 0xE1, 0xF0, 0x7F, 0xE0, 0xF8, 0x07, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF7, 0xC0, 0x07, 0xFC, 0x00, 0x7C, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0x9F, 0x80, 0x1F, 0xF0, 0x03, 0xF3, 0xF0, 0x03,
  0xDE, 0x00, 0x7E, 0x3E, 0x00, 0xFB, 0xC0, 0x0F, 0x87, 0xC0, 0x1F, 0x7C,
  0x01, 0xF0, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x1F, 0x80, 0x7D, 0xF0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x3E, 0x01, 0xF0, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x07,
  0xC0, 0x7C, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0x8F, 0x81, 0xF8, 0x1F, 0x83,
  0xE1, 0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x07, 0xE1, 0xF0, 0x7C, 0x3F, 0x00, 0xFC, 0x3C, 0x0F, 0x87,
  0xC0, 0x0F, 0x8F, 0x80, 0xF0, 0xF8, 0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x07, 0xE7, 0xC0, 0x7C, 0xF8, 0x00, 0xFC,
  0xF0, 0x0F, 0x9F, 0x00, 0x0F, 0xBE, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x03, 0xEF, 0x80, 0x07, 0xDE, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF8, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x00,
  0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF9, 0xF8, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF,
  0x7F, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x60, 0x00, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x01,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00,
  0x7F, 0xC0, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x13, 0xFF, 0xC0, 0x03, 0x7F,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x3F, 0xFE, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x0F, 0xF0,
};

const GFXglyph NotoSans_Condensed_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 50, 17, 4, -49 },
  { 51, 18, 18, 26, 4, -49 },
  { 92, 33, 49, 35, 1, -49 },
  { 295, 26, 56, 32, 3, -52 },
  { 477, 43, 50, 49, 3, -49 },
  { 746, 36, 50, 38, 2, -49 },
  { 971, 6, 18, 14, 4, -49 },
  { 985, 15, 60, 20, 3, -49 },
  { 1098, 15, 60, 20, 2, -49 },
  { 1211, 25, 25, 30, 3, -52 },
  { 1290, 28, 32, 32, 2, -40 },
  { 1402, 9, 17, 16, 3, -8 },
  { 1422, 15, 5, 20, 2, -21 },
  { 1432, 8, 9, 16, 4, -8 },
  { 1441, 23, 49, 25, 1, -49 },
  { 1582, 26, 50, 32, 3, -49 },
  { 1745, 16, 49, 32, 5, -49 },
  { 1843, 26, 49, 32, 3, -49 },
  { 2003, 26, 50, 32, 3, -49 },
  { 2166, 30, 49, 32, 1, -49 },
  { 2350, 25, 50, 32, 4, -49 },
  { 2507, 26, 50, 32, 3, -49 },
  { 2670, 27, 49, 32, 2, -49 },
  { 2836, 27, 50, 32, 3, -49 },
  { 3005, 26, 50, 32, 3, -49 },
  { 3168, 8, 38, 16, 4, -37 },
  { 3206, 10, 46, 16, 2, -37 },
  { 3264, 28, 31, 32, 2, -40 },
  { 3373, 26, 19, 32, 3, -33 },
  { 3435, 28, 31, 32, 2, -40 },
  { 3544, 21, 50, 24, 1, -49 },
  { 3676, 43, 55, 49, 3, -49 },
  { 3972, 34, 49, 34, 0, -49 },
  { 4181, 28, 49, 36, 5, -49 },
  { 4353, 28, 50, 34, 4, -49 },
  { 4528, 31, 49, 39, 5, -49 },
  { 4718, 22, 49, 30, 5, -49 },
  { 4853, 22, 49, 29, 5, -49 },
  { 4988, 33, 50, 41, 4, -49 },
  { 5195, 30, 49, 40, 5, -49 },
  { 5379, 16, 49, 20, 2, -49 },
  { 5477, 15, 62, 16, -4, -49 },
  { 5594, 29, 49, 34, 5, -49 },
  { 5772, 22, 49, 28, 5, -49 },
  { 5907, 42, 49, 53, 5, -49 },
  { 6165, 32, 49, 43, 5, -49 },
  { 6361, 35, 50, 42, 4, -49 },
  { 6580, 26, 49, 33, 5, -49 },
  { 6740, 35, 61, 42, 4, -49 },
  { 7007, 29, 49, 35, 5, -49 },
  { 7185, 25, 50, 31, 3, -49 },
  { 7342, 28, 49, 29, 1, -49 },
  { 7514, 30, 50, 40, 5, -49 },
  { 7702, 33, 49, 33, 0, -49 },
  { 7905, 53, 49, 53, 0, -49 },
  { 8230, 31, 49, 31, 0, -49 },
  { 8420, 30, 49, 30, 0, -49 },
  { 8604, 25, 49, 29, 2, -49 },
  { 8758, 15, 60, 22, 5, -49 },
  { 8871, 23, 49, 25, 1, -49 },
  { 9012, 15, 60, 22, 2, -49 },
  { 9125, 30, 28, 33, 1, -49 },
  { 9230, 30, 4, 30, 0, 6 },
  { 9245, 13, 11, 18, 3, -52 },
  { 9263, 24, 38, 31, 3, -37 },
  { 9377, 26, 53, 35, 5, -52 },
  { 9550, 22, 38, 26, 3, -37 },
  { 9655, 27, 53, 35, 3, -52 },
  { 9834, 25, 38, 31, 3, -37 },
  { 9953, 20, 52, 19, 1, -52 },
  { 10083, 27, 53, 35, 3, -37 },
  { 10262, 25, 52, 34, 5, -52 },
  { 10425, 7, 50, 15, 4, -50 },
  { 10469, 13, 66, 15, -2, -50 },
  { 10577, 25, 52, 30, 5, -52 },
  { 10740, 5, 52, 15, 5, -52 },
  { 10773, 42, 37, 52, 5, -37 },
  { 10968, 25, 37, 34, 5, -37 },
  { 11084, 27, 38, 34, 3, -37 },
  { 11213, 26, 53, 35, 5, -37 },
  { 11386, 27, 53, 35, 3, -37 },
  { 11565, 17, 37, 23, 5, -37 },
  { 11644, 20, 38, 26, 3, -37 },
  { 11739, 18, 46, 20, 1, -45 },
  { 11843, 25, 38, 34, 5, -37 },
  { 11962, 28, 37, 28, 0, -37 },
  { 12092, 43, 37, 45, 1, -37 },
  { 12291, 27, 37, 29, 1, -37 },
  { 12416, 28, 53, 28, 0, -37 },
  { 12602, 20, 37, 24, 2, -37 },
  { 12695, 19, 60, 25, 3, -49 },
  { 12838, 5, 68, 31, 13, -52 },
  { 12881, 19, 60, 25, 3, -49 },
  { 13024, 28, 8, 32, 2, -28 },
};

const GFXfont NotoSans_Condensed_Regular68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_REGULAR68PT7B_H_
