#ifndef _NOTOSANS_CONDENSED_REGULAR19PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x50, 0xF0, 0xDE, 0x73, 0x9C, 0x80, 0x09, 0x0C, 0x86,
  0x42, 0x27, 0xFB, 0xFC, 0x48, 0x24, 0x32, 0x7F, 0xC9, 0x84, 0xC2, 0x41,
  0x20, 0x10, 0x7B, 0xFC, 0x89, 0x1A, 0x1C, 0x0E, 0x16, 0x24, 0x4E, 0xFF,
  0x82, 0x04, 0x00, 0x60, 0x8D, 0x18, 0x91, 0x09, 0x90, 0x9B, 0x09, 0xA0,
  0x96, 0xED, 0x5A, 0x65, 0x30, 0x93, 0x09, 0x31, 0x93, 0x11, 0xA3, 0x0E,
  0x38, 0x1F, 0x04, 0x41, 0x10, 0x6C, 0x1A, 0x03, 0x01, 0xE6, 0xD9, 0xA3,
  0x48, 0x72, 0x1C, 0xCF, 0x1E, 0x70, 0xFF, 0xC0, 0x32, 0x64, 0xCC, 0xCC,
  0x88, 0xCC, 0xC4, 0x62, 0x30, 0x8C, 0x46, 0x22, 0x33, 0x33, 0x32, 0x26,
  0x6C, 0x80, 0x30, 0x23, 0xF9, 0x87, 0x89, 0x92, 0x00, 0x10, 0x20, 0x40,
  0x8F, 0xE2, 0x04, 0x08, 0x10, 0x7E, 0xFF, 0xF0, 0x06, 0x08, 0x10, 0x60,
  0x83, 0x06, 0x08, 0x30, 0x40, 0x83, 0x04, 0x18, 0x00, 0x38, 0xFB, 0x16,
  0x3C, 0x78, 0xE1, 0xC3, 0x87, 0x8F, 0x1E, 0x36, 0xCF, 0x00, 0x19, 0xDF,
  0xB1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x39, 0xFA, 0x18, 0x30, 0x60,
  0x83, 0x04, 0x18, 0x61, 0x82, 0x0C, 0x1F, 0xC0, 0x39, 0xFA, 0x18, 0x30,
  0x61, 0x9E, 0x3E, 0x06, 0x0C, 0x18, 0x38, 0xDF, 0x00, 0x06, 0x03, 0x02,
  0x81, 0x41, 0xA0, 0x90, 0x88, 0x44, 0x42, 0x61, 0x3F, 0xE0, 0x40, 0x20,
  0x10, 0x7C, 0xFB, 0x06, 0x0C, 0x18, 0x3F, 0x03, 0x06, 0x0C, 0x18, 0x38,
  0xDF, 0x00, 0x1C, 0x79, 0x82, 0x0C, 0x1B, 0x2F, 0x63, 0xC7, 0x87, 0x0E,
  0x36, 0x67, 0x80, 0xFF, 0xFC, 0x18, 0x30, 0x41, 0x82, 0x0C, 0x18, 0x20,
  0xC1, 0x82, 0x0C, 0x00, 0x38, 0xFB, 0x1E, 0x3C, 0x6D, 0x8E, 0x3E, 0xC7,
  0x0E, 0x0C, 0x1C, 0x6F, 0x80, 0x38, 0xFB, 0x14, 0x38, 0x70, 0xF1, 0xF7,
  0x7E, 0x0C, 0x18, 0x61, 0xDF, 0x00, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xFE,
  0x02, 0x1C, 0xE7, 0x0C, 0x0E, 0x07, 0x03, 0x02, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x81, 0xC0, 0xE0, 0x70, 0x63, 0x9C, 0x60, 0x80, 0x3B, 0xF0, 0x41,
  0x04, 0x31, 0x84, 0x30, 0x80, 0x00, 0x30, 0xC0, 0x07, 0x01, 0xFC, 0x20,
  0x66, 0x02, 0x47, 0x2C, 0x93, 0x99, 0x19, 0x91, 0x91, 0x19, 0x93, 0x9A,
  0xAC, 0xEC, 0x40, 0x06, 0x00, 0x3F, 0x80, 0xE0, 0x0C, 0x03, 0x01, 0xC0,
  0x58, 0x16, 0x0C, 0x83, 0x20, 0x8C, 0x3F, 0x1F, 0xC6, 0x19, 0x06, 0xC1,
  0xB0, 0x30, 0xF1, 0xFA, 0x1C, 0x38, 0x70, 0xFF, 0x7E, 0x87, 0x0E, 0x0C,
  0x38, 0xFF, 0x80, 0x1E, 0x3F, 0x60, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x71, 0x1F, 0xF0, 0xFC, 0x86, 0x82, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x86, 0x9C, 0xF8, 0xFF, 0xF8, 0x20, 0x82, 0x0F,
  0xBE, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xFF, 0xF8, 0x20, 0x82, 0x08, 0x3E,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x0F, 0x1F, 0xD8, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x8F, 0xC0, 0xE0, 0x70, 0x2C, 0x13, 0x18, 0xFC, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0xFF, 0xFF, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xFE,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0xFC, 0x82, 0x86, 0x8C, 0x88, 0x98, 0xB0, 0xA0, 0xF0, 0x98,
  0x98, 0x8C, 0x8C, 0x86, 0x87, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x83, 0xF0, 0xC0, 0x78, 0x0F, 0x83, 0xF0, 0x5A, 0x0B, 0x43,
  0x6C, 0x4C, 0x89, 0x93, 0x33, 0x46, 0x28, 0xC7, 0x18, 0xE3, 0x18, 0x40,
  0xC1, 0xC1, 0xC1, 0xE1, 0xA1, 0xB1, 0x91, 0x99, 0x89, 0x8D, 0x85, 0x87,
  0x83, 0x83, 0x1E, 0x0F, 0xC6, 0x19, 0x06, 0xC0, 0xB0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x09, 0x86, 0x73, 0x0F, 0x80, 0xE1, 0xFA, 0x34, 0x38,
  0x70, 0xE3, 0x7E, 0xF1, 0x02, 0x04, 0x08, 0x10, 0x00, 0x1E, 0x0F, 0xC6,
  0x19, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x09, 0x86,
  0x73, 0x0F, 0x80, 0x60, 0x0C, 0x01, 0x80, 0xE1, 0xFA, 0x34, 0x38, 0x70,
  0xE3, 0x7C, 0x99, 0x32, 0x34, 0x68, 0x70, 0xC0, 0x3C, 0xFF, 0x06, 0x0C,
  0x18, 0x1C, 0x1E, 0x0C, 0x0C, 0x18, 0x38, 0xDF, 0x00, 0xFF, 0xFF, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x68,
  0x26, 0x31, 0xF0, 0xC0, 0xE0, 0xD0, 0x6C, 0x26, 0x13, 0x18, 0x8C, 0x64,
  0x36, 0x1B, 0x05, 0x83, 0x81, 0xC0, 0x60, 0xC1, 0x07, 0x86, 0x0D, 0x0E,
  0x12, 0x14, 0x66, 0x28, 0xCC, 0xD1, 0x99, 0xB2, 0x12, 0x64, 0x34, 0x58,
  0x68, 0xB0, 0xF1, 0x60, 0xE3, 0x81, 0x83, 0x03, 0x06, 0x00, 0xC1, 0x31,
  0x98, 0x86, 0xC3, 0x40, 0xE0, 0x70, 0x38, 0x1C, 0x1A, 0x09, 0x8C, 0x44,
  0x36, 0x0C, 0xC1, 0xC3, 0x63, 0x62, 0x26, 0x34, 0x3C, 0x1C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFD, 0xF8, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x20,
  0xC1, 0x06, 0x08, 0x1F, 0xC0, 0xFF, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xF0, 0xC0, 0x81, 0x83, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x30,
  0x60, 0x40, 0xC0, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0,
  0x08, 0x04, 0x05, 0x02, 0x83, 0x21, 0x11, 0x8D, 0x83, 0xFF, 0xD9, 0x80,
  0x7D, 0x10, 0x41, 0x7F, 0x18, 0x61, 0xCD, 0xD0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0xE6, 0xDC, 0x7D, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0x65, 0xF0, 0x02, 0x04, 0x08, 0x17, 0xB8, 0xF1,
  0xE1, 0x83, 0x07, 0x0E, 0x34, 0x6F, 0x40, 0x7C, 0x8B, 0x1E, 0x3F, 0xF0,
  0x30, 0x60, 0x62, 0x7C, 0x08, 0xF2, 0x08, 0x23, 0xE2, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x00, 0x7B, 0x8F, 0x1E, 0x18, 0x30, 0x70, 0xE3, 0x46,
  0xF4, 0x08, 0x18, 0x7F, 0x8C, 0x00, 0xC1, 0x83, 0x06, 0x0F, 0xFC, 0xF0,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x40, 0xF0, 0xFF, 0xFF, 0xF0, 0x33,
  0x00, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x3F, 0x40, 0xC1, 0x83, 0x06,
  0x0C, 0x79, 0xB6, 0x68, 0xF1, 0xF3, 0x26, 0x6C, 0x58, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFD, 0xEE, 0x73, 0xC6, 0x3C, 0x61, 0xC6, 0x1C, 0x61, 0xC6,
  0x1C, 0x61, 0xC6, 0x1C, 0x61, 0xFF, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x84, 0x7C, 0x46, 0xC2, 0xC2, 0x83, 0x82, 0xC2, 0xC2, 0x66, 0x3C,
  0xFE, 0xE6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2, 0xE6, 0xDC, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0x7B, 0x8F, 0x1E, 0x18, 0x30, 0x70, 0xE3, 0x66, 0xF4,
  0x08, 0x10, 0x20, 0x40, 0x80, 0xDF, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x00,
  0xFA, 0x28, 0x30, 0x70, 0xE0, 0x83, 0x9B, 0xE0, 0x21, 0x09, 0xF6, 0x31,
  0x8C, 0x63, 0x18, 0x43, 0x80, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3,
  0x66, 0xF4, 0xC3, 0x42, 0x46, 0x66, 0x64, 0x24, 0x2C, 0x3C, 0x18, 0x18,
  0xC6, 0x14, 0x73, 0x47, 0x36, 0x52, 0x6D, 0x22, 0x92, 0x29, 0xE2, 0x8E,
  0x38, 0xC3, 0x0C, 0xE3, 0x66, 0x34, 0x3C, 0x18, 0x18, 0x3C, 0x24, 0x66,
  0xC3, 0xC3, 0x42, 0x46, 0x66, 0x24, 0x24, 0x3C, 0x3C, 0x18, 0x18, 0x18,
  0x10, 0x30, 0xE0, 0x40, 0xF8, 0xC4, 0x62, 0x31, 0x18, 0x87, 0xC0, 0x09,
  0xC8, 0x42, 0x10, 0x8C, 0xC3, 0x08, 0x42, 0x10, 0x86, 0x18, 0xFF, 0xFF,
  0xE0, 0x87, 0x18, 0x42, 0x10, 0x86, 0x19, 0x88, 0x42, 0x10, 0x8C, 0xC0,
  0xE3, 0x7E, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 5, 1, -14 },
  { 5, 5, 5, 7, 1, -14 },
  { 9, 9, 14, 10, 0, -14 },
  { 25, 7, 15, 9, 1, -14 },
  { 39, 12, 14, 14, 1, -14 },
  { 60, 10, 14, 11, 1, -14 },
  { 78, 2, 5, 4, 1, -14 },
  { 80, 4, 17, 6, 1, -14 },
  { 89, 4, 17, 6, 1, -14 },
  { 98, 7, 7, 8, 1, -14 },
  { 105, 7, 9, 9, 1, -11 },
  { 113, 2, 4, 5, 1, -2 },
  { 114, 4, 2, 5, 1, -6 },
  { 115, 2, 2, 5, 1, -2 },
  { 116, 7, 14, 7, 0, -14 },
  { 129, 7, 14, 9, 1, -14 },
  { 142, 5, 14, 9, 1, -14 },
  { 151, 7, 14, 9, 1, -14 },
  { 164, 7, 14, 9, 1, -14 },
  { 177, 9, 14, 9, 0, -14 },
  { 193, 7, 14, 9, 1, -14 },
  { 206, 7, 14, 9, 1, -14 },
  { 219, 7, 14, 9, 1, -14 },
  { 232, 7, 14, 9, 1, -14 },
  { 245, 7, 14, 9, 1, -14 },
  { 258, 2, 10, 5, 1, -10 },
  { 261, 2, 12, 5, 1, -10 },
  { 264, 7, 9, 9, 1, -11 },
  { 272, 7, 5, 9, 1, -9 },
  { 277, 7, 9, 9, 1, -11 },
  { 285, 6, 14, 7, 0, -14 },
  { 296, 12, 16, 14, 1, -14 },
  { 320, 10, 14, 10, 0, -14 },
  { 338, 7, 14, 10, 2, -14 },
  { 351, 8, 14, 10, 1, -14 },
  { 365, 8, 14, 11, 2, -14 },
  { 379, 6, 14, 9, 2, -14 },
  { 390, 6, 14, 8, 2, -14 },
  { 401, 9, 14, 11, 1, -14 },
  { 417, 8, 14, 11, 2, -14 },
  { 431, 4, 14, 6, 1, -14 },
  { 438, 4, 18, 5, -1, -14 },
  { 447, 8, 14, 9, 2, -14 },
  { 461, 6, 14, 8, 2, -14 },
  { 472, 11, 14, 15, 2, -14 },
  { 492, 8, 14, 12, 2, -14 },
  { 506, 10, 14, 12, 1, -14 },
  { 524, 7, 14, 9, 2, -14 },
  { 537, 10, 17, 12, 1, -14 },
  { 559, 7, 14, 10, 2, -14 },
  { 572, 7, 14, 9, 1, -14 },
  { 585, 8, 14, 8, 0, -14 },
  { 599, 9, 14, 11, 1, -14 },
  { 615, 9, 14, 9, 0, -14 },
  { 631, 15, 14, 15, 0, -14 },
  { 658, 9, 14, 9, 0, -14 },
  { 674, 8, 14, 8, 0, -14 },
  { 688, 7, 14, 8, 1, -14 },
  { 701, 4, 17, 6, 1, -14 },
  { 710, 7, 14, 7, 0, -14 },
  { 723, 4, 17, 6, 1, -14 },
  { 732, 9, 8, 9, 0, -14 },
  { 741, 8, 1, 8, 0, 2 },
  { 742, 3, 3, 5, 1, -15 },
  { 744, 6, 10, 9, 1, -10 },
  { 752, 8, 14, 10, 1, -14 },
  { 766, 6, 10, 7, 1, -10 },
  { 774, 7, 14, 10, 1, -14 },
  { 787, 7, 10, 9, 1, -10 },
  { 796, 6, 15, 5, 0, -15 },
  { 808, 7, 15, 10, 1, -10 },
  { 822, 7, 14, 10, 1, -14 },
  { 835, 2, 14, 4, 1, -14 },
  { 839, 4, 19, 4, -1, -14 },
  { 849, 7, 14, 8, 1, -14 },
  { 862, 2, 14, 4, 1, -14 },
  { 866, 12, 10, 14, 1, -10 },
  { 881, 7, 10, 10, 1, -10 },
  { 890, 8, 10, 9, 1, -10 },
  { 900, 8, 15, 10, 1, -10 },
  { 915, 7, 15, 10, 1, -10 },
  { 929, 5, 10, 6, 1, -10 },
  { 936, 6, 10, 7, 1, -10 },
  { 944, 5, 13, 6, 0, -13 },
  { 953, 7, 10, 10, 1, -10 },
  { 962, 8, 10, 8, 0, -10 },
  { 972, 12, 10, 13, 0, -10 },
  { 987, 8, 10, 8, 0, -10 },
  { 997, 8, 15, 8, 0, -10 },
  { 1012, 5, 10, 7, 1, -10 },
  { 1019, 5, 17, 7, 1, -14 },
  { 1030, 1, 19, 9, 4, -14 },
  { 1033, 5, 17, 7, 1, -14 },
  { 1044, 7, 3, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Regular19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_REGULAR19PT7B_H_
