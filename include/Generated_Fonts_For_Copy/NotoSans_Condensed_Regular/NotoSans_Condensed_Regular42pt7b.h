#ifndef _NOTOSANS_CONDENSED_REGULAR42PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xC6, 0x30, 0x00, 0x03, 0xBD, 0xFF, 0x78, 0xE1, 0xFC, 0x3F, 0x87,
  0xF0, 0xFE, 0x1F, 0xC3, 0xB8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B, 0x83, 0x00,
  0x01, 0xC3, 0x80, 0x18, 0x38, 0x01, 0x83, 0x80, 0x38, 0x38, 0x03, 0x83,
  0x00, 0x38, 0x30, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x07, 0x07, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF0, 0x70, 0x60, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0xE0, 0xE0, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xE1, 0xC0, 0x0C, 0x1C, 0x00, 0xC1, 0xC0,
  0x1C, 0x1C, 0x01, 0xC1, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0x83, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F,
  0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x79, 0x84, 0xF1, 0x80, 0xE1, 0x80, 0xE1,
  0x80, 0xE1, 0x80, 0xF1, 0x80, 0xF9, 0x80, 0x7F, 0x80, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xBE, 0x01, 0x8F, 0x01, 0x87, 0x01,
  0x87, 0x01, 0x87, 0x01, 0x8F, 0x81, 0x8E, 0xF1, 0xBE, 0xFF, 0xFC, 0xFF,
  0xF8, 0x0F, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3F,
  0x00, 0x78, 0x1F, 0xE0, 0x1C, 0x07, 0x38, 0x07, 0x03, 0x87, 0x03, 0x80,
  0xE1, 0xC0, 0xE0, 0x38, 0x70, 0x70, 0x0E, 0x1C, 0x1C, 0x03, 0x87, 0x07,
  0x00, 0xE1, 0xC3, 0x80, 0x38, 0x70, 0xE0, 0x0E, 0x1C, 0x70, 0x03, 0x87,
  0x1C, 0x00, 0xE1, 0xC6, 0x3F, 0x38, 0x73, 0x9F, 0xE6, 0x1C, 0xE7, 0x39,
  0xCE, 0x73, 0x86, 0x7F, 0x9C, 0xE1, 0xCF, 0xCE, 0x38, 0x70, 0x03, 0x8E,
  0x1C, 0x00, 0xE3, 0x87, 0x00, 0x70, 0xE1, 0xC0, 0x1C, 0x38, 0x70, 0x0E,
  0x0E, 0x1C, 0x03, 0x83, 0x87, 0x00, 0xE0, 0xE1, 0xC0, 0x70, 0x38, 0x70,
  0x1C, 0x0E, 0x18, 0x0E, 0x01, 0xCE, 0x03, 0x80, 0x7F, 0x01, 0xC0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xBE, 0x00, 0x78, 0x70, 0x03,
  0x83, 0xC0, 0x1C, 0x1E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0x3C, 0x38,
  0x00, 0xE3, 0xC0, 0x07, 0x9C, 0x00, 0x3D, 0xE0, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7D, 0xE0, 0xF3, 0xC7, 0x87,
  0xBC, 0x3C, 0x39, 0xE0, 0xF1, 0xCE, 0x03, 0xDE, 0x70, 0x0F, 0xE3, 0x80,
  0x7F, 0x1C, 0x01, 0xF0, 0xE0, 0x0F, 0x87, 0x80, 0xFE, 0x3E, 0x0F, 0xF8,
  0xFF, 0xFB, 0xC3, 0xFF, 0x8F, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x83, 0x83, 0xC1, 0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x78, 0x3C,
  0x1C, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0,
  0x38, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0xF0, 0x3C, 0x0E, 0x07, 0x81,
  0xC0, 0xF0, 0x38, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x78, 0x3C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0F, 0x07, 0x83,
  0xC1, 0xC0, 0xE0, 0xF0, 0x70, 0x38, 0x3C, 0x1C, 0x1E, 0x0E, 0x0E, 0x0E,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1C, 0x73,
  0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x0F, 0x80, 0x3B, 0x80, 0xE7, 0x83,
  0xC7, 0x0F, 0x0F, 0x06, 0x0C, 0x04, 0x10, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x7D,
  0xE7, 0x9E, 0x71, 0xCF, 0x38, 0xE3, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xF8,
  0x3F, 0xF8, 0x3C, 0x3C, 0x78, 0x1C, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x78, 0x1C,
  0x3C, 0x3C, 0x3F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0, 0x01, 0xC1, 0xF0, 0xFC,
  0x7F, 0x3D, 0xDE, 0x7F, 0x1D, 0x87, 0x41, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xE0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xF0, 0x3C, 0x40, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xF0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xE0, 0x3C, 0x40, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0xF8,
  0x1F, 0xE0, 0x1F, 0xC0, 0x1F, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x1E, 0xC0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x1D, 0xE0, 0x07, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x80, 0x71, 0xE0, 0x1C,
  0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1E,
  0x1E, 0x07, 0x87, 0x01, 0xE3, 0x80, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0x7F, 0xFC, 0x7F, 0xFC,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0xC0, 0x7C,
  0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x03, 0xFC, 0x07, 0xFC, 0x0F, 0xFC,
  0x1F, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0xF7, 0xF8, 0xEF, 0xFC, 0xFC, 0x3E,
  0xF8, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0E, 0x78, 0x1E, 0x3C, 0x3E,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E,
  0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8,
  0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x3E, 0xFC, 0x78, 0x3C, 0x70, 0x1E,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0xF8, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x78, 0x3C, 0x70, 0x1C, 0xF0, 0x1E, 0xF0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0x78, 0x1F, 0x7C, 0x7F, 0x3F, 0xEF, 0x1F, 0xEF, 0x0F, 0x8E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x6F, 0xFF,
  0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0xF3,
  0xCF, 0x3C, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xCF, 0x3C, 0xF3, 0x8E, 0x79, 0xC7, 0x1C, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0xC0, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x00,
  0x60, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80, 0x00, 0x3F, 0xE3, 0xFF, 0xC7, 0xFF,
  0x98, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x1F, 0x00,
  0xF8, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0x78, 0xF0,
  0x00, 0x0E, 0x38, 0x1F, 0xC3, 0x9E, 0x0F, 0xF8, 0x77, 0x07, 0xDE, 0x1D,
  0xC3, 0xC3, 0x87, 0x70, 0xE0, 0xE1, 0xF8, 0x38, 0x38, 0x3E, 0x1C, 0x0E,
  0x0F, 0x87, 0x03, 0x83, 0xE1, 0xC0, 0xE0, 0xF8, 0x70, 0x78, 0x7E, 0x1C,
  0x1E, 0x1F, 0x87, 0x07, 0x87, 0xE1, 0xC1, 0xE1, 0xF8, 0x38, 0x78, 0xEE,
  0x0F, 0x77, 0x79, 0xC1, 0xFD, 0xFC, 0x70, 0x3E, 0x3E, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xC0,
  0x04, 0x00, 0xFC, 0x07, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x7B, 0xC0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x3C, 0x1E, 0x01, 0xE0, 0x70, 0x0E, 0x03, 0x80,
  0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x1E, 0x00,
  0xF0, 0xF0, 0x07, 0x87, 0x80, 0x1C, 0x38, 0x00, 0xF3, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xFF, 0xF0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x00, 0xF7, 0x80, 0x3B, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xDE, 0x01, 0xEF,
  0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xFC, 0xF0, 0x1F, 0x78, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xDF, 0xFF, 0xCF, 0xFF, 0xC7,
  0xFF, 0x80, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xF8, 0x7E, 0x06, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF8, 0x08, 0x3F, 0xFE, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x3F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F,
  0x3C, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x07, 0x9E, 0x01, 0xE3,
  0xC1, 0xFC, 0x7F, 0xFF, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xEF, 0xFF,
  0xBF, 0xFE, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0x00, 0xC1, 0xF0, 0x02, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3F, 0xFE,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xE0, 0x00,
  0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x3E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0xE0, 0x1E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF,
  0x80, 0xFF, 0xF0, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xC0, 0xFF, 0xFF, 0xDF, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0xCF, 0xFF,
  0xFC, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x87, 0xA7, 0xDF, 0xEF, 0xE7, 0xC0, 0xF0, 0x07, 0xFC, 0x01,
  0xEF, 0x00, 0xF3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x0F, 0x03, 0x83,
  0xC1, 0xE0, 0xF0, 0xF0, 0x3C, 0x38, 0x0F, 0x1E, 0x03, 0xCF, 0x00, 0xF3,
  0x80, 0x3D, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFD, 0xE0, 0x3E, 0x78,
  0x0F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0xC3,
  0xC0, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x00, 0xF0, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0x7F, 0xF0, 0x01, 0xDF, 0xDC, 0x00, 0x77, 0xF7,
  0x00, 0x3D, 0xFD, 0xE0, 0x0E, 0x7F, 0x38, 0x03, 0x9F, 0xCE, 0x01, 0xE7,
  0xF3, 0x80, 0x71, 0xFC, 0xF0, 0x1C, 0x7F, 0x1C, 0x0F, 0x1F, 0xC7, 0x03,
  0x87, 0xF1, 0xE0, 0xE1, 0xFC, 0x38, 0x38, 0x7F, 0x0E, 0x1C, 0x1F, 0xC3,
  0xC7, 0x07, 0xF0, 0x71, 0xC1, 0xFC, 0x1C, 0xE0, 0x7F, 0x07, 0xB8, 0x1F,
  0xC0, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7F, 0x01, 0xF0,
  0x1F, 0xC0, 0x7C, 0x07, 0xF0, 0x1E, 0x01, 0xFC, 0x07, 0x80, 0x70, 0xF8,
  0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7E,
  0xE0, 0x07, 0xFF, 0x00, 0x7F, 0x70, 0x07, 0xF7, 0x80, 0x7F, 0x38, 0x07,
  0xF3, 0xC0, 0x7F, 0x1C, 0x07, 0xF1, 0xE0, 0x7F, 0x0E, 0x07, 0xF0, 0xF0,
  0x7F, 0x07, 0x07, 0xF0, 0x78, 0x7F, 0x03, 0x87, 0xF0, 0x3C, 0x7F, 0x01,
  0xC7, 0xF0, 0x1E, 0x7F, 0x01, 0xE7, 0xF0, 0x0F, 0x7F, 0x00, 0xF7, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0,
  0xF8, 0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1E,
  0x78, 0x00, 0x79, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x79,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF8,
  0x07, 0xC1, 0xF0, 0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8,
  0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x7E, 0xF0, 0x1E, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xE0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8,
  0x3E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x79, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x3C, 0x00, 0xF0, 0xF8, 0x07,
  0xC1, 0xF0, 0x3E, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xC1, 0xF8, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x1E,
  0x3C, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xE0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0x78, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x07,
  0xBC, 0x00, 0xF0, 0x0F, 0xF8, 0x3F, 0xFC, 0xFF, 0xF3, 0xE0, 0x6F, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x1F, 0x00, 0x3F, 0x01, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x9C, 0x00, 0x3C,
  0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xE0, 0x07, 0x87, 0x80,
  0x38, 0x3C, 0x01, 0xC0, 0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07, 0x01,
  0xE0, 0x78, 0x07, 0x03, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x0F,
  0x00, 0x38, 0x78, 0x01, 0xE3, 0x80, 0x0F, 0x1C, 0x00, 0x39, 0xE0, 0x01,
  0xCF, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xC0, 0x07, 0xB8, 0x01, 0xE0, 0x03, 0x9C, 0x00, 0xF8, 0x03, 0xCF,
  0x00, 0x7C, 0x01, 0xE7, 0x80, 0x3E, 0x00, 0xF3, 0xC0, 0x3F, 0x00, 0x70,
  0xE0, 0x1D, 0xC0, 0x38, 0x78, 0x0E, 0xE0, 0x3C, 0x3C, 0x07, 0x70, 0x1E,
  0x1E, 0x07, 0xB8, 0x0E, 0x07, 0x03, 0x9E, 0x07, 0x03, 0x81, 0xC7, 0x07,
  0x81, 0xE0, 0xE3, 0x83, 0xC0, 0xF0, 0x71, 0xC1, 0xE0, 0x38, 0x78, 0xE0,
  0xE0, 0x1C, 0x38, 0x38, 0x70, 0x0E, 0x1C, 0x1C, 0x78, 0x07, 0x8E, 0x0E,
  0x3C, 0x03, 0xCF, 0x07, 0x1C, 0x00, 0xE7, 0x03, 0xCE, 0x00, 0x73, 0x80,
  0xEF, 0x00, 0x39, 0xC0, 0x77, 0x80, 0x1E, 0xE0, 0x3B, 0xC0, 0x07, 0xF0,
  0x1D, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x78, 0x03, 0xC7, 0x00, 0x78, 0xF0, 0x0E, 0x0E, 0x03,
  0xC1, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0xC3, 0x80, 0x78, 0xF0, 0x07, 0x1E,
  0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xF0,
  0x03, 0xDE, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03, 0x83, 0x80, 0xF0, 0x78,
  0x1E, 0x07, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x3D,
  0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xEE, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03,
  0xC3, 0xC0, 0x78, 0x78, 0x0E, 0x07, 0x03, 0xC0, 0xF0, 0x78, 0x1E, 0x0E,
  0x01, 0xE3, 0xC0, 0x3C, 0x70, 0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0x70,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x3F, 0xFF, 0xFF, 0xF8, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xCE, 0x00, 0x73, 0x80,
  0x38, 0x70, 0x0E, 0x1C, 0x07, 0x87, 0x81, 0xC0, 0xE0, 0xF0, 0x3C, 0x38,
  0x07, 0x0E, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x0F, 0xE0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x0E, 0x07, 0x07,
  0xE1, 0xFF, 0xC3, 0xFF, 0x8E, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x03, 0xF1, 0xFF, 0xCF, 0xFF, 0x7C, 0x1F, 0xC0, 0x7F,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x03, 0xFC, 0x1F, 0xFD, 0xFD,
  0xFF, 0x33, 0xF8, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xE0,
  0xE7, 0xF8, 0xEF, 0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0E,
  0xFC, 0x1E, 0xEF, 0xFC, 0xE7, 0xFC, 0xE3, 0xF0, 0x03, 0xF0, 0x7F, 0xC7,
  0xFE, 0x7C, 0x27, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03,
  0x80, 0x1E, 0x00, 0xF8, 0x13, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x07, 0xC7, 0x1F, 0xE7, 0x3F, 0xF7, 0x3C, 0x3F,
  0x78, 0x1F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xF7,
  0x0F, 0xE7, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E,
  0x70, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xF0, 0x0E, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3C, 0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC,
  0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xFF, 0x1F, 0xF9, 0xFF, 0xC0, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0xC7, 0x1F, 0xE7, 0x3F, 0xF7, 0x3C, 0x3F,
  0x78, 0x1F, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xF7,
  0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x40, 0x0E, 0x70, 0x3E, 0x7F, 0xFC, 0x7F, 0xF8, 0x1F, 0xE0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC3, 0xE3, 0x9F, 0xE7, 0x7F, 0xEF, 0xC3, 0xFF, 0x03,
  0xFC, 0x07, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xEF, 0xFF,
  0x60, 0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xE0, 0x0E, 0x0F, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1E, 0xFE, 0xFC, 0xF8, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x3F, 0x80, 0xF7, 0x03, 0xCE, 0x07, 0x9C, 0x1E, 0x38, 0x78, 0x70,
  0xE0, 0xE3, 0xC1, 0xCF, 0x03, 0x9C, 0x07, 0x7C, 0x0F, 0xF8, 0x1F, 0x78,
  0x3E, 0x70, 0x78, 0xF0, 0xE0, 0xE1, 0xC1, 0xE3, 0x81, 0xC7, 0x03, 0xCE,
  0x03, 0x9C, 0x07, 0xB8, 0x07, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x7E, 0x39, 0xFE,
  0x3F, 0xCE, 0xFF, 0xDF, 0xFB, 0xF1, 0xFE, 0x1E, 0xF8, 0x3F, 0x03, 0xFC,
  0x07, 0x80, 0xFF, 0x01, 0xE0, 0x3F, 0xC0, 0x78, 0x0F, 0xF0, 0x1E, 0x03,
  0xFC, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x78, 0x0F, 0xE0, 0x1E,
  0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x78, 0x0F, 0xE0,
  0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3F, 0x80, 0x78, 0x0F,
  0xE0, 0x1E, 0x03, 0xF8, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x3C, 0xE1, 0xF1,
  0xCF, 0xF3, 0xBF, 0xF7, 0xE1, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0x80, 0x07, 0xE0, 0x07, 0xFC, 0x0F, 0xFF,
  0x07, 0x87, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0E, 0xF0, 0x07, 0x38, 0x07, 0x9E, 0x03, 0xC7, 0x83,
  0xC3, 0xFF, 0xC0, 0xFF, 0xE0, 0x1F, 0xC0, 0xE1, 0xF0, 0xE7, 0xF8, 0xEF,
  0xFC, 0xFC, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0E, 0xFC, 0x1E, 0xEF,
  0xFC, 0xE7, 0xFC, 0xE3, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x07, 0xC7, 0x1F, 0xE7, 0x3F, 0xF7, 0x3C, 0x3F, 0x78, 0x1F, 0x78,
  0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x70,
  0x0F, 0x78, 0x0F, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xF7, 0x0F, 0xE7, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE1, 0xFC, 0xFF, 0xBF, 0x77,
  0xEF, 0xC1, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x0F, 0xC3, 0xFF, 0x7F, 0xFF, 0x06, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xF0, 0x07, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xC0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x07, 0xF1, 0xFC,
  0x3F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0xC1, 0xF7, 0xFE, 0xE7, 0xFD, 0xC7, 0xF3, 0x80, 0xF0, 0x03, 0xF8,
  0x03, 0xDC, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x38,
  0x78, 0x1C, 0x3C, 0x1E, 0x0E, 0x0F, 0x07, 0x07, 0x03, 0xC3, 0x80, 0xE3,
  0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x01,
  0xDC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xEE, 0x01, 0xE0, 0x1D, 0xC0, 0x7C, 0x07, 0xBC, 0x0F, 0xC0, 0xF7,
  0x81, 0xF8, 0x1C, 0x70, 0x3F, 0x03, 0x8E, 0x0E, 0xE0, 0xF1, 0xE1, 0xDC,
  0x1E, 0x3C, 0x39, 0xC3, 0x83, 0x87, 0x38, 0x70, 0x70, 0xE7, 0x0E, 0x0E,
  0x38, 0xE3, 0xC1, 0xE7, 0x0E, 0x70, 0x3C, 0xE1, 0xCE, 0x03, 0x9C, 0x39,
  0xC0, 0x77, 0x07, 0x38, 0x0E, 0xE0, 0xEE, 0x01, 0xDC, 0x0F, 0xC0, 0x1F,
  0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0x80, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x70, 0x1E, 0x78, 0x1E, 0x38, 0x3C,
  0x3C, 0x3C, 0x1C, 0x78, 0x1E, 0x78, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0,
  0x1E, 0x78, 0x1C, 0x78, 0x3C, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xDC, 0x01, 0xEF, 0x00, 0xE7, 0x80,
  0xF1, 0xC0, 0x78, 0xE0, 0x38, 0x78, 0x1C, 0x1C, 0x1E, 0x0E, 0x0F, 0x07,
  0x87, 0x01, 0xC3, 0x80, 0xE3, 0xC0, 0x71, 0xC0, 0x3C, 0xE0, 0x0E, 0xF0,
  0x07, 0x78, 0x03, 0xB8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x78, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07,
  0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x3F, 0x07, 0xF0, 0x78, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x3E, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x07, 0xF0, 0x1F, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3F, 0x00, 0xF0, 0x7F, 0x07, 0x80, 0xF0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1E, 0x03, 0xE0, 0xFC, 0x0F, 0x80, 0xC0, 0x00, 0x08,
  0x00, 0x9F, 0xC0, 0x5F, 0xF8, 0x7E, 0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0xF0,
};

const GFXglyph NotoSans_Condensed_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 30, 10, 3, -30 },
  { 20, 11, 11, 16, 3, -30 },
  { 36, 20, 30, 22, 1, -30 },
  { 111, 16, 34, 20, 2, -32 },
  { 179, 26, 30, 30, 2, -30 },
  { 277, 21, 30, 23, 2, -30 },
  { 356, 3, 11, 9, 3, -30 },
  { 361, 9, 37, 12, 2, -30 },
  { 403, 9, 37, 12, 1, -30 },
  { 445, 15, 16, 19, 2, -32 },
  { 475, 16, 20, 20, 2, -25 },
  { 515, 6, 11, 10, 2, -5 },
  { 524, 10, 3, 12, 1, -13 },
  { 528, 4, 5, 10, 3, -5 },
  { 531, 14, 30, 16, 1, -30 },
  { 584, 16, 30, 20, 2, -30 },
  { 644, 10, 30, 20, 3, -30 },
  { 682, 16, 30, 20, 2, -30 },
  { 742, 16, 30, 20, 2, -30 },
  { 802, 18, 30, 20, 1, -30 },
  { 870, 16, 30, 20, 2, -30 },
  { 930, 16, 30, 20, 2, -30 },
  { 990, 17, 30, 20, 1, -30 },
  { 1054, 16, 30, 20, 2, -30 },
  { 1114, 16, 30, 20, 2, -30 },
  { 1174, 4, 23, 10, 3, -23 },
  { 1186, 6, 29, 10, 1, -23 },
  { 1208, 17, 20, 20, 1, -25 },
  { 1251, 16, 12, 20, 2, -21 },
  { 1275, 16, 20, 20, 2, -25 },
  { 1315, 14, 30, 15, 0, -30 },
  { 1368, 26, 34, 30, 2, -30 },
  { 1479, 21, 30, 21, 0, -30 },
  { 1558, 17, 30, 22, 3, -30 },
  { 1622, 18, 30, 21, 2, -30 },
  { 1690, 19, 30, 24, 3, -30 },
  { 1762, 14, 30, 19, 3, -30 },
  { 1815, 14, 30, 18, 3, -30 },
  { 1868, 21, 30, 25, 2, -30 },
  { 1947, 19, 30, 25, 3, -30 },
  { 2019, 9, 30, 13, 2, -30 },
  { 2053, 9, 38, 10, -2, -30 },
  { 2096, 18, 30, 21, 3, -30 },
  { 2164, 14, 30, 18, 3, -30 },
  { 2217, 26, 30, 33, 3, -30 },
  { 2315, 20, 30, 26, 3, -30 },
  { 2390, 22, 30, 26, 2, -30 },
  { 2473, 16, 30, 21, 3, -30 },
  { 2533, 22, 37, 26, 2, -30 },
  { 2635, 18, 30, 21, 3, -30 },
  { 2703, 15, 30, 19, 2, -30 },
  { 2760, 18, 30, 18, 0, -30 },
  { 2828, 18, 30, 25, 3, -30 },
  { 2896, 21, 30, 21, 0, -30 },
  { 2975, 33, 30, 33, 0, -30 },
  { 3099, 19, 30, 19, 0, -30 },
  { 3171, 19, 30, 19, 0, -30 },
  { 3243, 16, 30, 18, 1, -30 },
  { 3303, 9, 37, 13, 3, -30 },
  { 3345, 14, 30, 16, 1, -30 },
  { 3398, 9, 37, 13, 1, -30 },
  { 3440, 18, 17, 20, 1, -30 },
  { 3479, 19, 2, 18, 0, 4 },
  { 3484, 8, 7, 11, 2, -32 },
  { 3491, 14, 23, 19, 2, -23 },
  { 3532, 16, 32, 21, 3, -32 },
  { 3596, 13, 23, 16, 2, -23 },
  { 3634, 16, 32, 21, 2, -32 },
  { 3698, 16, 23, 19, 2, -23 },
  { 3744, 13, 32, 12, 0, -32 },
  { 3796, 16, 33, 21, 2, -23 },
  { 3862, 15, 32, 21, 3, -32 },
  { 3922, 4, 31, 9, 3, -31 },
  { 3938, 8, 41, 9, -1, -31 },
  { 3979, 15, 32, 18, 3, -32 },
  { 4039, 3, 32, 9, 3, -32 },
  { 4051, 26, 23, 32, 3, -23 },
  { 4126, 15, 23, 21, 3, -23 },
  { 4170, 17, 23, 21, 2, -23 },
  { 4219, 16, 33, 21, 3, -23 },
  { 4285, 16, 33, 21, 2, -23 },
  { 4351, 11, 23, 14, 3, -23 },
  { 4383, 12, 23, 16, 2, -23 },
  { 4418, 10, 28, 12, 1, -28 },
  { 4453, 15, 23, 21, 3, -23 },
  { 4497, 17, 23, 17, 0, -23 },
  { 4546, 27, 23, 28, 0, -23 },
  { 4624, 16, 23, 18, 1, -23 },
  { 4670, 17, 33, 17, 0, -23 },
  { 4741, 13, 23, 15, 1, -23 },
  { 4779, 12, 37, 15, 2, -30 },
  { 4835, 3, 42, 19, 8, -32 },
  { 4851, 12, 37, 15, 2, -30 },
  { 4907, 17, 6, 20, 1, -18 },
};

const GFXfont NotoSans_Condensed_Regular42pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular42pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular42pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _NOTOSANS_CONDENSED_REGULAR42PT7B_H_
