#ifndef _NOTOSANS_CONDENSED_REGULAR67PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR67PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular67pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x7F, 0x7F, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F,
  0x7E, 0x18, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFD, 0xF0, 0x3F, 0x7C, 0x0F, 0x9F, 0x03,
  0xE7, 0xC0, 0xF9, 0xF0, 0x3E, 0x7C, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79,
  0xE0, 0x1E, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x1E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x03,
  0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x03,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x07, 0x80, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0xF0, 0x1F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x3E,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xF1, 0xFC, 0x78, 0x38, 0x7E, 0x1E, 0x02, 0x1F,
  0x07, 0x80, 0x0F, 0xC1, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00,
  0x3E, 0x07, 0x80, 0x0F, 0x81, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0x7C, 0x1E,
  0x00, 0x1F, 0x87, 0x80, 0x03, 0xF9, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xEF, 0xF0, 0x00, 0x78,
  0xFE, 0x00, 0x1E, 0x1F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0xFC, 0x00,
  0x78, 0x3F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x83, 0xF0, 0x01, 0xE0, 0xF8,
  0x00, 0x78, 0x3E, 0x80, 0x1E, 0x1F, 0xBC, 0x07, 0x8F, 0xCF, 0xF1, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x80, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x00, 0xF8, 0x1F,
  0x00, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xF0, 0x07,
  0x80, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0xF0, 0x00,
  0x3C, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xC0,
  0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x3C, 0x03, 0xE0,
  0xF0, 0x00, 0x0F, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x0F, 0x0F, 0x83, 0xF8, 0x3E, 0x03, 0xC3, 0xE1, 0xFF, 0x07,
  0x81, 0xF0, 0xF0, 0xFF, 0xE1, 0xE0, 0x7C, 0x7C, 0x7F, 0xFC, 0x7C, 0x1F,
  0x1E, 0x1F, 0x1F, 0x0F, 0x0F, 0x8F, 0x8F, 0x83, 0xE3, 0xFF, 0xE3, 0xE3,
  0xE0, 0xF8, 0x7F, 0xF0, 0xF0, 0xF0, 0x1E, 0x1F, 0xF8, 0x7C, 0x3C, 0x07,
  0xC1, 0xFC, 0x1E, 0x1F, 0x01, 0xF0, 0x18, 0x0F, 0x87, 0xC0, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x00, 0x7C,
  0x1F, 0x01, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0x0F,
  0x80, 0x3C, 0x07, 0xC0, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xEF, 0xC0, 0x03, 0xC0, 0x00, 0xFF, 0xE0, 0x01,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x7E, 0x07, 0xE7, 0xF0, 0x0F, 0xC1, 0xF8, 0x7F, 0x01, 0xF0, 0x7E, 0x07,
  0xE0, 0x3E, 0x0F, 0xC0, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1, 0xF8, 0x7E,
  0x00, 0xFC, 0x3E, 0x0F, 0x80, 0x0F, 0xCF, 0xC1, 0xF0, 0x01, 0xFD, 0xF8,
  0x7E, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x01, 0xFF, 0xC1, 0xF8, 0x00, 0x1F,
  0xF0, 0x3F, 0x00, 0x03, 0xFE, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F,
  0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0x7F, 0xF7, 0xF0, 0x3F, 0xFF, 0xFC, 0x7E,
  0x03, 0xFF, 0xFF, 0x0F, 0xE0, 0x3F, 0xFF, 0x80, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xE0, 0x0B, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x7D, 0xF7, 0xDF, 0x7D, 0xE7, 0x9E, 0x78, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x80,
  0x3C, 0x02, 0x7C, 0x1E, 0x0F, 0x3F, 0xCF, 0x7F, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0xFC, 0x3E, 0x00, 0xFC, 0x1F, 0x80, 0xFE, 0x07, 0xE0, 0x1E, 0x03,
  0xE0, 0x07, 0x00, 0xC0, 0x00, 0x80, 0x40, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC7, 0xF1, 0xFC,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x3F, 0x0F, 0xC3, 0xE0, 0xF8, 0x3C,
  0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7E, 0x7E, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0x7C,
  0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xEF,
  0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0x83, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0xF7, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF,
  0x03, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x3F, 0xBF, 0x7F, 0x3F,
  0xFE, 0x3F, 0x7C, 0x3F, 0x78, 0x3F, 0x30, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83,
  0xF0, 0x0F, 0xF0, 0x70, 0x01, 0xFC, 0x18, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7,
  0xFF, 0x7F, 0xE1, 0xF0, 0x03, 0xF8, 0xE0, 0x00, 0xFC, 0x20, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xA0, 0x00, 0x1F, 0xDC, 0x00,
  0x1F, 0xCF, 0xE0, 0x7F, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFA, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x78,
  0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x01, 0xF0, 0x3F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x01,
  0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0x1F, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x80, 0x01, 0xFC, 0xE0, 0x03, 0xFC, 0xFE, 0x1F, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0x80, 0x7F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x7F, 0x80, 0x7C, 0x7F, 0xF0, 0x3F, 0x3F, 0xFF, 0x0F,
  0xDF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x7F, 0x3F, 0xE0, 0x0F,
  0xCF, 0xF0, 0x03, 0xFB, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F,
  0xDF, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F,
  0xF1, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xF8, 0x7F, 0x83, 0xF8, 0x07, 0xF1,
  0xFC, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01,
  0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xC1,
  0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xF3, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x8F, 0xF0, 0x1F, 0x81, 0xFE, 0x0F,
  0xC0, 0x3F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFE,
  0x3F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xEF, 0xC0, 0x01,
  0xF7, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x7F,
  0x00, 0x7F, 0x9F, 0xC0, 0x7F, 0xCF, 0xFF, 0xFB, 0xE3, 0xFF, 0xFD, 0xF0,
  0xFF, 0xFC, 0xF8, 0x3F, 0xFC, 0xFC, 0x0F, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x03, 0x83, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x7E, 0x18, 0x1F, 0x87,
  0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xF1, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0xFC, 0x3F, 0x0F, 0x83, 0xE0, 0xF8,
  0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF9, 0xE0, 0x1F, 0xC4, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xFC, 0x03, 0xE1, 0xF0,
  0x07, 0xFF, 0xC0, 0xF8, 0xF8, 0x03, 0xFF, 0xF0, 0x1E, 0x3E, 0x01, 0xFF,
  0xFC, 0x07, 0xCF, 0x80, 0xFC, 0x0F, 0x01, 0xF3, 0xC0, 0x3E, 0x07, 0xC0,
  0x7D, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xDF,
  0x03, 0xE0, 0x1F, 0x00, 0xF7, 0x80, 0xF8, 0x07, 0xC0, 0x3D, 0xE0, 0x3E,
  0x01, 0xF0, 0x0F, 0x78, 0x0F, 0x80, 0x7C, 0x03, 0xDE, 0x03, 0xC0, 0x1F,
  0x00, 0xFF, 0x80, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x3C, 0x01, 0xF0, 0x0F,
  0xF8, 0x0F, 0x00, 0x7C, 0x03, 0xFE, 0x03, 0xC0, 0x1F, 0x01, 0xFF, 0x80,
  0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x3C, 0x03, 0xF0, 0x1F, 0x78, 0x0F, 0x80,
  0xFC, 0x07, 0x9E, 0x03, 0xE0, 0x3F, 0x03, 0xE7, 0x80, 0xF8, 0x1F, 0xC0,
  0xF9, 0xF0, 0x1F, 0x07, 0x78, 0x7C, 0x7C, 0x07, 0xFF, 0xDF, 0xFF, 0x1F,
  0x00, 0xFF, 0xE3, 0xFF, 0x87, 0xC0, 0x1F, 0xF0, 0xFF, 0xC0, 0xF8, 0x03,
  0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x10, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00, 0x3E, 0x3F, 0x00,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01,
  0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0x0F, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xF0, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x7F, 0xF0,
  0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x7F, 0x8F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xF8, 0x01, 0xC0, 0xFF, 0x00, 0x04, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x0C, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1E, 0x80,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0,
  0x07, 0xFC, 0x3F, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03,
  0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x01,
  0xFF, 0x0F, 0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE,
  0x07, 0xFC, 0x00, 0x7C, 0x0F, 0xF8, 0x00, 0x0C, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x3F,
  0x0F, 0xF0, 0x00, 0x3F, 0x07, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x7F, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x61, 0xFE, 0xFF, 0xF9, 0xFF, 0xE3, 0xFF, 0xC7, 0xFE,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF7,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x3F, 0xEF, 0xE0, 0x01, 0xFE, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFE, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x7E, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xEF, 0x80,
  0x00, 0x07, 0xFF, 0xFB, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0xFB, 0xFF, 0xDF, 0x00, 0x00, 0x3E, 0xFF, 0xF7, 0xC0, 0x00, 0x0F, 0xBF,
  0xFD, 0xF0, 0x00, 0x07, 0xCF, 0xFF, 0x3E, 0x00, 0x01, 0xF3, 0xFF, 0xCF,
  0x80, 0x00, 0x7C, 0xFF, 0xF3, 0xE0, 0x00, 0x1F, 0x3F, 0xFC, 0x7C, 0x00,
  0x0F, 0x8F, 0xFF, 0x1F, 0x00, 0x03, 0xE3, 0xFF, 0xC7, 0xC0, 0x00, 0xF8,
  0xFF, 0xF1, 0xF8, 0x00, 0x7C, 0x3F, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0xFF,
  0x0F, 0x80, 0x07, 0xC3, 0xFF, 0xC3, 0xF0, 0x03, 0xE0, 0xFF, 0xF0, 0x7C,
  0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0xFF, 0x07, 0xE0, 0x1F,
  0x03, 0xFF, 0xC0, 0xF8, 0x07, 0xC0, 0xFF, 0xF0, 0x3E, 0x01, 0xF0, 0x3F,
  0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0x01, 0xF0, 0x3E, 0x03, 0xFF, 0xC0,
  0x7C, 0x0F, 0x80, 0xFF, 0xF0, 0x1F, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE1,
  0xF0, 0x0F, 0xFF, 0x00, 0xF8, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0x1F, 0x00,
  0xFF, 0xF0, 0x0F, 0xCF, 0x80, 0x3F, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xFF,
  0x00, 0x7C, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFB, 0xF0, 0x00,
  0x3F, 0xFB, 0xF0, 0x00, 0x3F, 0xF9, 0xF8, 0x00, 0x3F, 0xFD, 0xF8, 0x00,
  0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0xFC, 0x00, 0x3F, 0xFC, 0x7E, 0x00,
  0x3F, 0xFC, 0x7E, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x3F, 0x00,
  0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x1F, 0x80, 0x3F, 0xFC, 0x0F, 0xC0,
  0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0xFC, 0x07, 0xE0, 0x3F, 0xFC, 0x07, 0xE0,
  0x3F, 0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x03, 0xF0, 0x3F, 0xFC, 0x01, 0xF8,
  0x3F, 0xFC, 0x01, 0xF8, 0x3F, 0xFC, 0x00, 0xFC, 0x3F, 0xFC, 0x00, 0xFC,
  0x3F, 0xFC, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x3F,
  0x3F, 0xFC, 0x00, 0x3F, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0xFC, 0x00, 0x1F,
  0xBF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xDF, 0xFC, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0x80, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0x74, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F,
  0xF3, 0xF0, 0x03, 0xFD, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x0F, 0xE7,
  0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFF, 0xE0,
  0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x01, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7F, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0xF8, 0xFE, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0xA0, 0x00, 0x3F, 0x9E, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80,
  0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x3F, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xFB,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xDE, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0x9F,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F,
  0x9F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xF9, 0xF0, 0x01, 0xF8, 0x0F, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x00, 0xFC, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x7C, 0x03,
  0xE0, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0,
  0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0xFC, 0x00, 0x1F,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x8F, 0x80, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0xDF, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x7B, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C,
  0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x0C, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xF0, 0x3F, 0x83,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF9, 0xFF, 0xC1, 0xF7, 0xF8, 0x03, 0xEF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE,
  0x00, 0xFF, 0x7F, 0x07, 0xFE, 0xFF, 0xFF, 0x7C, 0xFF, 0xFC, 0x78, 0xFF,
  0xF0, 0xF0, 0xFF, 0xC1, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x20, 0x03, 0xE0, 0xFF, 0x80,
  0xF8, 0xFF, 0xF8, 0x3E, 0x7F, 0xFF, 0x0F, 0xBF, 0xFF, 0xC3, 0xEF, 0x87,
  0xF8, 0xFF, 0x80, 0x7F, 0x3F, 0xC0, 0x0F, 0xCF, 0xE0, 0x03, 0xFB, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07,
  0xEF, 0xE0, 0x01, 0xFB, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x3F, 0xE0,
  0x1F, 0xCF, 0xFE, 0x1F, 0xE3, 0xEF, 0xFF, 0xF0, 0xF9, 0xFF, 0xFC, 0x3C,
  0x3F, 0xFE, 0x0F, 0x07, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFC,
  0xF8, 0x7F, 0x00, 0x47, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0x1F, 0xF0, 0x78,
  0x7F, 0xFF, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x03,
  0xC0, 0x7C, 0x07, 0xFC, 0x1F, 0x07, 0xFF, 0xC7, 0xC3, 0xFF, 0xF9, 0xF0,
  0xFF, 0xFF, 0x7C, 0x7F, 0x87, 0xFF, 0x3F, 0x80, 0x7F, 0xCF, 0xC0, 0x0F,
  0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xDF, 0x80,
  0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x7C,
  0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x7F,
  0x3F, 0x00, 0x3F, 0xCF, 0xE0, 0x0F, 0xF1, 0xFE, 0x0F, 0xFC, 0x3F, 0xFF,
  0xDF, 0x0F, 0xFF, 0xE7, 0xC1, 0xFF, 0xF0, 0xF0, 0x1F, 0xF8, 0x3C, 0x00,
  0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFE, 0x0F, 0xE0, 0x7E, 0x01, 0xF8,
  0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x07,
  0xCF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x04, 0x3F, 0x80, 0x0E, 0x0F, 0xF0, 0x3F, 0x07, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x03,
  0xFF, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x7F, 0xE0, 0xF0, 0x3F, 0xFC, 0x3C, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF,
  0xF7, 0xC7, 0xF8, 0x7F, 0xF3, 0xF8, 0x07, 0xFC, 0xFC, 0x00, 0xFF, 0x3F,
  0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F,
  0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x07, 0xF3, 0xF0,
  0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0xF7, 0xC3, 0xFF, 0xFD, 0xF0,
  0xFF, 0xFE, 0x7C, 0x1F, 0xFF, 0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x0E, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE3, 0x00, 0x03, 0xF8, 0xF8, 0x03, 0xFC, 0x3F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x06, 0x00, 0xF8,
  0x3F, 0xE0, 0xF8, 0xFF, 0xF8, 0xF9, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xFF,
  0xF1, 0xFE, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C,
  0xFB, 0xFF, 0xFF, 0xEF, 0x8F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9F,
  0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9,
  0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xFE, 0x07,
  0xF0, 0x3F, 0x80, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xEF, 0xFE, 0x7F, 0xF3, 0xFF,
  0x1F, 0xF0, 0x7F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0xF8, 0x01,
  0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x0F,
  0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x7E,
  0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0xFB, 0xF8,
  0x00, 0xFB, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0x3F,
  0x00, 0xFE, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x1F, 0x80, 0xF8, 0x0F,
  0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0xF8, 0x03,
  0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00,
  0x03, 0xC0, 0x78, 0x3F, 0xF0, 0x0F, 0xFC, 0x3C, 0x3F, 0xFC, 0x1F, 0xFF,
  0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0xCF, 0xBF, 0xFF, 0x8F, 0xFF, 0xE7, 0xFF,
  0x1F, 0xEF, 0x87, 0xFB, 0xFC, 0x03, 0xFF, 0x00, 0xFD, 0xFC, 0x00, 0xFF,
  0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0xF0, 0x7F,
  0xE0, 0xF0, 0xFF, 0xF8, 0xF9, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xFF, 0xE1,
  0xFE, 0xFF, 0x80, 0x7E, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xC1, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xE0,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x3C, 0x1F,
  0xF8, 0x0F, 0x8F, 0xFF, 0x83, 0xE7, 0xFF, 0xF0, 0xFB, 0xFF, 0xFE, 0x3E,
  0xF0, 0x7F, 0x8F, 0xF8, 0x07, 0xF3, 0xFC, 0x00, 0xFC, 0xFE, 0x00, 0x3F,
  0xBF, 0x80, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xF0, 0x03, 0xF3,
  0xFE, 0x01, 0xFC, 0xFF, 0xE1, 0xFE, 0x3E, 0xFF, 0xFF, 0x0F, 0x9F, 0xFF,
  0xC3, 0xE3, 0xFF, 0xE0, 0xF8, 0x7F, 0xE0, 0x3E, 0x03, 0xC0, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x7F, 0xE0, 0xF0, 0x3F, 0xFC, 0x7C, 0x3F, 0xFF,
  0x9F, 0x0F, 0xFF, 0xF7, 0xC7, 0xF8, 0x7F, 0xF3, 0xF8, 0x07, 0xFC, 0xFC,
  0x00, 0xFF, 0x3F, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF7, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0xC0,
  0x07, 0xF3, 0xF0, 0x03, 0xFC, 0xFE, 0x01, 0xFF, 0x1F, 0xE1, 0xF7, 0xC3,
  0xFF, 0xFD, 0xF0, 0xFF, 0xFE, 0x7C, 0x1F, 0xFF, 0x1F, 0x01, 0xFF, 0x87,
  0xC0, 0x0E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x78, 0x1F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xEF, 0x9F, 0xF7, 0xDF, 0xFB, 0xEF, 0x81, 0xFF, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFF, 0x7F, 0xFF,
  0xEF, 0xF0, 0x3E, 0xFC, 0x00, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7E, 0xFC, 0x1F, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE1,
  0x07, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xC0, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x7E, 0x01, 0xFF, 0x7F, 0x87, 0xDF, 0x7F,
  0xFF, 0xDF, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x1F, 0x0F, 0xFC, 0x1F, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x80,
  0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00,
  0xFC, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xC0,
  0x07, 0xE7, 0xC0, 0x07, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0x1F, 0x80, 0x3F, 0xF0, 0x03, 0xE3, 0xF0, 0x07, 0xFE, 0x00, 0xFC, 0x3E,
  0x00, 0xFB, 0xC0, 0x1F, 0x87, 0xC0, 0x1E, 0x78, 0x03, 0xE0, 0xFC, 0x03,
  0xCF, 0x80, 0x7C, 0x1F, 0x80, 0xF9, 0xF0, 0x1F, 0x81, 0xF0, 0x1F, 0x3E,
  0x03, 0xF0, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x7C, 0x0F,
  0x80, 0xFC, 0x1F, 0x0F, 0x81, 0xF0, 0x1F, 0x83, 0xE1, 0xF0, 0x7E, 0x01,
  0xF0, 0x7C, 0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x03, 0xE1, 0xF0, 0x07, 0xE3,
  0xE0, 0x7C, 0x3E, 0x00, 0xFC, 0x7C, 0x0F, 0x8F, 0xC0, 0x0F, 0x8F, 0x81,
  0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x1E, 0x3E, 0x00, 0x3E, 0x3C, 0x03, 0xE7,
  0xC0, 0x07, 0xEF, 0x80, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x0F, 0xBE, 0x00,
  0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x01, 0xF7, 0x80, 0x1E, 0xF8, 0x00, 0x3E,
  0xF0, 0x03, 0xDF, 0x00, 0x07, 0xDE, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07,
  0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x07, 0xE0,
  0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x00,
  0xF8, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x03,
  0xF0, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0xFC,
  0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3D,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0,
  0x0F, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xF0, 0x01, 0xFE,
  0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x23, 0xFF, 0x00, 0x05, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF6,
  0x00, 0x0F, 0xFC, 0x80, 0x00, 0x0C, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 49, 16, 4, -48 },
  { 50, 18, 17, 26, 4, -48 },
  { 89, 32, 48, 35, 1, -48 },
  { 281, 26, 55, 32, 3, -51 },
  { 460, 42, 50, 48, 3, -49 },
  { 723, 35, 50, 37, 2, -49 },
  { 942, 6, 17, 14, 4, -48 },
  { 955, 15, 59, 20, 3, -48 },
  { 1066, 15, 59, 20, 2, -48 },
  { 1177, 25, 25, 30, 2, -51 },
  { 1256, 27, 32, 32, 2, -40 },
  { 1364, 10, 17, 16, 2, -8 },
  { 1386, 15, 6, 19, 2, -21 },
  { 1398, 8, 9, 16, 4, -8 },
  { 1407, 23, 48, 25, 1, -48 },
  { 1545, 26, 50, 32, 3, -49 },
  { 1708, 16, 48, 32, 5, -48 },
  { 1804, 26, 49, 32, 2, -49 },
  { 1964, 25, 50, 32, 3, -49 },
  { 2121, 30, 48, 32, 1, -48 },
  { 2301, 24, 49, 32, 4, -48 },
  { 2448, 26, 50, 32, 3, -49 },
  { 2611, 27, 48, 32, 2, -48 },
  { 2773, 26, 50, 32, 3, -49 },
  { 2936, 25, 50, 32, 3, -49 },
  { 3093, 8, 37, 16, 4, -36 },
  { 3130, 10, 45, 16, 2, -36 },
  { 3187, 27, 30, 32, 2, -39 },
  { 3289, 26, 19, 32, 3, -33 },
  { 3351, 27, 30, 32, 2, -39 },
  { 3453, 21, 50, 24, 1, -49 },
  { 3585, 42, 54, 49, 3, -48 },
  { 3869, 34, 48, 34, 0, -48 },
  { 4073, 28, 48, 35, 5, -48 },
  { 4241, 28, 50, 34, 4, -49 },
  { 4416, 30, 48, 39, 5, -48 },
  { 4596, 22, 48, 30, 5, -48 },
  { 4728, 22, 48, 28, 5, -48 },
  { 4860, 32, 50, 40, 4, -49 },
  { 5060, 30, 48, 40, 5, -48 },
  { 5240, 16, 48, 20, 2, -48 },
  { 5336, 15, 61, 16, -4, -48 },
  { 5451, 29, 48, 33, 5, -48 },
  { 5625, 22, 48, 28, 5, -48 },
  { 5757, 42, 48, 52, 5, -48 },
  { 6009, 32, 48, 42, 5, -48 },
  { 6201, 34, 50, 41, 4, -49 },
  { 6414, 25, 48, 33, 5, -48 },
  { 6564, 34, 60, 41, 4, -49 },
  { 6819, 28, 48, 34, 5, -48 },
  { 6987, 25, 50, 30, 3, -49 },
  { 7144, 27, 48, 29, 1, -48 },
  { 7306, 29, 49, 39, 5, -48 },
  { 7484, 33, 48, 33, 0, -48 },
  { 7682, 52, 48, 52, 0, -48 },
  { 7994, 30, 48, 31, 0, -48 },
  { 8174, 30, 48, 30, 0, -48 },
  { 8354, 25, 48, 28, 2, -48 },
  { 8504, 14, 59, 21, 5, -48 },
  { 8608, 23, 48, 25, 1, -48 },
  { 8746, 14, 59, 21, 2, -48 },
  { 8850, 30, 27, 32, 1, -48 },
  { 8952, 30, 4, 29, 0, 6 },
  { 8967, 12, 10, 18, 3, -51 },
  { 8982, 23, 38, 31, 3, -37 },
  { 9092, 26, 52, 34, 5, -51 },
  { 9261, 21, 38, 26, 3, -37 },
  { 9361, 26, 52, 34, 3, -51 },
  { 9530, 25, 38, 31, 3, -37 },
  { 9649, 20, 51, 19, 1, -51 },
  { 9777, 26, 53, 34, 3, -37 },
  { 9950, 24, 51, 34, 5, -51 },
  { 10103, 7, 49, 15, 4, -49 },
  { 10146, 13, 65, 15, -2, -49 },
  { 10252, 24, 51, 29, 5, -51 },
  { 10405, 5, 51, 15, 5, -51 },
  { 10437, 41, 37, 51, 5, -37 },
  { 10627, 24, 37, 34, 5, -37 },
  { 10738, 27, 38, 33, 3, -37 },
  { 10867, 26, 53, 34, 5, -37 },
  { 11040, 26, 53, 34, 3, -37 },
  { 11213, 17, 37, 23, 5, -37 },
  { 11292, 20, 38, 26, 3, -37 },
  { 11387, 17, 45, 19, 1, -44 },
  { 11483, 24, 37, 34, 5, -36 },
  { 11594, 27, 36, 28, 0, -36 },
  { 11716, 43, 36, 44, 1, -36 },
  { 11910, 26, 36, 28, 1, -36 },
  { 12027, 27, 52, 28, 0, -36 },
  { 12203, 20, 36, 24, 2, -36 },
  { 12293, 20, 59, 25, 2, -48 },
  { 12441, 5, 67, 30, 13, -51 },
  { 12483, 19, 59, 25, 3, -48 },
  { 12624, 27, 9, 32, 2, -28 },
};

const GFXfont NotoSans_Condensed_Regular67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_REGULAR67PT7B_H_
