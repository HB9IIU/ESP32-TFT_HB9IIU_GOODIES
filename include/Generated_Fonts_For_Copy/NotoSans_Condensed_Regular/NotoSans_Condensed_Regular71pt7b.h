#ifndef _NOTOSANS_CONDENSED_REGULAR71PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular71pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0xFE, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0x03, 0xF7, 0xE0, 0x7E, 0xFC, 0x0F, 0xDF, 0x81, 0xFB, 0xE0, 0x3F,
  0x7C, 0x07, 0xEF, 0x80, 0xFD, 0xF0, 0x1F, 0xBE, 0x03, 0xF7, 0xC0, 0x7C,
  0xF8, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x1E, 0x7C, 0x03, 0xCF, 0x80, 0x78,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F,
  0x80, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00,
  0x7C, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xF7, 0x9F, 0xC7, 0xF0, 0xF0, 0x38,
  0xFC, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xFC, 0x0F,
  0x00, 0x1F, 0x81, 0xE0, 0x03, 0xF0, 0x3C, 0x00, 0x7E, 0x07, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0xFC, 0x1E, 0x00, 0x1F, 0xC3, 0xC0, 0x01, 0xFC, 0x78,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x7F, 0xC0, 0x01, 0xE3, 0xF8, 0x00,
  0x3C, 0x3F, 0x80, 0x07, 0x83, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x01,
  0xE0, 0xFE, 0x00, 0x3C, 0x1F, 0xF0, 0x07, 0x87, 0xEF, 0xC0, 0xF3, 0xFD,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x78, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x0F,
  0x81, 0xF0, 0x03, 0xE0, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x00, 0x07, 0xC0,
  0x3C, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0,
  0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x1F,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x00,
  0x0F, 0x80, 0x7C, 0x3E, 0x0F, 0xE0, 0x7C, 0x03, 0xC1, 0xE0, 0xFF, 0x81,
  0xE0, 0x3E, 0x1F, 0x0F, 0xFE, 0x0F, 0x81, 0xF0, 0xF8, 0xFF, 0xF8, 0x7C,
  0x0F, 0x8F, 0x87, 0xC7, 0xE1, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0x0F, 0x8F,
  0xC7, 0xC3, 0xE0, 0xF8, 0x7F, 0xFC, 0x3E, 0x1F, 0x03, 0xE1, 0xFF, 0xE1,
  0xF1, 0xF0, 0x1F, 0x07, 0xFE, 0x1F, 0x0F, 0x80, 0xF8, 0x1F, 0xE0, 0xF8,
  0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x1F,
  0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x0F, 0xC1, 0xFE, 0xFC, 0x00, 0xFC, 0x1F, 0xCF, 0xE0, 0x0F, 0xC3,
  0xF8, 0x7F, 0x00, 0xFC, 0x7F, 0x03, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x81,
  0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0x8F, 0xC0, 0x0F, 0xE1, 0xF8, 0xFC, 0x00,
  0x7F, 0x3F, 0x0F, 0xC0, 0x07, 0xF3, 0xF0, 0xFC, 0x00, 0x3F, 0xFE, 0x0F,
  0xC0, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x00, 0xFF,
  0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0x07, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0x00, 0x3F, 0xFE, 0x07,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0xE3,
  0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xFF,
  0xC0, 0x07, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF,
  0xDF, 0xBE, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0xF0,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x3E,
  0x03, 0xBF, 0x87, 0x8F, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x07, 0x80, 0x70, 0x00, 0x40, 0x18, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC7, 0xE1, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C,
  0x1F, 0x0F, 0x83, 0xE0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x08, 0x1F, 0x1F, 0xCF, 0xEF, 0xF7,
  0xFD, 0xFC, 0xFE, 0x7E, 0x0E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC1, 0xFE, 0x07,
  0xF0, 0x1F, 0xC0, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x87, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC, 0x03, 0xF0, 0x3F,
  0xC0, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x1F, 0xFC,
  0x1F, 0xFE, 0x1F, 0xFF, 0x1F, 0xDF, 0x9F, 0xCF, 0xDF, 0xC7, 0xFF, 0xC3,
  0xF7, 0xC1, 0xF9, 0xC0, 0xFC, 0x40, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0x00, 0x1F, 0xE1,
  0xC0, 0x01, 0xFC, 0x10, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFE, 0x01,
  0xFE, 0x1F, 0x00, 0x1F, 0xE1, 0x80, 0x01, 0xFC, 0x20, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xEC, 0x00, 0x03,
  0xF9, 0xE0, 0x01, 0xFF, 0x3F, 0xF7, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFA, 0x00, 0x01, 0xFC, 0xC0, 0x00, 0xFF, 0x3C, 0x00, 0x7F,
  0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFC, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x07, 0xE3, 0xFF, 0x80, 0xF8, 0xFF, 0xFC, 0x1F, 0x3F,
  0xFF, 0xC3, 0xEF, 0xFF, 0xF8, 0xFD, 0xF0, 0xFF, 0x9F, 0xF8, 0x07, 0xFB,
  0xFE, 0x00, 0x7F, 0x7F, 0x80, 0x07, 0xEF, 0xE0, 0x00, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xE1, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01,
  0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3, 0xF8, 0x01, 0xF8,
  0x1F, 0xC0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x0F, 0xF0, 0xFE, 0x00, 0x7F,
  0xBF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xE1, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x01,
  0xFC, 0x7E, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x0F, 0xC7, 0xF8,
  0x03, 0xFC, 0x3F, 0xF0, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xC1, 0xF8,
  0x01, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xE7,
  0xF0, 0x07, 0xFC, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF,
  0x7E, 0x1F, 0xFF, 0xCF, 0xC0, 0xFF, 0xF1, 0xF8, 0x0F, 0xF8, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x10, 0x7C, 0xFE, 0xFE, 0xFE,
  0xFF, 0xFE, 0xFE, 0x7C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x7C, 0xFE, 0xFE, 0xFE, 0xFF, 0xFE, 0xFE, 0x7C, 0x38, 0x02,
  0x01, 0xF0, 0x7F, 0x0F, 0xE3, 0xFC, 0x7F, 0xC7, 0xF0, 0xFE, 0x1F, 0x80,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC3, 0xF8, 0x7F, 0x0F,
  0xE1, 0xF8, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x07,
  0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF9, 0xF0, 0x1F, 0xE3, 0x00, 0x1F, 0xC8, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x3F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xFF,
  0xE0, 0x3E, 0x3E, 0x00, 0xFF, 0xFE, 0x03, 0xE7, 0xE0, 0x1F, 0xFF, 0xE0,
  0x3E, 0x7C, 0x03, 0xF8, 0x3E, 0x01, 0xE7, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x7C, 0x07, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x0F,
  0x80, 0x3E, 0x01, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x0F, 0x80,
  0x3E, 0x01, 0xFF, 0x81, 0xF8, 0x03, 0xE0, 0x1F, 0xF8, 0x1F, 0x00, 0x3E,
  0x01, 0xFF, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0xF0, 0x1F, 0x00, 0x7E, 0x01,
  0xFF, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xEF,
  0x80, 0xF8, 0x07, 0xE0, 0x3E, 0xF8, 0x0F, 0x80, 0x7E, 0x03, 0xEF, 0x80,
  0xF8, 0x0F, 0xE0, 0x3E, 0xF8, 0x0F, 0xC0, 0xFE, 0x07, 0xCF, 0x80, 0x7C,
  0x1E, 0xF0, 0x7C, 0xF8, 0x07, 0xF3, 0xEF, 0x9F, 0x8F, 0xC0, 0x3F, 0xFC,
  0xFF, 0xF8, 0x7C, 0x03, 0xFF, 0x87, 0xFF, 0x07, 0xC0, 0x1F, 0xF8, 0x3F,
  0xE0, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xC0, 0x7F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x8F, 0xC0, 0xFF, 0xF8, 0xFC,
  0x00, 0x7F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC,
  0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x1F, 0xEF, 0xC0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xC0,
  0x7F, 0xC0, 0x03, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x08, 0x1F, 0xF8, 0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xF0, 0x7E, 0x00, 0x1F, 0xF0, 0xFC,
  0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xE7, 0xE0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFF, 0x0F, 0xC0, 0x07, 0xFC, 0x1F, 0x81,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0xF0, 0x1F, 0xE0,
  0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x3F, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x81, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF,
  0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0x1C, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0,
  0x7F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7F, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0x9F, 0x80, 0x03, 0xFC, 0x7F, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFB, 0xFF, 0x7C, 0x00, 0x00, 0x1F, 0x7F, 0xEF, 0xC0,
  0x00, 0x07, 0xEF, 0xFD, 0xF8, 0x00, 0x00, 0xF9, 0xFF, 0x9F, 0x00, 0x00,
  0x1F, 0x3F, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xFE, 0x7E, 0x00, 0x00, 0xF9,
  0xFF, 0xC7, 0xC0, 0x00, 0x1F, 0x3F, 0xF8, 0xF8, 0x00, 0x03, 0xE7, 0xFF,
  0x1F, 0x80, 0x00, 0xFC, 0xFF, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0xFC, 0x3E,
  0x00, 0x03, 0xE3, 0xFF, 0x87, 0xE0, 0x00, 0xFC, 0x7F, 0xF0, 0x7C, 0x00,
  0x1F, 0x0F, 0xFE, 0x0F, 0x80, 0x03, 0xE1, 0xFF, 0xC1, 0xF8, 0x00, 0xFC,
  0x3F, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xFF, 0x03, 0xE0, 0x03, 0xE0, 0xFF,
  0xE0, 0x7E, 0x00, 0xFC, 0x1F, 0xFC, 0x0F, 0xC0, 0x1F, 0x03, 0xFF, 0x80,
  0xF8, 0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xFE, 0x03, 0xF0,
  0x1F, 0x01, 0xFF, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0xF8, 0x07, 0xE0, 0x7C,
  0x07, 0xFF, 0x00, 0xFC, 0x1F, 0x80, 0xFF, 0xE0, 0x0F, 0x83, 0xE0, 0x1F,
  0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xFF, 0x80, 0x3F, 0x1F, 0x80, 0x7F, 0xF0,
  0x07, 0xE3, 0xE0, 0x0F, 0xFE, 0x00, 0x7C, 0x7C, 0x01, 0xFF, 0xC0, 0x0F,
  0xDF, 0x80, 0x3F, 0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0x7C,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0xFC, 0x00, 0x07,
  0xFF, 0x7F, 0x00, 0x03, 0xFF, 0x9F, 0x80, 0x01, 0xFF, 0xCF, 0xE0, 0x00,
  0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xF1, 0xF8, 0x00, 0x3F, 0xF8, 0x7E, 0x00,
  0x1F, 0xFC, 0x3F, 0x00, 0x0F, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0x07, 0xE0,
  0x03, 0xFF, 0x81, 0xF8, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0xFF, 0xE0, 0x3F,
  0x00, 0x7F, 0xF0, 0x1F, 0x80, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0xFC, 0x03,
  0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x07, 0xFF, 0x00, 0x7E, 0x03, 0xFF, 0x80,
  0x1F, 0x81, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0xE0, 0x07, 0xF0, 0x7F, 0xF0,
  0x01, 0xF8, 0x3F, 0xF8, 0x00, 0xFE, 0x1F, 0xFC, 0x00, 0x3F, 0x0F, 0xFE,
  0x00, 0x1F, 0xC7, 0xFF, 0x00, 0x07, 0xE3, 0xFF, 0x80, 0x03, 0xF9, 0xFF,
  0xC0, 0x00, 0xFC, 0xFF, 0xE0, 0x00, 0x7F, 0x7F, 0xF0, 0x00, 0x1F, 0xBF,
  0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x7F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00,
  0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xCF,
  0xC0, 0x1F, 0xF3, 0xF0, 0x01, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xFB, 0xF0, 0x01, 0xFE, 0xFC, 0x00,
  0xFF, 0x3F, 0x01, 0xFF, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F,
  0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07,
  0xE7, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00,
  0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xFC, 0x1F,
  0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x3F, 0x00,
  0x07, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFE, 0x1F, 0x80, 0x1F,
  0xE0, 0xFC, 0x07, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xF0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFC, 0x1F, 0xC3, 0xFC,
  0x00, 0x71, 0xFC, 0x00, 0x04, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFE, 0xE0, 0x00, 0x7F, 0xBF, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC,
  0x00, 0x03, 0xE8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3,
  0xFC, 0x00, 0x3F, 0x83, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x00,
  0x3E, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7D,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF3, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC7, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xF8,
  0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x0F, 0x81, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF0,
  0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x03, 0xF3, 0xF0, 0x00, 0x07,
  0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xCF, 0xC0,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF8,
  0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x07, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x03, 0xF8, 0x1F,
  0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7E, 0x0F, 0xF0, 0x38, 0x01, 0xFC,
  0x10, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFF, 0xC1, 0xF9, 0xFE, 0x00, 0xFD, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xBF, 0x00, 0xFF,
  0xDF, 0xE0, 0xFF, 0xEF, 0xFF, 0xF9, 0xF3, 0xFF, 0xF8, 0xF8, 0xFF, 0xF8,
  0x7C, 0x3F, 0xF8, 0x3E, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0xFC, 0x3F, 0xF8, 0x0F, 0xC7, 0xFF, 0xC0, 0xFC, 0xFF,
  0xFE, 0x0F, 0xDF, 0xFF, 0xF0, 0xFF, 0xF9, 0xFF, 0x8F, 0xFC, 0x03, 0xF8,
  0xFF, 0x80, 0x1F, 0xCF, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0xFC,
  0xFF, 0x00, 0x0F, 0xCF, 0xF8, 0x01, 0xFC, 0xFF, 0xC0, 0x3F, 0x8F, 0xFF,
  0x8F, 0xF8, 0xF9, 0xFF, 0xFF, 0x0F, 0x8F, 0xFF, 0xE0, 0xF8, 0x7F, 0xFC,
  0x0F, 0x83, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF,
  0xBF, 0x07, 0xF8, 0x02, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x18, 0x3F, 0xF3,
  0xF0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x3F, 0x01,
  0xFF, 0xC3, 0xF0, 0x3F, 0xFE, 0x3F, 0x07, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF,
  0xBF, 0x1F, 0xF9, 0xFF, 0xF1, 0xFC, 0x03, 0xFF, 0x3F, 0x80, 0x1F, 0xF3,
  0xF8, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7F, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xF3,
  0xF8, 0x01, 0xFF, 0x1F, 0xC0, 0x3F, 0xF1, 0xFF, 0x0F, 0xDF, 0x0F, 0xFF,
  0xF9, 0xF0, 0x7F, 0xFF, 0x1F, 0x03, 0xFF, 0xE1, 0xF0, 0x0F, 0xFC, 0x1F,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xC1, 0xFE,
  0x07, 0xF0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0x9F, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x83, 0xFC, 0x00, 0x70, 0x3F,
  0xF0, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFC, 0x08, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x1F,
  0x03, 0xFF, 0xE1, 0xF0, 0x7F, 0xFF, 0x1F, 0x0F, 0xFF, 0xF9, 0xF1, 0xFF,
  0x9F, 0xDF, 0x1F, 0xC0, 0x3F, 0xF3, 0xF8, 0x01, 0xFF, 0x3F, 0x80, 0x0F,
  0xF3, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x1F,
  0xF1, 0xFC, 0x03, 0xFF, 0x1F, 0xF8, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0x07,
  0xFF, 0xF3, 0xF0, 0x3F, 0xFE, 0x3F, 0x01, 0xFF, 0xC3, 0xF0, 0x01, 0xC0,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x20, 0x00, 0x0F, 0xE3, 0x80, 0x01, 0xFC,
  0x3F, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0xFC, 0x3F, 0xF8, 0x3F, 0x1F, 0xFF, 0x0F, 0xCF, 0xFF, 0xE3, 0xF7,
  0xFF, 0xFC, 0xFF, 0xFD, 0xFF, 0xBF, 0xF0, 0x0F, 0xEF, 0xF8, 0x01, 0xFB,
  0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x0C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x0F, 0xD0, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF9, 0xFF, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x1F, 0xCF,
  0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xBF,
  0x80, 0x3F, 0xC7, 0xE0, 0x0F, 0xE1, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC,
  0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0,
  0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC3, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF3, 0xF0,
  0x00, 0xFE, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x83, 0xFF, 0x00, 0xFF,
  0xE0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x8F, 0x9F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xF9, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0xBF, 0x1F, 0xF7, 0xE3, 0xFE, 0xFF,
  0x80, 0x7F, 0xF0, 0x0F, 0xEF, 0xF0, 0x03, 0xFE, 0x00, 0x7E, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xEF, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x3E, 0x0F, 0xFE, 0x0F, 0x87, 0xFF, 0xC3, 0xE3,
  0xFF, 0xF8, 0xF9, 0xFF, 0xFF, 0x3E, 0xFE, 0x3F, 0xEF, 0xFC, 0x03, 0xFB,
  0xFE, 0x00, 0x7E, 0xFF, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xFC, 0x7F, 0xC0, 0x7F, 0x00, 0x7F, 0x03, 0xF0, 0x01,
  0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xFC,
  0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFF, 0x01, 0xFE, 0x03,
  0xFF, 0x7F, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0x83, 0xFF, 0x80, 0xF8, 0x7F, 0xFC, 0x0F, 0x8F, 0xFF, 0xE0, 0xF9,
  0xFF, 0xFF, 0x0F, 0xBF, 0x0F, 0xF8, 0xFF, 0xC0, 0x3F, 0x8F, 0xF8, 0x01,
  0xFC, 0xFF, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFE,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xCF, 0xF0, 0x00,
  0xFC, 0xFF, 0x80, 0x1F, 0xCF, 0xFC, 0x03, 0xF8, 0xFF, 0xFD, 0xFF, 0x8F,
  0xDF, 0xFF, 0xF0, 0xFC, 0xFF, 0xFE, 0x0F, 0xC7, 0xFF, 0xC0, 0xFC, 0x3F,
  0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFC, 0x1F, 0x03, 0xFF, 0xE1, 0xF0,
  0x7F, 0xFF, 0x1F, 0x0F, 0xFF, 0xF9, 0xF1, 0xFF, 0x9F, 0xDF, 0x1F, 0xC0,
  0x3F, 0xF3, 0xF8, 0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF3, 0xF0, 0x00, 0x7F,
  0x7F, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0x3F, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xF1, 0xFC, 0x03, 0xFF,
  0x1F, 0xF9, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0x07, 0xFF, 0xF3, 0xF0, 0x3F,
  0xFE, 0x3F, 0x01, 0xFF, 0xC3, 0xF0, 0x01, 0xC0, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xBE, 0x0F, 0xFF, 0x87, 0xFF,
  0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7F, 0xEF, 0xBF, 0x07, 0xEF, 0x00, 0xFF,
  0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF1, 0xFE,
  0x0F, 0xCF, 0xE0, 0x07, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x80, 0x01, 0xFB, 0xC0, 0x0F, 0xEF, 0xF3, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xDC,
  0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x78, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x03, 0xFD, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0xFF, 0xDF, 0xFB,
  0xFF, 0xF3, 0xFF, 0xFE, 0x7C, 0x7F, 0xFF, 0x1F, 0x0F, 0xFF, 0x87, 0xC1,
  0xFF, 0xC1, 0xF0, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xE7, 0xE0,
  0x03, 0xFE, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0xF7, 0x80, 0x0F, 0xCF, 0xC0, 0x0F, 0xBC, 0x00, 0x7C, 0x3F, 0x00, 0x7D,
  0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xEF, 0x80, 0x3F, 0x0F, 0xC0, 0x1F, 0x7C,
  0x01, 0xF8, 0x7E, 0x01, 0xF3, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x8F, 0x80,
  0xFC, 0x0F, 0xC0, 0x7C, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE3, 0xE0, 0x3F,
  0x03, 0xF0, 0x3F, 0x1F, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0xFC, 0x0F, 0x80,
  0x7E, 0x0F, 0x83, 0xE0, 0xFC, 0x03, 0xF0, 0x7C, 0x1F, 0x07, 0xE0, 0x1F,
  0x87, 0xE0, 0xF8, 0x3E, 0x00, 0xFC, 0x3E, 0x07, 0xE1, 0xF0, 0x03, 0xE1,
  0xF0, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0xF8, 0xFC, 0x00, 0xFC, 0x7C,
  0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xC0, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x01,
  0xF9, 0xF0, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x07, 0xCF, 0x80, 0x3E,
  0xFC, 0x00, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x0F, 0xBE,
  0x00, 0x07, 0xFE, 0x00, 0x3D, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3F,
  0x00, 0x1F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7C, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x3E,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x02, 0x1F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x70, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0,
  0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x7F, 0xC0, 0x00, 0x4F, 0xFF,
  0x80, 0x06, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xDC, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x7F, 0xC4,
  0x00, 0x00, 0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 52, 17, 5, -51 },
  { 53, 19, 19, 28, 4, -51 },
  { 99, 34, 51, 37, 1, -51 },
  { 316, 27, 58, 34, 3, -54 },
  { 512, 45, 52, 51, 3, -51 },
  { 805, 36, 52, 39, 3, -51 },
  { 1039, 7, 19, 15, 4, -51 },
  { 1056, 16, 62, 21, 3, -51 },
  { 1180, 16, 62, 21, 2, -51 },
  { 1304, 26, 26, 31, 3, -54 },
  { 1389, 28, 34, 34, 3, -42 },
  { 1508, 10, 17, 17, 3, -8 },
  { 1530, 16, 6, 20, 2, -22 },
  { 1542, 9, 10, 17, 4, -9 },
  { 1554, 24, 51, 26, 1, -51 },
  { 1707, 27, 52, 34, 3, -51 },
  { 1883, 17, 51, 34, 5, -51 },
  { 1992, 27, 51, 34, 3, -51 },
  { 2165, 27, 52, 34, 3, -51 },
  { 2341, 31, 51, 34, 1, -51 },
  { 2539, 26, 52, 34, 4, -51 },
  { 2708, 27, 52, 34, 3, -51 },
  { 2884, 29, 51, 34, 2, -51 },
  { 3069, 28, 52, 34, 3, -51 },
  { 3251, 27, 52, 34, 3, -51 },
  { 3427, 8, 40, 17, 5, -39 },
  { 3467, 11, 48, 17, 2, -39 },
  { 3533, 29, 33, 34, 2, -42 },
  { 3653, 28, 20, 34, 3, -35 },
  { 3723, 28, 33, 34, 3, -42 },
  { 3839, 22, 52, 25, 1, -51 },
  { 3982, 44, 57, 51, 4, -51 },
  { 4296, 36, 51, 36, 0, -51 },
  { 4526, 28, 51, 38, 6, -51 },
  { 4705, 30, 52, 36, 4, -51 },
  { 4900, 31, 51, 41, 6, -51 },
  { 5098, 22, 51, 32, 6, -51 },
  { 5239, 22, 51, 30, 6, -51 },
  { 5380, 34, 52, 43, 4, -51 },
  { 5601, 31, 51, 42, 6, -51 },
  { 5799, 16, 51, 21, 3, -51 },
  { 5901, 16, 65, 17, -4, -51 },
  { 6031, 30, 51, 35, 6, -51 },
  { 6223, 22, 51, 30, 6, -51 },
  { 6364, 43, 51, 55, 6, -51 },
  { 6639, 33, 51, 44, 6, -51 },
  { 6850, 36, 52, 44, 4, -51 },
  { 7084, 26, 51, 35, 6, -51 },
  { 7250, 36, 63, 44, 4, -51 },
  { 7534, 29, 51, 36, 6, -51 },
  { 7719, 26, 52, 32, 3, -51 },
  { 7888, 29, 51, 31, 1, -51 },
  { 8073, 31, 52, 42, 5, -51 },
  { 8275, 35, 51, 35, 0, -51 },
  { 8499, 55, 51, 56, 0, -51 },
  { 8850, 32, 51, 32, 0, -51 },
  { 9054, 32, 51, 32, 0, -51 },
  { 9258, 26, 51, 30, 2, -51 },
  { 9424, 15, 62, 23, 5, -51 },
  { 9541, 24, 51, 26, 1, -51 },
  { 9694, 15, 62, 23, 2, -51 },
  { 9811, 31, 29, 34, 2, -51 },
  { 9924, 31, 5, 31, 0, 6 },
  { 9944, 13, 11, 19, 3, -54 },
  { 9962, 25, 40, 33, 3, -39 },
  { 10087, 28, 55, 36, 5, -54 },
  { 10280, 23, 40, 27, 3, -39 },
  { 10395, 28, 55, 36, 3, -54 },
  { 10588, 27, 40, 33, 3, -39 },
  { 10723, 21, 54, 20, 1, -54 },
  { 10865, 28, 56, 36, 3, -39 },
  { 11061, 26, 54, 36, 5, -54 },
  { 11237, 6, 52, 16, 5, -52 },
  { 11276, 13, 69, 16, -2, -52 },
  { 11389, 26, 54, 31, 5, -54 },
  { 11565, 6, 54, 16, 5, -54 },
  { 11606, 44, 39, 54, 5, -39 },
  { 11821, 26, 39, 36, 5, -39 },
  { 11948, 29, 40, 35, 3, -39 },
  { 12093, 28, 56, 36, 5, -39 },
  { 12289, 28, 56, 36, 3, -39 },
  { 12485, 18, 39, 24, 5, -39 },
  { 12573, 22, 40, 27, 3, -39 },
  { 12683, 18, 48, 21, 1, -47 },
  { 12791, 26, 39, 36, 5, -38 },
  { 12918, 29, 38, 29, 0, -38 },
  { 13056, 45, 38, 47, 1, -38 },
  { 13270, 28, 38, 30, 1, -38 },
  { 13403, 29, 55, 29, 0, -38 },
  { 13603, 21, 38, 25, 2, -38 },
  { 13703, 20, 62, 26, 3, -51 },
  { 13858, 6, 71, 32, 13, -54 },
  { 13912, 20, 62, 26, 3, -51 },
  { 14067, 29, 10, 34, 2, -30 },
};

const GFXfont NotoSans_Condensed_Regular71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_REGULAR71PT7B_H_
