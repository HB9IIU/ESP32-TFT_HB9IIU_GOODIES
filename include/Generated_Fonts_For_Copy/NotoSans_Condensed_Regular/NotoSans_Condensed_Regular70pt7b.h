#ifndef _NOTOSANS_CONDENSED_REGULAR70PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFE, 0xFF,
  0xFE, 0xFE, 0x7E, 0x38, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8, 0x1F, 0xFF,
  0x03, 0xF7, 0xE0, 0x7E, 0xF8, 0x0F, 0xDF, 0x01, 0xFB, 0xE0, 0x3E, 0x7C,
  0x07, 0xCF, 0x80, 0xF9, 0xF0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0xF8,
  0x0F, 0x9F, 0x01, 0xF3, 0xE0, 0x3E, 0x7C, 0x03, 0xCF, 0x80, 0x78, 0x00,
  0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x3C,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x78, 0x03, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x0F, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00,
  0x00, 0x78, 0x07, 0xC0, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x78,
  0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x3C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xC7, 0x07,
  0xC7, 0xE0, 0xE0, 0x10, 0xFC, 0x1C, 0x00, 0x1F, 0x03, 0x80, 0x07, 0xE0,
  0x70, 0x00, 0xFC, 0x0E, 0x00, 0x1F, 0x81, 0xC0, 0x03, 0xF0, 0x38, 0x00,
  0x7E, 0x07, 0x00, 0x07, 0xC0, 0xE0, 0x00, 0xFC, 0x1C, 0x00, 0x1F, 0xC3,
  0x80, 0x01, 0xFE, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x77, 0xFC, 0x00, 0x0E, 0x3F, 0xC0,
  0x01, 0xC1, 0xF8, 0x00, 0x38, 0x1F, 0x80, 0x07, 0x03, 0xF0, 0x00, 0xE0,
  0x7E, 0x00, 0x1C, 0x07, 0xC0, 0x03, 0x80, 0xF8, 0x00, 0x70, 0x3F, 0x00,
  0x0E, 0x07, 0xE0, 0x01, 0xC1, 0xFB, 0x00, 0x38, 0x3F, 0x7C, 0x07, 0x1F,
  0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0xF8, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x78,
  0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x0F, 0x80,
  0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x07, 0xC1, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0x00, 0xF8,
  0x07, 0x83, 0xE0, 0x78, 0x0F, 0x80, 0xF8, 0x7C, 0x1F, 0xE0, 0x78, 0x0F,
  0x87, 0xC3, 0xFF, 0x07, 0x80, 0xF8, 0x78, 0x7F, 0xF8, 0x7C, 0x0F, 0x8F,
  0x8F, 0xFF, 0xC7, 0xC1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3E, 0x1F, 0x1F, 0x0F,
  0x83, 0xE3, 0xFF, 0xE1, 0xF1, 0xF0, 0x3E, 0x1F, 0xFE, 0x3E, 0x1F, 0x03,
  0xE0, 0xFF, 0xC3, 0xE1, 0xF0, 0x1F, 0x07, 0xF8, 0x3E, 0x1F, 0x01, 0xF0,
  0x1E, 0x07, 0xC1, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x1E, 0x01, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x00, 0x0F,
  0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xE0,
  0x1F, 0x00, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7C, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x01,
  0xF8, 0x1F, 0xCF, 0xE0, 0x1F, 0x83, 0xF8, 0x7E, 0x01, 0xF8, 0x7F, 0x07,
  0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x81, 0xF8, 0xFE, 0x01, 0xFC, 0x1F, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x0F, 0xC0, 0x07, 0xF7,
  0xE0, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0xFC, 0x00,
  0x1F, 0xFC, 0x0F, 0xC0, 0x00, 0xFF, 0xC0, 0xFC, 0x00, 0x07, 0xF8, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFF,
  0xC0, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xF8, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x7F, 0x03, 0xFF, 0xFF, 0xE3, 0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0xC0,
  0xFF, 0xFF, 0x01, 0xFE, 0x03, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xEF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x7C, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x80, 0x7C, 0x02, 0xF8, 0x3E, 0x0F, 0xFF,
  0x9F, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x1F,
  0x80, 0xFE, 0x0F, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0xFE, 0x3F,
  0x8F, 0xC3, 0xF0, 0xFC, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x3F, 0x0F,
  0x83, 0xE0, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x7F, 0x7E,
  0x18, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x3F, 0x80,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xF0, 0x3F, 0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xFF, 0x3F, 0xDF, 0xBF, 0xCF,
  0xFF, 0xC7, 0xFF, 0xC3, 0xF7, 0x81, 0xF9, 0x80, 0xFC, 0x40, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x1F, 0x80,
  0x3F, 0xC1, 0xE0, 0x03, 0xF8, 0x30, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFD, 0xFF, 0xC7, 0xE0, 0x0F, 0xF1, 0xE0, 0x00, 0xFE, 0x30, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0xC0, 0x00, 0x7F, 0xBC, 0x00, 0x3F,
  0xCF, 0xF8, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xBF, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xF0, 0x3F, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF2, 0x00, 0x03, 0xF8, 0xF0, 0x03, 0xFE,
  0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0x9E, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0xC0, 0x07, 0xC1, 0xFF, 0x00, 0xF8, 0xFF, 0xF8, 0x1F, 0x3F,
  0xFF, 0x83, 0xEF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0x1F, 0xF8, 0x07, 0xF3,
  0xFE, 0x00, 0x7E, 0x7F, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0xFD, 0xFC, 0x00,
  0x1F, 0xBF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3E,
  0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x0F,
  0xE1, 0xFC, 0x01, 0xF8, 0x1F, 0xC0, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xE3, 0xFE, 0x0F, 0xE0, 0x0F, 0xE1, 0xF8,
  0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x0F, 0xF3,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x3F,
  0xE0, 0x3F, 0x81, 0xFE, 0x0F, 0xE0, 0x1F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E,
  0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x01, 0xFC, 0xFF, 0x00, 0x7F, 0x8F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x00, 0x17, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xF0, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x03,
  0xFB, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x1F, 0xEF, 0xE0, 0x07, 0xFC, 0xFE,
  0x01, 0xFF, 0x1F, 0xFF, 0xFB, 0xE1, 0xFF, 0xFF, 0x7C, 0x1F, 0xFF, 0xCF,
  0x81, 0xFF, 0xF1, 0xF0, 0x0F, 0xF8, 0x7E, 0x00, 0x30, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x07, 0x9F, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0x7F, 0xFF, 0x7F, 0x7F, 0x7F, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F,
  0xFF, 0xFF, 0x7F, 0x7F, 0x7E, 0x1C, 0x0F, 0x07, 0xF1, 0xFC, 0xFF, 0x3F,
  0xCF, 0xF1, 0xFC, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x1F, 0xC7,
  0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE1,
  0xF0, 0x7C, 0x1F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE7, 0x80, 0x3F, 0x88, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC1, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0x00, 0x0F,
  0x0F, 0x80, 0x0F, 0xFF, 0x01, 0xF1, 0xF0, 0x07, 0xFF, 0xF0, 0x3E, 0x3E,
  0x01, 0xFF, 0xFE, 0x03, 0xCF, 0x80, 0x7F, 0x9F, 0xC0, 0x7D, 0xF0, 0x0F,
  0x80, 0xF8, 0x0F, 0xBE, 0x03, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0xF0, 0x1F, 0x00, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x0F, 0x80,
  0x7F, 0xC0, 0x7C, 0x03, 0xF0, 0x0F, 0xF8, 0x0F, 0x80, 0x7E, 0x01, 0xFF,
  0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x7C, 0x01, 0xF0, 0x07, 0xF8, 0x0F,
  0x80, 0x3E, 0x00, 0xFF, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0xE0, 0x3E, 0x00,
  0xF8, 0x07, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xFF, 0x80, 0xF8, 0x03, 0xE0,
  0x1F, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xFE, 0x03, 0xE0, 0x1F, 0x80, 0x7B,
  0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x7C, 0x07, 0xC0, 0x7F, 0x03, 0xEF, 0x80,
  0xFC, 0x1F, 0xE0, 0xF9, 0xF0, 0x0F, 0xC7, 0x9E, 0x3F, 0x3E, 0x01, 0xFF,
  0xF3, 0xFF, 0xC3, 0xE0, 0x1F, 0xFC, 0x7F, 0xF0, 0x7C, 0x01, 0xFF, 0x07,
  0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x20, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x7F, 0x80,
  0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xE3, 0xF0,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFC, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x1F, 0xF8, 0xFC, 0x00,
  0x3F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x8F,
  0xC0, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xFC, 0xFC,
  0x00, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xF8, 0x03, 0xC0, 0xFF, 0x00,
  0x04, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0x03, 0xFF, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x1F, 0x80, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0xBF,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0xFF, 0x07, 0xE0, 0x03, 0xFE, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0, 0x03,
  0xF0, 0x1F, 0xE0, 0x00, 0x18, 0x0F, 0xF0, 0x00, 0x02, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0xC0,
  0x00, 0x3F, 0x07, 0xF8, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0x07, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0xFD, 0x03, 0xFB, 0xFF, 0xF7, 0xFF, 0xCF, 0xFF,
  0x1F, 0xFC, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF0, 0x3F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xF1,
  0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0xFC, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x01,
  0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0xFC,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x3E, 0xFF, 0xEF, 0x80, 0x00, 0x07, 0xDF,
  0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xFF, 0x9F, 0x00, 0x00, 0x3E, 0x7F, 0xF3,
  0xE0, 0x00, 0x07, 0xCF, 0xFE, 0x7E, 0x00, 0x01, 0xF9, 0xFF, 0xC7, 0xC0,
  0x00, 0x3E, 0x3F, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xFF, 0x1F, 0x80, 0x00,
  0xF8, 0xFF, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0xFC, 0x3E, 0x00, 0x07, 0xC3,
  0xFF, 0x87, 0xE0, 0x00, 0xF8, 0x7F, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xFE,
  0x0F, 0x80, 0x07, 0xC1, 0xFF, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0xF8, 0x3F,
  0x00, 0x3F, 0x07, 0xFF, 0x03, 0xE0, 0x07, 0xC0, 0xFF, 0xE0, 0x7E, 0x00,
  0xF8, 0x1F, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0x80, 0xF8, 0x07, 0xC0,
  0x7F, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xFE, 0x03, 0xF0, 0x3F, 0x01, 0xFF,
  0xC0, 0x3E, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xFF, 0x00,
  0xFC, 0x1F, 0x00, 0xFF, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0xFC, 0x01, 0xF0,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0x1F, 0x00, 0x7F, 0xF0, 0x07, 0xE7, 0xE0,
  0x0F, 0xFE, 0x00, 0x7C, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFB, 0xF0,
  0x00, 0x1F, 0xFB, 0xF0, 0x00, 0x1F, 0xF9, 0xF8, 0x00, 0x1F, 0xF9, 0xF8,
  0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x1F, 0xF8, 0xFC, 0x00, 0x1F, 0xF8, 0x7E,
  0x00, 0x1F, 0xF8, 0x7E, 0x00, 0x1F, 0xF8, 0x3F, 0x00, 0x1F, 0xF8, 0x3F,
  0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0xF8, 0x1F, 0x80, 0x1F, 0xF8, 0x0F,
  0xC0, 0x1F, 0xF8, 0x0F, 0xC0, 0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07,
  0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x03, 0xF0, 0x1F, 0xF8, 0x01,
  0xF8, 0x1F, 0xF8, 0x01, 0xF8, 0x1F, 0xF8, 0x00, 0xFC, 0x1F, 0xF8, 0x00,
  0xFC, 0x1F, 0xF8, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0x7E, 0x1F, 0xF8, 0x00,
  0x7F, 0x1F, 0xF8, 0x00, 0x3F, 0x1F, 0xF8, 0x00, 0x3F, 0x9F, 0xF8, 0x00,
  0x1F, 0x9F, 0xF8, 0x00, 0x1F, 0xDF, 0xF8, 0x00, 0x0F, 0xDF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0xC0, 0x00, 0x3F, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE,
  0x3F, 0x01, 0xFF, 0x8F, 0xC0, 0x0F, 0xF3, 0xF0, 0x01, 0xFE, 0xFC, 0x00,
  0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7F, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xF3, 0xF0,
  0x03, 0xFC, 0xFC, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0x1F, 0xC7, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x83, 0xF0, 0x03, 0xFC,
  0x1F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xFC, 0x1F, 0x80,
  0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFE, 0x01, 0xF0,
  0xFE, 0x00, 0x0C, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFA, 0x00, 0x00, 0xFE,
  0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xBC,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFB, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xEF, 0x80, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7E,
  0x03, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xC7, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0x83, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xC0, 0xFC, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3E, 0x01, 0xF8, 0x3F, 0x00, 0x07,
  0xE0, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0,
  0x00, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0xFC,
  0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xC0,
  0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0x80, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x0F, 0x00,
  0xFE, 0x0C, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xDF, 0x3F, 0xC0, 0x1F, 0x7F, 0x00,
  0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0x7F, 0x03,
  0xDF, 0x7F, 0xFF, 0xDF, 0x3F, 0xFF, 0x8F, 0x1F, 0xFF, 0x0F, 0x0F, 0xFC,
  0x0F, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x00, 0xFC, 0x7F,
  0xF8, 0x1F, 0x9F, 0xFF, 0x83, 0xF7, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x8F,
  0xFC, 0x07, 0xF9, 0xFF, 0x00, 0x7F, 0x3F, 0xC0, 0x07, 0xF7, 0xF8, 0x00,
  0x7E, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0xFD,
  0xFE, 0x00, 0x3F, 0xBF, 0xE0, 0x07, 0xE7, 0xFE, 0x01, 0xFC, 0xFB, 0xF0,
  0xFF, 0x1F, 0x3F, 0xFF, 0xE3, 0xE3, 0xFF, 0xF8, 0x7C, 0x3F, 0xFE, 0x0F,
  0x83, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x7F, 0xC0, 0xE1,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xE0, 0x0C, 0x3F, 0xF1, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x0F, 0xF8, 0x3F, 0x03, 0xFF, 0xC3, 0xF0, 0x7F, 0xFF, 0x3F, 0x0F, 0xFF,
  0xFB, 0xF0, 0xFF, 0xFF, 0xBF, 0x1F, 0xE0, 0x7F, 0xF3, 0xF8, 0x01, 0xFF,
  0x3F, 0x80, 0x1F, 0xF3, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x0F, 0xF7, 0xE0,
  0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x0F, 0xF3, 0xF0, 0x00, 0xFF,
  0x3F, 0x80, 0x1F, 0xF1, 0xFC, 0x03, 0xFF, 0x1F, 0xF0, 0xFF, 0xF0, 0xFF,
  0xFF, 0xBF, 0x07, 0xFF, 0xF1, 0xF0, 0x3F, 0xFE, 0x1F, 0x01, 0xFF, 0xC1,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xC1,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0x80, 0x03,
  0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x02,
  0x1F, 0xE0, 0x03, 0x83, 0xFE, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x02, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x1F, 0xFF,
  0x01, 0xFF, 0x70, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x81,
  0xF0, 0x1F, 0xFC, 0x1F, 0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0xBF, 0x0F,
  0xFF, 0xFB, 0xF1, 0xFE, 0x07, 0xFF, 0x3F, 0x80, 0x3F, 0xF3, 0xF8, 0x01,
  0xFF, 0x3F, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xF3, 0xF8, 0x01,
  0xFF, 0x1F, 0xC0, 0x3F, 0xF1, 0xFF, 0x0F, 0xBF, 0x0F, 0xFF, 0xFB, 0xF0,
  0x7F, 0xFF, 0x3F, 0x03, 0xFF, 0xE3, 0xF0, 0x1F, 0xF8, 0x3F, 0x00, 0x1C,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC2, 0x00, 0x01, 0xFC, 0x3C, 0x00, 0x3F,
  0xC3, 0xF8, 0x1F, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x7F, 0x80, 0xFC, 0x7F, 0xF8, 0x3F, 0x3F, 0xFF, 0x0F, 0xDF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0xFB, 0xE0, 0x7F, 0x3F, 0xE0, 0x0F, 0xEF, 0xF0, 0x01,
  0xFB, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xC0,
  0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xC0, 0x33, 0xEF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0F, 0x80, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F,
  0xD9, 0xFE, 0xFF, 0xF7, 0xFF, 0x3F, 0xF1, 0xFF, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x8F, 0xC0, 0x1F, 0x87, 0xE0, 0x1F, 0x83, 0xF0, 0x1F, 0x81, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F,
  0x87, 0xE0, 0x0F, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x01,
  0xFB, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7D, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x1F, 0xF7, 0xE0, 0x0F, 0xF1, 0xF8, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0x3F,
  0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x7E, 0x03, 0xF0, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xE3, 0xF0,
  0x03, 0xF1, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xBF,
  0x00, 0x0F, 0xDF, 0x80, 0x07, 0xFF, 0xC0, 0x01, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x1F, 0xE0, 0x07, 0xFC, 0x1F, 0x0F, 0xFF, 0x03, 0xFF, 0xC3,
  0xE3, 0xFF, 0xF0, 0xFF, 0xFC, 0x7C, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xBF,
  0xFF, 0xE7, 0xFF, 0xFD, 0xF7, 0x81, 0xFD, 0xF0, 0x3F, 0xBF, 0xE0, 0x1F,
  0xF8, 0x03, 0xF7, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E, 0x1F, 0xFE, 0x0F, 0x8F, 0xFF, 0xE3,
  0xE7, 0xFF, 0xF8, 0xFB, 0xFF, 0xFF, 0x3E, 0xF0, 0x1F, 0xCF, 0xF8, 0x03,
  0xFB, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xEF, 0xE0,
  0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFE, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0,
  0x3F, 0x80, 0xFF, 0x9F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x1F, 0xE0, 0x1F, 0x0F, 0xFF, 0x03, 0xE3, 0xFF, 0xF0, 0x7C, 0xFF, 0xFF,
  0x0F, 0xBF, 0xFF, 0xF1, 0xF7, 0x80, 0xFF, 0x3F, 0xE0, 0x0F, 0xE7, 0xF8,
  0x00, 0xFE, 0xFE, 0x00, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFD, 0xFC, 0x00, 0x1F, 0xBF, 0xC0, 0x07, 0xF7, 0xFC, 0x00, 0xFC, 0xFF,
  0xC0, 0x3F, 0x9F, 0x7F, 0x3F, 0xE3, 0xF7, 0xFF, 0xFC, 0x7E, 0x7F, 0xFF,
  0x0F, 0xC7, 0xFF, 0xC1, 0xF8, 0x7F, 0xE0, 0x3F, 0x01, 0xF0, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x81, 0xF0, 0x1F, 0xFC, 0x1F,
  0x07, 0xFF, 0xF1, 0xF0, 0xFF, 0xFF, 0x3F, 0x0F, 0xFF, 0xFB, 0xF1, 0xFE,
  0x07, 0xFF, 0x1F, 0x80, 0x1F, 0xF3, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x0F,
  0xF7, 0xF0, 0x00, 0xFF, 0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F,
  0x7E, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0xFF, 0x3F, 0x00, 0x0F, 0xF3, 0xF8, 0x01, 0xFF, 0x1F, 0xC0, 0x3F,
  0xF1, 0xFF, 0x9F, 0xBF, 0x0F, 0xFF, 0xFB, 0xF0, 0x7F, 0xFF, 0x3F, 0x03,
  0xFF, 0xE3, 0xF0, 0x1F, 0xF8, 0x3F, 0x00, 0x1C, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F,
  0xFB, 0xE3, 0xFE, 0xF9, 0xFF, 0xBE, 0xFF, 0xEF, 0xBE, 0x03, 0xFE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0x07, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFF, 0x7F, 0x00, 0x73,
  0xF0, 0x00, 0x9F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xF7, 0xF1,
  0xFF, 0xBF, 0xFF, 0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01,
  0xFE, 0x30, 0x7F, 0xFC, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x01,
  0xE0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0xFF, 0x7F, 0x00, 0xFF, 0xBF, 0xE7, 0xF7, 0xCF,
  0xFF, 0xFB, 0xE3, 0xFF, 0xF9, 0xF0, 0xFF, 0xF8, 0xF8, 0x3F, 0xF0, 0x3C,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x00, 0xF8,
  0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80,
  0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0xDF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xF0,
  0x00, 0xFD, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xE7, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0xE0, 0x01, 0xF1, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xE1,
  0xF8, 0x03, 0xEF, 0x00, 0x3E, 0x0F, 0xC0, 0x3E, 0x7C, 0x03, 0xF0, 0x7E,
  0x01, 0xF3, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0x9F, 0x00, 0xFC, 0x0F, 0x80,
  0x7C, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE3, 0xE0, 0x3E, 0x03, 0xF0, 0x3E,
  0x1F, 0x03, 0xF0, 0x1F, 0x81, 0xF0, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0x87,
  0xC0, 0xF8, 0x03, 0xF0, 0x7C, 0x3F, 0x07, 0xC0, 0x1F, 0x87, 0xC0, 0xF8,
  0x7E, 0x00, 0xFC, 0x3E, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF0, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x81, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0,
  0x07, 0xE7, 0xC0, 0x3E, 0x7E, 0x00, 0x3F, 0x3E, 0x01, 0xF3, 0xF0, 0x00,
  0xF9, 0xF0, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x00, 0x3E,
  0x78, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xEF, 0xE0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8,
  0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0xFC, 0x00,
  0x1F, 0x9F, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x07, 0xE7, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x02, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x00, 0x01,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x08, 0xFF, 0xE0,
  0x00, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFB, 0x80, 0x1F, 0xFF, 0x98, 0x00, 0x1F, 0xF8, 0x80,
  0x00, 0x0E, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 8, 51, 17, 5, -50 },
  { 52, 19, 18, 27, 4, -50 },
  { 95, 34, 50, 36, 1, -50 },
  { 308, 27, 57, 33, 3, -53 },
  { 501, 44, 52, 50, 3, -51 },
  { 787, 36, 52, 39, 3, -51 },
  { 1021, 7, 18, 15, 4, -50 },
  { 1037, 15, 61, 21, 3, -50 },
  { 1152, 15, 61, 21, 2, -50 },
  { 1267, 25, 25, 31, 3, -53 },
  { 1346, 27, 33, 33, 3, -41 },
  { 1458, 10, 17, 17, 3, -8 },
  { 1480, 16, 6, 20, 2, -22 },
  { 1492, 8, 9, 17, 4, -8 },
  { 1501, 24, 50, 26, 1, -50 },
  { 1651, 27, 52, 33, 3, -51 },
  { 1827, 17, 50, 33, 5, -50 },
  { 1934, 27, 51, 33, 3, -51 },
  { 2107, 26, 52, 33, 3, -51 },
  { 2276, 31, 50, 33, 1, -50 },
  { 2470, 26, 51, 33, 4, -50 },
  { 2636, 27, 52, 33, 3, -51 },
  { 2812, 28, 50, 33, 2, -50 },
  { 2987, 27, 52, 33, 3, -51 },
  { 3163, 27, 52, 33, 3, -51 },
  { 3339, 8, 39, 17, 4, -38 },
  { 3378, 10, 47, 17, 2, -38 },
  { 3437, 29, 32, 33, 2, -41 },
  { 3553, 27, 19, 33, 3, -34 },
  { 3618, 28, 32, 33, 3, -41 },
  { 3730, 22, 52, 25, 1, -51 },
  { 3873, 43, 56, 51, 4, -50 },
  { 4174, 35, 50, 35, 0, -50 },
  { 4393, 28, 50, 37, 6, -50 },
  { 4568, 29, 52, 35, 4, -51 },
  { 4757, 31, 50, 41, 6, -50 },
  { 4951, 22, 50, 31, 6, -50 },
  { 5089, 22, 50, 30, 6, -50 },
  { 5227, 34, 52, 42, 4, -51 },
  { 5448, 30, 50, 42, 6, -50 },
  { 5636, 15, 50, 21, 3, -50 },
  { 5730, 15, 63, 17, -4, -50 },
  { 5849, 29, 50, 35, 6, -50 },
  { 6031, 22, 50, 29, 6, -50 },
  { 6169, 43, 50, 54, 6, -50 },
  { 6438, 32, 50, 44, 6, -50 },
  { 6638, 36, 52, 43, 4, -51 },
  { 6872, 26, 50, 34, 6, -50 },
  { 7035, 36, 63, 43, 4, -51 },
  { 7319, 29, 50, 36, 6, -50 },
  { 7501, 26, 52, 32, 3, -51 },
  { 7670, 29, 50, 30, 1, -50 },
  { 7852, 31, 51, 41, 5, -50 },
  { 8050, 34, 50, 34, 0, -50 },
  { 8263, 54, 50, 55, 0, -50 },
  { 8601, 32, 50, 32, 0, -50 },
  { 8801, 31, 50, 31, 0, -50 },
  { 8995, 26, 50, 30, 2, -50 },
  { 9158, 15, 61, 22, 5, -50 },
  { 9273, 24, 50, 26, 1, -50 },
  { 9423, 15, 61, 22, 2, -50 },
  { 9538, 30, 28, 34, 2, -50 },
  { 9643, 31, 4, 31, 0, 6 },
  { 9659, 13, 12, 19, 3, -54 },
  { 9679, 24, 39, 32, 3, -38 },
  { 9796, 27, 54, 36, 5, -53 },
  { 9979, 22, 39, 27, 3, -38 },
  { 10087, 28, 54, 36, 3, -53 },
  { 10276, 26, 39, 32, 3, -38 },
  { 10403, 21, 54, 20, 1, -54 },
  { 10545, 28, 55, 36, 3, -38 },
  { 10738, 26, 53, 35, 5, -53 },
  { 10911, 6, 52, 16, 5, -52 },
  { 10950, 13, 69, 16, -2, -52 },
  { 11063, 25, 53, 31, 5, -53 },
  { 11229, 6, 53, 16, 5, -53 },
  { 11269, 43, 38, 53, 5, -38 },
  { 11474, 26, 38, 35, 5, -38 },
  { 11598, 28, 39, 35, 3, -38 },
  { 11735, 27, 55, 36, 5, -38 },
  { 11921, 28, 55, 36, 3, -38 },
  { 12114, 18, 38, 24, 5, -38 },
  { 12200, 21, 39, 27, 3, -38 },
  { 12303, 18, 47, 20, 1, -46 },
  { 12409, 25, 39, 35, 5, -38 },
  { 12531, 29, 38, 29, 0, -38 },
  { 12669, 45, 38, 46, 1, -38 },
  { 12883, 27, 38, 29, 1, -38 },
  { 13012, 29, 55, 29, 0, -38 },
  { 13212, 21, 38, 25, 2, -38 },
  { 13312, 20, 61, 26, 3, -50 },
  { 13465, 5, 70, 31, 13, -53 },
  { 13509, 20, 61, 26, 3, -50 },
  { 13662, 29, 9, 33, 2, -29 },
};

const GFXfont NotoSans_Condensed_Regular70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_REGULAR70PT7B_H_
