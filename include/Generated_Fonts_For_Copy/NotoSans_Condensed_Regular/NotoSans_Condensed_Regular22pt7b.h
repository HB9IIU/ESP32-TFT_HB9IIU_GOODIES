#ifndef _NOTOSANS_CONDENSED_REGULAR22PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x49, 0x20, 0xBB, 0xCF, 0x3C, 0xD3, 0x4D, 0x10,
  0x0C, 0x81, 0x10, 0x22, 0x04, 0x40, 0x98, 0xFF, 0xC6, 0x60, 0xC8, 0x11,
  0x02, 0x23, 0xFF, 0x09, 0x83, 0x30, 0x66, 0x0C, 0x81, 0x10, 0x08, 0x08,
  0x3E, 0x7F, 0xC8, 0xC8, 0xC8, 0xE8, 0x78, 0x1E, 0x0B, 0x09, 0x09, 0x8B,
  0xFF, 0x7C, 0x08, 0x08, 0x70, 0x61, 0x61, 0x0C, 0x8C, 0x32, 0x30, 0x88,
  0x82, 0x26, 0x0C, 0x93, 0x32, 0xDE, 0x5A, 0x49, 0xCB, 0x30, 0x6C, 0xC1,
  0x33, 0x0C, 0xCC, 0x23, 0x31, 0x84, 0x86, 0x1E, 0x3C, 0x0F, 0xC1, 0x98,
  0x33, 0x06, 0x60, 0xCC, 0x0F, 0x01, 0xC0, 0x78, 0x5D, 0x9B, 0x1B, 0x61,
  0xEC, 0x39, 0x87, 0x3B, 0xF3, 0xE3, 0xFD, 0x50, 0x19, 0x8C, 0xC6, 0x23,
  0x18, 0xC6, 0x31, 0x8C, 0x61, 0x0C, 0x61, 0x8E, 0xCC, 0x66, 0x33, 0x33,
  0x11, 0x11, 0x33, 0x33, 0x66, 0xC0, 0x18, 0x18, 0x18, 0xF7, 0x7E, 0x3C,
  0x6C, 0x66, 0x18, 0x0C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18,
  0x0C, 0x00, 0x6D, 0x6D, 0x00, 0xFF, 0xC0, 0x5D, 0x80, 0x03, 0x02, 0x06,
  0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x20, 0x60, 0x60,
  0xC0, 0x3C, 0x7E, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC1, 0xC1, 0xC1, 0xC3,
  0xC3, 0xC3, 0x63, 0x76, 0x3C, 0x19, 0xDF, 0xB9, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x3C, 0xFE, 0x43, 0x03, 0x03, 0x03, 0x03, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x60, 0x60, 0xFF, 0xFF, 0x3C, 0xFE, 0x83, 0x03, 0x03,
  0x03, 0x06, 0x3C, 0x3E, 0x07, 0x03, 0x03, 0x03, 0x03, 0xCE, 0xFC, 0x03,
  0x00, 0xC0, 0x70, 0x3C, 0x0B, 0x06, 0xC1, 0x30, 0xCC, 0x23, 0x18, 0xC4,
  0x33, 0xFF, 0xFF, 0xC0, 0xC0, 0x30, 0x0C, 0x7E, 0x7E, 0x40, 0x40, 0x40,
  0x40, 0xF8, 0xFE, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0xCE, 0xFC, 0x0F,
  0x3F, 0x70, 0x60, 0x40, 0xC0, 0xDC, 0xFF, 0xE3, 0xC3, 0xC1, 0xC1, 0xC3,
  0x63, 0x77, 0x3E, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x20, 0x30, 0x18, 0x08,
  0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0xC0, 0x3C, 0x3F, 0x30,
  0xD8, 0x6C, 0x33, 0x19, 0xD8, 0x78, 0x3E, 0x33, 0xB0, 0xD8, 0x3C, 0x1E,
  0x1B, 0x9C, 0xFC, 0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67,
  0x7F, 0x03, 0x03, 0x03, 0x06, 0x5C, 0x78, 0x7D, 0x80, 0x00, 0x0B, 0xB0,
  0x7D, 0x80, 0x00, 0x0D, 0xED, 0xA0, 0x00, 0x81, 0xC3, 0x87, 0x0E, 0x06,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x38, 0x70, 0xE0, 0x40,
  0x00, 0x7D, 0xFE, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x18, 0x20, 0xC1, 0x80,
  0x02, 0x0C, 0x18, 0x07, 0x80, 0x7F, 0x83, 0x03, 0x08, 0x06, 0x61, 0x09,
  0x1F, 0x3C, 0xCC, 0xF3, 0x33, 0xC8, 0xCF, 0x23, 0x3C, 0x8C, 0xF3, 0x32,
  0xC7, 0x79, 0x08, 0x86, 0x00, 0x0C, 0x00, 0x1C, 0xC0, 0x3E, 0x00, 0x0E,
  0x01, 0xC0, 0x28, 0x05, 0x81, 0xB0, 0x36, 0x04, 0x41, 0x8C, 0x31, 0x87,
  0xF0, 0xFF, 0x30, 0x66, 0x0C, 0xC1, 0xB0, 0x1E, 0x03, 0xF8, 0x7F, 0x30,
  0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0xF8, 0xFE, 0x61, 0xB0, 0x78, 0x3C, 0x1E,
  0x1B, 0xFD, 0xFC, 0x0F, 0x9F, 0xCC, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xF6, 0x3F, 0xF8, 0x3F, 0x8C,
  0x73, 0x06, 0xC1, 0xB0, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0x06,
  0xC1, 0xB0, 0xCF, 0xE3, 0xF0, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x7E,
  0xFD, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xFD, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x0F, 0x83, 0xFC,
  0xC1, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC3, 0xF8, 0x0F, 0x01,
  0xB0, 0x36, 0x06, 0xE0, 0xCF, 0x78, 0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xFF, 0x98, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x9F, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x19, 0xBD, 0xC0,
  0xC1, 0xE1, 0xB1, 0x98, 0xCC, 0xC6, 0xC3, 0x61, 0xE0, 0xF8, 0x6C, 0x33,
  0x19, 0xCC, 0x66, 0x1B, 0x0D, 0x83, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xE0, 0x1F, 0x01, 0xF8,
  0x0F, 0x40, 0x5F, 0x07, 0xF8, 0x3F, 0x41, 0x7B, 0x1B, 0xD8, 0xDE, 0x44,
  0xF3, 0x67, 0x9B, 0x3C, 0x51, 0xE3, 0x8F, 0x1C, 0x78, 0x43, 0xC0, 0xF8,
  0x3E, 0x0E, 0xC3, 0xB0, 0xF6, 0x3D, 0x8F, 0x33, 0xCC, 0xF1, 0xBC, 0x6F,
  0x0F, 0xC3, 0xF0, 0x7C, 0x1F, 0x03, 0x0F, 0x07, 0xF1, 0xC3, 0x30, 0x36,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0, 0x36, 0x06,
  0xC1, 0x8E, 0xF0, 0xFC, 0xF8, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7,
  0xFE, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0x07, 0xF1, 0xC3,
  0x30, 0x36, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xB0,
  0x36, 0x06, 0xC1, 0x8E, 0xF0, 0xFC, 0x03, 0x80, 0x30, 0x03, 0x00, 0x70,
  0xF8, 0x7F, 0x31, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x8C, 0xFC, 0x66, 0x33,
  0x18, 0xCC, 0x66, 0x1B, 0x0D, 0x83, 0x3E, 0x7F, 0xE1, 0xC0, 0xC0, 0xC0,
  0x60, 0x78, 0x1E, 0x07, 0x03, 0x03, 0x03, 0x03, 0xFE, 0xFC, 0xFF, 0xFF,
  0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0xDC, 0x7C, 0xC0, 0x78,
  0x19, 0x83, 0x30, 0x66, 0x0C, 0xC3, 0x0C, 0x61, 0x8C, 0x31, 0x02, 0x60,
  0x6C, 0x0D, 0x81, 0xA0, 0x1C, 0x03, 0x80, 0x70, 0xC0, 0xC1, 0xE0, 0xE0,
  0xD8, 0x70, 0x6C, 0x38, 0x66, 0x14, 0x33, 0x1B, 0x18, 0x8D, 0x8C, 0x66,
  0xC4, 0x32, 0x26, 0x19, 0x1B, 0x0D, 0x8D, 0x82, 0xC6, 0xC1, 0xE1, 0x40,
  0xE0, 0xE0, 0x70, 0x70, 0x18, 0x38, 0xE0, 0xD8, 0x62, 0x18, 0xCC, 0x33,
  0x07, 0x81, 0xE0, 0x30, 0x0C, 0x07, 0x81, 0xA0, 0xCC, 0x33, 0x18, 0x66,
  0x1B, 0x03, 0xC0, 0xF0, 0x66, 0x19, 0x84, 0x33, 0x0C, 0xC1, 0x60, 0x78,
  0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0xC0,
  0xFF, 0xFF, 0xFF, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xFF,
  0xC0, 0x60, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x08, 0x0C, 0x0C,
  0x06, 0x06, 0x02, 0x03, 0xFF, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0xFF, 0x04, 0x03, 0x00, 0xE0, 0x68, 0x13, 0x0C, 0x42, 0x19, 0x82,
  0xC0, 0xC0, 0xFF, 0xC0, 0xC6, 0x21, 0x3C, 0x7E, 0x02, 0x03, 0x03, 0x3F,
  0xE3, 0xC3, 0xC3, 0xC7, 0xCF, 0x7B, 0x80, 0x80, 0x80, 0x80, 0x80, 0x9C,
  0xBE, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC3, 0xE6, 0xBC, 0x3E,
  0xFD, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC1, 0xC9, 0xF0, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x19, 0xED, 0xFE, 0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0E, 0xCF, 0x3D, 0x80, 0x3C, 0x7E, 0x63, 0xC3, 0xC3, 0xFF,
  0xC0, 0xC0, 0xC0, 0x60, 0x73, 0x3F, 0x1E, 0x78, 0xC1, 0x83, 0x0F, 0xBF,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x3D, 0xBF, 0xD8,
  0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE1, 0xD9, 0xE7, 0xB0, 0x18,
  0x0C, 0x0C, 0x8E, 0x7E, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xBE,
  0xC6, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xDC, 0x04,
  0x92, 0x49, 0x24, 0x92, 0x31, 0xC0, 0x01, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x10, 0x85, 0x6F, 0x00, 0x80, 0x80, 0x80, 0x80, 0x80, 0x86,
  0x8C, 0x8C, 0x98, 0xB0, 0xB0, 0xD8, 0xD8, 0x8C, 0x8C, 0x86, 0x87, 0xFF,
  0xFF, 0x80, 0xBC, 0xF5, 0xFF, 0xF1, 0xC7, 0x8C, 0x38, 0x61, 0xC3, 0x0E,
  0x18, 0x70, 0xC3, 0x86, 0x1C, 0x30, 0xE1, 0x87, 0x0C, 0x30, 0xBC, 0xBE,
  0xC6, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x3E, 0x3F,
  0x98, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xB1, 0x9D, 0xC7, 0xC0,
  0x9C, 0xBE, 0xC3, 0xC3, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC3, 0xE6, 0xBC,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x3D, 0xBF, 0xD8, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE1, 0xD9, 0xE7, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0x9D, 0xF1, 0x8C, 0x42, 0x10, 0x84, 0x21, 0x00, 0x7F, 0xFB, 0x06,
  0x0C, 0x0E, 0x0F, 0x06, 0x06, 0x0F, 0x37, 0xC0, 0x20, 0x87, 0xFF, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x0C, 0x34, 0xF0, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0x41, 0xB1, 0xD9, 0xE7, 0xB0, 0xC1, 0xE0, 0xD8,
  0xCC, 0x66, 0x31, 0x10, 0xD8, 0x6C, 0x36, 0x0A, 0x07, 0x03, 0x80, 0xC3,
  0x0D, 0x0E, 0x36, 0x38, 0xD9, 0xE3, 0x66, 0x89, 0x9B, 0x62, 0x4D, 0x8D,
  0x36, 0x3C, 0x50, 0xF1, 0x41, 0x87, 0x06, 0x1C, 0xE1, 0xB1, 0x8C, 0xC6,
  0xC1, 0xC0, 0xE0, 0x70, 0x3C, 0x36, 0x19, 0x98, 0xDC, 0x30, 0xC1, 0xE0,
  0xD8, 0xCC, 0x66, 0x31, 0x10, 0xD8, 0x6C, 0x16, 0x0A, 0x07, 0x01, 0x80,
  0x80, 0xC0, 0x60, 0x60, 0xF0, 0x00, 0xFF, 0xF0, 0xC6, 0x18, 0xC3, 0x18,
  0x63, 0x0F, 0xFF, 0x0C, 0x73, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0x8E, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xE1, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xC3, 0x83, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x71, 0xCC, 0x30, 0xC3, 0x0C,
  0x30, 0xCE, 0x20, 0xF0, 0xCF, 0xE1, 0x80,
};

const GFXglyph NotoSans_Condensed_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 3, 16, 5, 1, -16 },
  { 7, 6, 6, 9, 1, -16 },
  { 12, 11, 16, 11, 0, -16 },
  { 34, 8, 18, 10, 1, -17 },
  { 52, 14, 16, 16, 1, -16 },
  { 80, 11, 16, 12, 1, -16 },
  { 102, 2, 6, 5, 1, -16 },
  { 104, 5, 19, 6, 1, -16 },
  { 116, 4, 19, 6, 1, -16 },
  { 126, 8, 8, 10, 1, -17 },
  { 134, 9, 10, 10, 1, -13 },
  { 146, 3, 6, 5, 1, -3 },
  { 149, 5, 2, 6, 1, -7 },
  { 151, 3, 3, 5, 1, -3 },
  { 153, 8, 16, 8, 0, -16 },
  { 169, 8, 16, 10, 1, -16 },
  { 185, 5, 16, 10, 2, -16 },
  { 195, 8, 16, 10, 1, -16 },
  { 211, 8, 16, 10, 1, -16 },
  { 227, 10, 16, 10, 0, -16 },
  { 247, 8, 16, 10, 1, -16 },
  { 263, 8, 16, 10, 1, -16 },
  { 279, 9, 16, 10, 1, -16 },
  { 297, 9, 16, 10, 1, -16 },
  { 315, 8, 16, 10, 1, -16 },
  { 331, 3, 12, 5, 1, -12 },
  { 336, 3, 15, 5, 1, -12 },
  { 342, 9, 10, 10, 1, -13 },
  { 354, 9, 6, 10, 1, -11 },
  { 361, 9, 10, 10, 1, -13 },
  { 373, 7, 16, 8, 0, -16 },
  { 387, 14, 18, 16, 1, -16 },
  { 419, 11, 16, 11, 0, -16 },
  { 441, 9, 16, 12, 2, -16 },
  { 459, 9, 16, 11, 1, -16 },
  { 477, 10, 16, 13, 2, -16 },
  { 497, 7, 16, 10, 2, -16 },
  { 511, 7, 16, 9, 2, -16 },
  { 525, 11, 16, 13, 1, -16 },
  { 547, 9, 16, 13, 2, -16 },
  { 565, 5, 16, 7, 1, -16 },
  { 575, 5, 20, 5, -1, -16 },
  { 588, 9, 16, 11, 2, -16 },
  { 606, 7, 16, 9, 2, -16 },
  { 620, 13, 16, 17, 2, -16 },
  { 646, 10, 16, 14, 2, -16 },
  { 666, 11, 16, 14, 1, -16 },
  { 688, 8, 16, 11, 2, -16 },
  { 704, 11, 20, 14, 1, -16 },
  { 732, 9, 16, 11, 2, -16 },
  { 750, 8, 16, 10, 1, -16 },
  { 766, 9, 16, 10, 0, -16 },
  { 784, 9, 16, 13, 2, -16 },
  { 802, 11, 16, 11, 0, -16 },
  { 824, 17, 16, 17, 0, -16 },
  { 858, 10, 16, 10, 0, -16 },
  { 878, 10, 16, 10, 0, -16 },
  { 898, 8, 16, 9, 1, -16 },
  { 914, 4, 20, 7, 2, -16 },
  { 924, 8, 16, 8, 0, -16 },
  { 940, 4, 20, 7, 1, -16 },
  { 950, 10, 9, 11, 0, -16 },
  { 962, 10, 1, 10, 0, 2 },
  { 964, 4, 4, 6, 1, -17 },
  { 966, 8, 12, 10, 1, -12 },
  { 978, 8, 17, 11, 2, -17 },
  { 995, 7, 12, 9, 1, -12 },
  { 1006, 9, 17, 11, 1, -17 },
  { 1026, 8, 12, 10, 1, -12 },
  { 1038, 7, 17, 6, 0, -17 },
  { 1053, 9, 17, 11, 1, -12 },
  { 1073, 8, 17, 11, 2, -17 },
  { 1090, 3, 16, 5, 1, -16 },
  { 1096, 5, 21, 5, -1, -16 },
  { 1110, 8, 17, 10, 2, -17 },
  { 1127, 1, 17, 5, 2, -17 },
  { 1130, 13, 12, 17, 2, -12 },
  { 1150, 8, 12, 11, 2, -12 },
  { 1162, 9, 12, 11, 1, -12 },
  { 1176, 8, 17, 11, 2, -12 },
  { 1193, 9, 17, 11, 1, -12 },
  { 1213, 5, 12, 7, 2, -12 },
  { 1221, 7, 12, 8, 1, -12 },
  { 1232, 6, 14, 6, 0, -14 },
  { 1243, 9, 12, 11, 1, -12 },
  { 1257, 9, 12, 9, 0, -12 },
  { 1271, 14, 12, 15, 0, -12 },
  { 1292, 9, 12, 9, 0, -12 },
  { 1306, 9, 17, 9, 0, -12 },
  { 1326, 6, 12, 8, 1, -12 },
  { 1335, 6, 20, 8, 1, -16 },
  { 1350, 2, 22, 10, 4, -17 },
  { 1356, 6, 20, 8, 1, -16 },
  { 1371, 9, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Regular22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_REGULAR22PT7B_H_
