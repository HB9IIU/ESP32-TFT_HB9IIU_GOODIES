#ifndef _NOTOSANS_CONDENSED_REGULAR38PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x00,
  0x4F, 0xFF, 0xE0, 0xF1, 0xFC, 0x7F, 0x1D, 0xC7, 0x71, 0xD8, 0x76, 0x1D,
  0x87, 0x61, 0xD8, 0x30, 0x03, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C,
  0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xC0, 0x1C, 0x30, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x61, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x86, 0x00,
  0xE1, 0x80, 0x30, 0x60, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x70,
  0xE0, 0x1C, 0x30, 0x07, 0x0C, 0x01, 0x83, 0x00, 0x61, 0xC0, 0x18, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xE0,
  0x3F, 0xFD, 0xFF, 0xE7, 0xB1, 0xB8, 0xC0, 0xE3, 0x03, 0x8C, 0x0E, 0x30,
  0x38, 0xC0, 0xF3, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x0D,
  0xE0, 0x33, 0xC0, 0xC7, 0x03, 0x1C, 0x0C, 0x70, 0x31, 0xE0, 0xCF, 0xFF,
  0xFB, 0xFF, 0xC3, 0xFC, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0x08, 0x00, 0x00, 0x3E, 0x00, 0xC0, 0x7F, 0x01, 0xC0, 0xE3, 0x01, 0x80,
  0xE3, 0x83, 0x80, 0xC3, 0x83, 0x80, 0xC3, 0x87, 0x00, 0xC3, 0x87, 0x00,
  0xC1, 0x86, 0x00, 0xC1, 0x8E, 0x00, 0xC3, 0x8C, 0x00, 0xC3, 0x9C, 0x70,
  0xC3, 0x9C, 0xFC, 0xE3, 0x99, 0xFC, 0xE3, 0x39, 0x8E, 0x7F, 0x33, 0x8E,
  0x3E, 0x73, 0x86, 0x08, 0x73, 0x86, 0x00, 0x63, 0x86, 0x00, 0xE3, 0x87,
  0x00, 0xC3, 0x87, 0x01, 0xC3, 0x86, 0x01, 0xC3, 0x86, 0x03, 0x83, 0x86,
  0x03, 0x81, 0x8E, 0x03, 0x01, 0xCE, 0x07, 0x01, 0xFC, 0x06, 0x00, 0xF8,
  0x01, 0x80, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7,
  0x80, 0x0E, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0xC0, 0x03, 0xDE, 0x0E, 0x38, 0xE1, 0xE7, 0x8F, 0x1C, 0x70, 0x79, 0xCF,
  0x03, 0xFC, 0xF0, 0x1F, 0x8F, 0x01, 0xF8, 0xF0, 0x0F, 0x07, 0x00, 0xF8,
  0x78, 0x3F, 0x87, 0xFF, 0xFC, 0x3F, 0xF1, 0xE1, 0xFE, 0x0F, 0xFF, 0xF7,
  0x76, 0x66, 0x66, 0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x38, 0x78, 0x70, 0x70,
  0x70, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x07,
  0xF0, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x0F, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F,
  0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x38, 0x38, 0x70, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x43, 0x85, 0xFF, 0xF7, 0xFF, 0xE7, 0xFC, 0x07,
  0xC0, 0x3B, 0x80, 0xEE, 0x07, 0x1C, 0x3C, 0x78, 0x20, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x3C, 0xE3,
  0x8E, 0x79, 0xC7, 0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x23, 0xBF, 0xF7,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x03, 0x00, 0x7F,
  0x03, 0xFE, 0x0F, 0x3C, 0x78, 0x79, 0xC0, 0xEF, 0x03, 0xB8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF,
  0x03, 0x9C, 0x0E, 0x78, 0x78, 0xFF, 0xC3, 0xFE, 0x03, 0xF0, 0x07, 0x87,
  0xC7, 0xE7, 0xF7, 0xBF, 0x9F, 0x8E, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x01, 0x00, 0x3F, 0xC0, 0xFF, 0xE3, 0xE7,
  0xC3, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x00,
  0x3F, 0xE1, 0xFF, 0xE7, 0xC3, 0xE6, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x01, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x40, 0x3C, 0xFB, 0xF1, 0xFF,
  0xE3, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xB8, 0x03, 0xB8, 0x03, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x38, 0x38, 0x38, 0x70, 0x38, 0x70,
  0x38, 0xE0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x7F, 0xF9, 0xFF,
  0xE7, 0xFF, 0x9C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0xF0, 0x3F, 0xF8, 0xFF, 0xF0, 0x83, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xA0, 0x1E, 0xFB, 0xF3, 0xFF, 0x87, 0xFC, 0x00, 0x00, 0x40, 0x1F,
  0xE0, 0xFF, 0x87, 0xC2, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x39, 0xF8, 0xEF, 0xF3, 0xFF, 0xEF, 0x83, 0xBC,
  0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77,
  0x01, 0xDC, 0x0F, 0x78, 0x38, 0xFF, 0xE1, 0xFF, 0x03, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0x01, 0x80, 0x1F, 0xE0, 0x7F, 0xE1, 0xE1, 0xE3, 0x81, 0xCF, 0x03,
  0xDC, 0x03, 0xB8, 0x07, 0x70, 0x1E, 0x70, 0x38, 0xF0, 0xF0, 0xF3, 0xC0,
  0xFF, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0x7C, 0x3C, 0x7C, 0xF0, 0x39, 0xC0,
  0x7B, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x78, 0x1E,
  0x7C, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0x02, 0x00, 0x7F, 0x03, 0xFE, 0x1F,
  0x3C, 0x70, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x3F, 0xC0, 0xF7, 0x07, 0xDF, 0xF7, 0x3F, 0xDC,
  0x7C, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C,
  0x00, 0xE1, 0x9F, 0x87, 0xFC, 0x1F, 0xC0, 0x23, 0xBF, 0xF7, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x23, 0xBF, 0xF7, 0x00, 0x10, 0xE7, 0xDF,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0x8E,
  0x79, 0xC7, 0x1C, 0x63, 0x80, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x02, 0x01,
  0xFE, 0x3F, 0xF8, 0xF3, 0xE4, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x0E, 0x00, 0xF8, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x07, 0xC1, 0xF0, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x3C,
  0x00, 0x1C, 0x38, 0x00, 0x0C, 0x70, 0x3F, 0x0E, 0x70, 0x7F, 0x8E, 0x70,
  0xE3, 0x86, 0x61, 0xC3, 0x86, 0xE1, 0xC3, 0x87, 0xE1, 0x83, 0x87, 0xE3,
  0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x87, 0xE3, 0x83, 0x86, 0xE3,
  0x83, 0x86, 0xE3, 0x87, 0x8E, 0xE1, 0xC7, 0x8E, 0xE1, 0xFD, 0xFC, 0x60,
  0xFC, 0xF8, 0x70, 0x30, 0x70, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1E, 0x00, 0x40, 0x0F, 0x81, 0xC0, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xD8, 0x00,
  0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x07, 0x1C, 0x00,
  0xE3, 0x80, 0x1C, 0x70, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03,
  0x83, 0xC0, 0xE0, 0x38, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x1E,
  0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0x80, 0xFF, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF7, 0x01, 0xEE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3B, 0x80, 0xF7, 0xFF, 0xCF, 0xFE, 0x1F, 0xFF, 0x38, 0x1F, 0x70,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x07, 0xF0, 0x1E, 0xFF, 0xFD, 0xFF, 0xF3, 0xFF, 0x80, 0x00, 0x60,
  0x03, 0xFE, 0x0F, 0xFF, 0x1F, 0x9E, 0x1E, 0x02, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x01,
  0x1F, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1C, 0x07, 0xCE, 0x01, 0xE7, 0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x0E, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xDC, 0x00,
  0xEE, 0x00, 0xF7, 0x00, 0x73, 0x80, 0x79, 0xC0, 0xF8, 0xFF, 0xF8, 0x7F,
  0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE7, 0xE1,
  0xE0, 0x08, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xB8,
  0x00, 0xF7, 0x00, 0x1E, 0xF0, 0x03, 0xCE, 0x00, 0x79, 0xE0, 0x0F, 0x1E,
  0x01, 0xE1, 0xFF, 0xFC, 0x1F, 0xFF, 0x81, 0xFF, 0xC0, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xE0, 0xFF, 0xFF, 0xC7, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x7F,
  0xFF, 0xE0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0xFE, 0xFE, 0xFC,
  0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x78, 0xE0, 0xF0,
  0xE0, 0xE0, 0xE1, 0xE0, 0xE1, 0xC0, 0xE3, 0x80, 0xE7, 0x80, 0xE7, 0x00,
  0xEF, 0x00, 0xFF, 0x80, 0xFB, 0x80, 0xF3, 0xC0, 0xE1, 0xC0, 0xE1, 0xE0,
  0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x3C,
  0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFD, 0x80, 0x0F, 0xFB, 0x80, 0x1F, 0xF7, 0x00, 0x77, 0xEE, 0x00,
  0xEF, 0xCE, 0x01, 0xDF, 0x9C, 0x07, 0x3F, 0x38, 0x0E, 0x7E, 0x38, 0x1C,
  0xFC, 0x70, 0x71, 0xF8, 0xE0, 0xE3, 0xF0, 0xE1, 0xC7, 0xE1, 0xC3, 0x0F,
  0xC3, 0x8E, 0x1F, 0x83, 0x9C, 0x3F, 0x07, 0x30, 0x7E, 0x0E, 0xE0, 0xFC,
  0x0F, 0xC1, 0xF8, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0x7C, 0x0F, 0xC0,
  0x78, 0x1F, 0x80, 0xE0, 0x38, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7E, 0xE0, 0x1F, 0xBC, 0x07, 0xE7,
  0x01, 0xF9, 0xE0, 0x7E, 0x38, 0x1F, 0x8F, 0x07, 0xE1, 0xC1, 0xF8, 0x78,
  0x7E, 0x0E, 0x1F, 0x83, 0xC7, 0xE0, 0x71, 0xF8, 0x1E, 0x7E, 0x03, 0x9F,
  0x80, 0xF7, 0xE0, 0x1D, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x0F,
  0xFF, 0x01, 0xF9, 0xF8, 0x3C, 0x07, 0x83, 0x80, 0x3C, 0x78, 0x01, 0xC7,
  0x00, 0x1E, 0x70, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00,
  0x1E, 0x78, 0x01, 0xC3, 0xC0, 0x3C, 0x3E, 0x07, 0x81, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0,
  0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0F, 0xE0, 0x7B, 0x8F, 0xEF, 0xFF, 0x3F, 0xF0, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x01,
  0xF9, 0xF8, 0x3C, 0x07, 0x83, 0x80, 0x3C, 0x78, 0x01, 0xC7, 0x00, 0x1E,
  0x70, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEF, 0x00,
  0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x00, 0x1E, 0x78,
  0x01, 0xC3, 0xC0, 0x3C, 0x3E, 0x07, 0x81, 0xFF, 0xF0, 0x0F, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0,
  0x78, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xFF,
  0xC0, 0xE1, 0xE0, 0xE0, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0xE0,
  0x38, 0xE0, 0x3C, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0F, 0x01,
  0x00, 0x7F, 0xE3, 0xFF, 0x9F, 0xFE, 0xF0, 0x0B, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x80, 0x7B, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0xF0, 0x01, 0xFE, 0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xE7, 0x80, 0x38,
  0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x38, 0x3C, 0x07, 0x03, 0x80, 0xE0,
  0x70, 0x3C, 0x0E, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x80,
  0x70, 0xE0, 0x07, 0x1C, 0x00, 0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xDC, 0x00,
  0x3B, 0x80, 0x07, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x3B, 0x80, 0x3C, 0x01,
  0xDC, 0x01, 0xE0, 0x0E, 0xE0, 0x1F, 0x00, 0xF7, 0x80, 0xF8, 0x07, 0x3C,
  0x07, 0xE0, 0x38, 0xE0, 0x3F, 0x01, 0xC7, 0x01, 0xB8, 0x0E, 0x38, 0x1C,
  0xC0, 0xF1, 0xE0, 0xE7, 0x07, 0x07, 0x07, 0x38, 0x38, 0x38, 0x31, 0xC1,
  0xC1, 0xC3, 0x8E, 0x1E, 0x0F, 0x1C, 0x38, 0xE0, 0x38, 0xE1, 0xC7, 0x01,
  0xC7, 0x0E, 0x38, 0x0E, 0x70, 0x71, 0xC0, 0x73, 0x81, 0x9E, 0x03, 0xDC,
  0x0E, 0xE0, 0x0E, 0xE0, 0x77, 0x00, 0x76, 0x03, 0xB8, 0x03, 0xF0, 0x0D,
  0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x1E, 0x00, 0xF8, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x07, 0x9C, 0x03, 0x8E,
  0x03, 0xC3, 0x81, 0xC1, 0xC1, 0xE0, 0x70, 0xE0, 0x38, 0xF0, 0x1E, 0x70,
  0x07, 0x38, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0x70, 0x03, 0xBC, 0x03, 0x8E, 0x01,
  0xC7, 0x81, 0xE1, 0xC0, 0xE0, 0xF0, 0xF0, 0x38, 0x70, 0x1C, 0x78, 0x0F,
  0x38, 0x03, 0xBC, 0x01, 0xE0, 0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x03, 0xCF,
  0x01, 0xC3, 0x80, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x38, 0x78, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0xDE, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x38,
  0x1C, 0x38, 0x1C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF1, 0xE1, 0xE1, 0xC1, 0xC1, 0xC0,
  0x03, 0x80, 0x7F, 0xC3, 0xFF, 0x86, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x3F, 0xF1, 0xFF, 0xCF, 0x07, 0x78, 0x1D, 0xC0,
  0x7F, 0x01, 0xFC, 0x0F, 0xF0, 0x3D, 0xC1, 0xF7, 0x8F, 0xCF, 0xF7, 0x1F,
  0x9C, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE3, 0xC1, 0xDF, 0xE3, 0xFF, 0xE7, 0xC3, 0xCF,
  0x03, 0xDE, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xF0, 0x3D,
  0xE0, 0x73, 0xF3, 0xE6, 0x7F, 0x8C, 0x7E, 0x00, 0x07, 0xC1, 0xFF, 0x3F,
  0xE7, 0xC2, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3E,
  0x63, 0xFE, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x07, 0x1E, 0x3F, 0xBC, 0xFF,
  0xBB, 0xC3, 0xF7, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF8,
  0x0F, 0xF0, 0x1E, 0xE0, 0x7D, 0xF3, 0xB9, 0xFF, 0x71, 0xFC, 0xE0, 0x07,
  0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0, 0xEE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x23, 0xE7, 0x87, 0xFE, 0x0F, 0xF0,
  0x03, 0xE0, 0x7E, 0x0F, 0xE0, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x07, 0xFC, 0xFF, 0xC1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x3F, 0x9C,
  0xFF, 0xBB, 0xC3, 0xF7, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07,
  0xF8, 0x0F, 0xF0, 0x1E, 0xE0, 0x7D, 0xF3, 0xB9, 0xFF, 0x71, 0xF9, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x39, 0x00, 0xF3, 0xFF,
  0xC7, 0xFF, 0x07, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE3, 0xC3, 0xBF, 0xCF, 0xFF,
  0x3E, 0x1E, 0xF0, 0x3B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0x7F, 0xF7, 0x00, 0x00,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x0E, 0x3C,
  0x78, 0x70, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x3F, 0xF7, 0xEF, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x03, 0xB8,
  0x3D, 0xC1, 0xCE, 0x1C, 0x71, 0xE3, 0x9E, 0x1C, 0xE0, 0xEE, 0x07, 0xF8,
  0x3F, 0xC1, 0xFF, 0x0F, 0x38, 0x71, 0xE3, 0x87, 0x1C, 0x3C, 0xE0, 0xE7,
  0x07, 0xB8, 0x1D, 0xC0, 0xFE, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0xE1, 0x9F, 0xC7, 0xF3,
  0xFF, 0xDF, 0xF7, 0xC3, 0xB0, 0xFF, 0x07, 0xC1, 0xFC, 0x07, 0x81, 0xF8,
  0x0E, 0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80,
  0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xFC, 0x07, 0x01, 0xF8, 0x0E,
  0x03, 0xF0, 0x1C, 0x07, 0xE0, 0x38, 0x0F, 0xC0, 0x70, 0x1F, 0x80, 0xE0,
  0x3F, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xE0, 0x03, 0xC3, 0x3F, 0xCF, 0xFF,
  0xBE, 0x1E, 0xF0, 0x3B, 0xC0, 0xEE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3C, 0x07, 0x80, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF8, 0x0E, 0x70, 0x1C, 0xF0, 0x78, 0xFB, 0xE0, 0xFF, 0x80, 0xFE, 0x00,
  0x03, 0xC1, 0x9F, 0xE3, 0xFF, 0xE7, 0xC3, 0xCF, 0x03, 0xDE, 0x03, 0xB8,
  0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01,
  0xFC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xF0, 0x3D, 0xE0, 0x73, 0xF3, 0xE7,
  0x7F, 0x8E, 0x7E, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x3F,
  0x9C, 0xFF, 0xBB, 0xC3, 0xF7, 0x03, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x7D, 0xFB, 0xB9, 0xFF, 0xF1, 0xF9,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xE3, 0xF3, 0xFF, 0x9F, 0x87,
  0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x00, 0x07, 0x83, 0xFF, 0x7F, 0xF7, 0x02,
  0x70, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x78, 0x0F, 0xF9, 0xEF, 0xFE,
  0x7F, 0xC0, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x87, 0xFF, 0xFE, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xFA, 0x3F, 0x1F, 0x80, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0x7F, 0xCE,
  0xDF, 0xF6, 0x7E, 0x30, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x1E, 0x70, 0x1C,
  0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x38,
  0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xB8,
  0x1F, 0x03, 0x9C, 0x0F, 0x81, 0xCE, 0x06, 0xC0, 0xE3, 0x83, 0x60, 0xF1,
  0xC3, 0xB8, 0x70, 0xE1, 0xDC, 0x38, 0x70, 0xEE, 0x1C, 0x3C, 0x63, 0x0E,
  0x0E, 0x71, 0xCE, 0x07, 0x38, 0xE7, 0x03, 0x9C, 0x73, 0x81, 0xCC, 0x19,
  0xC0, 0x76, 0x0C, 0xC0, 0x3F, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1,
  0xF8, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0,
  0x3D, 0xC0, 0xE7, 0x87, 0x8E, 0x1C, 0x3C, 0xF0, 0x73, 0x80, 0xFE, 0x03,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x73, 0x83,
  0xCE, 0x0E, 0x1C, 0x78, 0x79, 0xC0, 0xEF, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x3C,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xEF, 0xFC, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F,
  0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0xE0, 0x7C, 0x1F, 0x83, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x87, 0xE0, 0xF0, 0x1F,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xF8, 0x1F, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x3F, 0x00, 0xF0, 0x3F, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0xFE, 0x0F,
  0xC0, 0xF0, 0x00, 0x1C, 0x01, 0x7F, 0x83, 0xFF, 0xFF, 0xC1, 0xFE, 0x80,
  0x7C,
};

const GFXglyph NotoSans_Condensed_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 4, 27, 9, 3, -27 },
  { 15, 10, 10, 15, 2, -27 },
  { 28, 18, 27, 20, 1, -27 },
  { 89, 14, 31, 18, 2, -29 },
  { 144, 24, 28, 27, 2, -28 },
  { 228, 20, 28, 21, 1, -28 },
  { 298, 4, 10, 8, 2, -27 },
  { 303, 8, 33, 11, 2, -27 },
  { 336, 8, 33, 11, 1, -27 },
  { 369, 14, 14, 17, 1, -29 },
  { 394, 16, 18, 18, 1, -22 },
  { 430, 6, 9, 9, 1, -4 },
  { 437, 9, 3, 11, 1, -12 },
  { 441, 5, 5, 9, 2, -5 },
  { 445, 13, 27, 14, 1, -27 },
  { 489, 14, 28, 18, 2, -28 },
  { 538, 9, 27, 18, 3, -27 },
  { 569, 15, 28, 18, 1, -28 },
  { 622, 15, 28, 18, 1, -28 },
  { 675, 16, 27, 18, 1, -27 },
  { 729, 14, 27, 18, 2, -27 },
  { 777, 14, 28, 18, 2, -28 },
  { 826, 15, 27, 18, 1, -27 },
  { 877, 15, 28, 18, 1, -28 },
  { 930, 14, 28, 18, 2, -28 },
  { 979, 5, 21, 9, 2, -21 },
  { 993, 6, 26, 9, 1, -21 },
  { 1013, 16, 17, 18, 1, -22 },
  { 1047, 15, 11, 18, 1, -19 },
  { 1068, 16, 17, 18, 1, -22 },
  { 1102, 13, 28, 13, 0, -28 },
  { 1148, 24, 30, 28, 2, -27 },
  { 1238, 19, 27, 19, 0, -27 },
  { 1303, 15, 27, 20, 3, -27 },
  { 1354, 16, 28, 19, 2, -28 },
  { 1410, 17, 27, 22, 3, -27 },
  { 1468, 12, 27, 17, 3, -27 },
  { 1509, 12, 27, 16, 3, -27 },
  { 1550, 19, 28, 23, 2, -28 },
  { 1617, 17, 27, 23, 3, -27 },
  { 1675, 9, 27, 11, 1, -27 },
  { 1706, 8, 34, 9, -2, -27 },
  { 1740, 16, 27, 19, 3, -27 },
  { 1794, 12, 27, 16, 3, -27 },
  { 1835, 23, 27, 29, 3, -27 },
  { 1913, 18, 27, 24, 3, -27 },
  { 1974, 20, 28, 24, 2, -28 },
  { 2044, 14, 27, 19, 3, -27 },
  { 2092, 20, 34, 24, 2, -28 },
  { 2177, 16, 27, 19, 3, -27 },
  { 2231, 14, 28, 17, 2, -28 },
  { 2280, 16, 27, 16, 0, -27 },
  { 2334, 16, 27, 22, 3, -27 },
  { 2388, 19, 27, 19, 0, -27 },
  { 2453, 29, 27, 30, 0, -27 },
  { 2551, 17, 27, 17, 0, -27 },
  { 2609, 17, 27, 17, 0, -27 },
  { 2667, 14, 27, 16, 1, -27 },
  { 2715, 8, 33, 12, 3, -27 },
  { 2748, 13, 27, 14, 1, -27 },
  { 2792, 8, 33, 12, 1, -27 },
  { 2825, 16, 15, 18, 1, -27 },
  { 2855, 17, 3, 17, 0, 3 },
  { 2862, 7, 6, 10, 2, -29 },
  { 2868, 14, 21, 17, 1, -21 },
  { 2905, 15, 29, 19, 3, -29 },
  { 2960, 12, 21, 15, 2, -21 },
  { 2992, 15, 29, 19, 2, -29 },
  { 3047, 14, 21, 18, 2, -21 },
  { 3084, 12, 29, 11, 0, -29 },
  { 3128, 15, 30, 19, 2, -21 },
  { 3185, 14, 29, 19, 3, -29 },
  { 3236, 4, 28, 9, 2, -28 },
  { 3250, 7, 37, 9, -1, -28 },
  { 3283, 13, 29, 17, 3, -29 },
  { 3331, 3, 29, 9, 3, -29 },
  { 3342, 23, 21, 29, 3, -21 },
  { 3403, 14, 21, 19, 3, -21 },
  { 3440, 15, 21, 19, 2, -21 },
  { 3480, 15, 30, 19, 3, -21 },
  { 3537, 15, 30, 19, 2, -21 },
  { 3594, 9, 21, 13, 3, -21 },
  { 3618, 12, 21, 14, 1, -21 },
  { 3650, 9, 25, 11, 1, -25 },
  { 3679, 13, 20, 19, 3, -20 },
  { 3712, 16, 20, 16, 0, -20 },
  { 3752, 25, 20, 25, 0, -20 },
  { 3815, 14, 20, 16, 1, -20 },
  { 3850, 16, 29, 16, 0, -20 },
  { 3908, 11, 20, 13, 1, -20 },
  { 3936, 11, 33, 14, 1, -27 },
  { 3982, 3, 38, 17, 7, -29 },
  { 3997, 12, 33, 14, 1, -27 },
  { 4047, 16, 5, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Regular38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_REGULAR38PT7B_H_
