#ifndef _NOTOSANS_CONDENSED_REGULAR58PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR58PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7D, 0xF7, 0xDF, 0x7D, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0x7C, 0x40, 0xFC, 0x1F, 0x7C,
  0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1F, 0x78, 0x1F, 0x78,
  0x1F, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x0E, 0x38, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0x80, 0xF0, 0x00, 0x78,
  0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x70, 0x1E, 0x00, 0x0F,
  0x01, 0xC0, 0x00, 0xF0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x0E, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x00,
  0x3C, 0x07, 0x80, 0x03, 0xC0, 0x70, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x0F, 0x00,
  0x07, 0x80, 0xE0, 0x00, 0x78, 0x0E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78,
  0x1E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x01, 0xE0,
  0x00, 0x70, 0x1C, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF1, 0xF9, 0xC3, 0xCF, 0xC7, 0x01, 0x3E, 0x1C, 0x00,
  0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x00, 0x3C, 0x1C, 0x00, 0xF0,
  0x70, 0x03, 0xE1, 0xC0, 0x0F, 0xC7, 0x00, 0x1F, 0xDC, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xC0, 0x07, 0x3F, 0x80, 0x1C, 0x7E, 0x00, 0x70, 0x78, 0x01,
  0xC1, 0xF0, 0x07, 0x07, 0xC0, 0x1C, 0x1F, 0x00, 0x70, 0x7C, 0x01, 0xC1,
  0xF8, 0x07, 0x0F, 0xB0, 0x1C, 0x7E, 0xF8, 0x77, 0xF3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xC0, 0x07, 0xFE,
  0x00, 0x3C, 0x00, 0x7F, 0xF0, 0x01, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x00,
  0x3C, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x78, 0x00, 0x78, 0x1E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x1E, 0x00, 0x1C,
  0x07, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0xF0,
  0x00, 0x78, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x78, 0x00, 0x0E, 0x03,
  0xC3, 0xC0, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x03, 0xC0, 0xF1, 0xE1, 0xFC,
  0x1E, 0x07, 0x8F, 0x1F, 0xF0, 0xF0, 0x78, 0xF1, 0xFF, 0xC7, 0x83, 0xC7,
  0x8F, 0x1E, 0x1E, 0x1E, 0x3C, 0xF0, 0x78, 0xFF, 0xE3, 0xC7, 0x83, 0xC3,
  0xFF, 0x1E, 0x3C, 0x1E, 0x0F, 0xF1, 0xE1, 0xE0, 0x78, 0x3E, 0x0F, 0x0F,
  0x03, 0xC0, 0x00, 0x78, 0xF0, 0x1E, 0x00, 0x07, 0x87, 0x80, 0xF0, 0x00,
  0x3C, 0x3C, 0x07, 0x80, 0x03, 0xC1, 0xE0, 0x3C, 0x00, 0x1E, 0x0F, 0x01,
  0xE0, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x78,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x1E, 0x00, 0x3C, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x1E, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x03,
  0xC7, 0x80, 0x0F, 0x00, 0x1F, 0xFC, 0x00, 0x78, 0x00, 0x7F, 0xC0, 0x07,
  0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF0, 0x1E,
  0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x1F, 0x07, 0xEF,
  0xC0, 0x7C, 0x3F, 0x1F, 0x81, 0xF1, 0xF8, 0x3F, 0x07, 0xC7, 0xC0, 0x7C,
  0x1E, 0x1F, 0x01, 0xF8, 0xF8, 0xF8, 0x03, 0xF3, 0xE3, 0xE0, 0x07, 0xDF,
  0x0F, 0x80, 0x0F, 0xFC, 0x3E, 0x00, 0x3F, 0xF0, 0xF8, 0x00, 0x7F, 0x83,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xFF, 0x3E, 0x07, 0xFF,
  0xF8, 0xFC, 0x0F, 0xFF, 0xC1, 0xF8, 0x1F, 0xFC, 0x03, 0xF0, 0x0E, 0x00,
  0x00, 0x00, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7, 0x9E, 0x79, 0xE7, 0x9E, 0x79,
  0xE3, 0x80, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x78, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x01, 0x01, 0xE0, 0x6F, 0x8F, 0x1F, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0x7C, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0x7C, 0x3E, 0x07,
  0xC1, 0xF8, 0x1E, 0x07, 0x80, 0x20, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C,
  0x78, 0x78, 0x78, 0xF0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x7B, 0xFF, 0xFF, 0xFF, 0xFF, 0x88, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFE, 0xFF, 0x03, 0xF0, 0x3E, 0x07, 0xC0,
  0x7E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF9, 0xF0, 0x01,
  0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x0F,
  0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0,
  0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x07,
  0xC1, 0xF0, 0x1F, 0x03, 0xF0, 0x7E, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x7F, 0xF3, 0xF7, 0xDF, 0x9F, 0xFC,
  0x7D, 0xE1, 0xF3, 0x07, 0xC8, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xF9, 0xFF, 0x07,
  0x80, 0x7E, 0x0C, 0x00, 0x7E, 0x08, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFE,
  0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x0F, 0xF1,
  0xE0, 0x07, 0xE3, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0xC0, 0x01, 0xFB, 0xC0, 0x0F, 0xEF, 0xFF, 0xFF, 0x3F, 0xFF, 0xF8,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x05, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1D, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC3, 0xE0, 0x03, 0xC1, 0xF0, 0x01,
  0xE0, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x1F, 0x00,
  0x78, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFE, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF8, 0x20, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x20, 0x00, 0xFC,
  0xF0, 0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x01, 0xFF, 0xF8, 0x07, 0xF8, 0x20, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x7F, 0x03, 0xE7, 0xFF, 0x0F, 0xBF, 0xFE, 0x3F, 0xFF, 0xF8,
  0xFF, 0x87, 0xF3, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xF8,
  0x00, 0xFB, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xF0, 0x03, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF0, 0x7E,
  0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3F, 0x3F, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03,
  0xE3, 0xC0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0xFC,
  0x0F, 0x83, 0xF0, 0x1F, 0xCF, 0xC0, 0x1F, 0xFF, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x07, 0xE3, 0xF8, 0x1F,
  0x03, 0xF8, 0x7C, 0x03, 0xF1, 0xF8, 0x03, 0xF3, 0xE0, 0x03, 0xE7, 0xC0,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xE0, 0x07,
  0xC7, 0xE0, 0x1F, 0x8F, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFC, 0xFE, 0x07, 0xE0, 0x7E, 0x0F,
  0x80, 0x7E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0xFD, 0xF0, 0x01,
  0xFB, 0xE0, 0x07, 0xF7, 0xE0, 0x0F, 0xC7, 0xE0, 0x7F, 0x8F, 0xFF, 0xEF,
  0x0F, 0xFF, 0xDE, 0x0F, 0xFF, 0x3C, 0x0F, 0xF8, 0xF8, 0x03, 0xC1, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x23, 0xEF,
  0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x20, 0x08,
  0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78,
  0x78, 0xF0, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x7C, 0x7F,
  0x9C, 0x03, 0xE4, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0xC0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x01, 0xF0, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x00, 0x3E, 0x3C, 0x01, 0xFF, 0x81,
  0xE3, 0xC0, 0x3F, 0xFC, 0x1E, 0x3C, 0x07, 0xFF, 0xC0, 0xE7, 0x80, 0xF8,
  0x3C, 0x0F, 0x78, 0x1F, 0x03, 0xC0, 0xF7, 0x81, 0xE0, 0x3C, 0x0F, 0x78,
  0x3E, 0x03, 0xC0, 0xFF, 0x03, 0xC0, 0x7C, 0x0F, 0xF0, 0x3C, 0x07, 0xC0,
  0xFF, 0x03, 0xC0, 0x7C, 0x0F, 0xF0, 0x3C, 0x07, 0xC0, 0xFF, 0x03, 0xC0,
  0x78, 0x0F, 0xF0, 0x3C, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x78, 0x0F, 0xF0,
  0x3C, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0x81,
  0xEF, 0x03, 0xC0, 0xFC, 0x1E, 0xF0, 0x3E, 0x0F, 0xC1, 0xEF, 0x81, 0xF1,
  0xDE, 0x3C, 0x78, 0x1F, 0xFD, 0xFF, 0xC7, 0x80, 0xFF, 0x8F, 0xF8, 0x78,
  0x07, 0xF0, 0x7F, 0x07, 0xC0, 0x08, 0x00, 0x80, 0x3C, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x02, 0x00, 0x03,
  0xF0, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x1E,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x3C,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3C, 0x00,
  0x0F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E,
  0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xF8, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0x80, 0x3F, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0,
  0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00,
  0xFC, 0xF8, 0x03, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7E,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xEF, 0x80,
  0x7F, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xE7, 0xF0, 0x7F, 0x80, 0x30, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x30,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xD0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xF8, 0x3E, 0x00, 0x7F, 0x0F,
  0x80, 0x0F, 0xE3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x0F,
  0xE0, 0xF8, 0x3F, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xBF, 0xE0, 0x7F, 0x00, 0x1E, 0x0F, 0xE0, 0x00,
  0x41, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x1F,
  0x80, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x0F, 0xE0, 0x01, 0xF0, 0x7F, 0x80,
  0x3F, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF8, 0xFE, 0xFF,
  0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0x80, 0xF8,
  0x1F, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFB,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFE,
  0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x7F,
  0xBC, 0x00, 0x01, 0xEF, 0xF7, 0xC0, 0x00, 0x7D, 0xFE, 0xF8, 0x00, 0x0F,
  0x3F, 0xCF, 0x00, 0x01, 0xE7, 0xF9, 0xF0, 0x00, 0x7C, 0xFF, 0x3E, 0x00,
  0x0F, 0x3F, 0xE3, 0xC0, 0x01, 0xE7, 0xFC, 0x78, 0x00, 0x7C, 0xFF, 0x8F,
  0x80, 0x0F, 0x9F, 0xF0, 0xF0, 0x01, 0xE3, 0xFE, 0x1E, 0x00, 0x3C, 0x7F,
  0xC3, 0xE0, 0x0F, 0x8F, 0xF8, 0x7C, 0x01, 0xE1, 0xFF, 0x07, 0x80, 0x3C,
  0x3F, 0xE0, 0xF8, 0x0F, 0x87, 0xFC, 0x1F, 0x01, 0xE0, 0xFF, 0x81, 0xE0,
  0x3C, 0x1F, 0xF0, 0x3E, 0x0F, 0x83, 0xFE, 0x07, 0xC1, 0xE0, 0x7F, 0xC0,
  0x78, 0x3C, 0x0F, 0xF8, 0x0F, 0x8F, 0x81, 0xFF, 0x01, 0xF1, 0xE0, 0x3F,
  0xE0, 0x1E, 0x3C, 0x07, 0xFC, 0x03, 0xCF, 0x80, 0xFF, 0x80, 0x7D, 0xF0,
  0x1F, 0xF0, 0x07, 0xBC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x07, 0xF0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x1F,
  0xF0, 0x01, 0xF0, 0x03, 0xE0, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xC0, 0x03, 0xFE,
  0xFC, 0x00, 0x7F, 0xCF, 0x80, 0x0F, 0xF9, 0xF0, 0x01, 0xFF, 0x1F, 0x00,
  0x3F, 0xE3, 0xE0, 0x07, 0xFC, 0x3E, 0x00, 0xFF, 0x87, 0xC0, 0x1F, 0xF0,
  0x7C, 0x03, 0xFE, 0x0F, 0x80, 0x7F, 0xC0, 0xF8, 0x0F, 0xF8, 0x1F, 0x01,
  0xFF, 0x01, 0xF0, 0x3F, 0xE0, 0x3E, 0x07, 0xFC, 0x03, 0xE0, 0xFF, 0x80,
  0x7C, 0x1F, 0xF0, 0x07, 0xC3, 0xFE, 0x00, 0xF8, 0x7F, 0xC0, 0x0F, 0x8F,
  0xF8, 0x01, 0xF1, 0xFF, 0x00, 0x1F, 0x3F, 0xE0, 0x03, 0xE7, 0xFC, 0x00,
  0x3E, 0xFF, 0x80, 0x07, 0xDF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E,
  0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0xFF, 0x7C, 0x01, 0xFB, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFD, 0xF0, 0x0F, 0xEF, 0x8F,
  0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x3F, 0x80, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0xF0,
  0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8,
  0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x3F, 0x00,
  0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0,
  0xF8, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0,
  0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0xFE, 0x01, 0xC7, 0xE0, 0x01, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0xC0, 0x01, 0xFB, 0xF0, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xF8, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7,
  0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1E,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x0F, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xE7, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xBC, 0x00, 0x7C, 0x3E,
  0x00, 0x3D, 0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0x07, 0xC0,
  0x0F, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xFB, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xCF, 0x00, 0x7C, 0x0F, 0x80, 0x3C, 0x78, 0x03, 0xE0, 0x3E, 0x01, 0xE3,
  0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x78,
  0x0F, 0x80, 0x7C, 0x07, 0xC3, 0xC0, 0x7C, 0x01, 0xF0, 0x3C, 0x1E, 0x03,
  0xE0, 0x0F, 0x81, 0xE0, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0x80, 0xF0, 0x7C, 0x00,
  0x7C, 0x3C, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xE0, 0x3E, 0x1E, 0x00, 0x1F,
  0x1F, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x07, 0x8F, 0x80, 0x03, 0xC7,
  0x80, 0x3C, 0x7C, 0x00, 0x1F, 0x3C, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xE0,
  0x0F, 0x9E, 0x00, 0x07, 0xDF, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x80, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00, 0x7B,
  0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE1,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xC0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xDF, 0x00,
  0x03, 0xE7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0,
  0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x03,
  0xC0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x00, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xF0,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0xF8, 0xFE, 0x06, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x0F, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF9,
  0xFC, 0x07, 0xDF, 0x80, 0x3E, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xDF,
  0x00, 0xFE, 0xF8, 0x0F, 0xF7, 0xF1, 0xFF, 0x9F, 0xFF, 0x3C, 0x7F, 0xF1,
  0xE1, 0xFE, 0x0F, 0x01, 0x80, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xC0, 0x1F, 0x1F, 0xF0, 0x3E, 0x7F,
  0xF8, 0x7D, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1, 0xFE, 0x03, 0xF3, 0xF8, 0x03,
  0xE7, 0xE0, 0x07, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF7, 0xE0,
  0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0xBF, 0x80, 0x3E, 0x7F, 0x80,
  0xFC, 0xFF, 0xFF, 0xF1, 0xE7, 0xFF, 0xC3, 0xC7, 0xFF, 0x07, 0x87, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFE, 0x1F, 0xFF, 0x8F, 0xC0, 0x23, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFC, 0x0F, 0xFC, 0x00, 0x50, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x3C, 0x1F, 0xF0, 0xF0, 0xFF, 0xF3,
  0xC7, 0xFF, 0xEF, 0x3F, 0xFF, 0xBC, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF,
  0x00, 0x3F, 0x7C, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xF0, 0x03, 0xF7, 0xE0, 0x0F, 0xCF, 0xC0, 0xFF, 0x3F, 0xFF, 0xBC,
  0x7F, 0xFC, 0xF0, 0xFF, 0xF3, 0xC1, 0xFF, 0x0F, 0x00, 0xE0, 0x00, 0x00,
  0x30, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xF8, 0xFE,
  0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x3E, 0x7C, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x04, 0x7F, 0x00,
  0x61, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0x18, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7C,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0xFE, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xF0, 0xF0, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x3F,
  0xFF, 0xBC, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x00, 0x3F, 0x7C, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03, 0xF7,
  0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0xFF, 0xBC, 0x7F, 0xFC, 0xF0, 0xFF,
  0xE3, 0xC1, 0xFF, 0x0F, 0x00, 0x40, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x70, 0x01, 0xF9, 0xF8, 0x3F, 0xC7, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x81, 0xC0, 0x7C, 0x7F, 0xC3, 0xE7, 0xFF, 0x9F, 0x7F,
  0xFC, 0xFF, 0xFF, 0xF7, 0xF8, 0x0F, 0xBF, 0x80, 0x7F, 0xF8, 0x01, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xF0, 0x77, 0xFF, 0xFF, 0xFD, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xFC, 0xFD, 0xFF, 0xBF, 0xE7, 0xF8, 0x7E,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0xF8, 0x07, 0xC7, 0xC0, 0x7C,
  0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C, 0x3E, 0x03, 0xE3,
  0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x80, 0x3E, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0xBE, 0x03, 0xF9, 0xF0, 0x1F, 0x87,
  0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x0F,
  0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0xF8, 0x03,
  0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x0F, 0x0F, 0xF8, 0x1F, 0xF0, 0xF1, 0xFF,
  0xC3, 0xFF, 0xCF, 0x3F, 0xFE, 0x7F, 0xFC, 0xFF, 0xFF, 0xEF, 0xFF, 0xEF,
  0xF0, 0x3F, 0xE0, 0x7E, 0xFE, 0x01, 0xFC, 0x03, 0xEF, 0xC0, 0x1F, 0xC0,
  0x1F, 0xFC, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x00,
  0xF8, 0x01, 0xFF, 0x80, 0x0F, 0x80, 0x1F, 0xF8, 0x00, 0xF8, 0x01, 0xFF,
  0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00,
  0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00,
  0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x07, 0x87, 0xFC, 0x3C, 0x7F, 0xF9, 0xE7, 0xFF, 0xEF,
  0xFF, 0xFF, 0x7F, 0x80, 0xFB, 0xF8, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0x00, 0x38, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFE, 0xFF, 0x07, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7E,
  0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF8, 0x0F, 0x81, 0xFF, 0xFF,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x30, 0x00,
  0x00, 0x1E, 0x01, 0xE1, 0xFF, 0x03, 0xC7, 0xFF, 0x87, 0x9F, 0xFF, 0x8F,
  0xFE, 0xFF, 0x1F, 0xE0, 0x3F, 0x3F, 0x80, 0x3E, 0x7E, 0x00, 0x7E, 0xFC,
  0x00, 0x7D, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D,
  0xFC, 0x01, 0xFB, 0xF8, 0x03, 0xE7, 0xF8, 0x0F, 0xCF, 0xFF, 0xFF, 0x1F,
  0x7F, 0xFC, 0x3E, 0x7F, 0xF0, 0x7C, 0x7F, 0xC0, 0xF8, 0x08, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0xF0, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF,
  0x3F, 0xFF, 0xBC, 0xFC, 0x0F, 0xF7, 0xE0, 0x1F, 0xDF, 0x00, 0x3F, 0x7C,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x03,
  0xF7, 0xE0, 0x1F, 0xCF, 0xC0, 0xFF, 0x3F, 0xFF, 0xBC, 0x7F, 0xFC, 0xF0,
  0xFF, 0xE3, 0xC1, 0xFF, 0x0F, 0x00, 0x40, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3D, 0xE1, 0xFF,
  0xC7, 0xFF, 0x9F, 0xFF, 0x3F, 0xDE, 0xF8, 0x7F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0xC1, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0x0F, 0x9F, 0x00, 0x4F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x3E, 0xFF,
  0xFF, 0xBF, 0xFF, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x1F, 0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC0, 0x08,
  0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFB, 0xE0, 0x1F, 0xDF, 0x81, 0xFE,
  0xFF, 0xFE, 0xF3, 0xFF, 0xE7, 0x8F, 0xFE, 0x3C, 0x3F, 0xE1, 0xE0, 0x18,
  0x00, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x00,
  0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x83,
  0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC7,
  0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF,
  0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x01,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xBE, 0x00, 0x7E, 0x00, 0x7D,
  0xF0, 0x03, 0xF8, 0x03, 0xE7, 0x80, 0x3F, 0xC0, 0x1F, 0x3E, 0x01, 0xFE,
  0x00, 0xF1, 0xF0, 0x0F, 0xF0, 0x0F, 0x8F, 0x80, 0x7B, 0xC0, 0x7C, 0x3C,
  0x07, 0xDE, 0x03, 0xE1, 0xF0, 0x3C, 0xF0, 0x1E, 0x0F, 0x81, 0xE7, 0x80,
  0xF0, 0x7C, 0x0F, 0x3E, 0x0F, 0x81, 0xE0, 0xF8, 0xF0, 0x7C, 0x0F, 0x07,
  0x87, 0x83, 0xC0, 0x7C, 0x3C, 0x3C, 0x1E, 0x03, 0xE1, 0xE1, 0xE1, 0xF0,
  0x1F, 0x1F, 0x0F, 0x8F, 0x80, 0x78, 0xF0, 0x3C, 0x7C, 0x03, 0xC7, 0x81,
  0xE3, 0xC0, 0x1F, 0x3C, 0x0F, 0x1E, 0x00, 0xF9, 0xE0, 0x7D, 0xF0, 0x03,
  0xDF, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x07, 0xFC, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x7D, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x01, 0xF0,
  0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8,
  0x7C, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x1F,
  0x0F, 0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xC0,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x7C,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF0,
  0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x07, 0xC3, 0xE0,
  0x07, 0xC3, 0xE0, 0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0xC0,
  0x03, 0xE7, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x47, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x80,
  0x0F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x80,
  0xFF, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x0F,
  0xE0, 0x1F, 0xF0, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xA0, 0x01, 0xFE,
  0x00,
};

const GFXglyph NotoSans_Condensed_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 42, 14, 4, -41 },
  { 33, 16, 15, 23, 3, -41 },
  { 63, 28, 41, 30, 1, -41 },
  { 207, 22, 47, 27, 3, -44 },
  { 337, 37, 43, 41, 2, -42 },
  { 536, 30, 43, 32, 2, -42 },
  { 698, 6, 15, 12, 3, -41 },
  { 710, 12, 51, 17, 3, -42 },
  { 787, 12, 51, 17, 2, -42 },
  { 864, 21, 21, 26, 2, -44 },
  { 920, 23, 27, 27, 2, -34 },
  { 998, 8, 15, 14, 2, -7 },
  { 1013, 13, 5, 17, 2, -18 },
  { 1022, 6, 8, 14, 4, -7 },
  { 1028, 20, 42, 22, 1, -42 },
  { 1133, 23, 43, 27, 2, -42 },
  { 1257, 14, 41, 27, 4, -41 },
  { 1329, 23, 42, 27, 2, -42 },
  { 1450, 22, 43, 27, 2, -42 },
  { 1569, 25, 42, 27, 1, -42 },
  { 1701, 22, 42, 27, 3, -41 },
  { 1817, 22, 43, 27, 3, -42 },
  { 1936, 23, 41, 27, 2, -41 },
  { 2054, 23, 43, 27, 2, -42 },
  { 2178, 23, 43, 27, 2, -42 },
  { 2302, 6, 33, 14, 4, -32 },
  { 2327, 8, 40, 14, 2, -32 },
  { 2367, 23, 27, 27, 2, -34 },
  { 2445, 23, 16, 27, 2, -28 },
  { 2491, 23, 27, 27, 2, -34 },
  { 2569, 18, 43, 20, 1, -42 },
  { 2666, 36, 47, 42, 3, -42 },
  { 2878, 29, 41, 29, 0, -41 },
  { 3027, 23, 41, 31, 5, -41 },
  { 3145, 25, 43, 29, 3, -42 },
  { 3280, 26, 41, 34, 5, -41 },
  { 3414, 18, 41, 26, 5, -41 },
  { 3507, 18, 41, 24, 5, -41 },
  { 3600, 28, 43, 35, 3, -42 },
  { 3751, 25, 41, 35, 5, -41 },
  { 3880, 13, 41, 17, 2, -41 },
  { 3947, 12, 52, 14, -3, -41 },
  { 4025, 24, 41, 29, 5, -41 },
  { 4148, 18, 41, 24, 5, -41 },
  { 4241, 35, 41, 45, 5, -41 },
  { 4421, 27, 41, 36, 5, -41 },
  { 4560, 30, 43, 36, 3, -42 },
  { 4722, 21, 41, 29, 5, -41 },
  { 4830, 30, 52, 36, 3, -42 },
  { 5025, 24, 41, 30, 5, -41 },
  { 5148, 22, 43, 26, 2, -42 },
  { 5267, 23, 41, 25, 1, -41 },
  { 5385, 26, 42, 34, 4, -41 },
  { 5522, 28, 41, 28, 0, -41 },
  { 5666, 45, 41, 45, 0, -41 },
  { 5897, 26, 41, 26, 0, -41 },
  { 6031, 26, 41, 26, 0, -41 },
  { 6165, 21, 41, 25, 2, -41 },
  { 6273, 13, 51, 18, 4, -42 },
  { 6356, 20, 42, 22, 1, -42 },
  { 6461, 12, 51, 18, 2, -42 },
  { 6538, 26, 23, 28, 1, -41 },
  { 6613, 26, 4, 25, 0, 5 },
  { 6626, 11, 9, 16, 2, -44 },
  { 6639, 21, 33, 27, 2, -32 },
  { 6726, 23, 45, 29, 4, -44 },
  { 6856, 18, 33, 22, 3, -32 },
  { 6931, 22, 45, 29, 3, -44 },
  { 7055, 21, 33, 27, 3, -32 },
  { 7142, 17, 44, 16, 1, -44 },
  { 7236, 22, 46, 29, 3, -32 },
  { 7363, 21, 44, 29, 4, -44 },
  { 7479, 5, 43, 13, 4, -43 },
  { 7506, 11, 57, 13, -2, -43 },
  { 7585, 21, 44, 25, 4, -44 },
  { 7701, 5, 44, 13, 4, -44 },
  { 7729, 36, 32, 44, 4, -32 },
  { 7873, 21, 32, 29, 4, -32 },
  { 7957, 23, 33, 29, 3, -32 },
  { 8052, 23, 46, 29, 4, -32 },
  { 8185, 22, 46, 29, 3, -32 },
  { 8312, 15, 32, 20, 4, -32 },
  { 8372, 18, 33, 22, 2, -32 },
  { 8447, 15, 39, 17, 1, -38 },
  { 8521, 21, 32, 29, 4, -31 },
  { 8605, 24, 31, 24, 0, -31 },
  { 8698, 37, 31, 38, 1, -31 },
  { 8842, 22, 31, 24, 1, -31 },
  { 8928, 24, 45, 24, 0, -31 },
  { 9063, 17, 31, 20, 2, -31 },
  { 9129, 17, 51, 21, 2, -42 },
  { 9238, 4, 58, 26, 11, -44 },
  { 9267, 17, 51, 21, 2, -42 },
  { 9376, 23, 7, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Regular58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular58pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_CONDENSED_REGULAR58PT7B_H_
