#ifndef _NOTOSANS_CONDENSED_REGULAR57PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE0,
  0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0xFC, 0x3F, 0x7C,
  0x3F, 0x7C, 0x1F, 0x7C, 0x1F, 0x7C, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xE0,
  0x38, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0x1E, 0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x03, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x07, 0x80,
  0x03, 0xC0, 0xF0, 0x1F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x01, 0xE0, 0x78, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0x80, 0xE0, 0x00, 0x70, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x7F, 0xFF, 0xF3, 0xE3, 0x83,
  0x3E, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x03, 0xC1,
  0xC0, 0x1E, 0x0E, 0x00, 0xF8, 0x70, 0x07, 0xC3, 0x80, 0x1F, 0x9C, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xBF, 0x80, 0x1C, 0x7E, 0x00, 0xE1, 0xF0,
  0x07, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00, 0x70,
  0x78, 0x03, 0x87, 0xE0, 0x1C, 0x7D, 0xF0, 0xEF, 0xEF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x07,
  0xE0, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x0F, 0x00, 0x1F, 0xF8, 0x00, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x07, 0x83, 0xC0,
  0x1E, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0x07, 0x83, 0xC0, 0x3C, 0x00, 0x78,
  0x1E, 0x07, 0x80, 0x07, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x07, 0x00,
  0x0F, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x1E, 0x0F, 0x00, 0x0F, 0x01, 0xE1,
  0xE0, 0x00, 0xF0, 0x1E, 0x1E, 0x00, 0x07, 0x01, 0xE3, 0xC0, 0x00, 0x78,
  0x1E, 0x3C, 0x1F, 0x07, 0x83, 0xC3, 0xC7, 0xF8, 0x78, 0x3C, 0x78, 0xFF,
  0xC7, 0x83, 0xC7, 0x8F, 0xFE, 0x3C, 0x3C, 0xF1, 0xE1, 0xE3, 0xEF, 0x8F,
  0x1E, 0x1E, 0x1F, 0xF8, 0xF1, 0xC0, 0xF1, 0xFF, 0x1E, 0x3C, 0x0F, 0x07,
  0xE1, 0xE3, 0xC0, 0xF0, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0xF0, 0x00, 0x38, 0x3C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x78,
  0x3C, 0x0F, 0x00, 0x0F, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x0F, 0x00,
  0x1E, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0xF0, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x01, 0xE1, 0xE0, 0x07, 0x80,
  0x1F, 0x3E, 0x00, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0x80, 0x07, 0xFC, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0xC0,
  0x78, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x03, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x07, 0xC1, 0xFB, 0xF0, 0x1F, 0x0F, 0xC7,
  0xC0, 0x78, 0x7E, 0x1F, 0x83, 0xE1, 0xF0, 0x3F, 0x0F, 0x87, 0xC0, 0x7C,
  0x3E, 0x3E, 0x00, 0xF9, 0xF0, 0xF8, 0x03, 0xF7, 0xC3, 0xE0, 0x07, 0xFF,
  0x0F, 0x80, 0x0F, 0xF8, 0x3E, 0x00, 0x1F, 0xE0, 0xF8, 0x00, 0x7F, 0x03,
  0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0xE0, 0x7F,
  0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xDF, 0x81, 0xFF, 0xFC, 0x3F, 0x03, 0xFF,
  0xE0, 0x7C, 0x07, 0xFE, 0x01, 0xFC, 0x01, 0xC0, 0x00, 0x00, 0xFD, 0xF7,
  0xDF, 0x7D, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1F, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0xCF, 0xCE,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x01, 0xEF, 0x00, 0x1F, 0x7C, 0x00, 0xF1, 0xF0, 0x0F, 0x8F,
  0x80, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x0C, 0x06, 0x00, 0x20, 0x20, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x3E, 0x3E,
  0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0x78, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0x8C, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8,
  0x1F, 0x87, 0xE0, 0x7C, 0x07, 0xC3, 0xF0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E,
  0x00, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x1E, 0x3E, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xE0,
  0x1F, 0x87, 0xC0, 0x7C, 0x1F, 0x83, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0x7C, 0x03,
  0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xCF, 0xDF, 0x7E,
  0x7F, 0xF1, 0xF7, 0x87, 0xC8, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xFE, 0x00,
  0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0x7E, 0x07, 0xF0, 0xE0,
  0x0F, 0xC1, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0xFF,
  0xF8, 0x7E, 0x07, 0xF0, 0xE0, 0x07, 0xC2, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xA0, 0x00, 0x7E, 0xF0, 0x07, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1, 0xE0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7C, 0x01,
  0xE0, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1F, 0x00,
  0x1E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0x81, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFD, 0x00, 0x0F, 0xCE, 0x00, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x04, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFE, 0x02, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x07, 0x00, 0xF8, 0xFF, 0x87, 0xDF, 0xFE, 0x3C, 0xFF, 0xF9,
  0xEF, 0xFF, 0xCF, 0xE0, 0x3F, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x7C, 0x00,
  0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x7C, 0x7C, 0x03, 0xE3, 0xF0, 0x3E, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8,
  0x3F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x0F, 0xC7, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xF8, 0x03, 0xF3, 0xF8, 0x0F, 0xC3, 0xF8, 0x3E, 0x01, 0xF8, 0xFC,
  0x01, 0xF1, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xF0, 0x1F, 0x87, 0xFD, 0xFF,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0x20, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0x87, 0xE0, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00,
  0xF9, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xF0,
  0x01, 0xF7, 0xC0, 0x0F, 0xDF, 0x80, 0x3F, 0x3E, 0x01, 0xFC, 0xFE, 0x1F,
  0xF1, 0xFF, 0xF7, 0xC3, 0xFF, 0xDF, 0x07, 0xFE, 0x7C, 0x07, 0xE1, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFF,
  0xFF, 0x88, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0x88, 0x1E, 0x3F, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x3F, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C, 0x78, 0x78, 0xF0, 0xF0, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFC, 0x78,
  0x1F, 0x98, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x03, 0xC3, 0xE0, 0x0F, 0xE0, 0x3C, 0x3C, 0x03, 0xFF, 0x83, 0xC3,
  0xC0, 0x7F, 0xF8, 0x1E, 0x78, 0x0F, 0xCF, 0x81, 0xE7, 0x81, 0xF0, 0x78,
  0x1E, 0x78, 0x1E, 0x07, 0x81, 0xE7, 0x83, 0xE0, 0x78, 0x0E, 0xF0, 0x3C,
  0x07, 0x80, 0xEF, 0x03, 0xC0, 0x78, 0x0F, 0xF0, 0x3C, 0x07, 0x80, 0xFF,
  0x07, 0xC0, 0x78, 0x0F, 0xF0, 0x78, 0x07, 0x80, 0xEF, 0x07, 0x80, 0x78,
  0x0E, 0xF0, 0x78, 0x07, 0x81, 0xEF, 0x07, 0x80, 0x78, 0x1E, 0xF0, 0x7C,
  0x0F, 0x81, 0xEF, 0x03, 0xC0, 0xF8, 0x1E, 0xF0, 0x3C, 0x0F, 0x81, 0xCF,
  0x03, 0xC1, 0xF8, 0x3C, 0xF0, 0x3E, 0x1D, 0xC7, 0xCF, 0x81, 0xFF, 0x9F,
  0xF8, 0x78, 0x0F, 0xF9, 0xFF, 0x07, 0x80, 0x7F, 0x0F, 0xE0, 0x7C, 0x01,
  0x80, 0x10, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x20, 0x00, 0x7F, 0x00, 0x1C, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x03, 0xCF, 0x80, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x78, 0x7C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3E,
  0x0F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x0F,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xF8, 0xFF, 0xF8, 0x01,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x03, 0xFF, 0x1E,
  0x00, 0x7F, 0x3C, 0x00, 0x7E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xFD, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00,
  0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0xFC, 0xF0, 0x03, 0xF1, 0xE0, 0x3F,
  0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x3C, 0x00, 0xFE, 0x78, 0x00, 0xFC, 0xF0, 0x00, 0xFD, 0xE0, 0x00, 0xFB,
  0xC0, 0x01, 0xF7, 0x80, 0x03, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0,
  0x03, 0xF7, 0x80, 0x0F, 0xCF, 0x00, 0xFF, 0x9F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF8, 0x1E, 0x0F, 0xE0,
  0x06, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x0E, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0x80, 0x3F, 0xC3, 0xC0, 0x07, 0xF1, 0xE0,
  0x01, 0xF8, 0xF0, 0x00, 0x7E, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xDE,
  0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xFB, 0xC0,
  0x00, 0xFD, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0x78, 0x00, 0x7E, 0x3C,
  0x00, 0x7F, 0x1E, 0x00, 0x7F, 0x0F, 0x03, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x07, 0xC0, 0xFE, 0x00,
  0x0C, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x07, 0xF8,
  0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7F, 0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x03, 0xEE, 0xFE, 0xFF, 0xEF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF0,
  0x00, 0x7E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0,
  0x0F, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3F, 0x00, 0xF0,
  0x3E, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0xFC, 0x00, 0xF0, 0xF8, 0x00, 0xF1,
  0xF0, 0x00, 0xF3, 0xF0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xF0, 0x00, 0xF7,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0x7E, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x1F, 0x00, 0xF0,
  0x1F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xC0, 0xF0,
  0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF8, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF7, 0x80,
  0x00, 0x7B, 0xFE, 0xF0, 0x00, 0x0F, 0x7F, 0xDF, 0x00, 0x03, 0xEF, 0xF9,
  0xE0, 0x00, 0x79, 0xFF, 0x3C, 0x00, 0x0F, 0x3F, 0xE7, 0xC0, 0x03, 0xE7,
  0xFC, 0x78, 0x00, 0x78, 0xFF, 0x8F, 0x00, 0x0F, 0x1F, 0xF1, 0xF0, 0x01,
  0xE3, 0xFE, 0x1E, 0x00, 0x78, 0x7F, 0xC3, 0xC0, 0x0F, 0x0F, 0xF8, 0x7C,
  0x01, 0xE1, 0xFF, 0x0F, 0x80, 0x7C, 0x3F, 0xE0, 0xF0, 0x0F, 0x07, 0xFC,
  0x1F, 0x01, 0xE0, 0xFF, 0x83, 0xE0, 0x7C, 0x1F, 0xF0, 0x3C, 0x0F, 0x03,
  0xFE, 0x07, 0x81, 0xE0, 0x7F, 0xC0, 0xF8, 0x7C, 0x0F, 0xF8, 0x0F, 0x0F,
  0x01, 0xFF, 0x01, 0xE1, 0xE0, 0x3F, 0xE0, 0x3E, 0x7C, 0x07, 0xFC, 0x03,
  0xCF, 0x00, 0xFF, 0x80, 0x79, 0xE0, 0x1F, 0xF0, 0x0F, 0xBC, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0xFC,
  0x00, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0xFC,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFD, 0xF0, 0x00, 0xFF, 0x7C, 0x00, 0x3F, 0xCF,
  0x80, 0x0F, 0xF3, 0xE0, 0x03, 0xFC, 0x7C, 0x00, 0xFF, 0x1F, 0x00, 0x3F,
  0xC3, 0xE0, 0x0F, 0xF0, 0xF8, 0x03, 0xFC, 0x1F, 0x00, 0xFF, 0x07, 0xC0,
  0x3F, 0xC0, 0xF8, 0x0F, 0xF0, 0x3E, 0x03, 0xFC, 0x07, 0xC0, 0xFF, 0x01,
  0xF0, 0x3F, 0xC0, 0x3E, 0x0F, 0xF0, 0x0F, 0x83, 0xFC, 0x01, 0xF0, 0xFF,
  0x00, 0x7C, 0x3F, 0xC0, 0x0F, 0x8F, 0xF0, 0x03, 0xE3, 0xFC, 0x00, 0x7C,
  0xFF, 0x00, 0x1F, 0x3F, 0xC0, 0x03, 0xEF, 0xF0, 0x00, 0xFB, 0xFC, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF0, 0x3F, 0x80, 0x1F, 0x80,
  0xFE, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x78,
  0x03, 0xF3, 0xC0, 0x0F, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0xFD,
  0xE0, 0x0F, 0xCF, 0x01, 0xFE, 0x7F, 0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF,
  0xC0, 0xFF, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0x80, 0xFE, 0x03, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1E, 0x00, 0xFE, 0x3C, 0x00, 0xFC, 0x78,
  0x00, 0xF8, 0xF0, 0x01, 0xF9, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0x80,
  0x07, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x78, 0x00,
  0xFC, 0xF0, 0x01, 0xF1, 0xE0, 0x07, 0xE3, 0xC0, 0x1F, 0x87, 0x80, 0xFF,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0xF0, 0x3E, 0x01, 0xE0, 0x7E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0xFC, 0x0F,
  0x00, 0xF8, 0x1E, 0x01, 0xF8, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xF0, 0xF0,
  0x03, 0xE1, 0xE0, 0x07, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0xCF, 0x00,
  0x0F, 0x9E, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0xF0, 0x00,
  0x3E, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC,
  0x3F, 0xC3, 0xF0, 0xFC, 0x00, 0xC7, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0xB0, 0x00, 0xFC, 0xF8, 0x07, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7, 0xE0, 0x07, 0xE3,
  0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF1, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x7B, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x80, 0x01, 0xF7,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xE3, 0xC0,
  0x01, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xDE,
  0x00, 0x7C, 0x1F, 0x00, 0x3D, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xDE, 0x00,
  0x7C, 0x1F, 0x00, 0x79, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0x9F, 0x00, 0xF8,
  0x0F, 0x00, 0x78, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x0F, 0x80, 0xF0, 0x0F, 0x80,
  0xF0, 0xF8, 0x1F, 0x00, 0x78, 0x1F, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xF0,
  0x78, 0x1F, 0x00, 0x7C, 0x1E, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x7C,
  0x3E, 0x00, 0x3C, 0x1E, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xE0, 0x3C, 0x3E,
  0x00, 0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x00,
  0x3E, 0x3C, 0x01, 0xE7, 0xC0, 0x01, 0xE7, 0xC0, 0x1E, 0x7C, 0x00, 0x1F,
  0x7C, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x00, 0x1F, 0x78,
  0x01, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3,
  0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF1, 0xE0, 0x00,
  0x3C, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03,
  0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF9,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xE0,
  0x00, 0xF9, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x87,
  0x80, 0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x0F,
  0xC1, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x01,
  0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0E, 0x07, 0xE0,
  0x80, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0x80, 0xF7, 0xE0, 0x0F, 0x7C, 0x00, 0xF7, 0xC0,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0x7C, 0x07, 0xF7, 0xF1, 0xEF, 0x3F, 0xFE, 0xF1,
  0xFF, 0xCF, 0x0F, 0xF0, 0x70, 0x38, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x7F, 0x03, 0xE7, 0xFF, 0x0F, 0xBF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0x83, 0xF3, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xBF,
  0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3E, 0xFC, 0x00,
  0xFB, 0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0x3D, 0xFB, 0xFC, 0xF3, 0xFF, 0xE3,
  0xC7, 0xFF, 0x0F, 0x0F, 0xF8, 0x00, 0x02, 0x00, 0x01, 0xFF, 0x01, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0x83, 0x0F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x08, 0xFF, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x01, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xF8, 0x7C, 0x3F, 0xF9, 0xF1, 0xFF,
  0xF7, 0xC7, 0xFF, 0xFF, 0x3F, 0x07, 0xFD, 0xF8, 0x07, 0xF7, 0xC0, 0x1F,
  0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F, 0x7C,
  0x00, 0xFD, 0xF8, 0x07, 0xF3, 0xE0, 0x3F, 0xCF, 0xF7, 0xEF, 0x1F, 0xFF,
  0x3C, 0x3F, 0xF8, 0xF0, 0x7F, 0xC3, 0xC0, 0x30, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01,
  0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x78, 0x00, 0xF7, 0xC0, 0x07, 0xBE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x8F, 0xC0, 0x1C, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x18, 0x00,
  0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0x70, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0xFF, 0xE1, 0xFF, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x3C, 0x1F, 0xF8,
  0xF1, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x3F, 0x07, 0xFD, 0xF8, 0x07, 0xF7,
  0xC0, 0x1F, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xF3, 0xF0, 0x3F, 0xCF, 0xFF, 0xFF,
  0x1F, 0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x7F, 0xC7, 0xC0, 0x10, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE4, 0x00, 0x1F, 0x9C, 0x00, 0xFC, 0x7F, 0xBF, 0xF1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x87, 0xF0, 0x7C, 0xFF, 0xE3,
  0xEF, 0xFF, 0x9F, 0xFF, 0xFC, 0xF7, 0x83, 0xF7, 0xF0, 0x0F, 0xBF, 0x00,
  0x7D, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3E, 0x77, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x81, 0xF0, 0x7C, 0x1F,
  0x07, 0xC1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07,
  0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0,
  0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xFB, 0xFE,
  0xFF, 0xBF, 0xCF, 0xE1, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x9F, 0x00, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x87, 0xC0,
  0x7C, 0x3C, 0x03, 0xE3, 0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xE0, 0x07, 0xDF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x7F, 0x3E, 0x03,
  0xF1, 0xF0, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC0, 0xF8, 0x3E, 0x07,
  0xC1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0xF8, 0x03, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF0, 0x7F, 0x00, 0xFE, 0x1E, 0x3F, 0xF0, 0x7F, 0xE3, 0xCF, 0xFF,
  0x1F, 0xFE, 0x7B, 0xFF, 0xF7, 0xFF, 0xEF, 0x70, 0x7E, 0xF0, 0xFD, 0xFC,
  0x07, 0xF8, 0x0F, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x1F,
  0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xC0,
  0x07, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF0, 0x03,
  0xE0, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xF8,
  0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x07,
  0xFC, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF0, 0x03, 0xE0,
  0x03, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x0F, 0x80, 0x0F, 0xF8, 0x01,
  0xF0, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x07, 0xFC,
  0x00, 0xF8, 0x00, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xF0, 0x03, 0xE0, 0x03,
  0xFE, 0x00, 0x7C, 0x00, 0x78, 0xF0, 0x7F, 0x07, 0x8F, 0xFE, 0x3C, 0xFF,
  0xF9, 0xEF, 0xFF, 0xCF, 0x78, 0x3F, 0x7F, 0x00, 0xFB, 0xF0, 0x07, 0xDF,
  0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF8, 0x3F, 0x03, 0xF0, 0xF8, 0x07, 0xC7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0xF8,
  0xF8, 0x07, 0xE3, 0xF0, 0x3F, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0C, 0x00, 0xF0, 0x7F, 0x03, 0xC7, 0xFF,
  0x0F, 0x3F, 0xFE, 0x3D, 0xFF, 0xFC, 0xF7, 0x83, 0xF3, 0xF8, 0x07, 0xEF,
  0xC0, 0x0F, 0xBF, 0x00, 0x3E, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3E, 0xFC, 0x00, 0xFB, 0xF8, 0x07, 0xEF, 0xF0, 0x3F, 0x3F, 0xFF, 0xFC,
  0xFB, 0xFF, 0xE3, 0xE7, 0xFF, 0x0F, 0x8F, 0xF8, 0x3E, 0x02, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x3C, 0x3F, 0xF8, 0xF1, 0xFF, 0xF3, 0xC7, 0xFF, 0xEF, 0x3F, 0x07,
  0xFD, 0xF8, 0x07, 0xF7, 0xC0, 0x1F, 0xDF, 0x00, 0x3F, 0xF8, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0x7C, 0x00, 0xFD, 0xF8, 0x07, 0xF3, 0xF0,
  0x3F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x7F, 0xC7,
  0xC0, 0x10, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0xF0, 0x7F, 0xE1, 0xFB, 0xC7, 0xF7, 0x9F, 0xEF, 0x7F,
  0xDE, 0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7E,
  0x07, 0x3E, 0x00, 0x4F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x03,
  0xEE, 0x01, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0x3F, 0xFF, 0x83, 0xFF, 0x80,
  0x06, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0xFE, 0x7F, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x7F, 0xF0, 0x7F, 0xE0,
  0x7F, 0xC0, 0x18, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F,
  0xDF, 0x81, 0xFE, 0xFF, 0xFF, 0xF3, 0xFF, 0xE7, 0x8F, 0xFE, 0x3C, 0x3F,
  0xE1, 0xE0, 0x18, 0x00, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0,
  0xF8, 0x0F, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x78, 0x03,
  0xC1, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x1E,
  0x3E, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7,
  0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x01,
  0xF0, 0x01, 0xFF, 0x80, 0x1F, 0x80, 0x1F, 0xF8, 0x01, 0xF8, 0x01, 0xFF,
  0x80, 0x3F, 0x80, 0x1E, 0x78, 0x03, 0xF8, 0x03, 0xE7, 0x80, 0x3F, 0xC0,
  0x3E, 0x7C, 0x03, 0xFC, 0x03, 0xE7, 0xC0, 0x7B, 0xC0, 0x3C, 0x7C, 0x07,
  0xBC, 0x03, 0xC3, 0xC0, 0x79, 0xE0, 0x7C, 0x3E, 0x07, 0x9E, 0x07, 0xC3,
  0xE0, 0x79, 0xE0, 0x78, 0x3E, 0x0F, 0x1E, 0x07, 0x81, 0xE0, 0xF1, 0xF0,
  0xF8, 0x1E, 0x0F, 0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0xF0, 0xF0, 0x1F, 0x1E,
  0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0xF0, 0xF0, 0x0F, 0x1E, 0x0F, 0x9F, 0x00,
  0xF1, 0xE0, 0x79, 0xF0, 0x0F, 0xBE, 0x07, 0x9E, 0x00, 0xFB, 0xC0, 0x79,
  0xE0, 0x07, 0xBC, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x3F, 0xE0, 0x07, 0xBC,
  0x03, 0xFC, 0x00, 0x7B, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7D, 0xF0, 0x03, 0xE7,
  0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0xF8,
  0x3E, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xE1, 0xF0,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7C,
  0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xC7, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x1E, 0x00, 0xF8, 0x3E, 0x01,
  0xF0, 0x7C, 0x03, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3C,
  0x03, 0xE0, 0x78, 0x03, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80,
  0x0F, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F,
  0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x3F, 0xE0, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x7E, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x02, 0x7F, 0xC0, 0x05, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xA0, 0x03, 0xFE, 0x40,
  0x00, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 6, 42, 14, 4, -41 },
  { 33, 16, 15, 22, 3, -41 },
  { 63, 27, 41, 29, 1, -41 },
  { 202, 21, 46, 27, 3, -43 },
  { 323, 36, 42, 41, 2, -41 },
  { 512, 30, 42, 32, 2, -41 },
  { 670, 6, 15, 12, 3, -41 },
  { 682, 12, 50, 17, 3, -41 },
  { 757, 12, 50, 17, 2, -41 },
  { 832, 21, 21, 25, 2, -43 },
  { 888, 23, 27, 27, 2, -34 },
  { 966, 8, 14, 14, 2, -7 },
  { 980, 13, 5, 16, 2, -18 },
  { 989, 6, 8, 14, 4, -7 },
  { 995, 19, 41, 21, 1, -41 },
  { 1093, 22, 42, 27, 2, -41 },
  { 1209, 14, 41, 27, 4, -41 },
  { 1281, 22, 41, 27, 2, -41 },
  { 1394, 22, 42, 27, 2, -41 },
  { 1510, 25, 41, 27, 1, -41 },
  { 1639, 21, 42, 27, 3, -41 },
  { 1750, 21, 42, 27, 3, -41 },
  { 1861, 23, 41, 27, 2, -41 },
  { 1979, 23, 42, 27, 2, -41 },
  { 2100, 22, 42, 27, 2, -41 },
  { 2216, 6, 32, 14, 4, -31 },
  { 2240, 8, 38, 14, 2, -31 },
  { 2278, 23, 26, 27, 2, -33 },
  { 2353, 23, 16, 27, 2, -28 },
  { 2399, 23, 26, 27, 2, -33 },
  { 2474, 18, 42, 20, 1, -41 },
  { 2569, 36, 46, 41, 3, -41 },
  { 2776, 29, 41, 29, 0, -41 },
  { 2925, 23, 41, 30, 5, -41 },
  { 3043, 24, 42, 29, 3, -41 },
  { 3169, 25, 41, 33, 5, -41 },
  { 3298, 18, 41, 26, 5, -41 },
  { 3391, 18, 41, 24, 5, -41 },
  { 3484, 28, 42, 34, 3, -41 },
  { 3631, 24, 41, 34, 5, -41 },
  { 3754, 13, 41, 17, 2, -41 },
  { 3821, 12, 52, 14, -3, -41 },
  { 3899, 24, 41, 28, 5, -41 },
  { 4022, 18, 41, 24, 5, -41 },
  { 4115, 35, 41, 44, 5, -41 },
  { 4295, 26, 41, 36, 5, -41 },
  { 4429, 29, 42, 35, 3, -41 },
  { 4582, 21, 41, 28, 5, -41 },
  { 4690, 29, 51, 35, 3, -41 },
  { 4875, 23, 41, 29, 5, -41 },
  { 4993, 22, 42, 26, 2, -41 },
  { 5109, 23, 41, 25, 1, -41 },
  { 5227, 25, 42, 33, 4, -41 },
  { 5359, 28, 41, 28, 0, -41 },
  { 5503, 44, 41, 45, 0, -41 },
  { 5729, 26, 41, 26, 0, -41 },
  { 5863, 25, 41, 25, 0, -41 },
  { 5992, 21, 41, 24, 2, -41 },
  { 6100, 12, 50, 18, 4, -41 },
  { 6175, 19, 41, 21, 1, -41 },
  { 6273, 12, 50, 18, 2, -41 },
  { 6348, 25, 23, 27, 1, -41 },
  { 6420, 25, 3, 25, 0, 5 },
  { 6430, 11, 9, 15, 2, -44 },
  { 6443, 20, 32, 26, 2, -31 },
  { 6523, 22, 44, 29, 4, -43 },
  { 6644, 18, 32, 22, 3, -31 },
  { 6716, 22, 44, 29, 3, -43 },
  { 6837, 21, 32, 26, 3, -31 },
  { 6921, 17, 44, 16, 1, -44 },
  { 7015, 22, 45, 29, 3, -31 },
  { 7139, 21, 43, 29, 4, -43 },
  { 7252, 5, 42, 13, 4, -42 },
  { 7279, 10, 56, 13, -1, -42 },
  { 7349, 21, 43, 25, 4, -43 },
  { 7462, 5, 43, 13, 4, -43 },
  { 7489, 35, 31, 43, 4, -31 },
  { 7625, 21, 31, 29, 4, -31 },
  { 7707, 22, 32, 28, 3, -31 },
  { 7795, 22, 45, 29, 4, -31 },
  { 7919, 22, 45, 29, 3, -31 },
  { 8043, 15, 31, 19, 4, -31 },
  { 8102, 18, 32, 22, 2, -31 },
  { 8174, 15, 39, 17, 1, -38 },
  { 8248, 21, 32, 29, 4, -31 },
  { 8332, 23, 31, 23, 0, -31 },
  { 8422, 36, 31, 38, 1, -31 },
  { 8562, 22, 31, 24, 1, -31 },
  { 8648, 23, 45, 23, 0, -31 },
  { 8778, 17, 31, 20, 2, -31 },
  { 8844, 17, 50, 21, 2, -41 },
  { 8951, 4, 57, 26, 11, -43 },
  { 8980, 17, 50, 21, 2, -41 },
  { 9087, 23, 8, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Regular57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_REGULAR57PT7B_H_
