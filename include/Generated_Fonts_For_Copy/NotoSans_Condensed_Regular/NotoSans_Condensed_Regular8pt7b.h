#ifndef _NOTOSANS_CONDENSED_REGULAR8PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR8PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x56, 0xF6, 0xF6, 0x7B, 0x17, 0x80, 0x55, 0xAA, 0xF3,
  0xAC, 0x66, 0x6B, 0xB7, 0xC0, 0x5A, 0xA4, 0x95, 0x5C, 0x5D, 0x80, 0x4B,
  0xA0, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00, 0x76, 0xDA, 0xC0, 0x75, 0x50,
  0xE4, 0x95, 0xC0, 0xE4, 0xB3, 0xC0, 0x22, 0x6A, 0xF2, 0x73, 0x13, 0xC0,
  0x6B, 0xDA, 0xC0, 0xE4, 0x94, 0x80, 0x75, 0xBA, 0xC0, 0x76, 0xB2, 0xC0,
  0x90, 0x98, 0x2B, 0x10, 0xFC, 0x86, 0x3C, 0xC4, 0xA0, 0x80, 0x32, 0x6F,
  0x7B, 0xA0, 0xC0, 0x26, 0x66, 0x99, 0xD6, 0xFB, 0xC0, 0x34, 0x88, 0x87,
  0xD6, 0xDB, 0x80, 0xEB, 0xB0, 0xEB, 0xA0, 0x34, 0x89, 0x97, 0xB6, 0xFB,
  0x40, 0xD5, 0x70, 0xFF, 0xBA, 0x6D, 0x40, 0xAA, 0xB0, 0x8C, 0xE7, 0xDE,
  0xD4, 0xB7, 0xFB, 0x40, 0x72, 0xA3, 0x19, 0x38, 0xD6, 0xE9, 0x00, 0x72,
  0xA3, 0x19, 0x38, 0x40, 0xD6, 0xED, 0x40, 0x71, 0x13, 0xC0, 0xE9, 0x24,
  0x80, 0xB6, 0xDB, 0xC0, 0x99, 0xA6, 0x64, 0x96, 0x5B, 0x5D, 0x49, 0x20,
  0x96, 0x44, 0x6B, 0x9A, 0x64, 0x44, 0xE5, 0x25, 0xC0, 0xFE, 0x91, 0x24,
  0x40, 0xD5, 0x5C, 0x46, 0xA9, 0xF0, 0xC0, 0x6E, 0xF0, 0x9A, 0xDB, 0x80,
  0xF2, 0x30, 0x15, 0xB9, 0x97, 0xFE, 0x30, 0x5D, 0x50, 0xF9, 0x97, 0x16,
  0xAF, 0xF0, 0xBC, 0xBF, 0xAE, 0xF0, 0xFC, 0xFD, 0x6B, 0x50, 0xFF, 0xE9,
  0x96, 0xF6, 0xE9, 0x00, 0xF9, 0x97, 0x11, 0xEA, 0xE8, 0xF0, 0xEA, 0x40,
  0xFF, 0xB5, 0x20, 0xAD, 0x56, 0xA0, 0xA9, 0x50, 0xB5, 0x25, 0x00, 0xE9,
  0x70, 0x29, 0x64, 0x98, 0xFF, 0x89, 0x34, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 0, -6 },
  { 2, 3, 2, 3, 0, -6 },
  { 3, 4, 6, 4, 0, -6 },
  { 6, 3, 6, 4, 0, -6 },
  { 9, 5, 6, 6, 0, -6 },
  { 13, 4, 6, 4, 0, -6 },
  { 16, 1, 2, 2, 0, -6 },
  { 17, 2, 7, 2, 0, -6 },
  { 19, 2, 7, 2, 0, -6 },
  { 21, 3, 3, 4, 0, -6 },
  { 23, 3, 4, 4, 0, -5 },
  { 25, 1, 2, 2, 0, -1 },
  { 26, 2, 1, 2, 0, -3 },
  { 27, 1, 1, 2, 0, -1 },
  { 28, 3, 6, 3, 0, -6 },
  { 31, 3, 6, 4, 0, -6 },
  { 34, 2, 6, 4, 1, -6 },
  { 36, 3, 6, 4, 0, -6 },
  { 39, 3, 6, 4, 0, -6 },
  { 42, 4, 6, 4, 0, -6 },
  { 45, 3, 6, 4, 0, -6 },
  { 48, 3, 6, 4, 0, -6 },
  { 51, 3, 6, 4, 0, -6 },
  { 54, 3, 6, 4, 0, -6 },
  { 57, 3, 6, 4, 0, -6 },
  { 60, 1, 4, 2, 0, -4 },
  { 61, 1, 5, 2, 0, -4 },
  { 62, 3, 4, 4, 0, -5 },
  { 64, 3, 2, 4, 0, -4 },
  { 65, 4, 4, 4, 0, -5 },
  { 67, 3, 6, 3, 0, -6 },
  { 70, 5, 7, 6, 0, -6 },
  { 75, 4, 6, 4, 0, -6 },
  { 78, 3, 6, 4, 1, -6 },
  { 81, 4, 6, 4, 0, -6 },
  { 84, 3, 6, 5, 1, -6 },
  { 87, 2, 6, 4, 1, -6 },
  { 89, 2, 6, 3, 1, -6 },
  { 91, 4, 6, 5, 0, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 2, 6, 2, 0, -6 },
  { 99, 1, 8, 2, 0, -6 },
  { 100, 3, 6, 4, 1, -6 },
  { 103, 2, 6, 3, 1, -6 },
  { 105, 5, 6, 6, 1, -6 },
  { 109, 3, 6, 5, 1, -6 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 3, 6, 4, 1, -6 },
  { 119, 5, 7, 5, 0, -6 },
  { 124, 3, 6, 4, 1, -6 },
  { 127, 3, 6, 4, 0, -6 },
  { 130, 3, 6, 3, 0, -6 },
  { 133, 3, 6, 5, 1, -6 },
  { 136, 4, 6, 4, 0, -6 },
  { 139, 6, 6, 6, 0, -6 },
  { 144, 4, 6, 4, 0, -6 },
  { 147, 4, 6, 4, 0, -6 },
  { 150, 3, 6, 3, 0, -6 },
  { 153, 1, 7, 3, 1, -6 },
  { 154, 3, 6, 3, 0, -6 },
  { 157, 2, 7, 3, 0, -6 },
  { 159, 4, 4, 4, 0, -6 },
  { 161, 4, 1, 4, 0, 0 },
  { 162, 2, 1, 2, 0, -6 },
  { 163, 3, 4, 4, 0, -4 },
  { 165, 3, 6, 4, 1, -6 },
  { 168, 3, 4, 3, 0, -4 },
  { 170, 4, 6, 4, 0, -6 },
  { 173, 3, 4, 4, 0, -4 },
  { 175, 2, 6, 2, 0, -6 },
  { 177, 4, 6, 4, 0, -4 },
  { 180, 2, 6, 4, 1, -6 },
  { 182, 1, 6, 2, 0, -6 },
  { 183, 1, 8, 2, 0, -6 },
  { 184, 2, 6, 4, 1, -6 },
  { 186, 1, 6, 2, 0, -6 },
  { 187, 5, 4, 6, 1, -4 },
  { 190, 2, 4, 4, 1, -4 },
  { 191, 4, 4, 4, 0, -4 },
  { 193, 3, 6, 4, 1, -4 },
  { 196, 4, 6, 4, 0, -4 },
  { 199, 2, 4, 3, 1, -4 },
  { 200, 3, 4, 3, 0, -4 },
  { 202, 2, 5, 2, 0, -5 },
  { 204, 2, 4, 4, 1, -4 },
  { 205, 3, 4, 3, 0, -4 },
  { 207, 5, 4, 5, 0, -4 },
  { 210, 3, 4, 3, 0, -4 },
  { 212, 3, 6, 3, 0, -4 },
  { 215, 3, 4, 3, 0, -4 },
  { 217, 3, 7, 3, 0, -6 },
  { 220, 1, 8, 4, 1, -6 },
  { 221, 3, 7, 3, 0, -6 },
  { 224, 4, 1, 4, 0, -3 },
};

const GFXfont NotoSans_Condensed_Regular8pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular8pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _NOTOSANS_CONDENSED_REGULAR8PT7B_H_
