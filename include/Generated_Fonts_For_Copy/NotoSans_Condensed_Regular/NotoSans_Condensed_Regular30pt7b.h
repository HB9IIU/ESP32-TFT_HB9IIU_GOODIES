#ifndef _NOTOSANS_CONDENSED_REGULAR30PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x6D, 0xB6, 0xD8, 0x0B, 0xFE, 0xE7, 0xE7, 0xC7,
  0xC7, 0xC7, 0xC6, 0xC6, 0x0E, 0x30, 0x30, 0xC0, 0xC2, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x8F, 0xFF, 0xFF, 0xFF, 0x18, 0x60, 0x63, 0x01, 0x8C, 0x06,
  0x30, 0x18, 0xC3, 0xFF, 0xEF, 0xFF, 0x8C, 0x30, 0x30, 0x80, 0xC6, 0x03,
  0x18, 0x0C, 0x60, 0x31, 0x80, 0x06, 0x00, 0x60, 0x06, 0x01, 0xFE, 0x3F,
  0xE7, 0x62, 0x66, 0x0E, 0x60, 0xE6, 0x06, 0x60, 0x7E, 0x03, 0xF0, 0x0F,
  0xC0, 0x7E, 0x06, 0x60, 0x67, 0x06, 0x30, 0x67, 0x86, 0x6F, 0xFE, 0xFF,
  0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x18, 0x00, 0x07, 0xC0, 0xC1,
  0x98, 0x30, 0x33, 0x06, 0x0C, 0x31, 0xC1, 0x86, 0x30, 0x30, 0xC6, 0x06,
  0x19, 0x80, 0xC3, 0x30, 0x18, 0x6C, 0xF1, 0x99, 0x9F, 0x33, 0x36, 0x73,
  0xEC, 0xC6, 0x31, 0x98, 0xC0, 0x63, 0x18, 0x0C, 0x63, 0x03, 0x8C, 0x60,
  0x61, 0x8C, 0x0C, 0x31, 0x83, 0x06, 0x30, 0x60, 0x7C, 0x1C, 0x0F, 0x00,
  0x07, 0x00, 0x1F, 0x80, 0x39, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x30, 0xC0,
  0x30, 0xC0, 0x39, 0xC0, 0x1B, 0x80, 0x1F, 0x00, 0x0E, 0x00, 0x3F, 0x00,
  0x77, 0x0E, 0x73, 0x8C, 0xE1, 0xCC, 0xE0, 0xFC, 0xE0, 0xF8, 0xE0, 0x78,
  0xE0, 0x78, 0x70, 0xFC, 0x7F, 0xDC, 0x3F, 0x8F, 0xFF, 0x6D, 0xB0, 0x06,
  0x18, 0x70, 0xC3, 0x86, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0x60, 0xC1, 0x83, 0x87, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x38, 0xC1,
  0x87, 0x0C, 0x38, 0xE1, 0x87, 0x1C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x31, 0xC7, 0x18, 0x63, 0x8C, 0x71, 0x8C, 0x00, 0x0E, 0x01, 0xC0, 0x18,
  0x43, 0x1F, 0x7F, 0xFF, 0xC3, 0x80, 0xD8, 0x3B, 0x8E, 0x38, 0xC6, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF, 0xFF,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x77, 0x76, 0x6E,
  0xC0, 0xFF, 0xFC, 0x5F, 0xF0, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x00, 0x06, 0x01,
  0xF8, 0x3F, 0xC7, 0x0E, 0x70, 0xE6, 0x06, 0x60, 0x6E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x60, 0x66,
  0x06, 0x70, 0xE3, 0x9C, 0x3F, 0xC1, 0xF8, 0x0E, 0x3C, 0xFB, 0xBE, 0x68,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0x0E, 0x07, 0xF8, 0xFF, 0xC6, 0x0E, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x0F,
  0x07, 0xFC, 0xFB, 0xC4, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xC0, 0x3C, 0x1F, 0x01, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xEC, 0x1E, 0xFF, 0xC7, 0xF8, 0x01, 0xC0, 0x0E, 0x00,
  0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x33, 0x01, 0x98, 0x18, 0xC0, 0xC6,
  0x0C, 0x30, 0x61, 0x86, 0x0C, 0x70, 0x63, 0x03, 0x1F, 0xFF, 0xFF, 0xF8,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0x9F, 0xF3, 0x80,
  0x70, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0x1F, 0xF0, 0x0F, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x3A, 0x0F, 0x7F, 0xCF,
  0xF0, 0x03, 0xC0, 0xFE, 0x1F, 0x63, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0x63, 0x06, 0xFC, 0xFF, 0xEF, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x76,
  0x07, 0x60, 0x77, 0x07, 0x70, 0x63, 0x8E, 0x3F, 0xC0, 0xF8, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x00, 0x0F, 0x03, 0xFC, 0x79, 0xE7, 0x0E,
  0x60, 0x66, 0x06, 0x60, 0x67, 0x0E, 0x38, 0xE3, 0xFC, 0x1F, 0x01, 0xF8,
  0x39, 0xC7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x0E,
  0x7F, 0xE1, 0xF8, 0x0E, 0x03, 0xF8, 0x3F, 0xC7, 0x0E, 0x60, 0xEE, 0x06,
  0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0xF7, 0x1F, 0x3F, 0xF1, 0xE6,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0x87, 0xE0,
  0xFF, 0xA0, 0x00, 0x00, 0x05, 0xFF, 0x77, 0x72, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x77, 0x66, 0xEC, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x80, 0x0C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x08, 0x00,
  0x1C, 0x3F, 0xC7, 0xF9, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80,
  0xE0, 0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x70, 0x1C, 0x07, 0x00, 0x00, 0x40, 0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x70,
  0x1C, 0x30, 0x03, 0x9C, 0x00, 0x66, 0x0F, 0x1F, 0x8F, 0xE3, 0xC3, 0x18,
  0xF1, 0x86, 0x3C, 0x61, 0x8F, 0x18, 0x63, 0xC6, 0x18, 0xF1, 0x8E, 0x3C,
  0x63, 0x8F, 0x18, 0xE3, 0xC7, 0x79, 0xB0, 0xFB, 0xEC, 0x08, 0x61, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE3, 0x80, 0x3F, 0xE0, 0x00, 0x80,
  0x00, 0x03, 0x80, 0x07, 0x80, 0x1B, 0x00, 0x36, 0x00, 0x6C, 0x01, 0xDC,
  0x03, 0x98, 0x06, 0x30, 0x0C, 0x70, 0x38, 0xE0, 0x60, 0xC0, 0xC1, 0x83,
  0xFF, 0x87, 0xFF, 0x0E, 0x06, 0x18, 0x0E, 0x70, 0x1C, 0xE0, 0x19, 0x80,
  0x37, 0x00, 0x7E, 0x00, 0xE0, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0xEE,
  0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0C, 0xE1, 0xE7, 0xFC, 0x3F, 0xF9, 0xC1,
  0xEE, 0x07, 0x70, 0x1B, 0x80, 0xFC, 0x07, 0xE0, 0x37, 0x03, 0xB8, 0x3D,
  0xFF, 0xCF, 0xF8, 0x00, 0x03, 0xC0, 0xFF, 0x3F, 0xF3, 0x81, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0xC1, 0x1F, 0xF0,
  0xFF, 0xFF, 0xC3, 0xFF, 0x8E, 0x0F, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xEE,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x1E, 0x3F, 0xF0,
  0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x03, 0xC0, 0x3F, 0xF1,
  0xFF, 0xCE, 0x02, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x3F, 0xC0, 0xFF, 0x00, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0D, 0xC0, 0x37, 0x00, 0xCF, 0x03, 0x1F, 0xFC, 0x3F, 0xE0, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0x80, 0xFE, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE7, 0xFF, 0xE0, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0xFD, 0xFB, 0xC0, 0xE0, 0x7F, 0x03, 0xB8, 0x39, 0xC3, 0x8E,
  0x1C, 0x71, 0xC3, 0x9C, 0x1C, 0xE0, 0xEE, 0x07, 0xF0, 0x3F, 0x81, 0xEE,
  0x0E, 0x30, 0x71, 0xC3, 0x86, 0x1C, 0x38, 0xE0, 0xE7, 0x07, 0x38, 0x1D,
  0xC0, 0xEE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xD8, 0x0F, 0xFB, 0x01, 0xBF,
  0x70, 0x37, 0xE6, 0x0E, 0xFC, 0xC1, 0x9F, 0x9C, 0x33, 0xF3, 0x8E, 0x7E,
  0x31, 0x8F, 0xC6, 0x31, 0xF8, 0xEE, 0x3F, 0x0D, 0x87, 0xE1, 0xB0, 0xFC,
  0x3E, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0E, 0xF0, 0x0F, 0xC0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x0F, 0xB0, 0x3E, 0xE0, 0xF9, 0x83, 0xE7,
  0x0F, 0x8C, 0x3E, 0x38, 0xF8, 0x63, 0xE1, 0xCF, 0x83, 0x3E, 0x0E, 0xF8,
  0x1B, 0xE0, 0x7F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1C, 0x03, 0x80,
  0x3F, 0xC0, 0xFF, 0xC3, 0xC1, 0xC7, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x70,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0C, 0xC0, 0x39, 0xC0, 0x71, 0xC3, 0xC3,
  0xFF, 0x01, 0xFC, 0x00, 0xFF, 0x8F, 0xFC, 0xE0, 0xEE, 0x0E, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEE, 0x0E, 0xFF, 0xCF, 0xF8, 0xFC, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x3F, 0xC0, 0xFF, 0xE3, 0xC1, 0xC7, 0x01, 0xDC, 0x03, 0xB8,
  0x03, 0x70, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0C, 0xC0, 0x39, 0xC0, 0x71,
  0xC3, 0xC3, 0xFF, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0xFF, 0x87, 0xFE, 0x38, 0x39, 0xC0, 0xCE, 0x07, 0x70,
  0x3B, 0x81, 0xDC, 0x0C, 0xE0, 0xE7, 0x0F, 0x3F, 0xF1, 0xFE, 0x0E, 0x38,
  0x71, 0xC3, 0x87, 0x1C, 0x38, 0xE0, 0xE7, 0x07, 0x38, 0x1D, 0xC0, 0xEE,
  0x03, 0x80, 0x0F, 0x87, 0xFD, 0xFF, 0xB8, 0x16, 0x01, 0xC0, 0x38, 0x03,
  0x00, 0x70, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03,
  0x00, 0x60, 0x0C, 0x03, 0xE0, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3B,
  0x81, 0xDE, 0x1C, 0x7F, 0xE1, 0xFC, 0x00, 0xE0, 0x0E, 0xC0, 0x39, 0x80,
  0x73, 0x80, 0xE7, 0x01, 0x86, 0x07, 0x0C, 0x0E, 0x1C, 0x18, 0x38, 0x30,
  0x30, 0xE0, 0x71, 0xC0, 0xE3, 0x00, 0xC6, 0x01, 0x9C, 0x03, 0xB8, 0x07,
  0x60, 0x06, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0,
  0x38, 0x0E, 0xC0, 0x70, 0x1D, 0x80, 0xF0, 0x3B, 0x81, 0xE0, 0x67, 0x07,
  0xC0, 0xC6, 0x0D, 0x83, 0x8C, 0x1B, 0x87, 0x1C, 0x37, 0x0E, 0x38, 0xE6,
  0x18, 0x71, 0x8C, 0x70, 0x63, 0x18, 0xE0, 0xC6, 0x39, 0xC1, 0xCC, 0x33,
  0x03, 0xB8, 0x66, 0x03, 0x60, 0xDC, 0x06, 0xC1, 0xF8, 0x0D, 0x81, 0xF0,
  0x1B, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1E, 0x00,
  0x70, 0x38, 0xC0, 0xC3, 0x87, 0x06, 0x18, 0x1C, 0xE0, 0x73, 0x00, 0xDC,
  0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x37,
  0x01, 0xCE, 0x06, 0x38, 0x38, 0x60, 0xC1, 0xC7, 0x03, 0x1C, 0x0E, 0xE0,
  0x3C, 0xE0, 0x3B, 0x01, 0xDC, 0x1C, 0x60, 0xE3, 0x86, 0x1C, 0x70, 0x63,
  0x03, 0x98, 0x0D, 0xC0, 0x7C, 0x03, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x80, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xFF, 0xF8, 0xE0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x70, 0x06,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0xFF, 0xFF,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x06, 0x00, 0x78, 0x03, 0xC0,
  0x3B, 0x01, 0x98, 0x0C, 0x60, 0xC3, 0x06, 0x1C, 0x60, 0x63, 0x03, 0xB8,
  0x0D, 0x80, 0x70, 0xFF, 0xF8, 0xE1, 0xC3, 0x86, 0x0C, 0x7F, 0x87, 0xF8,
  0x83, 0x00, 0x70, 0x0E, 0x01, 0xC1, 0xF9, 0xFF, 0x78, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC3, 0xDF, 0xD9, 0xF3, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xF8, 0xFF, 0xCF, 0x0E, 0xE0, 0x6E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x06, 0xF0, 0xED, 0xFC, 0xCF, 0x80, 0x1F, 0xCF, 0xE3, 0x81, 0xC0, 0x60,
  0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x1E, 0x13,
  0xFC, 0x7F, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x31, 0xF3, 0x3F, 0xB7, 0x0F, 0x70, 0x76, 0x07, 0x60, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x36, 0x03, 0x60, 0x77, 0x07, 0x70, 0xF3, 0xFB, 0x1F,
  0x30, 0x1F, 0x83, 0xFC, 0x70, 0xE7, 0x06, 0x60, 0x66, 0x06, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03, 0x82, 0x3F, 0xE0,
  0xFC, 0x07, 0x8F, 0xC7, 0x23, 0x01, 0x80, 0xC0, 0x60, 0xFE, 0xFF, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x1F, 0x33, 0xFB, 0x70, 0xF7, 0x07, 0x60, 0x76, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x07, 0x70, 0x77, 0x0F,
  0x3F, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x60, 0xE7, 0xFE,
  0x3F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x7C, 0xFF, 0xDE, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x18, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x71, 0xC0, 0x00, 0x01,
  0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xC7, 0x1C, 0x71, 0xBE, 0xF0, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x0F, 0xE1, 0xDC, 0x73, 0x9C, 0x73, 0x0E, 0xE1, 0xF8,
  0x37, 0x87, 0xF0, 0xE7, 0x1C, 0xE3, 0x8E, 0x71, 0xCE, 0x1D, 0xC3, 0xB8,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xCF, 0x8F,
  0x9B, 0xFB, 0xFB, 0xC7, 0xC7, 0x70, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1,
  0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83,
  0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07,
  0xCF, 0x9B, 0xFB, 0xC3, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x1F, 0xC3,
  0xFE, 0x70, 0xE7, 0x07, 0x60, 0x76, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0x60, 0x36, 0x07, 0x70, 0x73, 0x8E, 0x3F, 0xE1, 0xF8, 0xCF, 0x8D,
  0xFC, 0xF0, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6F, 0x0E, 0xFF, 0xCE, 0xF8, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x33, 0xFB,
  0x70, 0xF7, 0x07, 0x60, 0x76, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0x60, 0x76, 0x07, 0x70, 0x77, 0x0F, 0x3F, 0xB1, 0xF3, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xCF, 0xDF, 0xD8, 0xF0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0x3F, 0xBF, 0xF8, 0x3C, 0x0E, 0x07, 0x01, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0xE0, 0x30, 0x1C, 0x1F, 0xFF, 0xFC, 0x30, 0x60, 0xC3, 0x8F, 0xFF, 0xDC,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xF9, 0xF0,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC3, 0xDF, 0xD9, 0xF3, 0xE0, 0x76,
  0x07, 0x60, 0x77, 0x06, 0x70, 0xE3, 0x0E, 0x30, 0xC3, 0x8C, 0x19, 0xC1,
  0x98, 0x19, 0x81, 0xD8, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0xE0, 0xE0,
  0x76, 0x0F, 0x06, 0x60, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xF0, 0xC3, 0x1B,
  0x8C, 0x31, 0x98, 0xC3, 0x99, 0x9C, 0x3B, 0x99, 0x81, 0xB1, 0xD8, 0x1B,
  0x0D, 0x81, 0xB0, 0xF8, 0x1B, 0x0F, 0x81, 0xE0, 0xF0, 0x0E, 0x0F, 0x00,
  0xE0, 0x70, 0x70, 0x73, 0x0E, 0x38, 0xE1, 0x9C, 0x1D, 0xC0, 0xF8, 0x0F,
  0x00, 0x70, 0x0F, 0x00, 0xF8, 0x1D, 0x81, 0x9C, 0x38, 0xC3, 0x0E, 0x70,
  0x6E, 0x07, 0xE0, 0x36, 0x07, 0x60, 0x77, 0x06, 0x30, 0xE3, 0x0E, 0x38,
  0xC3, 0x8C, 0x19, 0xC1, 0x98, 0x1D, 0x80, 0xD8, 0x0F, 0x80, 0xF0, 0x07,
  0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x0F, 0x80, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x18, 0x1C,
  0x0C, 0x0E, 0x06, 0x07, 0x03, 0xFF, 0xFF, 0x07, 0x87, 0xC3, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x0F, 0x0E, 0x07, 0xC0, 0x60,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x1C, 0x07, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x7C, 0x06,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xE0, 0x38,
  0x7C, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70,
  0xF0, 0x70, 0x00, 0x10, 0x17, 0xE1, 0xFF, 0xF8, 0x3E,
};

const GFXglyph NotoSans_Condensed_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 8, 7, 12, 2, -21 },
  { 16, 14, 21, 15, 1, -21 },
  { 53, 12, 25, 14, 1, -23 },
  { 91, 19, 22, 21, 1, -22 },
  { 144, 16, 22, 17, 1, -22 },
  { 188, 3, 7, 6, 2, -21 },
  { 191, 7, 27, 9, 1, -22 },
  { 215, 6, 27, 9, 1, -22 },
  { 236, 11, 11, 13, 1, -23 },
  { 252, 12, 14, 14, 1, -18 },
  { 273, 4, 7, 7, 1, -3 },
  { 277, 7, 2, 9, 1, -9 },
  { 279, 3, 4, 7, 2, -4 },
  { 281, 11, 21, 11, 0, -21 },
  { 310, 12, 22, 14, 1, -22 },
  { 343, 7, 21, 14, 2, -21 },
  { 362, 12, 22, 14, 1, -22 },
  { 395, 12, 22, 14, 1, -22 },
  { 428, 13, 22, 14, 1, -22 },
  { 464, 11, 21, 14, 2, -21 },
  { 493, 12, 22, 14, 1, -22 },
  { 526, 12, 21, 14, 1, -21 },
  { 558, 12, 22, 14, 1, -22 },
  { 591, 12, 22, 14, 1, -22 },
  { 624, 3, 16, 7, 2, -16 },
  { 630, 4, 20, 7, 1, -16 },
  { 640, 12, 14, 14, 1, -18 },
  { 661, 12, 9, 14, 1, -15 },
  { 675, 12, 14, 14, 1, -18 },
  { 696, 10, 22, 11, 0, -22 },
  { 724, 18, 25, 22, 2, -22 },
  { 781, 15, 21, 15, 0, -21 },
  { 821, 13, 21, 16, 2, -21 },
  { 856, 12, 22, 15, 2, -22 },
  { 889, 14, 21, 17, 2, -21 },
  { 926, 10, 21, 13, 2, -21 },
  { 953, 10, 21, 13, 2, -21 },
  { 980, 14, 22, 18, 2, -22 },
  { 1019, 13, 21, 18, 2, -21 },
  { 1054, 7, 21, 9, 1, -21 },
  { 1073, 7, 27, 7, -2, -21 },
  { 1097, 13, 21, 15, 2, -21 },
  { 1132, 10, 21, 13, 2, -21 },
  { 1159, 19, 21, 23, 2, -21 },
  { 1209, 14, 21, 19, 2, -21 },
  { 1246, 15, 22, 19, 2, -22 },
  { 1288, 12, 21, 15, 2, -21 },
  { 1320, 15, 27, 19, 2, -22 },
  { 1371, 13, 21, 15, 2, -21 },
  { 1406, 11, 22, 14, 1, -22 },
  { 1437, 13, 21, 13, 0, -21 },
  { 1472, 13, 21, 18, 2, -21 },
  { 1507, 15, 21, 15, 0, -21 },
  { 1547, 23, 21, 23, 0, -21 },
  { 1608, 14, 21, 14, 0, -21 },
  { 1645, 13, 21, 13, 0, -21 },
  { 1680, 11, 21, 13, 1, -21 },
  { 1709, 7, 27, 10, 2, -22 },
  { 1733, 11, 21, 11, 0, -21 },
  { 1762, 6, 27, 10, 1, -22 },
  { 1783, 13, 12, 14, 1, -21 },
  { 1803, 13, 1, 13, 0, 3 },
  { 1805, 6, 5, 8, 1, -23 },
  { 1809, 11, 16, 14, 1, -16 },
  { 1831, 12, 23, 15, 2, -23 },
  { 1866, 10, 16, 12, 1, -16 },
  { 1886, 12, 23, 15, 1, -23 },
  { 1921, 12, 16, 14, 1, -16 },
  { 1945, 9, 23, 8, 0, -23 },
  { 1971, 12, 23, 15, 1, -16 },
  { 2006, 11, 23, 15, 2, -23 },
  { 2038, 3, 22, 7, 2, -22 },
  { 2047, 6, 29, 7, -1, -22 },
  { 2069, 11, 23, 13, 2, -23 },
  { 2101, 3, 23, 7, 2, -23 },
  { 2110, 19, 16, 23, 2, -16 },
  { 2148, 11, 16, 15, 2, -16 },
  { 2170, 12, 16, 15, 1, -16 },
  { 2194, 12, 23, 15, 2, -16 },
  { 2229, 12, 23, 15, 1, -16 },
  { 2264, 8, 16, 10, 2, -16 },
  { 2280, 9, 16, 11, 1, -16 },
  { 2298, 7, 20, 9, 1, -20 },
  { 2316, 11, 16, 15, 2, -16 },
  { 2338, 12, 16, 12, 0, -16 },
  { 2362, 20, 16, 20, 0, -16 },
  { 2402, 12, 16, 13, 0, -16 },
  { 2426, 12, 23, 12, 0, -16 },
  { 2461, 9, 16, 11, 1, -16 },
  { 2479, 9, 26, 11, 1, -21 },
  { 2509, 2, 30, 13, 6, -23 },
  { 2517, 9, 26, 11, 1, -21 },
  { 2547, 12, 4, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_Regular30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_REGULAR30PT7B_H_
