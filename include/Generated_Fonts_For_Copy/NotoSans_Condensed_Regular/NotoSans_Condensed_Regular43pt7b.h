#ifndef _NOTOSANS_CONDENSED_REGULAR43PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR43PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x38, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xC0, 0xF1, 0xFE, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xE0, 0xFC, 0x1F, 0x83,
  0x00, 0x01, 0xC1, 0x80, 0x1C, 0x18, 0x01, 0xC3, 0x80, 0x18, 0x38, 0x03,
  0x83, 0x80, 0x38, 0x38, 0x03, 0x83, 0x80, 0x38, 0x30, 0x03, 0x83, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0x07, 0x00, 0x70, 0x70,
  0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x60, 0xE0, 0x0E, 0x0E,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0E, 0x1C, 0x00, 0xE1,
  0xC0, 0x0C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C,
  0x18, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x07, 0xF8, 0x1F, 0xFF, 0x3F, 0xFE, 0x7D, 0x8E, 0xF1,
  0x80, 0xF1, 0x80, 0xE1, 0x80, 0xE1, 0x80, 0xF1, 0x80, 0xF1, 0x80, 0x79,
  0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x01,
  0x9F, 0x01, 0x8F, 0x01, 0x87, 0x01, 0x87, 0x01, 0x87, 0x01, 0x87, 0x81,
  0x8F, 0xF9, 0xBE, 0xFF, 0xFC, 0xFF, 0xF8, 0x0F, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1F, 0x00, 0x38, 0x07, 0xF0,
  0x07, 0x01, 0xFE, 0x01, 0xC0, 0x38, 0xE0, 0x38, 0x0E, 0x1C, 0x0E, 0x01,
  0xC3, 0x81, 0xC0, 0x38, 0x30, 0x38, 0x07, 0x07, 0x0E, 0x00, 0xE0, 0xE1,
  0xC0, 0x1C, 0x1C, 0x70, 0x03, 0x83, 0x8E, 0x00, 0x70, 0x71, 0xC0, 0x0E,
  0x0C, 0x70, 0xE1, 0xC3, 0x8E, 0x7F, 0x38, 0x73, 0x9F, 0xE3, 0x8E, 0x73,
  0x8E, 0x7F, 0x9C, 0x71, 0xC7, 0xF3, 0x9C, 0x18, 0x7C, 0x73, 0x83, 0x80,
  0x1C, 0x70, 0x70, 0x03, 0x8E, 0x0E, 0x00, 0xE1, 0xC1, 0xC0, 0x1C, 0x38,
  0x38, 0x03, 0x87, 0x07, 0x00, 0xE0, 0xE0, 0xE0, 0x1C, 0x1C, 0x1C, 0x07,
  0x01, 0x87, 0x00, 0xE0, 0x38, 0xE0, 0x1C, 0x07, 0xBC, 0x07, 0x00, 0x7F,
  0x00, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x80,
  0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x70, 0x03, 0xC1, 0xC0, 0x0F,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xC7, 0x80, 0x07, 0x9E,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xE0, 0x71, 0xF7, 0xC1, 0xC7, 0x8F, 0x0F, 0x3C, 0x1E, 0x3C, 0xF0,
  0x3C, 0xE3, 0x80, 0xFF, 0x8E, 0x01, 0xFE, 0x38, 0x03, 0xF0, 0xE0, 0x07,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0xFC, 0x3E, 0x0F, 0xF8, 0x7F, 0xFD, 0xF0,
  0xFF, 0xE3, 0xE1, 0xFE, 0x07, 0xC0, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0,
  0x03, 0x83, 0xC3, 0xC1, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E,
  0x0E, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x38, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78,
  0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70, 0x1C, 0xF0, 0x1E, 0x03, 0x80, 0xF0,
  0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78, 0x1E, 0x07, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38,
  0x0E, 0x03, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x03, 0xC0, 0xF0, 0x38, 0x1E,
  0x07, 0x03, 0xC0, 0xE0, 0x70, 0x3C, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x18, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0F, 0x80, 0x3B, 0x80, 0x77, 0x01, 0xC7, 0x07, 0x8F, 0x1E, 0x0F, 0x04,
  0x10, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3D, 0xE7, 0x9E, 0x79,
  0xC7, 0x3C, 0xE3, 0x8C, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xF7, 0xBF, 0xEF,
  0x00, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF8,
  0x1F, 0xFC, 0x3E, 0x3C, 0x38, 0x1E, 0x78, 0x1E, 0x78, 0x0E, 0x70, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E,
  0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x01, 0xC0,
  0xF0, 0x7C, 0x3F, 0x1F, 0xCF, 0x77, 0x9F, 0xC7, 0x61, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0xE0, 0x3F, 0xF8, 0xFF, 0xFC, 0xF8, 0x7C, 0x60, 0x1E, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0x60,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x1F,
  0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x1E, 0xC0, 0x3E, 0xFF,
  0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0x70,
  0x01, 0xDE, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x03, 0x8F, 0x00, 0xF1, 0xE0,
  0x1C, 0x3C, 0x07, 0x87, 0x80, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x03, 0xC1,
  0xE0, 0x78, 0x38, 0x0F, 0x0E, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F,
  0xFC, 0x7F, 0xFC, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x7F, 0xF8, 0x7F,
  0xFC, 0x30, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x80,
  0x1E, 0xC0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x07,
  0xFE, 0x0F, 0xFE, 0x1F, 0x82, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF3, 0xF8, 0xF7,
  0xFC, 0xFF, 0xFE, 0xFC, 0x1E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78,
  0x0F, 0x78, 0x0F, 0x3C, 0x1E, 0x1F, 0xFC, 0x0F, 0xFC, 0x07, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0x87, 0xC7, 0x81, 0xE3, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0x70, 0x0F, 0x38, 0x07, 0x9E, 0x07, 0x87, 0x83, 0xC3, 0xE7,
  0xC0, 0xFF, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF8, 0x1E, 0x3E, 0x1E,
  0x07, 0x9E, 0x01, 0xEF, 0x00, 0xF7, 0x00, 0x3B, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF8, 0x03, 0xBC, 0x03, 0xCF, 0x03, 0xE7, 0xFF, 0xE1, 0xFF,
  0xE0, 0x3F, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x7C, 0x3C, 0x78,
  0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0x78, 0x1F, 0x7F,
  0xF7, 0x3F, 0xF7, 0x1F, 0xEF, 0x03, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x7F,
  0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0xF7, 0xBF, 0xEF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0xFB, 0xC0, 0x3C, 0x78, 0xF9, 0xE3,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xE1, 0xC3, 0x8E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xF0, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x70,
  0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x00, 0x3F, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xF8, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0xE0, 0x00, 0x1C, 0x38, 0x03,
  0x01, 0xC7, 0x03, 0xFC, 0x39, 0xC0, 0xFF, 0x83, 0x38, 0x3C, 0x70, 0x77,
  0x0F, 0x0E, 0x0E, 0xE1, 0xC1, 0xC1, 0xF8, 0x38, 0x38, 0x3F, 0x07, 0x07,
  0x07, 0xE1, 0xC0, 0xE0, 0xFC, 0x38, 0x1C, 0x1F, 0x87, 0x03, 0x83, 0xF0,
  0xE0, 0x70, 0x7E, 0x1E, 0x0E, 0x0F, 0xC1, 0xC3, 0xC3, 0xB8, 0x38, 0x78,
  0x73, 0x87, 0xFF, 0xFC, 0x70, 0x7F, 0x3F, 0x8E, 0x07, 0xC3, 0xE1, 0xE0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x02, 0x00, 0x7E, 0x03, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1D,
  0xE0, 0x00, 0x73, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x3C, 0x00, 0x38, 0xF0,
  0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E, 0x1E, 0x00, 0x70, 0x78, 0x03,
  0xC0, 0xE0, 0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x0E, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x78,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xC0, 0xFF, 0xE0, 0x3F, 0xFF,
  0x0F, 0xFF, 0xE3, 0xC3, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B,
  0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1C, 0xF0,
  0x0F, 0x3F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0x3C, 0x03,
  0xEF, 0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x7E, 0xFF,
  0xFF, 0x3F, 0xFF, 0x8F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F,
  0xFC, 0x3F, 0x0F, 0x1F, 0x00, 0x4F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0x0F, 0xFF, 0xC1,
  0xFF, 0xF0, 0x1F, 0xF8, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3C,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F,
  0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x1F, 0xC1, 0xE1, 0xF0,
  0x01, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0x0E, 0xE0, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00,
  0xEF, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xF0, 0x01, 0xC7, 0xC0, 0x0E, 0x1F,
  0x00, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0x80, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x78,
  0xFF, 0xFF, 0xFF, 0xE3, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x87, 0xF7, 0xFF, 0xFE, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0xFF, 0xBF, 0xCF, 0xE0,
  0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x01, 0xE1,
  0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x1E, 0x03,
  0xC3, 0x80, 0x78, 0xF0, 0x0F, 0x3C, 0x01, 0xE7, 0x00, 0x3D, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xBC, 0x03, 0xE3, 0xC0, 0x78, 0x78, 0x0F,
  0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x1E, 0x1E,
  0x03, 0xE3, 0xC0, 0x3C, 0x78, 0x07, 0xCF, 0x00, 0x79, 0xE0, 0x07, 0xBC,
  0x00, 0xF8, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xB8, 0x00, 0xFF,
  0xF7, 0x00, 0x1D, 0xFE, 0xF0, 0x03, 0xBF, 0xCE, 0x00, 0xF7, 0xF9, 0xC0,
  0x1C, 0xFF, 0x3C, 0x03, 0x9F, 0xE3, 0x80, 0xF3, 0xFC, 0x70, 0x1C, 0x7F,
  0x8E, 0x03, 0x8F, 0xF1, 0xE0, 0x71, 0xFE, 0x1C, 0x1C, 0x3F, 0xC3, 0x83,
  0x87, 0xF8, 0x78, 0x70, 0xFF, 0x07, 0x1C, 0x1F, 0xE0, 0xE3, 0x83, 0xFC,
  0x1E, 0x70, 0x7F, 0x81, 0xDE, 0x0F, 0xF0, 0x3B, 0x81, 0xFE, 0x07, 0xF0,
  0x3F, 0xC0, 0x7E, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x01, 0xF0, 0x1F, 0xE0,
  0x3E, 0x03, 0xFC, 0x03, 0x80, 0x78, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x01,
  0xFE, 0xE0, 0x0F, 0xF7, 0x80, 0x7F, 0x9C, 0x03, 0xFC, 0xF0, 0x1F, 0xE3,
  0x80, 0xFF, 0x1E, 0x07, 0xF8, 0x70, 0x3F, 0xC3, 0xC1, 0xFE, 0x0E, 0x0F,
  0xF0, 0x78, 0x7F, 0x83, 0xC3, 0xFC, 0x0F, 0x1F, 0xE0, 0x78, 0xFF, 0x01,
  0xE7, 0xF8, 0x0F, 0x3F, 0xC0, 0x3D, 0xFE, 0x01, 0xEF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC,
  0x07, 0xE1, 0xF8, 0x1E, 0x01, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x07, 0x9E,
  0x00, 0x1E, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x3C, 0x00,
  0x78, 0xF0, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x3F, 0xFF,
  0x1F, 0xFF, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xEF, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x7D, 0xE0, 0xFC, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xF8, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8, 0x1E,
  0x01, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE1,
  0xE0, 0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xC0, 0x3F,
  0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8, 0xF0, 0x1F, 0x3C, 0x03, 0xCF, 0x00,
  0xF3, 0xC0, 0x1C, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x3C,
  0xF0, 0x0F, 0x3C, 0x07, 0xCF, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x3F,
  0xFC, 0x0F, 0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x03,
  0xC3, 0xC0, 0x78, 0xF0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x3E,
  0xF0, 0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3C, 0x07, 0xF8, 0x1F, 0xFE, 0x3F,
  0xFE, 0x7E, 0x3E, 0x78, 0x04, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x80,
  0x1E, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x1F,
  0x07, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xDC, 0x00, 0x1C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00,
  0x78, 0xE0, 0x03, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE0, 0xE0, 0x0E, 0x07,
  0x80, 0xF0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x38, 0x38, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0,
  0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xB8,
  0x00, 0xF0, 0x03, 0xDE, 0x00, 0xF8, 0x01, 0xEF, 0x00, 0x7C, 0x00, 0xF7,
  0x80, 0x3F, 0x00, 0x73, 0xC0, 0x1F, 0x80, 0x78, 0xE0, 0x0F, 0xC0, 0x3C,
  0x78, 0x0E, 0xE0, 0x1E, 0x3C, 0x07, 0x70, 0x0F, 0x1E, 0x03, 0xBC, 0x07,
  0x07, 0x01, 0xCE, 0x07, 0x83, 0x81, 0xE7, 0x03, 0xC1, 0xE0, 0xE3, 0x81,
  0xE0, 0xF0, 0x71, 0xE0, 0xE0, 0x78, 0x38, 0x70, 0x70, 0x1C, 0x1C, 0x38,
  0x78, 0x0F, 0x1E, 0x1C, 0x3C, 0x07, 0x8E, 0x0F, 0x1E, 0x03, 0xC7, 0x07,
  0x8E, 0x00, 0xE3, 0x81, 0xCF, 0x00, 0x73, 0xC0, 0xE7, 0x80, 0x3D, 0xC0,
  0x73, 0xC0, 0x1E, 0xE0, 0x3D, 0xC0, 0x07, 0x70, 0x0E, 0xE0, 0x03, 0xB8,
  0x07, 0x70, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x07,
  0x80, 0x0F, 0x80, 0x78, 0x01, 0xE7, 0x00, 0x38, 0xF0, 0x0F, 0x1E, 0x01,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC3, 0xC0, 0x78, 0x78, 0x07, 0x1E,
  0x00, 0xF3, 0xC0, 0x0E, 0x70, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x01, 0xDE, 0x00, 0x79, 0xE0, 0x0E, 0x3C, 0x03, 0xC3, 0x80, 0x78, 0x78,
  0x1E, 0x07, 0x03, 0xC0, 0xF0, 0xF0, 0x1E, 0x1E, 0x01, 0xE7, 0x80, 0x3C,
  0xF0, 0x03, 0xFC, 0x00, 0x78, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F,
  0x3C, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x07, 0x01, 0xE0, 0xF0, 0x78,
  0x1E, 0x0F, 0x01, 0xC1, 0xC0, 0x3C, 0x78, 0x03, 0x8F, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0xFF, 0xFF, 0xFC, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x70, 0x01, 0xCE, 0x00, 0x38,
  0xE0, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x78, 0x38, 0x0E, 0x03, 0x83, 0xC0,
  0x70, 0x70, 0x0F, 0x1E, 0x00, 0xE3, 0x80, 0x1E, 0xF0, 0x01, 0xDC, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF8, 0x78, 0x3C, 0x1E, 0x0E,
  0x07, 0x1F, 0xF0, 0x7F, 0xF0, 0xFB, 0xF1, 0x81, 0xE0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x07, 0xFC, 0x7F, 0xF9, 0xFF, 0xF7,
  0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0,
  0xFF, 0x83, 0xFF, 0xDE, 0xEF, 0xF9, 0xCF, 0xE3, 0x80, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xFE, 0x1E, 0xFF, 0x8E, 0xFF,
  0xE7, 0xE0, 0xF3, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01, 0xEF, 0x80, 0xF7, 0xE0,
  0xF3, 0xBF, 0xF9, 0xCF, 0xF8, 0xE3, 0xF8, 0x00, 0x00, 0x80, 0x1F, 0xF1,
  0xFF, 0x8F, 0xFE, 0x3C, 0x09, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x08, 0xFF, 0xE1, 0xFF,
  0x83, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x83, 0xC3,
  0xF9, 0xE3, 0xFE, 0xF3, 0xFF, 0xFB, 0xE0, 0xFD, 0xE0, 0x3E, 0xF0, 0x1F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEE,
  0x00, 0xF7, 0x80, 0xFB, 0xE0, 0xFC, 0xFF, 0xEE, 0x3F, 0xE7, 0x0F, 0xE3,
  0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C, 0x1E, 0x78, 0x0E, 0x70,
  0x0E, 0x70, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x02, 0x1F, 0xFE, 0x1F, 0xFE, 0x07, 0xFC, 0x01,
  0xF0, 0x1F, 0xC1, 0xFE, 0x1F, 0x10, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x0F, 0xFD, 0xFF, 0xEF, 0xFF, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x01, 0x00, 0x07, 0xF1, 0xC7, 0xFC, 0xE7,
  0xFF, 0xF7, 0xC1, 0xFB, 0xC0, 0x7D, 0xE0, 0x3F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xDC, 0x03, 0xEF, 0x01, 0xF7,
  0xC1, 0xF9, 0xFF, 0xFC, 0x7F, 0xDE, 0x1F, 0xCF, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x79, 0x80, 0x78, 0xFF,
  0xFC, 0x7F, 0xFC, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF3, 0xF8, 0xF7, 0xFC, 0xEF, 0xFE, 0xFC, 0x1E, 0xF8, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x6F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0F, 0x0F, 0x0F, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F,
  0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x0E, 0x1E, 0xFE, 0xFC, 0xF8, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x1E, 0xF0, 0x3C, 0xF0, 0x78,
  0xF0, 0x78, 0xF0, 0xF0, 0xF1, 0xE0, 0xF1, 0xC0, 0xF3, 0xC0, 0xF7, 0x80,
  0xF7, 0x80, 0xEF, 0x80, 0xFF, 0xC0, 0xFB, 0xC0, 0xF9, 0xE0, 0xF1, 0xE0,
  0xF0, 0xF0, 0xF0, 0xF0, 0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0xF0, 0x3C,
  0xF0, 0x1E, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x40, 0x08,
  0x1C, 0x7F, 0x0F, 0xE3, 0x9F, 0xF3, 0xFE, 0x77, 0xFE, 0xFF, 0xEF, 0xC3,
  0xF8, 0x3D, 0xF0, 0x3E, 0x03, 0xBC, 0x07, 0xC0, 0x7F, 0x80, 0xF0, 0x0F,
  0xF0, 0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x07, 0xF8, 0x07,
  0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC, 0x03, 0x80, 0x7F,
  0x80, 0x70, 0x0F, 0xF0, 0x0E, 0x01, 0xFE, 0x01, 0xC0, 0x3F, 0xC0, 0x38,
  0x07, 0xF8, 0x07, 0x00, 0xFF, 0x00, 0xE0, 0x1F, 0xE0, 0x1C, 0x03, 0xFC,
  0x03, 0x80, 0x7F, 0x80, 0x70, 0x0F, 0x00, 0x40, 0xE3, 0xF8, 0xE7, 0xFC,
  0xEF, 0xFE, 0xFC, 0x1E, 0xF8, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF,
  0x07, 0xFF, 0xC3, 0xC1, 0xF3, 0xC0, 0x79, 0xE0, 0x1D, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xB8, 0x03, 0xDE, 0x01, 0xCF, 0x01,
  0xE3, 0xC1, 0xE1, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x40, 0x71,
  0xFC, 0x39, 0xFF, 0x1D, 0xFF, 0xCF, 0xC1, 0xE7, 0xC0, 0x7B, 0xC0, 0x3D,
  0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xBC,
  0x03, 0xDF, 0x01, 0xEF, 0xC1, 0xE7, 0x7F, 0xF3, 0xDF, 0xF1, 0xE7, 0xF0,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x01, 0x00,
  0x07, 0xF1, 0xC7, 0xFC, 0xE7, 0xFF, 0xF7, 0xC1, 0xFB, 0xC0, 0x7D, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xDC, 0x03, 0xEF, 0x01, 0xF7, 0xC1, 0xF9, 0xFF, 0xFC, 0x7F, 0xDE, 0x1F,
  0xCF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0x9C, 0x7F, 0x9F, 0xF7, 0xFE, 0xE1, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x03, 0x00, 0xFF, 0x9F,
  0xFF, 0xFF, 0xEF, 0x01, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xFC, 0x0F, 0x7F, 0xFB, 0xFF, 0x9F, 0xF8, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x03, 0xC0, 0xFF, 0xBF, 0xF7, 0xFE, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xFC, 0x7F,
  0x87, 0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x1F, 0x78, 0x3F, 0x7F, 0xFF, 0x3F, 0xE7, 0x1F, 0xC7,
  0xF0, 0x03, 0xDC, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x0E,
  0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0x81, 0xE1,
  0xC0, 0x78, 0x70, 0x0E, 0x3C, 0x03, 0x8F, 0x00, 0xF3, 0x80, 0x1C, 0xE0,
  0x07, 0x78, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF7, 0x00, 0xF8, 0x0F, 0x78,
  0x0F, 0x80, 0xE7, 0x81, 0xF8, 0x0E, 0x38, 0x1F, 0x81, 0xE3, 0x81, 0xF8,
  0x1E, 0x38, 0x1D, 0xC1, 0xC3, 0xC3, 0x9C, 0x1C, 0x3C, 0x39, 0xC3, 0xC1,
  0xC3, 0x9C, 0x3C, 0x1C, 0x38, 0xE3, 0x81, 0xE7, 0x8E, 0x38, 0x1E, 0x70,
  0xE3, 0x80, 0xE7, 0x0E, 0x78, 0x0E, 0x70, 0xF7, 0x00, 0xE7, 0x07, 0x70,
  0x0F, 0xE0, 0x77, 0x00, 0x7E, 0x07, 0x70, 0x07, 0xE0, 0x7F, 0x00, 0x7E,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xC0, 0x3E,
  0x00, 0xF0, 0x0F, 0x78, 0x1E, 0x78, 0x1E, 0x3C, 0x3C, 0x3C, 0x3C, 0x1E,
  0x78, 0x0E, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E, 0x78, 0x1C,
  0x38, 0x3C, 0x3C, 0x78, 0x1E, 0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x03, 0xDC, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x03,
  0xC3, 0xC0, 0xF0, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x87, 0x81, 0xE1, 0xE0,
  0x38, 0x70, 0x0E, 0x3C, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07,
  0x78, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x7C, 0x07, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x0F, 0xE0, 0xF8, 0x0F, 0x80, 0xFC, 0x01,
  0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0xC0, 0x3F, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0x0F, 0x80, 0xFC, 0x03, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x7E, 0x01, 0xF0, 0x1F,
  0x07, 0xF0, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x0E, 0x00, 0x1F, 0x00, 0x5F, 0xF0, 0x3F, 0xFF, 0xBF, 0x87, 0xFF,
  0xC0, 0x7F, 0xA0, 0x01, 0x00,
};

const GFXglyph NotoSans_Condensed_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 5, 31, 11, 3, -31 },
  { 21, 11, 11, 17, 3, -31 },
  { 37, 20, 31, 22, 1, -31 },
  { 115, 16, 36, 20, 2, -33 },
  { 187, 27, 31, 31, 2, -31 },
  { 292, 22, 31, 24, 2, -31 },
  { 378, 4, 11, 9, 3, -31 },
  { 384, 9, 38, 13, 2, -31 },
  { 427, 10, 38, 13, 1, -31 },
  { 475, 15, 16, 19, 2, -33 },
  { 505, 17, 20, 20, 2, -25 },
  { 548, 6, 11, 10, 2, -5 },
  { 557, 10, 3, 12, 1, -13 },
  { 561, 5, 5, 10, 3, -5 },
  { 565, 14, 31, 16, 1, -31 },
  { 620, 16, 31, 20, 2, -31 },
  { 682, 10, 31, 20, 3, -31 },
  { 721, 16, 31, 20, 2, -31 },
  { 783, 16, 31, 20, 2, -31 },
  { 845, 19, 31, 20, 1, -31 },
  { 919, 16, 31, 20, 2, -31 },
  { 981, 16, 31, 20, 2, -31 },
  { 1043, 18, 31, 20, 1, -31 },
  { 1113, 17, 31, 20, 2, -31 },
  { 1179, 16, 31, 20, 2, -31 },
  { 1241, 5, 23, 10, 3, -23 },
  { 1256, 7, 29, 10, 1, -23 },
  { 1282, 18, 20, 20, 1, -25 },
  { 1327, 17, 12, 20, 2, -21 },
  { 1353, 17, 20, 20, 2, -25 },
  { 1396, 13, 31, 15, 1, -31 },
  { 1447, 27, 35, 31, 2, -31 },
  { 1566, 22, 31, 22, 0, -31 },
  { 1652, 18, 31, 23, 3, -31 },
  { 1722, 18, 31, 22, 2, -31 },
  { 1792, 20, 31, 25, 3, -31 },
  { 1870, 14, 31, 19, 3, -31 },
  { 1925, 14, 31, 18, 3, -31 },
  { 1980, 21, 31, 26, 2, -31 },
  { 2062, 19, 31, 26, 3, -31 },
  { 2136, 9, 31, 13, 2, -31 },
  { 2171, 10, 39, 10, -3, -31 },
  { 2220, 19, 31, 21, 3, -31 },
  { 2294, 14, 31, 18, 3, -31 },
  { 2349, 27, 31, 33, 3, -31 },
  { 2454, 21, 31, 27, 3, -31 },
  { 2536, 22, 31, 27, 2, -31 },
  { 2622, 17, 31, 21, 3, -31 },
  { 2688, 22, 38, 27, 2, -31 },
  { 2793, 18, 31, 22, 3, -31 },
  { 2863, 16, 31, 20, 2, -31 },
  { 2925, 18, 31, 19, 0, -31 },
  { 2995, 19, 31, 25, 3, -31 },
  { 3069, 21, 31, 21, 0, -31 },
  { 3151, 33, 31, 34, 0, -31 },
  { 3279, 19, 31, 20, 0, -31 },
  { 3353, 19, 31, 19, 0, -31 },
  { 3427, 16, 31, 18, 1, -31 },
  { 3489, 9, 38, 14, 3, -31 },
  { 3532, 14, 31, 16, 1, -31 },
  { 3587, 9, 38, 14, 1, -31 },
  { 3630, 19, 18, 21, 1, -31 },
  { 3673, 19, 2, 19, 0, 4 },
  { 3678, 8, 7, 12, 2, -33 },
  { 3685, 15, 23, 20, 2, -23 },
  { 3729, 17, 33, 22, 3, -33 },
  { 3800, 14, 24, 17, 2, -24 },
  { 3842, 17, 33, 22, 2, -33 },
  { 3913, 16, 23, 20, 2, -23 },
  { 3959, 13, 33, 12, 0, -33 },
  { 4013, 17, 34, 22, 2, -24 },
  { 4086, 16, 33, 22, 3, -33 },
  { 4152, 4, 32, 10, 3, -32 },
  { 4168, 8, 42, 10, -1, -32 },
  { 4210, 16, 33, 19, 3, -33 },
  { 4276, 4, 33, 10, 3, -33 },
  { 4293, 27, 24, 33, 3, -24 },
  { 4374, 16, 24, 22, 3, -24 },
  { 4422, 17, 24, 21, 2, -24 },
  { 4473, 17, 34, 22, 3, -24 },
  { 4546, 17, 34, 22, 2, -24 },
  { 4619, 11, 24, 14, 3, -24 },
  { 4652, 13, 24, 16, 2, -24 },
  { 4691, 11, 28, 12, 1, -28 },
  { 4730, 16, 23, 22, 3, -23 },
  { 4776, 18, 23, 18, 0, -23 },
  { 4828, 28, 23, 28, 0, -23 },
  { 4909, 16, 23, 18, 1, -23 },
  { 4955, 18, 33, 18, 0, -23 },
  { 5030, 13, 23, 15, 1, -23 },
  { 5068, 12, 38, 16, 2, -31 },
  { 5125, 3, 43, 19, 8, -33 },
  { 5142, 12, 38, 16, 2, -31 },
  { 5199, 18, 6, 20, 1, -18 },
};

const GFXfont NotoSans_Condensed_Regular43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_REGULAR43PT7B_H_
