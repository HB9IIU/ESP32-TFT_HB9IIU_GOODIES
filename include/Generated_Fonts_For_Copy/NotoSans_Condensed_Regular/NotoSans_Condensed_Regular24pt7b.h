#ifndef _NOTOSANS_CONDENSED_REGULAR24PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0xE6, 0xCD, 0x9A, 0x34, 0x68, 0xC0,
  0x0C, 0x40, 0xC4, 0x0C, 0xC0, 0xCC, 0x08, 0xC7, 0xFF, 0x08, 0x81, 0x88,
  0x19, 0x81, 0x98, 0xFF, 0xEF, 0xFE, 0x11, 0x81, 0x10, 0x31, 0x03, 0x30,
  0x33, 0x00, 0x08, 0x04, 0x0F, 0xEF, 0xFC, 0x86, 0x43, 0x21, 0xD0, 0x78,
  0x0F, 0x03, 0xE1, 0x30, 0x98, 0x4E, 0x27, 0xFE, 0x3C, 0x04, 0x02, 0x00,
  0x78, 0x30, 0x98, 0x43, 0x31, 0x86, 0x62, 0x0C, 0xCC, 0x19, 0x98, 0x33,
  0x22, 0x66, 0xDE, 0x4D, 0x26, 0xF6, 0xCC, 0x0D, 0x98, 0x33, 0x30, 0x66,
  0x60, 0x8C, 0xC3, 0x19, 0x84, 0x13, 0x18, 0x3C, 0x3E, 0x03, 0x70, 0x63,
  0x06, 0x30, 0x63, 0x03, 0x60, 0x3E, 0x01, 0xC0, 0x3C, 0x16, 0xE6, 0xC6,
  0x6C, 0x36, 0xC3, 0xCC, 0x1C, 0xC1, 0xC7, 0xF6, 0x3E, 0x70, 0xED, 0xA4,
  0x80, 0x19, 0x8C, 0xC6, 0x33, 0x98, 0xC6, 0x31, 0x8C, 0x61, 0x8C, 0x61,
  0x8C, 0x31, 0x80, 0xC3, 0x18, 0x63, 0x18, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0xC6, 0x33, 0x98, 0x8C, 0x00, 0x18, 0x0C, 0x22, 0x3F, 0xF1, 0xC1, 0xE0,
  0xD8, 0xCE, 0x24, 0x00, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC7, 0xFC, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0x6D, 0xED, 0x80, 0xFF, 0xC0, 0xFC, 0x03,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x08, 0x0C, 0x06, 0x06,
  0x03, 0x01, 0x81, 0x80, 0xC0, 0xE0, 0x00, 0x3E, 0x3B, 0x98, 0xCC, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1B, 0x0D, 0x8C,
  0xFE, 0x3E, 0x00, 0x19, 0xDB, 0xB9, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x18, 0x7E, 0x7B, 0x90, 0xC0, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x06,
  0x07, 0x03, 0x03, 0x03, 0x03, 0x81, 0x81, 0xFF, 0xFF, 0x80, 0x7E, 0x73,
  0xA0, 0xE0, 0x30, 0x18, 0x18, 0x0C, 0x7C, 0x3E, 0x03, 0x80, 0x60, 0x30,
  0x18, 0x0E, 0x0F, 0xFE, 0xFE, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x02, 0xC0,
  0xD8, 0x13, 0x06, 0x60, 0x8C, 0x31, 0x84, 0x31, 0x86, 0x7F, 0xFF, 0xFE,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x03,
  0x01, 0x21, 0xFE, 0x47, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x0F, 0xFE,
  0xFE, 0x00, 0x1F, 0x1E, 0x9C, 0x0C, 0x06, 0x06, 0x03, 0x39, 0xBE, 0xE3,
  0xF0, 0xF0, 0x78, 0x3C, 0x1B, 0x0D, 0x86, 0x7E, 0x3E, 0x00, 0xFF, 0xFF,
  0xC0, 0x60, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x00, 0x3F, 0x39, 0xB8, 0x78, 0x3E, 0x1B,
  0x1D, 0xCC, 0x7C, 0x3E, 0x3B, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x06, 0xEF,
  0x3F, 0x00, 0x3E, 0x3B, 0xB8, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x63,
  0xBF, 0xC6, 0x60, 0x30, 0x18, 0x18, 0x1C, 0xFC, 0x7C, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x6D, 0x80, 0x00, 0x01, 0xB7, 0xB6, 0x00, 0x81, 0xC3, 0xC3,
  0x87, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x20, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0C,
  0x1E, 0x3C, 0x78, 0x70, 0x20, 0x00, 0xFE, 0x6E, 0x03, 0x03, 0x03, 0x03,
  0x06, 0x0C, 0x1C, 0x18, 0x10, 0x10, 0x00, 0x00, 0x10, 0x38, 0x38, 0x07,
  0xE0, 0x38, 0x70, 0xE0, 0x31, 0x80, 0x66, 0x18, 0x6C, 0x7C, 0xD1, 0x99,
  0xE6, 0x31, 0xCC, 0x63, 0x98, 0xC7, 0x31, 0x9E, 0x63, 0x3C, 0x6A, 0x48,
  0xF7, 0x98, 0x00, 0x30, 0x00, 0x30, 0x00, 0x3D, 0xC0, 0x3F, 0x80, 0x06,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x09, 0x81, 0x98, 0x19, 0x81, 0x98, 0x30,
  0xC3, 0x0C, 0x3F, 0xC3, 0xFE, 0x60, 0x66, 0x06, 0x60, 0x6E, 0x03, 0xC0,
  0x30, 0xFE, 0x3F, 0xEC, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x3B, 0xFC, 0xFF,
  0x30, 0xEC, 0x1B, 0x07, 0xC1, 0xF0, 0x7C, 0x1B, 0xFE, 0xFE, 0x00, 0x0F,
  0xCF, 0x73, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xFF, 0x0F, 0xC0, 0xFE, 0x1F, 0xE3,
  0x0E, 0x60, 0xEC, 0x0D, 0x81, 0xB0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x6C, 0x0D, 0x83, 0xB0, 0xE7, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0xF1, 0xEE, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC1, 0xFC, 0x1F, 0xE0, 0x36,
  0x03, 0x60, 0x37, 0x03, 0x38, 0x31, 0xFF, 0x0F, 0xF0, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xF9, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xCE, 0xF8, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x7F, 0x60, 0xC1, 0xF0, 0xEC, 0x33,
  0x18, 0xC6, 0x33, 0x0D, 0x83, 0x60, 0xF8, 0x3B, 0x0C, 0xC3, 0x18, 0xC7,
  0x30, 0xCC, 0x3B, 0x06, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xBF, 0x03, 0x7B, 0x06, 0xF6, 0x09,
  0xEC, 0x33, 0xCC, 0x67, 0x98, 0xCF, 0x33, 0x1E, 0x36, 0x3C, 0x6C, 0x78,
  0xF0, 0xF0, 0xE1, 0xE1, 0xC3, 0xC3, 0x06, 0xE0, 0x7C, 0x0F, 0xC1, 0xF8,
  0x3D, 0x87, 0xB0, 0xF3, 0x1E, 0x63, 0xCE, 0x78, 0xCF, 0x1D, 0xE1, 0xBC,
  0x3F, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xE0, 0x1F, 0xC1, 0xEF, 0x1C, 0x18,
  0xC0, 0x66, 0x03, 0x70, 0x1B, 0x80, 0xD8, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x0C, 0xC0, 0x66, 0x03, 0x30, 0x38, 0xC1, 0x87, 0xFC, 0x0F, 0x80, 0xFE,
  0x7F, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x86, 0xDF, 0x7F, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x00, 0x1F, 0xC1, 0xEF, 0x1C, 0x18,
  0xC0, 0x66, 0x03, 0x70, 0x1B, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8,
  0x0E, 0xC0, 0x66, 0x03, 0x30, 0x38, 0xC1, 0x87, 0xFC, 0x1F, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC1,
  0xB0, 0x6C, 0x1B, 0x0C, 0xFE, 0x3F, 0x0C, 0xE3, 0x18, 0xC7, 0x30, 0xCC,
  0x3B, 0x06, 0xC1, 0xC0, 0x3F, 0xBF, 0xB8, 0x18, 0x0C, 0x07, 0x01, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x0D, 0xFE, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0xC0, 0x7E, 0x06, 0x60,
  0x66, 0x06, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x81, 0x98, 0x19,
  0x81, 0xB8, 0x1B, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x06, 0x00, 0xC0, 0xE0,
  0xEC, 0x1C, 0x19, 0x83, 0x83, 0x30, 0x70, 0x66, 0x1A, 0x0C, 0xC3, 0x63,
  0x0C, 0x6C, 0x61, 0x89, 0x8C, 0x33, 0x11, 0x86, 0x63, 0x60, 0x6C, 0x6C,
  0x0D, 0x8D, 0x81, 0xA1, 0xB0, 0x3C, 0x16, 0x07, 0x83, 0x80, 0x70, 0x70,
  0x0C, 0x0E, 0x00, 0x60, 0xEC, 0x18, 0xC6, 0x18, 0xC1, 0xB0, 0x36, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x6C, 0x0D, 0x83, 0x18, 0x63, 0x18, 0x73,
  0x06, 0xE0, 0xE0, 0xC0, 0xEC, 0x19, 0x87, 0x38, 0xC3, 0x18, 0x66, 0x06,
  0xC0, 0xD8, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x00, 0xFF, 0x7F, 0x80, 0xC0, 0xC0, 0x60, 0x70, 0x30, 0x38,
  0x18, 0x1C, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0xFE,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xFF,
  0x80, 0xE0, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x80, 0xF8, 0xC6, 0x31,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xFF, 0x80, 0x0C,
  0x07, 0x01, 0xE0, 0xD8, 0x33, 0x18, 0xC6, 0x1B, 0x06, 0xC0, 0xC0, 0xFF,
  0xFF, 0xFC, 0xE3, 0x0E, 0x3E, 0x7F, 0x03, 0x03, 0x03, 0x1F, 0x7F, 0xE3,
  0xC3, 0xC3, 0xC3, 0xED, 0x79, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0xF3,
  0xFD, 0xC6, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x87, 0xF7,
  0x4F, 0x00, 0x1F, 0x7E, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0,
  0x60, 0x7F, 0x3F, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xCF, 0x37, 0xED,
  0x87, 0xE1, 0xF0, 0x7C, 0x1F, 0x03, 0xC1, 0xF0, 0x7C, 0x1D, 0x87, 0x7E,
  0xCF, 0xB0, 0x1E, 0x3F, 0x98, 0xD8, 0x3C, 0x1F, 0xFF, 0xFF, 0x80, 0xC0,
  0x70, 0x18, 0x0F, 0x71, 0xF0, 0x1E, 0x74, 0xC1, 0x83, 0x0F, 0xBF, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x3C, 0xDF, 0xB6,
  0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x0F, 0x07, 0xC1, 0xF0, 0x76, 0x1D, 0xFB,
  0x3C, 0xC0, 0x30, 0x18, 0x06, 0x43, 0x9F, 0xC3, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xDE, 0xFF, 0xE3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xBC, 0x3F, 0xFF, 0xFF, 0xF0, 0x10, 0xC6, 0x00, 0x0C,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x9F, 0xDC, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC3, 0xC6, 0xCC, 0xCC, 0xD8, 0xF8, 0xF8, 0xDC,
  0xCC, 0xCE, 0xC6, 0xC7, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x9E, 0x79,
  0x7F, 0xFB, 0x0E, 0x36, 0x18, 0x6C, 0x30, 0x78, 0x60, 0xF0, 0xC1, 0xE1,
  0x83, 0xC3, 0x07, 0x86, 0x0F, 0x0C, 0x1E, 0x18, 0x3C, 0x30, 0x60, 0x9E,
  0xBF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x1E, 0x1F, 0xC6, 0x1B, 0x86, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8,
  0x66, 0x19, 0xFC, 0x3E, 0x00, 0x9E, 0x7F, 0xB8, 0xD8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xFE, 0xED, 0xE6, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x00, 0x3C, 0xDF, 0xB6, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x0F,
  0x07, 0xC1, 0xF0, 0x76, 0x1D, 0xFB, 0x3D, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x9E, 0xFE, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x7F, 0xFF, 0x06, 0x0C, 0x0E, 0x0F, 0x07, 0x06, 0x0E, 0x1F, 0xFF,
  0xC0, 0x30, 0x60, 0xC3, 0xEF, 0xC6, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0F, 0x8F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFD, 0x79, 0xC0, 0xF8, 0x66, 0x19, 0x86, 0x61, 0x8C, 0xC3,
  0x30, 0xCC, 0x16, 0x07, 0x81, 0xE0, 0x70, 0x0C, 0x00, 0xC1, 0x83, 0x63,
  0x86, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x62, 0x4C, 0x36, 0x6C, 0x36,
  0x6C, 0x36, 0x6C, 0x34, 0x68, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x61,
  0xD8, 0x63, 0x30, 0xCC, 0x1E, 0x07, 0x80, 0xC0, 0x78, 0x1E, 0x0C, 0xC3,
  0x31, 0x86, 0xE1, 0xC0, 0xC0, 0xD8, 0x66, 0x19, 0x86, 0x61, 0x8C, 0xC3,
  0x30, 0xCC, 0x16, 0x07, 0x81, 0xE0, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x3C, 0x0E, 0x00, 0xFF, 0xFC, 0x30, 0x61, 0x83, 0x0C, 0x18, 0x60,
  0xC3, 0x07, 0xFF, 0xE0, 0x0E, 0x3C, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x31,
  0xE3, 0x01, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x60, 0xF0, 0x60, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x18, 0x3C, 0x38, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC7, 0x8C, 0x00,
  0x70, 0x7F, 0xF8, 0x78,
};

const GFXglyph NotoSans_Condensed_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 17, 6, 2, -17 },
  { 6, 7, 6, 9, 1, -17 },
  { 12, 12, 17, 12, 0, -17 },
  { 38, 9, 19, 11, 1, -18 },
  { 60, 15, 17, 17, 1, -17 },
  { 92, 12, 17, 13, 1, -17 },
  { 118, 3, 6, 5, 1, -17 },
  { 121, 5, 21, 7, 1, -17 },
  { 135, 5, 21, 7, 1, -17 },
  { 149, 9, 9, 11, 1, -18 },
  { 160, 9, 11, 11, 1, -14 },
  { 173, 3, 6, 6, 1, -3 },
  { 176, 5, 2, 7, 1, -7 },
  { 178, 2, 3, 6, 2, -3 },
  { 179, 9, 17, 9, 0, -17 },
  { 199, 9, 17, 11, 1, -17 },
  { 219, 5, 17, 11, 2, -17 },
  { 230, 9, 17, 11, 1, -17 },
  { 250, 9, 17, 11, 1, -17 },
  { 270, 11, 17, 11, 0, -17 },
  { 294, 9, 17, 11, 1, -17 },
  { 314, 9, 17, 11, 1, -17 },
  { 334, 9, 17, 11, 1, -17 },
  { 354, 9, 17, 11, 1, -17 },
  { 374, 9, 17, 11, 1, -17 },
  { 394, 2, 13, 6, 2, -13 },
  { 398, 3, 16, 6, 1, -13 },
  { 404, 9, 11, 11, 1, -14 },
  { 417, 9, 7, 11, 1, -12 },
  { 425, 9, 11, 11, 1, -14 },
  { 438, 8, 17, 8, 0, -17 },
  { 455, 15, 19, 17, 1, -17 },
  { 491, 12, 17, 12, 0, -17 },
  { 517, 10, 17, 13, 2, -17 },
  { 539, 10, 17, 12, 1, -17 },
  { 561, 11, 17, 14, 2, -17 },
  { 585, 8, 17, 11, 2, -17 },
  { 602, 8, 17, 10, 2, -17 },
  { 619, 12, 17, 14, 1, -17 },
  { 645, 10, 17, 14, 2, -17 },
  { 667, 5, 17, 7, 1, -17 },
  { 678, 5, 22, 6, -1, -17 },
  { 692, 10, 17, 12, 2, -17 },
  { 714, 8, 17, 10, 2, -17 },
  { 731, 15, 17, 19, 2, -17 },
  { 763, 11, 17, 15, 2, -17 },
  { 787, 13, 17, 15, 1, -17 },
  { 815, 9, 17, 12, 2, -17 },
  { 835, 13, 21, 15, 1, -17 },
  { 870, 10, 17, 12, 2, -17 },
  { 892, 9, 17, 11, 1, -17 },
  { 912, 10, 17, 10, 0, -17 },
  { 934, 10, 17, 14, 2, -17 },
  { 956, 12, 17, 12, 0, -17 },
  { 982, 19, 17, 19, 0, -17 },
  { 1023, 11, 17, 11, 0, -17 },
  { 1047, 11, 17, 11, 0, -17 },
  { 1071, 9, 17, 10, 1, -17 },
  { 1091, 5, 21, 8, 2, -17 },
  { 1105, 9, 17, 9, 0, -17 },
  { 1125, 5, 21, 8, 1, -17 },
  { 1139, 10, 9, 12, 1, -17 },
  { 1151, 11, 2, 11, 0, 2 },
  { 1154, 5, 3, 6, 1, -18 },
  { 1156, 8, 13, 11, 1, -13 },
  { 1169, 9, 18, 12, 2, -18 },
  { 1190, 8, 13, 9, 1, -13 },
  { 1203, 10, 18, 12, 1, -18 },
  { 1226, 9, 13, 11, 1, -13 },
  { 1241, 7, 18, 7, 0, -18 },
  { 1257, 10, 19, 12, 1, -13 },
  { 1281, 8, 18, 12, 2, -18 },
  { 1299, 2, 18, 5, 2, -18 },
  { 1304, 5, 24, 5, -1, -18 },
  { 1319, 8, 18, 11, 2, -18 },
  { 1337, 2, 18, 5, 2, -18 },
  { 1342, 15, 13, 18, 2, -13 },
  { 1367, 8, 13, 12, 2, -13 },
  { 1380, 10, 13, 12, 1, -13 },
  { 1397, 9, 19, 12, 2, -13 },
  { 1419, 10, 19, 12, 1, -13 },
  { 1443, 6, 13, 8, 2, -13 },
  { 1453, 7, 13, 9, 1, -13 },
  { 1465, 7, 16, 7, 0, -16 },
  { 1479, 8, 13, 12, 2, -13 },
  { 1492, 10, 13, 10, 0, -13 },
  { 1509, 16, 13, 16, 0, -13 },
  { 1535, 10, 13, 10, 0, -13 },
  { 1552, 10, 19, 10, 0, -13 },
  { 1576, 7, 13, 8, 1, -13 },
  { 1588, 7, 21, 9, 1, -17 },
  { 1607, 2, 24, 11, 4, -18 },
  { 1613, 7, 21, 9, 1, -17 },
  { 1632, 10, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Regular24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_REGULAR24PT7B_H_
