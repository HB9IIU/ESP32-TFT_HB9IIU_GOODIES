#ifndef _NOTOSANS_CONDENSED_REGULAR14PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA8, 0xB0, 0xBA, 0xAA, 0x14, 0x48, 0x93, 0xF2, 0x85, 0x3F,
  0x94, 0x48, 0x90, 0x21, 0x3F, 0x4A, 0x70, 0xC5, 0x2F, 0x88, 0x40, 0xE6,
  0xA4, 0xA4, 0xA8, 0xAF, 0xF5, 0x15, 0x25, 0x25, 0x67, 0x38, 0x48, 0x48,
  0x28, 0x30, 0x72, 0x4A, 0xCE, 0x4E, 0x7B, 0xF0, 0x6A, 0x49, 0x24, 0x91,
  0x30, 0xC8, 0x92, 0x49, 0x25, 0xE0, 0x61, 0x3E, 0xCD, 0x28, 0x10, 0x41,
  0x3F, 0x10, 0x40, 0xEA, 0xF0, 0xC0, 0x08, 0x84, 0x22, 0x10, 0x88, 0x46,
  0x00, 0x74, 0xA3, 0x18, 0xC6, 0x31, 0x93, 0x80, 0x2E, 0x92, 0x49, 0x24,
  0xF4, 0xC6, 0x31, 0x18, 0x88, 0x87, 0xC0, 0xF4, 0xC6, 0x26, 0x18, 0x21,
  0x1F, 0x80, 0x08, 0x61, 0x8A, 0x29, 0x28, 0xBF, 0x08, 0x20, 0xF4, 0x21,
  0x0F, 0x0C, 0x21, 0x1F, 0x80, 0x76, 0x21, 0x0F, 0x46, 0x31, 0x9B, 0x80,
  0xFC, 0x10, 0x82, 0x08, 0x41, 0x0C, 0x21, 0x80, 0xF4, 0xE3, 0x37, 0x7A,
  0x31, 0x8F, 0x80, 0x74, 0xA3, 0x19, 0xF4, 0x23, 0x17, 0x00, 0xC3, 0x50,
  0x05, 0x70, 0x04, 0x66, 0x38, 0x18, 0x10, 0xF8, 0x01, 0xF0, 0xC0, 0xC0,
  0xC3, 0x33, 0x00, 0xF0, 0xC6, 0x23, 0x10, 0x80, 0x23, 0x00, 0x3C, 0x42,
  0x81, 0x9D, 0xA5, 0xA5, 0xA5, 0xBD, 0x82, 0x40, 0x3C, 0x10, 0x50, 0xA1,
  0x42, 0x88, 0x9F, 0x22, 0xC7, 0x04, 0xFA, 0x28, 0xE2, 0xFA, 0x28, 0xE1,
  0x8F, 0xE0, 0x7D, 0x08, 0x20, 0x82, 0x08, 0x20, 0x41, 0xE0, 0xFA, 0x38,
  0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0xFC, 0x21, 0x0F, 0x42, 0x10, 0x87,
  0xC0, 0xFC, 0x21, 0x08, 0x7A, 0x10, 0x84, 0x00, 0x3C, 0x8A, 0x04, 0x08,
  0x11, 0xE1, 0xC3, 0x46, 0x7C, 0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86,
  0x10, 0xF6, 0x66, 0x66, 0x66, 0x6F, 0x24, 0x92, 0x49, 0x24, 0xDC, 0x8E,
  0x29, 0x2C, 0xA3, 0xC9, 0x26, 0x8A, 0x30, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x87, 0xC0, 0xC1, 0xE0, 0xE8, 0xB4, 0x5A, 0x2D, 0xA6, 0x53, 0x29, 0x98,
  0xC4, 0x40, 0xC3, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5, 0x8F, 0x0C, 0x79,
  0x8A, 0x1C, 0x18, 0x30, 0x60, 0xC3, 0xC4, 0xF0, 0xF4, 0x63, 0x18, 0xFA,
  0x10, 0x84, 0x00, 0x79, 0x8A, 0x1C, 0x18, 0x30, 0x60, 0xC3, 0xC4, 0xF0,
  0x20, 0x70, 0xF2, 0x28, 0xA2, 0x9B, 0xC9, 0x26, 0x8A, 0x30, 0x7C, 0x21,
  0x0E, 0x18, 0x61, 0x9F, 0x80, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xE0, 0x87, 0x89, 0x12,
  0x24, 0xC5, 0x0A, 0x14, 0x30, 0x20, 0x84, 0x38, 0x8D, 0x29, 0x25, 0x24,
  0xA4, 0x95, 0x8C, 0xE1, 0x8C, 0x31, 0x86, 0x30, 0xC5, 0x26, 0x8E, 0x30,
  0xC3, 0x92, 0x4F, 0x10, 0x85, 0x34, 0x9A, 0x30, 0xC3, 0x0C, 0x30, 0xC0,
  0xF8, 0x21, 0x84, 0x10, 0x82, 0x10, 0x43, 0xF0, 0xF2, 0x49, 0x24, 0x92,
  0x70, 0xC2, 0x10, 0x42, 0x10, 0x42, 0x10, 0x40, 0xE4, 0x92, 0x49, 0x24,
  0xF0, 0x10, 0xC2, 0x92, 0x46, 0x10, 0xFC, 0xB4, 0x69, 0x13, 0xD9, 0x9F,
  0x84, 0x21, 0x6D, 0xC6, 0x31, 0x8E, 0x6E, 0x3D, 0x88, 0x88, 0x87, 0x08,
  0x42, 0xDD, 0xC6, 0x31, 0x8C, 0x5E, 0x66, 0xA3, 0x1F, 0x42, 0x0F, 0x36,
  0x47, 0xC4, 0x44, 0x44, 0x40, 0x6E, 0xE3, 0x18, 0xC6, 0x2F, 0x08, 0x7C,
  0x84, 0x21, 0x6D, 0xC6, 0x31, 0x8C, 0x62, 0xBF, 0xC0, 0x45, 0x55, 0x55,
  0xC0, 0x84, 0x21, 0x19, 0x52, 0x9C, 0x94, 0xA2, 0xFF, 0xE0, 0xB3, 0x6E,
  0xA2, 0x71, 0x38, 0x9C, 0x4E, 0x27, 0x13, 0xB6, 0xE3, 0x18, 0xC6, 0x31,
  0x66, 0xE3, 0x18, 0xC6, 0x2E, 0xB6, 0xE3, 0x18, 0xC7, 0x37, 0x84, 0x20,
  0x6E, 0xE3, 0x18, 0xC6, 0x2F, 0x08, 0x42, 0xBE, 0x88, 0x88, 0x88, 0x69,
  0x8C, 0x61, 0x1E, 0x47, 0xC4, 0x44, 0x44, 0x70, 0x8C, 0x63, 0x18, 0xC6,
  0x2F, 0x87, 0x24, 0x92, 0x59, 0xC3, 0x0C, 0x88, 0xE6, 0x55, 0x6A, 0xA5,
  0x52, 0xA8, 0xCC, 0x44, 0xCD, 0x27, 0x8C, 0x30, 0xC4, 0xB3, 0x87, 0x24,
  0x92, 0x58, 0xC3, 0x0C, 0x20, 0x8E, 0x00, 0x70, 0x84, 0x42, 0x21, 0x1F,
  0x34, 0x44, 0x4C, 0xC4, 0x44, 0x43, 0xFF, 0xFC, 0x84, 0x44, 0x46, 0x74,
  0x44, 0x4C, 0x66, 0x70,
};

const GFXglyph NotoSans_Condensed_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 2, 10, 3, 1, -10 },
  { 4, 4, 4, 5, 1, -10 },
  { 6, 7, 10, 7, 0, -10 },
  { 15, 5, 12, 7, 1, -11 },
  { 23, 8, 10, 10, 1, -10 },
  { 33, 8, 10, 8, 0, -10 },
  { 43, 1, 4, 3, 1, -10 },
  { 44, 3, 12, 4, 1, -10 },
  { 49, 3, 12, 4, 0, -10 },
  { 54, 5, 6, 6, 1, -11 },
  { 58, 6, 6, 7, 0, -8 },
  { 63, 2, 4, 3, 1, -2 },
  { 64, 4, 1, 4, 0, -4 },
  { 65, 1, 2, 3, 1, -2 },
  { 66, 5, 10, 5, 0, -10 },
  { 73, 5, 10, 7, 1, -10 },
  { 80, 3, 10, 7, 1, -10 },
  { 84, 5, 10, 7, 1, -10 },
  { 91, 5, 10, 7, 1, -10 },
  { 98, 6, 10, 7, 0, -10 },
  { 106, 5, 10, 7, 1, -10 },
  { 113, 5, 10, 7, 1, -10 },
  { 120, 6, 10, 7, 0, -10 },
  { 128, 5, 10, 7, 1, -10 },
  { 135, 5, 10, 7, 1, -10 },
  { 142, 1, 8, 3, 1, -8 },
  { 143, 2, 10, 3, 0, -8 },
  { 146, 6, 6, 7, 0, -8 },
  { 151, 5, 4, 7, 1, -7 },
  { 154, 6, 6, 7, 0, -8 },
  { 159, 5, 10, 5, 0, -10 },
  { 166, 8, 11, 10, 1, -10 },
  { 177, 7, 10, 7, 0, -10 },
  { 186, 6, 10, 7, 1, -10 },
  { 194, 6, 10, 7, 1, -10 },
  { 202, 6, 10, 8, 1, -10 },
  { 210, 5, 10, 6, 1, -10 },
  { 217, 5, 10, 6, 1, -10 },
  { 224, 7, 10, 8, 1, -10 },
  { 233, 6, 10, 8, 1, -10 },
  { 241, 4, 10, 4, 0, -10 },
  { 246, 3, 13, 3, -1, -10 },
  { 251, 6, 10, 7, 1, -10 },
  { 259, 5, 10, 6, 1, -10 },
  { 266, 9, 10, 11, 1, -10 },
  { 278, 7, 10, 9, 1, -10 },
  { 287, 7, 10, 9, 1, -10 },
  { 296, 5, 10, 7, 1, -10 },
  { 303, 7, 12, 9, 1, -10 },
  { 314, 6, 10, 7, 1, -10 },
  { 322, 5, 10, 6, 1, -10 },
  { 329, 6, 10, 6, 0, -10 },
  { 337, 6, 10, 8, 1, -10 },
  { 345, 7, 10, 7, 0, -10 },
  { 354, 11, 10, 11, 0, -10 },
  { 368, 6, 10, 6, 0, -10 },
  { 376, 6, 10, 6, 0, -10 },
  { 384, 6, 10, 6, 0, -10 },
  { 392, 3, 12, 4, 1, -10 },
  { 397, 5, 10, 5, 0, -10 },
  { 404, 3, 12, 4, 0, -10 },
  { 409, 6, 6, 7, 0, -10 },
  { 414, 6, 1, 6, 0, 1 },
  { 415, 2, 3, 4, 1, -11 },
  { 416, 4, 8, 6, 1, -8 },
  { 420, 5, 11, 7, 1, -11 },
  { 427, 4, 8, 5, 1, -8 },
  { 431, 5, 11, 7, 1, -11 },
  { 438, 5, 8, 6, 1, -8 },
  { 443, 4, 11, 4, 0, -11 },
  { 449, 5, 11, 7, 1, -8 },
  { 456, 5, 11, 7, 1, -11 },
  { 463, 1, 10, 3, 1, -10 },
  { 465, 2, 13, 3, 0, -10 },
  { 469, 5, 11, 6, 1, -11 },
  { 476, 1, 11, 3, 1, -11 },
  { 478, 9, 8, 11, 1, -8 },
  { 487, 5, 8, 7, 1, -8 },
  { 492, 5, 8, 7, 1, -8 },
  { 497, 5, 11, 7, 1, -8 },
  { 504, 5, 11, 7, 1, -8 },
  { 511, 4, 8, 5, 1, -8 },
  { 515, 4, 8, 5, 1, -8 },
  { 519, 4, 9, 4, 0, -9 },
  { 524, 5, 8, 7, 1, -8 },
  { 529, 6, 8, 6, 0, -8 },
  { 535, 9, 8, 9, 0, -8 },
  { 544, 6, 8, 6, 0, -8 },
  { 550, 6, 11, 6, 0, -8 },
  { 559, 5, 8, 5, 0, -8 },
  { 564, 4, 12, 5, 1, -10 },
  { 570, 1, 14, 6, 3, -11 },
  { 572, 4, 12, 5, 1, -10 },
  { 578, 6, 2, 7, 0, -6 },
};

const GFXfont NotoSans_Condensed_Regular14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_REGULAR14PT7B_H_
