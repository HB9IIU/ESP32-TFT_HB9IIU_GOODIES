#ifndef _NOTOSANS_CONDENSED_REGULAR72PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular72pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x7E, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x7E, 0x18, 0xFE, 0x07, 0xFF, 0xE0, 0x7E, 0x7E, 0x07,
  0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0,
  0x7E, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x03, 0xE3,
  0xC0, 0x3C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x01,
  0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x7C, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x03, 0xE0, 0x1E,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x1F, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0x80,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x3F, 0x8F, 0x07,
  0x87, 0xF0, 0xF0, 0x08, 0x7E, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xFC,
  0x0F, 0x00, 0x0F, 0xC0, 0xF0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0xF0,
  0x00, 0x7C, 0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7E, 0x0F, 0x00, 0x07,
  0xF8, 0xF0, 0x00, 0x3F, 0xCF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0xF3, 0xFC, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x0F, 0x03,
  0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xE8, 0x00, 0xF0,
  0x7E, 0xE0, 0x0F, 0x0F, 0xEF, 0xE0, 0xF3, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x10, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x1F, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x00, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0xF8, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x00, 0x3E,
  0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x80,
  0x7C, 0x1F, 0x01, 0xC0, 0x7C, 0x03, 0xE1, 0xF0, 0x7F, 0x81, 0xE0, 0x1F,
  0x0F, 0x87, 0xFE, 0x0F, 0x80, 0xF0, 0xF8, 0x7F, 0xF8, 0x7C, 0x0F, 0x87,
  0xC7, 0xFF, 0xE3, 0xE0, 0x7C, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xE3, 0xE1,
  0xF0, 0x7C, 0x7E, 0x7E, 0x1F, 0x1F, 0x03, 0xE1, 0xFF, 0xF1, 0xF0, 0xF8,
  0x0F, 0x0F, 0xFF, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0xF0, 0xF8, 0x3E, 0x03,
  0xE0, 0x7E, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x78, 0x07, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x7C,
  0x00, 0x1F, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xC1, 0xFE, 0xFE, 0x00, 0xFC, 0x1F, 0xE3, 0xF8, 0x07, 0xE0,
  0xFE, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x7E, 0x01, 0xFC,
  0x0F, 0x87, 0xF0, 0x07, 0xF0, 0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xE1, 0xF8,
  0x00, 0xFE, 0x7F, 0x0F, 0xC0, 0x03, 0xFB, 0xF0, 0x7E, 0x00, 0x0F, 0xFF,
  0x83, 0xF0, 0x00, 0x7F, 0xF8, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0xFC, 0x00,
  0x07, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x3F, 0x80, 0x1F,
  0xFF, 0x81, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE7, 0xF0, 0x3F,
  0xFF, 0xFE, 0x1F, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xFE, 0x03,
  0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F,
  0x3E, 0x7C, 0x78, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x60, 0x1E, 0x01, 0x9F, 0x07, 0x83, 0xEF,
  0xF9, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x07, 0xE1, 0xF8, 0x03,
  0xF8, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x7F, 0x03, 0xF8, 0x0F, 0x80, 0x7C,
  0x00, 0xE0, 0x1C, 0x00, 0x08, 0x04, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC7, 0xF1, 0xF8, 0x7E, 0x3F,
  0x8F, 0xE3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F,
  0x83, 0xE0, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x10, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7E, 0x38, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xF0, 0x1F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFE, 0x1F, 0xDF, 0x1F, 0xCF, 0xBF,
  0xC7, 0xFF, 0xC7, 0xEF, 0xC3, 0xF3, 0xC1, 0xF9, 0xC0, 0xFC, 0x40, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0x87,
  0xFE, 0x1F, 0x80, 0x1F, 0xE1, 0xE0, 0x01, 0xFC, 0x10, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x03, 0xFE, 0x1F, 0x00, 0x1F,
  0xE1, 0xC0, 0x01, 0xFC, 0x20, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE8, 0x00, 0x01, 0xFD, 0x80, 0x00, 0x7F,
  0xBE, 0x00, 0x3F, 0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0,
  0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x0D, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x02, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFE, 0x40, 0x00, 0x3F, 0xCC, 0x00, 0x0F, 0xF1,
  0xE0, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x18, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x1F,
  0xF8, 0x07, 0xE3, 0xFF, 0xC0, 0x7E, 0x7F, 0xFE, 0x07, 0xCF, 0xFF, 0xF0,
  0x7D, 0xFF, 0xFF, 0x8F, 0xFE, 0x03, 0xFC, 0xFF, 0xC0, 0x1F, 0xCF, 0xF8,
  0x00, 0xFE, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0,
  0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFE,
  0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0xFE, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0x81,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x9F, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xF3, 0xFE, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x83, 0xF8, 0x03, 0xFC, 0x7F, 0x00, 0x1F,
  0xE7, 0xE0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80,
  0x1F, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xE3, 0xFE, 0x0F, 0xF0, 0x1F, 0xC1, 0xFC,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0x3F,
  0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xEF,
  0xE0, 0x03, 0xFC, 0xFE, 0x00, 0xFF, 0x9F, 0xF0, 0x7F, 0xF1, 0xFF, 0xFF,
  0x7E, 0x1F, 0xFF, 0xEF, 0xC1, 0xFF, 0xF9, 0xF8, 0x1F, 0xFC, 0x3F, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0xFE,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x7E, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7E, 0x38, 0x1F, 0x0F, 0xE3, 0xF8, 0xFF, 0x3F, 0xCF, 0xF3, 0xF8, 0xFE,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x1F, 0xC7, 0xE3, 0xF8, 0xFE, 0x3F,
  0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F,
  0x83, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x81, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0xE1, 0xFF, 0x1E, 0x00, 0x7F,
  0x10, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x00,
  0x0F, 0x87, 0xE0, 0x07, 0xFF, 0xC0, 0x7C, 0x3E, 0x00, 0x7F, 0xFF, 0x03,
  0xE1, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0x9F, 0x80, 0x7F, 0xBF, 0xC0, 0x7C,
  0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x3E,
  0x03, 0xF0, 0x0F, 0x80, 0x7B, 0xE0, 0x1F, 0x00, 0xFC, 0x03, 0xFF, 0x00,
  0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xFF, 0xC0, 0x7C,
  0x01, 0xF8, 0x07, 0xFE, 0x03, 0xE0, 0x0F, 0x80, 0x3F, 0xF0, 0x1F, 0x00,
  0x7C, 0x01, 0xFF, 0x80, 0xF8, 0x03, 0xE0, 0x0F, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0x7F, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xDF, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF7, 0xC0, 0x7C, 0x01, 0xF0, 0x0F,
  0xBE, 0x03, 0xE0, 0x1F, 0x80, 0x7D, 0xF0, 0x1F, 0x00, 0xFC, 0x03, 0xEF,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x7C, 0x03, 0xE0, 0x7F, 0x81, 0xF3, 0xE0,
  0x1F, 0x83, 0xBC, 0x1F, 0x1F, 0x00, 0xFF, 0x7C, 0xFB, 0xF8, 0x7C, 0x03,
  0xFF, 0xC7, 0xFF, 0x83, 0xE0, 0x0F, 0xFE, 0x3F, 0xF8, 0x1F, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC,
  0x7E, 0x00, 0x3F, 0xE3, 0xF0, 0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0x7E, 0x03,
  0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE1, 0xF8, 0x00, 0xFF, 0x8F,
  0xC0, 0x01, 0xFE, 0x7E, 0x00, 0x07, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x1F, 0xEF, 0xC0, 0x01,
  0xFE, 0x7E, 0x00, 0x7F, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xE0, 0x7F, 0xC0,
  0x07, 0x81, 0xFE, 0x00, 0x04, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x20, 0x7F, 0xF0, 0x07, 0x80, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00,
  0x0F, 0xF0, 0xFC, 0x00, 0x07, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x03, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0xFC, 0x00,
  0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0xE0, 0xFC, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xC1, 0xFF, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xE0, 0x00, 0x18, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03,
  0xF0, 0xFF, 0x00, 0x00, 0x7E, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0xFF, 0xC0,
  0x07, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x01, 0xFE, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0,
  0x7F, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x7F, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03,
  0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x0F, 0xCF, 0xE0, 0x00, 0x3F, 0x7F, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0x9F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x3F, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xBE, 0x00, 0x00, 0x07,
  0xFF, 0xFB, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x0F, 0xBF,
  0xFB, 0xF0, 0x00, 0x00, 0xFB, 0xFF, 0x9F, 0x00, 0x00, 0x1F, 0xBF, 0xF9,
  0xF8, 0x00, 0x01, 0xFB, 0xFF, 0x9F, 0x80, 0x00, 0x1F, 0x3F, 0xFC, 0xF8,
  0x00, 0x01, 0xF3, 0xFF, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0xFC, 0xFC, 0x00,
  0x03, 0xE3, 0xFF, 0xC7, 0xC0, 0x00, 0x3E, 0x3F, 0xFC, 0x7E, 0x00, 0x07,
  0xE3, 0xFF, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0xFC, 0x3E, 0x00, 0x07, 0xC3,
  0xFF, 0xC3, 0xE0, 0x00, 0xFC, 0x3F, 0xFC, 0x3F, 0x00, 0x0F, 0x83, 0xFF,
  0xC3, 0xF0, 0x00, 0xF8, 0x3F, 0xFC, 0x1F, 0x00, 0x1F, 0x83, 0xFF, 0xC1,
  0xF8, 0x01, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xFF, 0xC0, 0xF8,
  0x03, 0xF0, 0x3F, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xFF, 0xC0, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x07, 0xC0, 0x7E, 0x03, 0xFF, 0xC0, 0x7E, 0x07, 0xE0,
  0x3F, 0xFC, 0x07, 0xE0, 0x7C, 0x03, 0xFF, 0xC0, 0x3E, 0x07, 0xC0, 0x3F,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0x0F, 0x80, 0x3F, 0xFC,
  0x01, 0xF0, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0x9F, 0x80, 0x3F, 0xFC, 0x01,
  0xF9, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0x9F, 0x00, 0x3F, 0xFC, 0x00, 0xFB,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFD,
  0xF8, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x03, 0xFF, 0x3F, 0x00, 0x01, 0xFF,
  0x9F, 0xC0, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0x7F, 0xE3, 0xF8, 0x00, 0x3F,
  0xF0, 0xFC, 0x00, 0x1F, 0xFC, 0x7F, 0x00, 0x0F, 0xFE, 0x1F, 0x80, 0x07,
  0xFF, 0x0F, 0xE0, 0x03, 0xFF, 0x83, 0xF0, 0x01, 0xFF, 0xC1, 0xF8, 0x00,
  0xFF, 0xE0, 0x7E, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x3F, 0xF8, 0x0F, 0xC0,
  0x1F, 0xFC, 0x07, 0xE0, 0x0F, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0x00, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0xFF, 0xE0, 0x0F,
  0xE0, 0x7F, 0xF0, 0x03, 0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x1F, 0xFC, 0x00,
  0x7E, 0x0F, 0xFE, 0x00, 0x3F, 0x87, 0xFF, 0x00, 0x0F, 0xC3, 0xFF, 0x80,
  0x07, 0xF1, 0xFF, 0xC0, 0x01, 0xF8, 0xFF, 0xE0, 0x00, 0xFE, 0x7F, 0xF0,
  0x00, 0x3F, 0x3F, 0xF8, 0x00, 0x1F, 0xDF, 0xFC, 0x00, 0x07, 0xEF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03,
  0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x07, 0xFF, 0x3F, 0x00, 0x1F, 0xE7, 0xE0,
  0x01, 0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFD, 0xF8, 0x00,
  0x3F, 0xBF, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0xFC, 0x00, 0xFF, 0x1F,
  0x87, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x0F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x0F, 0xFE, 0x0F, 0xC0,
  0x07, 0xF8, 0x3F, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF8, 0x3F, 0x00, 0x3F, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xF0, 0x03, 0xE1,
  0xFC, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE8, 0x00, 0x03, 0xF9, 0xC0, 0x00, 0xFF, 0x3F,
  0x80, 0x7F, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0xC0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFC,
  0x3F, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03,
  0xF7, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xE7, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE7, 0xE0, 0x03,
  0xF8, 0x0F, 0xC0, 0x07, 0xE7, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE3,
  0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC3, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC1, 0xF0,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0x81, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0x81, 0xF8, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x03,
  0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00,
  0xFC, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x78, 0x03, 0xF8, 0x10, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF3, 0xFF, 0x01, 0xFB, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xBF, 0x80, 0x7F, 0xDF, 0xE0, 0xFB, 0xEF,
  0xFF, 0xF9, 0xF3, 0xFF, 0xF8, 0xF8, 0xFF, 0xF8, 0x7C, 0x1F, 0xF8, 0x1E,
  0x01, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x1F, 0xF0, 0x0F, 0xC3, 0xFF, 0xC0, 0xFC, 0xFF, 0xFE, 0x0F, 0xDF, 0xFF,
  0xF0, 0xFD, 0xFF, 0xFF, 0x8F, 0xFE, 0x07, 0xF8, 0xFF, 0x80, 0x1F, 0xCF,
  0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xEF,
  0xF0, 0x00, 0xFE, 0xFF, 0x80, 0x1F, 0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0xFD,
  0xFF, 0x8F, 0x9F, 0xFF, 0xF0, 0xF8, 0xFF, 0xFF, 0x0F, 0x87, 0xFF, 0xC0,
  0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xFE, 0x03,
  0x87, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x1C, 0x3F, 0xFB, 0xF8,
  0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0xFF, 0x83, 0xF8, 0x0F, 0xFF, 0x0F, 0xC1, 0xFF, 0xFC, 0x7E, 0x0F,
  0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xDF, 0x8F, 0xF0, 0x3F, 0xFC, 0x7F, 0x00,
  0x7F, 0xE7, 0xF0, 0x01, 0xFF, 0x3F, 0x00, 0x07, 0xF9, 0xF8, 0x00, 0x3F,
  0xDF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF,
  0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x03,
  0xFC, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFF, 0x3F, 0x80, 0x0F, 0xF8,
  0xFE, 0x00, 0xFF, 0xC3, 0xFE, 0x3F, 0x7E, 0x1F, 0xFF, 0xFB, 0xF0, 0x7F,
  0xFF, 0x9F, 0x81, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0x03, 0xE0, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0x1F, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x41, 0xFC, 0x00, 0x78, 0x3F, 0xF8, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFE, 0x18, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0xF8, 0x0F, 0xFF, 0x0F,
  0xC0, 0xFF, 0xFC, 0x7E, 0x0F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xDF, 0x8F,
  0xF0, 0x3F, 0xFC, 0x7F, 0x00, 0x7F, 0xE7, 0xF0, 0x01, 0xFF, 0x3F, 0x00,
  0x07, 0xF9, 0xF8, 0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x01,
  0xFF, 0x3F, 0x80, 0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xC3, 0xFE, 0x7F, 0x7E,
  0x1F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFF, 0x9F, 0x81, 0xFF, 0xF8, 0xFC, 0x03,
  0xFF, 0x07, 0xE0, 0x03, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x20,
  0x00, 0x0F, 0xE0, 0xC0, 0x00, 0xFE, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0xF0, 0x3F,
  0x0F, 0xFF, 0x0F, 0xCF, 0xFF, 0xE3, 0xF7, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF,
  0xBF, 0xF8, 0x1F, 0xEF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFC, 0x79, 0xFB, 0xF7, 0xFF, 0xFF, 0xBF, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF,
  0xBF, 0x7E, 0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xFD, 0xFB, 0xF7,
  0xEF, 0xC0, 0x00, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x87, 0xF3, 0xFF, 0xCF, 0xFF, 0x3F,
  0xF8, 0xFF, 0xC3, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x07, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC,
  0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x3F, 0x80, 0x3F, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFE, 0x00, 0x3F, 0x7F, 0x80, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE7, 0xE0, 0x0F, 0xF1, 0xFC, 0x03,
  0xF8, 0x3F, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x1F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F,
  0xF0, 0x03, 0xFE, 0x07, 0xC3, 0xFF, 0xC0, 0x7F, 0xFC, 0x3E, 0x3F, 0xFF,
  0x07, 0xFF, 0xF1, 0xF3, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xDF, 0xFF, 0xF7,
  0xFF, 0xFE, 0x7F, 0xE0, 0x7F, 0xBE, 0x07, 0xF3, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xDF, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xF7, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xBF, 0x80, 0x07, 0xF0, 0x00, 0xFD,
  0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0xF8, 0x1F, 0xF0, 0x3E, 0x1F, 0xFF, 0x0F, 0x8F, 0xFF, 0xE3,
  0xE7, 0xFF, 0xFC, 0xFD, 0xFF, 0xFF, 0xBF, 0xF8, 0x1F, 0xEF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x07, 0xF0,
  0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE,
  0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x1F,
  0xF0, 0x0F, 0x83, 0xFF, 0xC0, 0xF8, 0xFF, 0xFE, 0x0F, 0x9F, 0xFF, 0xF0,
  0xFD, 0xFF, 0xFF, 0x8F, 0xFE, 0x03, 0xFC, 0xFF, 0x80, 0x1F, 0xCF, 0xF0,
  0x00, 0xFC, 0xFF, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7E, 0xFF, 0x00, 0x0F, 0xEF, 0xF0,
  0x00, 0xFC, 0xFF, 0x80, 0x1F, 0xCF, 0xFC, 0x03, 0xFC, 0xFF, 0xFD, 0xFF,
  0x8F, 0xDF, 0xFF, 0xF0, 0xFC, 0xFF, 0xFF, 0x0F, 0xC7, 0xFF, 0xC0, 0xFC,
  0x1F, 0xF8, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xF8, 0x0F, 0xFF, 0x0F, 0xC0, 0xFF, 0xFC,
  0x7E, 0x0F, 0xFF, 0xF3, 0xF0, 0xFF, 0xFF, 0xDF, 0x8F, 0xF0, 0x3E, 0xFC,
  0x7F, 0x00, 0x7F, 0xE7, 0xF0, 0x01, 0xFF, 0x3F, 0x00, 0x07, 0xF9, 0xF8,
  0x00, 0x3F, 0xDF, 0xC0, 0x01, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF,
  0x80, 0x03, 0xFC, 0xFC, 0x00, 0x1F, 0xE7, 0xF0, 0x01, 0xFF, 0x3F, 0x80,
  0x0F, 0xF8, 0xFF, 0x01, 0xFF, 0xC3, 0xFF, 0xFF, 0x7E, 0x1F, 0xFF, 0xF3,
  0xF0, 0x7F, 0xFF, 0x1F, 0x81, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0x0F, 0xE0,
  0x03, 0x80, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0xF8, 0x1F, 0xFE, 0x0F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF9, 0xFC, 0x03, 0xCF, 0xE0, 0x03,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFB,
  0xC0, 0x0F, 0xEF, 0xFB, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0x03, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xC7, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF,
  0xFF, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xF7, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x00,
  0xF0, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF,
  0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0x7F, 0x00, 0x7F,
  0xDF, 0xE0, 0x3F, 0xF3, 0xFF, 0xFF, 0x7C, 0xFF, 0xFF, 0x9F, 0x1F, 0xFF,
  0xC7, 0xC3, 0xFF, 0xE1, 0xF0, 0x7F, 0xF0, 0x7C, 0x01, 0xE0, 0x00, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E, 0x3F,
  0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFE,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3F, 0xE0,
  0x01, 0xF9, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xFF, 0x00,
  0x3F, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7D, 0xF0, 0x03,
  0xF0, 0xFC, 0x01, 0xF7, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xDF, 0x00, 0x3E,
  0x0F, 0xC0, 0x1F, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0xF8, 0x07, 0xE0,
  0x7E, 0x03, 0xE3, 0xE0, 0x1F, 0x81, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x07,
  0xE0, 0x3E, 0x3F, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x7C, 0x0F, 0xC0, 0x3F,
  0x07, 0xE1, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0x07, 0xC0, 0xF8, 0x03, 0xF0,
  0x7C, 0x1F, 0x83, 0xE0, 0x0F, 0xC1, 0xF0, 0x3E, 0x1F, 0x80, 0x1F, 0x0F,
  0xC0, 0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xF8,
  0x0F, 0x87, 0xC0, 0x07, 0xE3, 0xE0, 0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x80,
  0x7C, 0xFC, 0x00, 0x3E, 0x7C, 0x01, 0xF3, 0xF0, 0x00, 0xF9, 0xF0, 0x07,
  0xCF, 0x80, 0x03, 0xF7, 0xC0, 0x1F, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x3E,
  0xF8, 0x00, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xE0, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF7, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0xC1,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x9F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFE, 0x00,
  0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x7F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC,
  0x7F, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7F, 0xFF, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x08, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x09, 0xFF, 0xC0, 0x00, 0xDF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xD0, 0x00, 0x7F, 0xF8, 0x80, 0x00, 0x7F,
  0x00,
};

const GFXglyph NotoSans_Condensed_Regular72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 8, 52, 18, 5, -51 },
  { 53, 20, 18, 28, 4, -51 },
  { 98, 34, 51, 37, 2, -51 },
  { 315, 28, 59, 34, 3, -55 },
  { 522, 45, 53, 51, 3, -52 },
  { 821, 37, 53, 40, 3, -52 },
  { 1067, 7, 18, 15, 4, -51 },
  { 1083, 16, 63, 21, 3, -52 },
  { 1209, 16, 63, 21, 2, -52 },
  { 1335, 26, 27, 32, 3, -55 },
  { 1423, 28, 34, 34, 3, -42 },
  { 1542, 10, 17, 17, 3, -8 },
  { 1564, 17, 6, 21, 2, -22 },
  { 1577, 8, 10, 17, 5, -9 },
  { 1587, 25, 52, 27, 1, -52 },
  { 1750, 28, 53, 34, 3, -52 },
  { 1936, 17, 51, 34, 5, -51 },
  { 2045, 27, 52, 34, 3, -52 },
  { 2221, 27, 53, 34, 3, -52 },
  { 2400, 32, 52, 34, 1, -52 },
  { 2608, 27, 52, 34, 4, -51 },
  { 2784, 28, 53, 34, 3, -52 },
  { 2970, 28, 51, 34, 3, -51 },
  { 3149, 28, 53, 34, 3, -52 },
  { 3335, 27, 53, 34, 3, -52 },
  { 3514, 8, 40, 17, 5, -39 },
  { 3554, 10, 48, 17, 3, -39 },
  { 3614, 28, 33, 34, 3, -42 },
  { 3730, 28, 20, 34, 3, -35 },
  { 3800, 28, 33, 34, 3, -42 },
  { 3916, 23, 53, 25, 1, -52 },
  { 4069, 45, 58, 52, 4, -52 },
  { 4396, 36, 51, 37, 0, -51 },
  { 4626, 29, 51, 38, 6, -51 },
  { 4811, 30, 53, 36, 4, -52 },
  { 5010, 32, 51, 42, 6, -51 },
  { 5214, 23, 51, 32, 6, -51 },
  { 5361, 23, 51, 30, 6, -51 },
  { 5508, 35, 53, 43, 4, -52 },
  { 5740, 31, 51, 43, 6, -51 },
  { 5938, 16, 51, 22, 3, -51 },
  { 6040, 16, 65, 17, -4, -51 },
  { 6170, 30, 51, 36, 6, -51 },
  { 6362, 23, 51, 30, 6, -51 },
  { 6509, 44, 51, 56, 6, -51 },
  { 6790, 33, 51, 45, 6, -51 },
  { 7001, 37, 53, 45, 4, -52 },
  { 7247, 27, 51, 35, 6, -51 },
  { 7420, 37, 64, 45, 4, -52 },
  { 7716, 30, 51, 37, 6, -51 },
  { 7908, 27, 53, 33, 3, -52 },
  { 8087, 29, 51, 31, 1, -51 },
  { 8272, 32, 52, 42, 5, -51 },
  { 8480, 35, 51, 35, 0, -51 },
  { 8704, 56, 51, 56, 0, -51 },
  { 9061, 32, 51, 33, 0, -51 },
  { 9265, 32, 51, 32, 0, -51 },
  { 9469, 27, 51, 31, 2, -51 },
  { 9642, 16, 64, 23, 5, -52 },
  { 9770, 25, 52, 27, 1, -52 },
  { 9933, 16, 64, 23, 2, -52 },
  { 10061, 31, 28, 35, 2, -51 },
  { 10170, 32, 5, 32, 0, 6 },
  { 10190, 14, 11, 19, 3, -55 },
  { 10210, 25, 40, 33, 3, -39 },
  { 10335, 28, 56, 37, 5, -55 },
  { 10531, 23, 40, 28, 3, -39 },
  { 10646, 29, 56, 37, 3, -55 },
  { 10849, 27, 40, 33, 3, -39 },
  { 10984, 21, 55, 20, 1, -55 },
  { 11129, 29, 56, 37, 3, -39 },
  { 11332, 26, 55, 36, 5, -55 },
  { 11511, 7, 53, 16, 5, -53 },
  { 11558, 14, 70, 16, -2, -53 },
  { 11681, 26, 55, 32, 5, -55 },
  { 11860, 6, 55, 16, 5, -55 },
  { 11902, 45, 39, 55, 5, -39 },
  { 12122, 26, 39, 36, 5, -39 },
  { 12249, 29, 40, 36, 3, -39 },
  { 12394, 28, 56, 37, 5, -39 },
  { 12590, 29, 56, 37, 3, -39 },
  { 12793, 18, 39, 24, 5, -39 },
  { 12881, 22, 40, 27, 3, -39 },
  { 12991, 19, 48, 21, 1, -47 },
  { 13105, 26, 40, 36, 5, -39 },
  { 13235, 29, 39, 30, 0, -39 },
  { 13377, 46, 39, 47, 1, -39 },
  { 13602, 28, 39, 30, 1, -39 },
  { 13739, 29, 56, 30, 0, -39 },
  { 13942, 22, 39, 25, 2, -39 },
  { 14050, 21, 64, 26, 3, -52 },
  { 14218, 6, 72, 32, 13, -55 },
  { 14272, 21, 64, 26, 3, -52 },
  { 14440, 29, 9, 34, 3, -30 },
};

const GFXfont NotoSans_Condensed_Regular72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_REGULAR72PT7B_H_
