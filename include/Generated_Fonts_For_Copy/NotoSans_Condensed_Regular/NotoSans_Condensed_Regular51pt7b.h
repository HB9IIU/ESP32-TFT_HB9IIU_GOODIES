#ifndef _NOTOSANS_CONDENSED_REGULAR51PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7D, 0xF7, 0xDF, 0x7D, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3, 0x8E, 0x38, 0xE0, 0x00, 0x00, 0x07,
  0x9F, 0xFF, 0xFF, 0xDE, 0x10, 0xF8, 0x7F, 0xE1, 0xFF, 0x87, 0xFE, 0x1E,
  0xF8, 0x7B, 0xC1, 0xE7, 0x07, 0x9C, 0x1E, 0x70, 0x39, 0xC0, 0xE7, 0x03,
  0x9C, 0x0E, 0x70, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x78, 0x00, 0xF0,
  0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0,
  0x70, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xE0, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0xC0, 0xE0, 0x03, 0xC1,
  0xE0, 0x03, 0xC1, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x83, 0xC0, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x07, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x07, 0x03, 0x80, 0x0F, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x07,
  0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xE3, 0xFF, 0xFE,
  0x3F, 0x63, 0xC7, 0xC6, 0x04, 0x78, 0x60, 0x0F, 0x06, 0x00, 0xF0, 0x60,
  0x0F, 0x06, 0x00, 0xF0, 0x60, 0x07, 0x86, 0x00, 0x7C, 0x60, 0x03, 0xF6,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x06, 0xFE, 0x00, 0x63, 0xE0, 0x06, 0x1F, 0x00, 0x60, 0xF0,
  0x06, 0x0F, 0x00, 0x60, 0xF0, 0x06, 0x0F, 0x00, 0x61, 0xEC, 0x06, 0x3E,
  0xFC, 0x6F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0x07,
  0x80, 0x3D, 0xF0, 0x07, 0x00, 0x78, 0xF0, 0x0F, 0x00, 0x70, 0x70, 0x0E,
  0x00, 0x70, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x1C,
  0x00, 0xF0, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x38, 0x00, 0xF0, 0x78, 0x78,
  0x00, 0xF0, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x70, 0x00, 0xF0, 0x78, 0xF0,
  0x00, 0xF0, 0x78, 0xE1, 0xF8, 0x70, 0x79, 0xE3, 0xFC, 0x70, 0x71, 0xC7,
  0xFE, 0x78, 0xF1, 0xC7, 0x1E, 0x3D, 0xF3, 0xCF, 0x0E, 0x3F, 0xE3, 0x8E,
  0x0F, 0x1F, 0xC7, 0x8E, 0x0F, 0x0F, 0x87, 0x0E, 0x07, 0x00, 0x0F, 0x1E,
  0x07, 0x00, 0x0F, 0x1E, 0x07, 0x00, 0x0E, 0x1E, 0x07, 0x00, 0x1E, 0x1E,
  0x07, 0x00, 0x1C, 0x1E, 0x07, 0x00, 0x3C, 0x0E, 0x07, 0x00, 0x3C, 0x0E,
  0x07, 0x00, 0x38, 0x0E, 0x0F, 0x00, 0x78, 0x0E, 0x0F, 0x00, 0x70, 0x0F,
  0x0E, 0x00, 0xF0, 0x07, 0x1E, 0x00, 0xE0, 0x07, 0xFE, 0x00, 0xE0, 0x03,
  0xFC, 0x01, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x3E, 0x3F, 0x7C,
  0x0F, 0x0F, 0x8F, 0x03, 0xC7, 0xC3, 0xE0, 0xF1, 0xE0, 0x7C, 0x3C, 0xF8,
  0x0F, 0x9E, 0x3C, 0x03, 0xE7, 0x8F, 0x00, 0x7F, 0xE3, 0xC0, 0x0F, 0xF0,
  0xF0, 0x01, 0xFC, 0x3C, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x0F,
  0xF0, 0x7C, 0x07, 0xFE, 0x1F, 0xCF, 0xFF, 0xC3, 0xFF, 0xF9, 0xF0, 0x7F,
  0xF8, 0x3E, 0x0F, 0xFC, 0x07, 0xC0, 0x20, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xF9, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x00, 0xE0, 0x3C, 0x0F, 0x03, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0,
  0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0xF0, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78, 0x07,
  0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x18, 0x38, 0x77, 0xF7, 0x7E, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7B, 0x80, 0x0F,
  0x78, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x3E, 0x1F, 0x03, 0xC1, 0xC0, 0x10,
  0x20, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3E, 0x7C, 0xF9, 0xE3, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7,
  0x8E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE1, 0x00, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xFF, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0x7C,
  0x3C, 0x03, 0xC7, 0xC0, 0x3C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E,
  0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC1, 0xF9, 0xF8, 0x1F, 0xFF,
  0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x3F, 0x07,
  0xF0, 0xFF, 0x1F, 0xF3, 0xEF, 0x7C, 0xFF, 0x8F, 0xF0, 0xF6, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF8,
  0x7C, 0x0F, 0xC3, 0x00, 0x7C, 0x20, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0x80, 0xFC, 0xE0,
  0x0F, 0x88, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xDF, 0x07, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF,
  0x87, 0xFF, 0xC0, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01,
  0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x7F, 0xFF, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFE, 0x07,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE4, 0x00, 0xFC, 0xF8, 0x7F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xFC, 0x00, 0x10, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xFC, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x7C, 0x07, 0x9F, 0xF0, 0x7B, 0xFF, 0x8F, 0xFF,
  0xFC, 0xFF, 0x07, 0xCF, 0xC0, 0x3E, 0xFC, 0x01, 0xEF, 0x80, 0x1E, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xE0, 0x3E,
  0x1F, 0x07, 0xC1, 0xF8, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x03, 0xFE,
  0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x3E,
  0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x80, 0xF9,
  0xF0, 0x07, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xBF, 0x83, 0xE0, 0xFC, 0x7C, 0x07, 0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xFF,
  0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x03, 0xE7, 0xF0, 0x7E, 0x3F, 0xFF,
  0xC1, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x02, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0, 0x3E, 0x0F, 0x87, 0xC0, 0x7C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF8, 0x01, 0xFF, 0x80, 0x1F,
  0x78, 0x03, 0xF7, 0x80, 0x3F, 0x7C, 0x07, 0xF3, 0xF1, 0xFE, 0x3F, 0xFD,
  0xE1, 0xFF, 0xDE, 0x0F, 0xF1, 0xE0, 0x0C, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x02, 0x0F, 0xE0, 0x3F, 0xFC, 0x03,
  0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x31, 0xEF, 0xFF, 0xFD, 0xF7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xBF, 0xFF, 0xFF, 0xDE, 0x10, 0x18, 0x79, 0xFB, 0xF7, 0xE7, 0xCF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x9F, 0x3E, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x38, 0xF1, 0xE3, 0x80,
  0x00, 0x00, 0x10, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x70, 0x3E, 0x40, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x02, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0x3C, 0x03, 0xE0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x07, 0x80, 0x73, 0xC0, 0x7F,
  0xE0, 0xE7, 0x81, 0xFF, 0xC1, 0xEE, 0x07, 0xC7, 0x81, 0xFC, 0x0F, 0x07,
  0x03, 0xF8, 0x3C, 0x0E, 0x07, 0xF0, 0x78, 0x1C, 0x0F, 0xC0, 0xE0, 0x78,
  0x1F, 0x83, 0xC0, 0xF0, 0x3F, 0x07, 0x81, 0xE0, 0x7E, 0x0F, 0x03, 0xC0,
  0xFC, 0x1E, 0x07, 0x81, 0xF8, 0x3C, 0x0F, 0x03, 0xF0, 0x78, 0x1E, 0x07,
  0xE0, 0xF0, 0x3C, 0x1F, 0xC1, 0xE0, 0x78, 0x3F, 0x81, 0xC1, 0xF0, 0x77,
  0x83, 0xC3, 0x71, 0xEF, 0x07, 0xFE, 0xFF, 0x9E, 0x07, 0xF8, 0xFE, 0x1C,
  0x07, 0xE0, 0xF8, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x10, 0x00, 0xFC, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x03, 0xC0, 0x03, 0xC0,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x01, 0xE0, 0x0F,
  0x80, 0x78, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00,
  0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xE0,
  0x7F, 0xCF, 0x00, 0x3E, 0x78, 0x01, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3E,
  0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xEF, 0x00,
  0x1E, 0x78, 0x01, 0xF3, 0xC0, 0x1F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF1, 0xE0, 0x0F, 0xCF, 0x00, 0x3F, 0x78, 0x00,
  0xFB, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFE, 0x07, 0x0F, 0xC0, 0x08, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x10, 0x7F, 0xDF, 0x81, 0xFF, 0xFC, 0x07, 0xFF,
  0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0x83, 0xFF, 0x0F, 0x00, 0x7F, 0x1E, 0x00, 0x7E, 0x3C,
  0x00, 0x7E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0,
  0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7,
  0x80, 0x07, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x3E, 0x3C, 0x00, 0xFC, 0x78,
  0x07, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFE, 0x01, 0xE0, 0xFE, 0x00, 0x30, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0xC0, 0x0F, 0x87, 0xFE, 0x7F,
  0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x00, 0x10,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFD, 0xFF, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x03, 0xF0, 0xFB, 0xFF, 0x7F, 0xCF, 0xF0, 0xF8, 0x00, 0xF0, 0x00,
  0xFB, 0xC0, 0x07, 0xCF, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x07, 0xC3,
  0xC0, 0x3E, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0,
  0xF8, 0x0F, 0x07, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC7, 0xC0,
  0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF7, 0xE0, 0x03, 0xDF, 0x80, 0x0F,
  0xFF, 0x00, 0x3F, 0xBE, 0x00, 0xFC, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0x07,
  0xC0, 0x3C, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0,
  0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3E, 0x3C,
  0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00,
  0x3F, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF7, 0x80, 0x01, 0xFF, 0xF7, 0x80, 0x01, 0xFF, 0xF7, 0x80, 0x03,
  0xDF, 0xF7, 0x80, 0x03, 0xDF, 0xF3, 0xC0, 0x03, 0xDF, 0xF3, 0xC0, 0x07,
  0x9F, 0xF3, 0xC0, 0x07, 0x9F, 0xF1, 0xE0, 0x07, 0x9F, 0xF1, 0xE0, 0x0F,
  0x1F, 0xF1, 0xE0, 0x0F, 0x1F, 0xF0, 0xF0, 0x0F, 0x1F, 0xF0, 0xF0, 0x0E,
  0x1F, 0xF0, 0xF0, 0x1E, 0x1F, 0xF0, 0x78, 0x1E, 0x1F, 0xF0, 0x78, 0x1C,
  0x1F, 0xF0, 0x78, 0x3C, 0x1F, 0xF0, 0x3C, 0x3C, 0x1F, 0xF0, 0x3C, 0x3C,
  0x1F, 0xF0, 0x3C, 0x78, 0x1F, 0xF0, 0x3C, 0x78, 0x1F, 0xF0, 0x1E, 0x78,
  0x1F, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x1E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0,
  0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF0, 0x07, 0xE0,
  0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x03, 0xC0,
  0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xF7, 0x80,
  0x0F, 0xF7, 0xC0, 0x0F, 0xF3, 0xC0, 0x0F, 0xF3, 0xE0, 0x0F, 0xF1, 0xE0,
  0x0F, 0xF1, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0x78,
  0x0F, 0xF0, 0x7C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x1E,
  0x0F, 0xF0, 0x1F, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x07,
  0x8F, 0xF0, 0x07, 0xCF, 0xF0, 0x07, 0xCF, 0xF0, 0x03, 0xEF, 0xF0, 0x03,
  0xEF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xC0, 0xFC, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x7E,
  0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x78, 0x7F, 0xCF, 0x00, 0xFD, 0xE0, 0x0F, 0xBC, 0x00, 0xFF, 0x80, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x3E, 0xF0, 0x07, 0xDE, 0x03, 0xF3,
  0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xC0, 0xFC, 0x07,
  0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x1F, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x07, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFD, 0xFF, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x06, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F,
  0x00, 0xFC, 0x78, 0x03, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x01,
  0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78,
  0x01, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x1F, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x81, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x78, 0x3E, 0x03, 0xC0,
  0xF8, 0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0x80, 0xF8, 0x3C, 0x03, 0xE1,
  0xE0, 0x1F, 0x0F, 0x00, 0x7C, 0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x9E, 0x00,
  0x7C, 0xF0, 0x01, 0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3, 0xF0, 0x7C,
  0xFC, 0x01, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0x00, 0x3E, 0xE0, 0x0F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x80, 0x7C, 0x3F, 0xCF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x30, 0x00,
  0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xE0,
  0x0F, 0x80, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x7D, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x78, 0x00,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x3C, 0x00, 0xFE, 0x00, 0x3C, 0x3C,
  0x00, 0xFF, 0x00, 0x3C, 0x3E, 0x00, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xEF,
  0x00, 0x7C, 0x1E, 0x00, 0xE7, 0x00, 0x78, 0x1E, 0x01, 0xE7, 0x80, 0x78,
  0x1E, 0x01, 0xE7, 0x80, 0x78, 0x1F, 0x01, 0xE7, 0x80, 0xF8, 0x1F, 0x01,
  0xC7, 0x80, 0xF0, 0x0F, 0x03, 0xC3, 0x80, 0xF0, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0x0F, 0x03, 0xC3, 0xC1, 0xF0, 0x0F, 0x83, 0xC3, 0xC1, 0xF0, 0x07,
  0x87, 0x83, 0xC1, 0xE0, 0x07, 0x87, 0x81, 0xE1, 0xE0, 0x07, 0x87, 0x81,
  0xE1, 0xE0, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x07, 0xC7, 0x01, 0xE3, 0xC0,
  0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0xF7, 0xC0, 0x01, 0xEE, 0x00, 0x77,
  0x80, 0x01, 0xFE, 0x00, 0x77, 0x80, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0x78,
  0x01, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x78, 0x03, 0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x9E,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x0F, 0x80, 0x7C,
  0x0F, 0x00, 0xF0, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x3C, 0x1F, 0x00,
  0x7C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF9, 0xF0, 0x00, 0xF7, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xE1, 0xE0, 0x07,
  0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x1E, 0x07, 0x80, 0x7C, 0x0F, 0x80, 0xF0,
  0x0F, 0x01, 0xE0, 0x1E, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x3C, 0x3E, 0x00,
  0x7C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xF7, 0x80, 0x01,
  0xEF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1C, 0xF0,
  0x00, 0xF3, 0xC0, 0x03, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x70, 0x3C, 0x03,
  0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x03, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF8, 0x03,
  0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFE, 0x18, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x07, 0xFF, 0xC7, 0xFF, 0xF3, 0xFF, 0xFD, 0xF8, 0x0F, 0x7C, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x3F, 0x7C, 0x1F, 0xDF, 0xFE, 0xF3, 0xFF, 0x3C, 0x7F, 0x87,
  0x03, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0xF3, 0xFE, 0x0F,
  0x7F, 0xF0, 0xFF, 0xFF, 0x8F, 0xE0, 0xFC, 0xFC, 0x07, 0xCF, 0x80, 0x3E,
  0xF8, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF8,
  0x03, 0xEF, 0x80, 0x3C, 0xFC, 0x07, 0xCF, 0xF0, 0xF8, 0xE7, 0xFF, 0x8E,
  0x7F, 0xF0, 0xE1, 0xFE, 0x00, 0x02, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0x02, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x01, 0x1F, 0x87, 0x1F, 0xFF, 0x0F,
  0xFF, 0x03, 0xFE, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x0F, 0x07,
  0xFC, 0xF0, 0xFF, 0xEF, 0x1F, 0xFF, 0xF3, 0xF0, 0x7F, 0x3E, 0x03, 0xF7,
  0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x0F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x3E, 0x03, 0xF3, 0xF0, 0xFF, 0x1F,
  0xFE, 0xF0, 0xFF, 0xE7, 0x07, 0xF8, 0x70, 0x0C, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC1, 0xE0, 0x7C, 0x78, 0x07, 0x8F,
  0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x02, 0x1F, 0x83, 0xC1, 0xFF, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xC0, 0x01, 0x00, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF0,
  0x7F, 0xE0, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x07, 0xFF, 0x9F, 0xFF, 0x3F, 0xFE, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x7F,
  0xC7, 0x0F, 0xFE, 0x71, 0xFF, 0xFF, 0x3F, 0x07, 0xF3, 0xE0, 0x3F, 0x7C,
  0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0xF7, 0xC0, 0x1F, 0x3C, 0x01, 0xF3, 0xE0, 0x3F, 0x3F, 0x0F, 0xF1, 0xFF,
  0xEF, 0x0F, 0xFC, 0xF0, 0x7F, 0x8F, 0x00, 0x40, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE3,
  0x00, 0x3E, 0x3F, 0xBF, 0xC3, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0xFF, 0xC0,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC1, 0xE0, 0xF3, 0xFE, 0x3D, 0xFF, 0xCF, 0xFF, 0xFB, 0xF8, 0x3E,
  0xFC, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3C, 0x33, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBC, 0x03, 0x03, 0xC3, 0xE1, 0xF0, 0xF8, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0x7F, 0xFD, 0xFE, 0xFE, 0x7E,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x0F, 0xBC, 0x03, 0xCF, 0x01, 0xE3, 0xC0,
  0xF8, 0xF0, 0x7C, 0x3C, 0x1E, 0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF1, 0xE0,
  0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xDF, 0x00, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F,
  0xDF, 0x03, 0xE3, 0xC0, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC3, 0xC0,
  0xF0, 0xF0, 0x3E, 0x3C, 0x07, 0x8F, 0x01, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F,
  0xBC, 0x01, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0xF8, 0x07, 0xC1, 0xC7, 0xFC, 0x3F, 0xE3, 0x9F, 0xFC, 0xFF,
  0xE7, 0x7F, 0xF9, 0xFF, 0xEF, 0xE1, 0xFF, 0x07, 0xDF, 0x81, 0xFC, 0x07,
  0xFE, 0x01, 0xF8, 0x0F, 0xFC, 0x03, 0xE0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F,
  0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x80, 0x3E, 0x00, 0xFF,
  0x00, 0x78, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0xF8,
  0x03, 0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0,
  0x1E, 0x00, 0x7F, 0x80, 0x3C, 0x00, 0xFF, 0x00, 0x78, 0x01, 0xFE, 0x00,
  0xF0, 0x03, 0xFC, 0x01, 0xE0, 0x07, 0xF8, 0x03, 0xC0, 0x0F, 0xF0, 0x07,
  0x80, 0x1F, 0xE0, 0x0F, 0x00, 0x3F, 0xC0, 0x1E, 0x00, 0x7F, 0x80, 0x3C,
  0x00, 0xF0, 0x00, 0xF8, 0x38, 0xFF, 0x8E, 0x7F, 0xF3, 0xBF, 0xFE, 0xFE,
  0x0F, 0xBF, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x1F, 0x01, 0xF1, 0xF0, 0x07, 0xCF,
  0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x3E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x87, 0xC0, 0x7F,
  0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0xF8,
  0x0E, 0x3F, 0xE0, 0xE7, 0xFF, 0x0E, 0xFF, 0xF8, 0xFE, 0x0F, 0xCF, 0xC0,
  0x7C, 0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF8, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x03, 0xCF, 0xC0, 0x7C, 0xFF, 0x0F,
  0x8F, 0x7F, 0xF8, 0xF7, 0xFF, 0x0F, 0x1F, 0xE0, 0xF0, 0x20, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC7, 0x0F, 0xFE, 0x71, 0xFF, 0xFF,
  0x3F, 0x07, 0xF3, 0xE0, 0x3F, 0x7C, 0x01, 0xF7, 0xC0, 0x1F, 0x78, 0x01,
  0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7C, 0x01, 0xF3,
  0xE0, 0x3F, 0x3F, 0x0F, 0xF1, 0xFF, 0xEF, 0x0F, 0xFC, 0xF0, 0x7F, 0x8F,
  0x00, 0x40, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0x1F, 0xB9, 0xFD, 0xCF,
  0xEE, 0xF9, 0x7F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x1F, 0xFE, 0x3F, 0xFE, 0x7F, 0xFE,
  0xF8, 0x0C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1E, 0x80, 0x1E, 0xF0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xF0,
  0x02, 0x00, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x80, 0x7E, 0x21, 0xFF, 0x0F, 0xF8, 0x3F, 0xC0, 0x30, 0xF8,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xBC, 0x01, 0xF7, 0x80,
  0x3E, 0xF0, 0x0F, 0xDF, 0x01, 0xFB, 0xF8, 0xFF, 0x3F, 0xFD, 0xE3, 0xFF,
  0x3C, 0x3F, 0xC3, 0x80, 0xC0, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9E,
  0x00, 0x3C, 0xF8, 0x03, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07,
  0x87, 0xC0, 0x7C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E,
  0x0F, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x3E, 0x3C, 0x00, 0xF1, 0xE0,
  0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xE0,
  0x1F, 0xF0, 0x07, 0xE0, 0x1E, 0xF8, 0x07, 0xE0, 0x1E, 0x78, 0x0F, 0xE0,
  0x1E, 0x78, 0x0F, 0xF0, 0x1E, 0x78, 0x0E, 0xF0, 0x3E, 0x7C, 0x0E, 0xF0,
  0x3C, 0x3C, 0x1E, 0x70, 0x3C, 0x3C, 0x1E, 0x70, 0x3C, 0x3C, 0x1E, 0x78,
  0x7C, 0x3C, 0x1C, 0x78, 0x78, 0x3E, 0x3C, 0x78, 0x78, 0x1E, 0x3C, 0x38,
  0x78, 0x1E, 0x3C, 0x3C, 0x78, 0x1E, 0x38, 0x3C, 0xF0, 0x1E, 0x78, 0x3C,
  0xF0, 0x0F, 0x78, 0x1C, 0xF0, 0x0F, 0x78, 0x1E, 0xF0, 0x0F, 0x70, 0x1E,
  0xE0, 0x0F, 0x70, 0x1F, 0xE0, 0x07, 0x70, 0x1F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F,
  0xC0, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE7, 0xC0, 0x3C, 0x3C, 0x07,
  0xC3, 0xE0, 0x78, 0x1E, 0x0F, 0x81, 0xF0, 0xF0, 0x0F, 0x1F, 0x00, 0xF9,
  0xE0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00,
  0x7B, 0xE0, 0x0F, 0x9E, 0x00, 0xF1, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0xF8,
  0x3E, 0x07, 0x83, 0xC0, 0x7C, 0x7C, 0x03, 0xC7, 0x80, 0x3E, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x03, 0xE3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x07,
  0x83, 0xC0, 0x1E, 0x3E, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x1E, 0x78,
  0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE,
  0x7F, 0xFE, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x02, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x01, 0xF0, 0x1F, 0xC0, 0x3E, 0x00, 0x7E, 0x00, 0xFF,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80,
  0x01, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x0F, 0x80, 0x7E, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0x00, 0x00,
  0x3F, 0x80, 0x17, 0xFE, 0x03, 0xFF, 0xFC, 0xFF, 0x3F, 0xFF, 0xC0, 0x7F,
  0xE8, 0x01, 0xFC,
};

const GFXglyph NotoSans_Condensed_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 6, 37, 13, 3, -36 },
  { 29, 14, 13, 20, 3, -36 },
  { 52, 24, 36, 26, 1, -36 },
  { 160, 20, 42, 24, 2, -39 },
  { 265, 32, 37, 36, 2, -37 },
  { 413, 26, 38, 28, 2, -37 },
  { 537, 5, 13, 11, 3, -36 },
  { 546, 11, 45, 15, 2, -37 },
  { 608, 12, 45, 15, 1, -37 },
  { 676, 19, 19, 23, 2, -39 },
  { 722, 20, 24, 24, 2, -30 },
  { 782, 7, 13, 12, 2, -6 },
  { 794, 11, 4, 15, 2, -16 },
  { 800, 6, 7, 12, 3, -6 },
  { 806, 17, 37, 19, 1, -37 },
  { 885, 20, 38, 24, 2, -37 },
  { 980, 12, 36, 24, 4, -36 },
  { 1034, 20, 37, 24, 2, -37 },
  { 1127, 19, 38, 24, 2, -37 },
  { 1218, 22, 37, 24, 1, -37 },
  { 1320, 19, 37, 24, 3, -36 },
  { 1408, 20, 38, 24, 2, -37 },
  { 1503, 20, 36, 24, 2, -36 },
  { 1593, 20, 38, 24, 2, -37 },
  { 1688, 20, 38, 24, 2, -37 },
  { 1783, 6, 29, 12, 3, -28 },
  { 1805, 7, 35, 12, 2, -28 },
  { 1836, 20, 24, 24, 2, -30 },
  { 1896, 20, 14, 24, 2, -25 },
  { 1931, 20, 24, 24, 2, -30 },
  { 1991, 16, 38, 18, 1, -37 },
  { 2067, 31, 41, 37, 3, -37 },
  { 2226, 26, 36, 26, 0, -36 },
  { 2343, 21, 36, 27, 4, -36 },
  { 2438, 21, 38, 26, 3, -37 },
  { 2538, 23, 36, 30, 4, -36 },
  { 2642, 16, 36, 23, 4, -36 },
  { 2714, 16, 36, 22, 4, -36 },
  { 2786, 25, 38, 31, 3, -37 },
  { 2905, 22, 36, 30, 4, -36 },
  { 3004, 11, 36, 15, 2, -36 },
  { 3054, 11, 46, 12, -3, -36 },
  { 3118, 22, 36, 25, 4, -36 },
  { 3217, 16, 36, 21, 4, -36 },
  { 3289, 32, 36, 40, 4, -36 },
  { 3433, 24, 36, 32, 4, -36 },
  { 3541, 26, 38, 32, 3, -37 },
  { 3665, 19, 36, 25, 4, -36 },
  { 3751, 26, 46, 32, 3, -37 },
  { 3901, 21, 36, 26, 4, -36 },
  { 3996, 19, 38, 23, 2, -37 },
  { 4087, 21, 36, 22, 1, -36 },
  { 4182, 22, 37, 30, 4, -36 },
  { 4284, 25, 36, 25, 0, -36 },
  { 4397, 40, 36, 40, 0, -36 },
  { 4577, 23, 36, 23, 0, -36 },
  { 4681, 23, 36, 23, 0, -36 },
  { 4785, 18, 36, 22, 2, -36 },
  { 4866, 11, 45, 16, 4, -37 },
  { 4928, 17, 37, 19, 1, -37 },
  { 5007, 11, 45, 16, 1, -37 },
  { 5069, 22, 20, 25, 1, -36 },
  { 5124, 22, 4, 22, 0, 4 },
  { 5135, 10, 8, 14, 2, -39 },
  { 5145, 18, 29, 23, 2, -28 },
  { 5211, 20, 40, 26, 4, -39 },
  { 5311, 16, 29, 20, 2, -28 },
  { 5369, 20, 40, 26, 2, -39 },
  { 5469, 19, 29, 24, 2, -28 },
  { 5538, 15, 39, 14, 1, -39 },
  { 5612, 20, 40, 26, 2, -28 },
  { 5712, 18, 39, 26, 4, -39 },
  { 5800, 5, 38, 11, 3, -38 },
  { 5824, 9, 50, 11, -1, -38 },
  { 5881, 18, 39, 22, 4, -39 },
  { 5969, 4, 39, 11, 4, -39 },
  { 5989, 31, 28, 39, 4, -28 },
  { 6098, 18, 28, 26, 4, -28 },
  { 6161, 21, 29, 25, 2, -28 },
  { 6238, 20, 40, 26, 4, -28 },
  { 6338, 20, 40, 26, 2, -28 },
  { 6438, 13, 28, 17, 4, -28 },
  { 6484, 16, 29, 19, 2, -28 },
  { 6542, 13, 35, 15, 1, -34 },
  { 6599, 19, 28, 26, 3, -27 },
  { 6666, 21, 27, 21, 0, -27 },
  { 6737, 32, 27, 34, 1, -27 },
  { 6845, 20, 27, 21, 1, -27 },
  { 6913, 21, 39, 21, 0, -27 },
  { 7016, 16, 27, 18, 1, -27 },
  { 7070, 15, 45, 19, 2, -37 },
  { 7155, 3, 51, 23, 10, -39 },
  { 7175, 15, 45, 19, 2, -37 },
  { 7260, 20, 6, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Regular51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_REGULAR51PT7B_H_
