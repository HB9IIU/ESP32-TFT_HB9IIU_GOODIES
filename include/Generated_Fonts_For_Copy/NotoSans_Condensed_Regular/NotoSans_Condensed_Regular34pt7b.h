#ifndef _NOTOSANS_CONDENSED_REGULAR34PT7B_H_
#define _NOTOSANS_CONDENSED_REGULAR34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66, 0x60, 0x00, 0x7F,
  0xF7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1D, 0x8E, 0xC7, 0x61, 0x80,
  0x07, 0x1C, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18, 0x06, 0x18,
  0x0E, 0x38, 0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x30, 0x1C, 0x70, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x60,
  0x18, 0x60, 0x18, 0x60, 0x38, 0xE0, 0x38, 0xE0, 0x30, 0xC0, 0x30, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x3F, 0x87, 0xFF, 0x7F, 0xFB, 0x98, 0x58,
  0xC0, 0xC6, 0x06, 0x30, 0x39, 0x81, 0xEC, 0x07, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0xFE, 0x06, 0x70, 0x31, 0x81, 0x8E, 0x0C, 0x68, 0x67, 0x73, 0x7B,
  0xFF, 0x9F, 0xF0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x08, 0x00,
  0x00, 0xF8, 0x06, 0x07, 0xF0, 0x38, 0x18, 0xC0, 0xC0, 0x63, 0x87, 0x01,
  0x86, 0x18, 0x0E, 0x18, 0x60, 0x38, 0x63, 0x80, 0xE1, 0x8C, 0x01, 0x86,
  0x70, 0x06, 0x39, 0x8E, 0x18, 0xEE, 0x7C, 0x63, 0x33, 0xB9, 0xFC, 0xCC,
  0x63, 0xE7, 0x31, 0xC3, 0x19, 0xC7, 0x00, 0xE7, 0x1C, 0x03, 0x1C, 0x70,
  0x0C, 0x71, 0xC0, 0x71, 0xC7, 0x01, 0x87, 0x1C, 0x0E, 0x0C, 0x60, 0x30,
  0x31, 0x80, 0xC0, 0xFE, 0x07, 0x01, 0xF0, 0x03, 0x00, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xE1,
  0x80, 0x1C, 0xE0, 0x07, 0x78, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0xE7, 0x9C, 0x39, 0xC7, 0x9C, 0xF0, 0xE7, 0x38, 0x1D, 0xCE,
  0x07, 0xE3, 0x80, 0xF8, 0xE0, 0x1C, 0x1C, 0x0F, 0x87, 0x8F, 0xF0, 0xFF,
  0x9E, 0x1F, 0xC3, 0xC0, 0xFF, 0xFF, 0xDB, 0x60, 0x0E, 0x38, 0xE1, 0xC3,
  0x0E, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0xC3,
  0x87, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xC1, 0xC1, 0x83, 0x87, 0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xC1, 0x83,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC7, 0x0E, 0x18, 0x70, 0xE3, 0x8E, 0x00,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x06, 0x73, 0x7F, 0xFF, 0xFF, 0xE1,
  0xF0, 0x0D, 0x80, 0xEE, 0x0E, 0x38, 0x71, 0xC0, 0x88, 0x00, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF,
  0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x39, 0xCE, 0xE7, 0x39, 0x9C, 0xFF, 0xFF, 0xFF, 0x6F, 0xFF,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x00, 0x03, 0x00, 0x3F,
  0x01, 0xFE, 0x0E, 0x1C, 0x38, 0x71, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70,
  0x39, 0xC0, 0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xD8,
  0x06, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x38, 0xE1, 0xC3,
  0xCF, 0x07, 0xF8, 0x0F, 0xC0, 0x07, 0x87, 0xC7, 0xE7, 0x77, 0x3F, 0x1C,
  0x8E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x01, 0xFE, 0x3F,
  0xF8, 0xE1, 0xE2, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x78, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x06, 0x01, 0xFF, 0x3F, 0xFC, 0xE0, 0xE4, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x3F, 0x81, 0xF8, 0x0F, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x3F, 0x83, 0xDF, 0xFC, 0x7F, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x1F, 0x80, 0x37, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x38, 0x0C, 0x70, 0x38,
  0xE0, 0x61, 0xC1, 0xC3, 0x83, 0x07, 0x0E, 0x0E, 0x18, 0x1C, 0x70, 0x38,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x7F, 0xE7, 0xFE, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xF0, 0xFF, 0xC7, 0xFE, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0xFC, 0x1E,
  0xFF, 0xCF, 0xF8, 0x01, 0xC0, 0x7F, 0x07, 0xF8, 0x78, 0x07, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3B, 0xF1, 0xBF, 0xCF, 0x8F,
  0x70, 0x3B, 0x81, 0xDC, 0x06, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x6E,
  0x07, 0x38, 0x39, 0xE3, 0x87, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x03, 0x00, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x39, 0xC0,
  0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x38, 0xE1, 0xC1, 0xCE, 0x03, 0xF0, 0x0F,
  0x80, 0x7F, 0x83, 0x8F, 0x1C, 0x1E, 0x70, 0x3B, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1D, 0xC0, 0xE7, 0x87, 0x8F, 0xFC, 0x1F, 0xE0, 0x03, 0x00,
  0xFE, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x38, 0x1D, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xD8, 0x0E, 0xE0, 0x77, 0x07, 0x9E, 0xEC, 0xFF, 0xE1, 0xE7,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x71, 0x0F, 0x87,
  0xF8, 0x3F, 0x00, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x7B, 0xDE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE7, 0x73, 0x9C,
  0xC6, 0x70, 0x00, 0x04, 0x00, 0x70, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x3C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x03, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x0E, 0x00, 0x20, 0x00, 0x04, 0x0F, 0xF3, 0xFF, 0x30, 0xF0, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x18, 0x07, 0x80,
  0xF0, 0x1E, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0x80, 0xF0, 0x38,
  0x01, 0xC3, 0x80, 0x06, 0x18, 0x00, 0x39, 0xC1, 0xF0, 0xCC, 0x1F, 0xC6,
  0xE1, 0xCE, 0x3F, 0x1C, 0x70, 0xF0, 0xC3, 0x87, 0x86, 0x1C, 0x3C, 0x70,
  0xE1, 0xE3, 0x87, 0x0F, 0x1C, 0x38, 0x78, 0xE1, 0xC7, 0xC3, 0x0E, 0x36,
  0x1C, 0xF3, 0xB8, 0xFC, 0xF9, 0xC3, 0xE7, 0x86, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x07, 0x00, 0x7F, 0xF8, 0x00,
  0x7E, 0x00, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x6C, 0x00, 0x37,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0C, 0x60, 0x0E, 0x38, 0x07, 0x1C, 0x03,
  0x86, 0x01, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xE0, 0x7F, 0xF0, 0x7F, 0xFC,
  0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x77, 0x07, 0xBF, 0xF9, 0xFF,
  0x8F, 0xFF, 0x70, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x07, 0xFF, 0xFB, 0xFF, 0x9F, 0xF8, 0x00, 0xC0, 0x1F, 0xF1,
  0xFF, 0xCF, 0x82, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF1,
  0x83, 0xFE, 0x07, 0xF8, 0xFF, 0xC1, 0xFF, 0xC3, 0x87, 0xC7, 0x03, 0xCE,
  0x03, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1D,
  0xC0, 0x3B, 0x80, 0xF7, 0x01, 0xCE, 0x07, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xFF, 0x7F, 0xEF, 0xFD, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x7F, 0xEF, 0xFD, 0xFF, 0xB8, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x07, 0xFE, 0x0F,
  0xFF, 0x1E, 0x06, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x7F, 0xE0, 0x7F, 0xE0,
  0x7F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x07, 0x78,
  0x07, 0x3C, 0x07, 0x1F, 0x0F, 0x0F, 0xFF, 0x07, 0xFE, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0x7F, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x1C, 0x1C, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x1E, 0xFE, 0xFC,
  0x20, 0xE0, 0x3F, 0x81, 0xEE, 0x07, 0x38, 0x38, 0xE1, 0xE3, 0x87, 0x0E,
  0x38, 0x39, 0xE0, 0xE7, 0x03, 0xB8, 0x0E, 0xE0, 0x3F, 0x80, 0xFF, 0x03,
  0xDC, 0x0E, 0x38, 0x38, 0xE0, 0xE1, 0xC3, 0x87, 0x0E, 0x0E, 0x38, 0x3C,
  0xE0, 0x73, 0x81, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x03, 0xFD, 0x80, 0x1B, 0xEE, 0x00, 0xDF, 0x70, 0x0E, 0xF9, 0x80,
  0x77, 0xCE, 0x03, 0x3E, 0x70, 0x39, 0xF1, 0x81, 0xCF, 0x8E, 0x0C, 0x7C,
  0x70, 0xE3, 0xE1, 0x87, 0x1F, 0x0E, 0x30, 0xF8, 0x73, 0x87, 0xC3, 0x9C,
  0x3E, 0x0C, 0xC1, 0xF0, 0x76, 0x0F, 0x83, 0xF0, 0x7C, 0x0F, 0x03, 0xE0,
  0x78, 0x1F, 0x03, 0xC0, 0xF8, 0x0E, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xDC, 0x07, 0xDC, 0x07, 0xCE, 0x07, 0xCE, 0x07, 0xC7,
  0x07, 0xC7, 0x07, 0xC7, 0x87, 0xC3, 0x87, 0xC3, 0xC7, 0xC1, 0xC7, 0xC1,
  0xE7, 0xC0, 0xE7, 0xC0, 0xE7, 0xC0, 0x77, 0xC0, 0x77, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x00, 0x80, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xEE,
  0x00, 0xE7, 0x00, 0x71, 0xC0, 0x70, 0xF8, 0xF8, 0x3F, 0xF8, 0x07, 0xF0,
  0x00, 0xFF, 0x8F, 0xFE, 0xE3, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xFE, 0x1E, 0xFF, 0xEF, 0xF8, 0xF8, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3,
  0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x71, 0xC0, 0x70,
  0xF8, 0xF8, 0x3F, 0xF8, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0xFF, 0x83, 0xFF, 0x8E, 0x3E,
  0x38, 0x3C, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x0F, 0x3F, 0xF8, 0xFF, 0xC3, 0xFE, 0x0E, 0x38, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x8E, 0x0E, 0x38, 0x3C, 0xE0, 0x73, 0x81, 0xEE, 0x03, 0xB8,
  0x0F, 0x03, 0x00, 0xFF, 0xCF, 0xFC, 0xF0, 0x67, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x3B, 0xE7, 0xDF, 0xFC, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0,
  0x3D, 0xF1, 0xE3, 0xFF, 0x07, 0xF8, 0xE0, 0x07, 0xF8, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x38, 0x38,
  0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x03, 0x87, 0x01, 0xC3, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x1C, 0xE0, 0x06, 0x70, 0x03, 0xB8, 0x01, 0xD8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x03, 0x80, 0xE0, 0x0E, 0x01,
  0xDC, 0x07, 0x80, 0x77, 0x01, 0xE0, 0x1D, 0xC0, 0x7C, 0x07, 0x70, 0x1F,
  0x03, 0x8C, 0x06, 0xC0, 0xE3, 0x83, 0xB0, 0x38, 0xE0, 0xEC, 0x0E, 0x38,
  0x33, 0x83, 0x0E, 0x0C, 0xE1, 0xC1, 0xC7, 0x18, 0x70, 0x71, 0xC6, 0x1C,
  0x1C, 0x71, 0xC7, 0x07, 0x18, 0x73, 0x80, 0xCE, 0x1C, 0xE0, 0x3B, 0x83,
  0x38, 0x0E, 0xE0, 0xEE, 0x03, 0xB0, 0x3B, 0x00, 0xEC, 0x0F, 0xC0, 0x1B,
  0x01, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0x80,
  0x0E, 0x00, 0xE0, 0x70, 0x0E, 0x70, 0x38, 0xE0, 0x70, 0xE1, 0xC1, 0xC3,
  0x83, 0x8E, 0x03, 0x9C, 0x07, 0x70, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0x70, 0x0E, 0x70, 0x38,
  0xE0, 0x70, 0xE1, 0xC1, 0xC3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0xF0, 0x07,
  0xE0, 0x0E, 0xE0, 0x39, 0xC0, 0x71, 0xC0, 0xE3, 0x83, 0x87, 0x07, 0x07,
  0x1C, 0x0E, 0x38, 0x0E, 0x70, 0x1D, 0xC0, 0x3B, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0xFF, 0xF7, 0xFF,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07,
  0xFF, 0xE0, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0xFF,
  0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0xFF,
  0xE0, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xCC, 0x03, 0x9C,
  0x07, 0x18, 0x0C, 0x38, 0x38, 0x30, 0x60, 0x71, 0xC0, 0x63, 0x00, 0xEE,
  0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xF0, 0xE0, 0xE0, 0xE0, 0x02,
  0x03, 0xFE, 0x3F, 0xE1, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x07,
  0xF3, 0xFF, 0x78, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x70,
  0xF7, 0xFB, 0x3F, 0x30, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x40, 0xE7, 0xE3, 0xBF, 0xCF, 0x87, 0xBC,
  0x0E, 0xF0, 0x3B, 0x80, 0x6E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0xBE, 0x1C, 0xEF, 0xF3,
  0x9F, 0x80, 0x02, 0x07, 0xF3, 0xFD, 0xE1, 0xF0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x30, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xC0, 0x78, 0x4F,
  0xF1, 0xFC, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE1, 0xC7, 0x3F, 0xBB, 0xFF, 0xDC, 0x3F, 0xC0, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0xC1, 0xEE, 0x1F, 0x3F, 0xB8, 0xF8, 0xC0, 0x02, 0x01, 0xF8,
  0x3F, 0xC7, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x33, 0xFF,
  0x1F, 0xE0, 0x07, 0xE1, 0xF8, 0x79, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x7F, 0x9F, 0xF0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x06, 0x01, 0xFD, 0xDF, 0xFE, 0xE1, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFE, 0x0F, 0x78, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xD0, 0x0E, 0x71, 0xF3, 0xFF, 0x0F, 0xE0, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x20, 0xE7,
  0xE7, 0x7F, 0xBE, 0x1D, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xC0, 0x7F, 0xB0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0C, 0x71, 0xC3, 0x00, 0x00, 0x07, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x7B, 0xFE, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x77, 0x07, 0x38, 0x71, 0xC3, 0x8E,
  0x38, 0x73, 0x83, 0x98, 0x1D, 0xC0, 0xFF, 0x07, 0xF8, 0x3C, 0xE1, 0xC7,
  0x0E, 0x1C, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0x77, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x00, 0x87,
  0x7F, 0x3F, 0xBB, 0xFB, 0xFF, 0xF1, 0xF8, 0x7F, 0x07, 0x83, 0xF8, 0x3C,
  0x1F, 0x80, 0xC0, 0x7C, 0x06, 0x03, 0xE0, 0x30, 0x1F, 0x01, 0x80, 0xF8,
  0x0C, 0x07, 0xC0, 0x60, 0x3E, 0x03, 0x01, 0xF0, 0x18, 0x0F, 0x80, 0xC0,
  0x7C, 0x06, 0x03, 0xE0, 0x30, 0x1F, 0x01, 0x80, 0xF8, 0x0C, 0x06, 0x01,
  0x07, 0x3F, 0x3B, 0xFD, 0xF0, 0xEF, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0x03, 0x00, 0xFE, 0x0F, 0xF8, 0xE1,
  0xEE, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xEE, 0x0E, 0x78, 0xF1, 0xFF, 0x07,
  0xF0, 0x01, 0x83, 0x9F, 0x8E, 0xFF, 0x3E, 0x1E, 0xF0, 0x3B, 0xC0, 0xEE,
  0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xEF, 0x03, 0xBC, 0x0E, 0xF8, 0x73, 0xBF, 0xCE, 0x7E, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x00, 0x04, 0x01, 0xFD, 0xDF, 0xFE, 0xE1, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F,
  0x81, 0xFE, 0x0F, 0x78, 0xF9, 0xFD, 0xC7, 0xCE, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x01, 0xF3, 0xFB,
  0xFF, 0x8F, 0x87, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x00, 0x06, 0x07, 0xFD, 0xFF, 0x38,
  0x2E, 0x01, 0xC0, 0x38, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x3C, 0x07, 0xE1, 0xDF, 0xF9, 0xFC, 0x00, 0x30, 0x30,
  0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x38, 0x38, 0x3F, 0x1F, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3D, 0xC1, 0xEF, 0x1F, 0x7F, 0xB9,
  0xF9, 0xC0, 0xE0, 0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x0E, 0x70, 0x38, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x18, 0x60, 0x73, 0x81, 0xCE, 0x07, 0x30, 0x0C,
  0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x78,
  0x1D, 0xC1, 0xE0, 0x77, 0x07, 0x81, 0x9C, 0x1F, 0x0E, 0x70, 0x6C, 0x38,
  0xC3, 0xB0, 0xE3, 0x8C, 0xC3, 0x0E, 0x33, 0x8C, 0x38, 0xCE, 0x70, 0x67,
  0x19, 0xC1, 0xDC, 0x67, 0x07, 0x61, 0xD8, 0x1D, 0x87, 0xE0, 0x36, 0x1F,
  0x80, 0xF8, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00,
  0xE0, 0x7B, 0x83, 0x9C, 0x38, 0x71, 0xC3, 0x9C, 0x0E, 0xE0, 0x7E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x07, 0xE0, 0x3F, 0x03, 0x9C, 0x1C, 0xE1, 0xC3,
  0x8E, 0x1C, 0xE0, 0x77, 0x03, 0xC0, 0xE0, 0x1D, 0xC0, 0xE7, 0x03, 0x9C,
  0x0E, 0x30, 0x38, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x1C, 0x60, 0x73, 0x81,
  0xCE, 0x03, 0x30, 0x0E, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x27, 0x80,
  0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80,
  0xFF, 0xFF, 0xF0, 0x03, 0xC1, 0xF0, 0xF0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x3F, 0x0E, 0x03, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xF0, 0x1F, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x3E, 0x01, 0xC0, 0x70, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xF0, 0x1C,
  0x1F, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x01, 0xC3, 0xF0, 0xF0, 0x00, 0x7E, 0x07, 0xFE, 0x3C, 0x7F, 0xE0,
  0x7E,
};

const GFXglyph NotoSans_Condensed_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 4, 24, 8, 2, -24 },
  { 13, 9, 9, 13, 2, -24 },
  { 24, 16, 24, 18, 1, -24 },
  { 72, 13, 28, 16, 2, -26 },
  { 118, 22, 25, 24, 1, -25 },
  { 187, 18, 25, 19, 1, -25 },
  { 244, 3, 9, 7, 2, -24 },
  { 248, 7, 29, 10, 2, -24 },
  { 274, 7, 29, 10, 1, -24 },
  { 300, 13, 13, 15, 1, -26 },
  { 322, 14, 16, 16, 1, -20 },
  { 350, 5, 8, 8, 1, -4 },
  { 355, 8, 3, 10, 1, -11 },
  { 358, 4, 4, 8, 2, -4 },
  { 360, 11, 24, 13, 1, -24 },
  { 393, 14, 25, 16, 1, -25 },
  { 437, 9, 24, 16, 2, -24 },
  { 464, 13, 25, 16, 1, -25 },
  { 505, 13, 25, 16, 1, -25 },
  { 546, 15, 24, 16, 1, -24 },
  { 591, 12, 24, 16, 2, -24 },
  { 627, 13, 25, 16, 2, -25 },
  { 668, 14, 24, 16, 1, -24 },
  { 710, 14, 25, 16, 1, -25 },
  { 754, 13, 25, 16, 1, -25 },
  { 795, 4, 18, 8, 2, -18 },
  { 804, 5, 22, 8, 1, -18 },
  { 818, 14, 16, 16, 1, -20 },
  { 846, 14, 10, 16, 1, -17 },
  { 864, 14, 16, 16, 1, -20 },
  { 892, 11, 25, 12, 0, -25 },
  { 927, 21, 27, 25, 2, -24 },
  { 998, 17, 24, 17, 0, -24 },
  { 1049, 13, 24, 18, 3, -24 },
  { 1088, 14, 25, 17, 2, -25 },
  { 1132, 15, 24, 20, 3, -24 },
  { 1177, 11, 24, 15, 3, -24 },
  { 1210, 11, 24, 14, 3, -24 },
  { 1243, 16, 25, 20, 2, -25 },
  { 1293, 15, 24, 20, 3, -24 },
  { 1338, 8, 24, 10, 1, -24 },
  { 1362, 8, 31, 8, -2, -24 },
  { 1393, 14, 24, 17, 3, -24 },
  { 1435, 11, 24, 14, 3, -24 },
  { 1468, 21, 24, 26, 3, -24 },
  { 1531, 16, 24, 21, 3, -24 },
  { 1579, 17, 25, 21, 2, -25 },
  { 1633, 12, 24, 17, 3, -24 },
  { 1669, 17, 31, 21, 2, -25 },
  { 1735, 14, 24, 17, 3, -24 },
  { 1777, 13, 25, 15, 1, -25 },
  { 1818, 14, 24, 15, 0, -24 },
  { 1860, 14, 24, 20, 3, -24 },
  { 1902, 17, 24, 17, 0, -24 },
  { 1953, 26, 24, 27, 0, -24 },
  { 2031, 15, 24, 16, 0, -24 },
  { 2076, 15, 24, 15, 0, -24 },
  { 2121, 13, 24, 14, 1, -24 },
  { 2160, 7, 29, 11, 3, -24 },
  { 2186, 11, 24, 13, 1, -24 },
  { 2219, 7, 29, 11, 1, -24 },
  { 2245, 15, 13, 16, 1, -24 },
  { 2270, 15, 2, 15, 0, 3 },
  { 2274, 7, 5, 9, 1, -26 },
  { 2279, 12, 19, 16, 1, -19 },
  { 2308, 14, 26, 17, 2, -26 },
  { 2354, 10, 19, 13, 2, -19 },
  { 2378, 13, 26, 17, 2, -26 },
  { 2421, 12, 19, 16, 2, -19 },
  { 2450, 11, 26, 10, 0, -26 },
  { 2486, 13, 27, 17, 2, -19 },
  { 2530, 13, 26, 17, 2, -26 },
  { 2573, 3, 25, 8, 2, -25 },
  { 2583, 6, 33, 8, -1, -25 },
  { 2608, 13, 26, 15, 2, -26 },
  { 2651, 3, 26, 8, 2, -26 },
  { 2661, 21, 19, 26, 2, -19 },
  { 2711, 13, 19, 17, 2, -19 },
  { 2742, 13, 19, 17, 2, -19 },
  { 2773, 14, 27, 17, 2, -19 },
  { 2821, 13, 27, 17, 2, -19 },
  { 2865, 9, 19, 11, 2, -19 },
  { 2887, 11, 19, 13, 1, -19 },
  { 2914, 8, 22, 10, 1, -22 },
  { 2936, 13, 18, 17, 2, -18 },
  { 2966, 14, 18, 14, 0, -18 },
  { 2998, 22, 18, 22, 0, -18 },
  { 3048, 13, 18, 14, 1, -18 },
  { 3078, 14, 26, 14, 0, -18 },
  { 3124, 10, 18, 12, 1, -18 },
  { 3147, 10, 29, 12, 1, -24 },
  { 3184, 3, 34, 15, 6, -26 },
  { 3197, 10, 29, 12, 1, -24 },
  { 3234, 14, 4, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Regular34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Regular34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Regular34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_REGULAR34PT7B_H_
