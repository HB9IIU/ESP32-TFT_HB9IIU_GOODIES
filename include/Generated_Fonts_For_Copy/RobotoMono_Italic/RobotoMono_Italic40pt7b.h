#ifndef _ROBOTOMONO_ITALIC40PT7B_H_
#define _ROBOTOMONO_ITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x07,
  0x03, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x1E, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x3C, 0x3E, 0x0E, 0x00, 0x70, 0xEE, 0x1D,
  0xC3, 0xB8, 0x77, 0x0C, 0xC3, 0x98, 0x77, 0x0E, 0xE1, 0xC0, 0x00, 0x1C,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xC1, 0xC0, 0x03, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x30, 0x70, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x38, 0x00,
  0x70, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0x83, 0x80, 0x07, 0x07, 0x01, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x00, 0xE0, 0xC0, 0x03, 0x83,
  0x80, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70,
  0x00, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7E, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x3C,
  0x70, 0x03, 0xC7, 0x00, 0x3C, 0x78, 0x07, 0x87, 0xC0, 0xF8, 0x3F, 0xFF,
  0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x1C, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x70,
  0xE0, 0x0E, 0x1C, 0x11, 0x83, 0x87, 0x30, 0x70, 0xE6, 0x0E, 0x38, 0xC1,
  0xCE, 0x1C, 0x73, 0x83, 0xFE, 0x70, 0x3F, 0x9C, 0x01, 0xC7, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x73, 0xE0, 0x1C,
  0xFE, 0x07, 0x3C, 0xE0, 0xE7, 0x0C, 0x39, 0xC1, 0x8E, 0x38, 0x33, 0xC7,
  0x06, 0x30, 0xE0, 0xC0, 0x1C, 0x38, 0x03, 0x8F, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xC7, 0x00,
  0x38, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78, 0x07, 0x07,
  0x80, 0x3C, 0x7C, 0x01, 0xE7, 0xC0, 0x07, 0x78, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0x70, 0x39, 0xF3, 0xC1,
  0xDF, 0x0F, 0x1C, 0xF0, 0x78, 0xE7, 0x01, 0xEF, 0x78, 0x0F, 0x73, 0xC0,
  0x3F, 0x9E, 0x01, 0xF8, 0x70, 0x07, 0x83, 0xC0, 0xFE, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFB, 0xC0, 0xFF, 0x1F, 0x00, 0x77, 0x77, 0x6E, 0xEE, 0xE0, 0x00,
  0x08, 0x00, 0xE0, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x02, 0x00, 0x01,
  0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x01, 0xE0, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x60, 0x18, 0x18, 0x37, 0x8E, 0x3F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC1, 0xFF, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x70, 0x03,
  0xCE, 0x01, 0xE3, 0x80, 0xF0, 0xF0, 0x78, 0x1E, 0x06, 0x07, 0x01, 0x01,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x07,
  0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x9E,
  0x3C, 0xF1, 0xC1, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x77, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7C, 0x3C, 0x0F, 0x01, 0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x1F, 0x38, 0x03, 0xF3, 0x80, 0x7F, 0x38,
  0x1F, 0xE7, 0x83, 0xEE, 0x78, 0xF8, 0xE7, 0x9F, 0x1E, 0x77, 0xC1, 0xE7,
  0xF8, 0x1E, 0x7E, 0x01, 0xC7, 0xC0, 0x1C, 0xF0, 0x01, 0xC7, 0x00, 0x3C,
  0x70, 0x03, 0x87, 0x00, 0x78, 0x78, 0x07, 0x03, 0x80, 0xF0, 0x3F, 0xFE,
  0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x7C, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE3, 0xA0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38,
  0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x07, 0x80,
  0x78, 0x38, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E,
  0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x1F,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0x8F,
  0x00, 0x78, 0xF0, 0x07, 0x87, 0x81, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x3D, 0xC0, 0x07, 0x9C, 0x00,
  0xF3, 0xC0, 0x0E, 0x3C, 0x01, 0xC3, 0xC0, 0x3C, 0x38, 0x07, 0x83, 0x80,
  0xF0, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x03, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC6, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xC0, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x78, 0xE0, 0x07, 0x8F, 0x00,
  0xF0, 0x78, 0x1E, 0x07, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x1C, 0x03, 0x9F, 0xE0,
  0xFF, 0xFC, 0x7F, 0x9F, 0x9F, 0x81, 0xE7, 0xC0, 0x39, 0xE0, 0x0F, 0x70,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0x9C, 0x00,
  0xE7, 0x80, 0x79, 0xE0, 0x3C, 0x3C, 0x1F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0,
  0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x07, 0x81, 0xE0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E, 0x01,
  0xE0, 0xF0, 0x1E, 0x07, 0x87, 0xC0, 0x3F, 0xF0, 0x03, 0xFE, 0x00, 0xFF,
  0xF0, 0x1F, 0x07, 0x83, 0xC0, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x1C, 0x70,
  0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x78, 0x07, 0x87,
  0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x01, 0xF0,
  0x03, 0xFE, 0x03, 0xFF, 0x83, 0xE3, 0xE3, 0xC0, 0xF3, 0xC0, 0x3D, 0xC0,
  0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x3E, 0xF0, 0x3E, 0x7E, 0xFF, 0x1F, 0xFB,
  0x87, 0xFB, 0xC0, 0x41, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xC0, 0x00,
  0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF8, 0x03, 0xC0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x78,
  0x02, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0xFF, 0x80, 0xFF, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00,
  0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x80, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC7, 0xE7,
  0xC0, 0xF3, 0xC0, 0x3D, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x78, 0x3C, 0x03, 0x80, 0x38, 0x1C, 0x00, 0x60, 0xE0, 0xC1,
  0x87, 0x0F, 0xC7, 0x1C, 0x7F, 0x8C, 0xE3, 0x86, 0x33, 0x8C, 0x30, 0xCC,
  0x70, 0xC3, 0x71, 0x83, 0x0D, 0x8E, 0x0C, 0x36, 0x38, 0x71, 0x98, 0xC1,
  0x86, 0xE3, 0x06, 0x1B, 0x8C, 0x18, 0x6E, 0x30, 0xE3, 0x38, 0xC7, 0x8C,
  0xE3, 0xFE, 0xE3, 0x8F, 0x9F, 0x06, 0x1C, 0x38, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x10, 0x01, 0xE3, 0xC0, 0x03, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77, 0x00, 0x07, 0xB8, 0x00, 0x39,
  0xC0, 0x03, 0xCF, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x0E, 0x00,
  0xF0, 0x70, 0x07, 0x03, 0x80, 0x78, 0x1C, 0x03, 0xC0, 0xF0, 0x1F, 0xFF,
  0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0xDE, 0x00, 0x1F,
  0xE0, 0x00, 0x70, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF, 0xFC, 0x1E,
  0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x0F,
  0x0E, 0x00, 0x78, 0xF0, 0x07, 0x87, 0x80, 0x7C, 0x3C, 0x0F, 0xC1, 0xFF,
  0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0x07, 0x80, 0x7C, 0x3C, 0x01, 0xE1,
  0xE0, 0x07, 0x0E, 0x00, 0x3C, 0x70, 0x01, 0xE3, 0x80, 0x0E, 0x3C, 0x00,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x70, 0x0F, 0xC3, 0xFF, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x00, 0xFF,
  0xF0, 0x0F, 0x87, 0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xC7,
  0x80, 0x0E, 0x3C, 0x00, 0x79, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x1C,
  0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0x78, 0x07, 0x83, 0xC0,
  0x78, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x0F, 0x07,
  0x00, 0x78, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x38, 0xF0, 0x01,
  0xC7, 0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0xF0,
  0x01, 0xE7, 0x80, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x3C,
  0xF0, 0x01, 0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xC0, 0x1F, 0x0E, 0x01,
  0xF0, 0x70, 0x3F, 0x07, 0xFF, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0x87, 0xC0, 0xF0, 0x1F, 0x0F, 0x00, 0x78, 0x78,
  0x01, 0xC7, 0x80, 0x0E, 0x38, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x5E, 0x07,
  0xFC, 0xF0, 0x3F, 0xE7, 0x01, 0xFF, 0x38, 0x00, 0x39, 0xC0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x78, 0x03,
  0xC1, 0xE0, 0x3E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xE0,
  0xE0, 0x03, 0xC1, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1C,
  0x00, 0x38, 0x38, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x03, 0x83, 0xFF,
  0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1C, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0E,
  0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0xF0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x80, 0x0F, 0x07, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x41, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x7C, 0x1F, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x3F, 0x07, 0x00,
  0x3C, 0x07, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x03,
  0xC0, 0x0F, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1D, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xBC, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0x1C,
  0x00, 0x3C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x70, 0x03,
  0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3E, 0x1F, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x7E, 0x07, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x3B,
  0x83, 0xF0, 0x7F, 0x0F, 0xE1, 0xDC, 0x1D, 0xC3, 0xB8, 0x39, 0x8E, 0x70,
  0x73, 0x9C, 0xE0, 0xE7, 0x73, 0xC3, 0xCE, 0xE7, 0x87, 0x9F, 0x8E, 0x0E,
  0x3F, 0x1C, 0x1C, 0x7C, 0x38, 0x38, 0xF8, 0xF0, 0x70, 0xE1, 0xE1, 0xE1,
  0xC3, 0x83, 0xC3, 0x07, 0x07, 0x80, 0x0E, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x78, 0x38, 0x00, 0xF0, 0xF0, 0x01, 0xC1, 0xE0, 0x03, 0x83, 0x80, 0x07,
  0x07, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x38, 0x3E, 0x00,
  0xF0, 0x7C, 0x01, 0xE0, 0xFC, 0x03, 0xC1, 0xF8, 0x07, 0x07, 0xF0, 0x0E,
  0x0F, 0xF0, 0x1C, 0x1E, 0xE0, 0x78, 0x3D, 0xC0, 0xF0, 0x73, 0xC1, 0xE0,
  0xE3, 0x83, 0x83, 0xC7, 0x07, 0x07, 0x8F, 0x1E, 0x0F, 0x0E, 0x3C, 0x1C,
  0x1C, 0x78, 0x38, 0x3C, 0xF0, 0x70, 0x39, 0xC1, 0xE0, 0x73, 0x83, 0xC0,
  0xFF, 0x07, 0x80, 0xFE, 0x0E, 0x01, 0xFC, 0x1C, 0x03, 0xF8, 0x78, 0x03,
  0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7E, 0x7C, 0x0F,
  0x01, 0xE1, 0xE0, 0x0E, 0x1E, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0x73,
  0x80, 0x07, 0x78, 0x00, 0x77, 0x80, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x01,
  0xEE, 0x00, 0x1E, 0xF0, 0x01, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x00,
  0x78, 0x78, 0x0F, 0x07, 0xC1, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFC, 0x1C, 0x01,
  0xE0, 0xE0, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x1E,
  0x1E, 0x07, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0,
  0x7E, 0x7C, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x1C, 0x00, 0xF3, 0xC0, 0x07,
  0x38, 0x00, 0x77, 0x80, 0x07, 0x78, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xEF, 0x00, 0x1C, 0xF0,
  0x03, 0xC7, 0x00, 0x78, 0x78, 0x07, 0x07, 0xC1, 0xF0, 0x3F, 0xFE, 0x01,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0x80, 0x00, 0x20, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0E, 0x01, 0xE0, 0xF0, 0x07, 0x87, 0x80, 0x1C, 0x3C, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x01,
  0xE1, 0xE0, 0x1E, 0x0F, 0xFF, 0xF0, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x3C,
  0x0E, 0x01, 0xE0, 0x70, 0x0F, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0xC1, 0xE0, 0x1E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0xC3, 0x80,
  0x1E, 0x1C, 0x00, 0xF1, 0xE0, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xF0, 0x1F, 0x8F, 0xC0, 0xF0, 0x1F, 0x0F, 0x00, 0x78, 0x78,
  0x01, 0xC3, 0x80, 0x0F, 0x3C, 0x00, 0x78, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x70, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF8, 0x03,
  0xC3, 0xE0, 0x7C, 0x0F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x1C,
  0x38, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x3C, 0x78,
  0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xF0, 0x03, 0xC3,
  0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x1E, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xBC, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xE0,
  0x0E, 0x0F, 0x00, 0xF0, 0x78, 0x07, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0x80,
  0x70, 0x3C, 0x03, 0x81, 0xE0, 0x1C, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87,
  0x00, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xC0, 0x01,
  0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x38, 0x3D,
  0xC1, 0xE0, 0xF7, 0x07, 0x83, 0x9C, 0x1E, 0x0E, 0x70, 0xF8, 0x79, 0xC3,
  0xE1, 0xC7, 0x0F, 0x87, 0x1C, 0x7E, 0x1C, 0x71, 0xF8, 0xF1, 0xC7, 0xE3,
  0x87, 0x3B, 0x8E, 0x1C, 0xE6, 0x38, 0x73, 0x99, 0xE3, 0xDC, 0x67, 0x0F,
  0x71, 0x9C, 0x39, 0xC6, 0x70, 0xEE, 0x1B, 0x83, 0xB8, 0x6E, 0x0E, 0xE1,
  0xB8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03, 0xF0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x00, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x00, 0xF0, 0x0F, 0x80,
  0x78, 0x07, 0x80, 0x1C, 0x07, 0x80, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xC0,
  0x01, 0xC3, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x79,
  0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x3C, 0x03, 0x80, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0xFB, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x07, 0x83, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x3C,
  0x03, 0x81, 0xE0, 0x1C, 0x1E, 0x00, 0xF1, 0xE0, 0x03, 0x8F, 0x00, 0x1C,
  0xF0, 0x00, 0xE7, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F, 0x01, 0xFC, 0x0F,
  0xF0, 0x00, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x08, 0x70, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0,
  0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xFC, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0x03, 0x9C, 0x1E, 0x38,
  0x70, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x3F, 0xC0, 0x7E, 0x01, 0xC0, 0x7F,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF1, 0xC7, 0x8E, 0x1C, 0x00, 0x30,
  0x00, 0xFF, 0x80, 0xFF, 0xF0, 0x7E, 0x7E, 0x1E, 0x03, 0xCF, 0x00, 0xF3,
  0xC0, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x7F, 0xF0, 0xFF, 0xFC, 0xFF,
  0xFE, 0x7C, 0x03, 0x9E, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07,
  0xBC, 0x03, 0xCF, 0x83, 0xF1, 0xFF, 0xFC, 0x3F, 0xF7, 0x07, 0xF1, 0xE0,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x08, 0x00, 0xE7,
  0xF0, 0x0E, 0xFF, 0xC1, 0xFF, 0xFC, 0x1F, 0x83, 0xE1, 0xE0, 0x1E, 0x1E,
  0x00, 0xE1, 0xC0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0F, 0x3C, 0x00, 0xF3,
  0xC0, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE7, 0x80, 0x1C,
  0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x7E, 0x0F, 0x87, 0xFF, 0xF0, 0x77, 0xFE,
  0x0F, 0x3F, 0xC0, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xE7,
  0xC1, 0xF0, 0x3C, 0x78, 0x03, 0x8F, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x1C, 0x70, 0x03, 0x8F, 0x00, 0xF0, 0xF0, 0x3C,
  0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x60, 0xF0, 0x1F, 0xE7, 0x01, 0xFF,
  0xB8, 0x1F, 0xFF, 0xC1, 0xF0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F,
  0x00, 0x38, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xF1, 0xE0, 0x07,
  0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0x70,
  0x07, 0x83, 0xC0, 0x7C, 0x1F, 0x07, 0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0x70,
  0x07, 0xF3, 0x80, 0x00, 0x30, 0x00, 0x3F, 0xC0, 0x1F, 0xFC, 0x07, 0xE7,
  0xC1, 0xF0, 0x3C, 0x7C, 0x03, 0x8F, 0x00, 0x73, 0xC0, 0x0F, 0x78, 0x01,
  0xEE, 0x00, 0x3D, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x60, 0xF0, 0x1E,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xF8, 0x60, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0xF3, 0xC0,
  0xFF, 0xDC, 0x0F, 0xFF, 0xE0, 0xF8, 0x1F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0xF0,
  0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x38,
  0x38, 0x03, 0xC1, 0xE0, 0x3E, 0x0F, 0x83, 0xF0, 0x3F, 0xFF, 0x00, 0xFF,
  0xB8, 0x03, 0xF9, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x40, 0x0F, 0x03,
  0x00, 0x78, 0x3C, 0x0F, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x04, 0x00,
  0xE3, 0xF8, 0x0E, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x81, 0xE1, 0xF0, 0x0E,
  0x1E, 0x00, 0xE1, 0xC0, 0x0F, 0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00,
  0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80,
  0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x70,
  0x03, 0x8F, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x07, 0xFF, 0x01, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0x80, 0x00, 0x01,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x0E, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x07, 0xC3, 0x80, 0xF8, 0x3C, 0x0F, 0x81, 0xE0, 0xF8, 0x0F, 0x0F,
  0x80, 0x78, 0xF8, 0x03, 0x8F, 0x80, 0x1C, 0xF0, 0x01, 0xEF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x3C, 0x00, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0xF8, 0x1C, 0x03, 0xC0, 0xE0,
  0x0F, 0x07, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x07, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0xE0, 0x20, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xE0, 0x02, 0x20, 0x20, 0x77, 0xE7, 0xE1, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x1E, 0x3E, 0x1C, 0x70, 0x70, 0x73, 0xC1, 0xC1, 0xCF, 0x0F,
  0x07, 0x38, 0x3C, 0x3C, 0xE0, 0xE0, 0xF3, 0x83, 0x83, 0x8E, 0x0E, 0x0E,
  0x78, 0x38, 0x39, 0xE1, 0xE0, 0xE7, 0x07, 0x87, 0x9C, 0x1C, 0x1E, 0x70,
  0x70, 0x73, 0xC1, 0xC1, 0xCF, 0x07, 0x07, 0x3C, 0x3C, 0x1C, 0xE0, 0xF0,
  0xF3, 0x83, 0x83, 0xC0, 0x00, 0x04, 0x00, 0xE7, 0xF8, 0x0E, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0x81, 0xE1, 0xF0, 0x0E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E,
  0x1C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01,
  0xE3, 0x80, 0x1E, 0x38, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80,
  0x3C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x70, 0x03, 0x8F, 0x00, 0x38, 0x00,
  0x20, 0x00, 0x7F, 0xC0, 0x1F, 0xFC, 0x07, 0xEF, 0xC1, 0xE0, 0x3C, 0x78,
  0x07, 0x8E, 0x00, 0x73, 0xC0, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xBC, 0x00, 0xF7, 0x80,
  0x1E, 0xF0, 0x07, 0x8E, 0x00, 0xF1, 0xE0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF,
  0xC0, 0x1F, 0xE0, 0x00, 0x00, 0x04, 0x00, 0x39, 0xFC, 0x01, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0xF8, 0x1F, 0x07, 0x80, 0x78, 0x38, 0x01, 0xC1, 0xC0,
  0x0E, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x00, 0xE1,
  0xC0, 0x07, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1C, 0x3C, 0x01,
  0xE1, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x7F, 0xFF, 0x03, 0xBF, 0xF0, 0x3C,
  0xFF, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x3F, 0xCF, 0x07, 0xFE, 0xE0, 0xFD, 0xFE, 0x1F, 0x03, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x00, 0x1C,
  0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x03,
  0x8F, 0x00, 0x38, 0x70, 0x07, 0x87, 0x80, 0x78, 0x7C, 0x1F, 0x83, 0xFF,
  0xF0, 0x1F, 0xF7, 0x00, 0xFE, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x02, 0x03, 0x8F, 0xF0, 0xEF, 0xFC, 0x7F, 0xFE, 0x1F,
  0xC0, 0x87, 0xE0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x1F, 0xFE, 0x07,
  0xFF, 0xE1, 0xE0, 0x3C, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0xCF, 0x00, 0xF1, 0xE0,
  0x3E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0xF8,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3C, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCE, 0x00, 0x71,
  0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x1F, 0x1E, 0x07, 0xE1,
  0xFF, 0xF8, 0x3F, 0xF7, 0x03, 0xF8, 0xE0, 0xF0, 0x00, 0xF7, 0x00, 0x1E,
  0x70, 0x01, 0xC7, 0x80, 0x3C, 0x38, 0x03, 0x83, 0x80, 0x78, 0x38, 0x07,
  0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x01, 0xC1, 0xE0, 0x1C, 0x1C, 0x01, 0xC3,
  0x80, 0x1E, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x70, 0x3F, 0x07, 0x83, 0xF8, 0x3C, 0x1D, 0xC1, 0xE0, 0xEE, 0x1F,
  0x0F, 0x70, 0xD8, 0x73, 0x8E, 0xC3, 0x9C, 0x7E, 0x38, 0xE3, 0x31, 0xC7,
  0x39, 0x8E, 0x39, 0x8C, 0xE1, 0xDC, 0x67, 0x0E, 0xE3, 0x30, 0x76, 0x1B,
  0x83, 0xF0, 0xDC, 0x1F, 0x06, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3C,
  0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3E, 0x0F,
  0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x1E, 0x0F, 0x80, 0x1C, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0x39, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0xF3, 0xC0, 0x03, 0xC3, 0x80, 0x0F, 0x07, 0x80, 0x3E, 0x07, 0x80,
  0xF8, 0x0F, 0x03, 0xE0, 0x0F, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x87, 0x80, 0x07, 0x81, 0xC0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0x78, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0xC0,
  0xF0, 0x00, 0xE0, 0xF0, 0x00, 0x70, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xBC, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF,
  0x1F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x00, 0xFF, 0x00, 0x77, 0xFE, 0x01, 0x9F, 0xFC, 0x0E,
  0xE0, 0xFC, 0x7B, 0x80, 0xFF, 0xCC, 0x01, 0xFE, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_Italic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 28, 23, 7, -28 },
  { 33, 11, 9, 23, 8, -30 },
  { 46, 23, 28, 23, 1, -28 },
  { 127, 20, 37, 23, 2, -33 },
  { 220, 19, 29, 23, 3, -29 },
  { 289, 21, 29, 23, 1, -29 },
  { 366, 4, 9, 23, 11, -30 },
  { 371, 14, 41, 23, 6, -32 },
  { 443, 13, 41, 23, 3, -32 },
  { 510, 18, 19, 23, 4, -28 },
  { 553, 20, 21, 23, 2, -24 },
  { 606, 7, 11, 23, 4, -4 },
  { 616, 15, 3, 23, 4, -14 },
  { 622, 5, 5, 23, 8, -5 },
  { 626, 20, 30, 23, 2, -28 },
  { 701, 20, 29, 23, 2, -29 },
  { 774, 11, 28, 23, 6, -28 },
  { 813, 21, 29, 23, 0, -29 },
  { 890, 20, 29, 23, 1, -29 },
  { 963, 20, 28, 23, 1, -28 },
  { 1033, 20, 28, 23, 3, -28 },
  { 1103, 18, 28, 23, 2, -28 },
  { 1166, 19, 28, 23, 4, -28 },
  { 1233, 20, 29, 23, 2, -29 },
  { 1306, 17, 29, 23, 4, -29 },
  { 1368, 8, 22, 23, 9, -22 },
  { 1390, 11, 29, 23, 6, -22 },
  { 1430, 18, 18, 23, 3, -22 },
  { 1471, 19, 11, 23, 2, -18 },
  { 1498, 19, 17, 23, 2, -21 },
  { 1539, 17, 29, 23, 5, -29 },
  { 1601, 22, 29, 23, 1, -29 },
  { 1681, 21, 28, 23, -1, -28 },
  { 1755, 21, 28, 23, 1, -28 },
  { 1829, 21, 29, 23, 2, -29 },
  { 1906, 21, 28, 23, 1, -28 },
  { 1980, 22, 28, 23, 1, -28 },
  { 2057, 21, 28, 23, 2, -28 },
  { 2131, 21, 29, 23, 2, -29 },
  { 2208, 23, 28, 23, 1, -28 },
  { 2289, 22, 28, 23, 1, -28 },
  { 2366, 22, 28, 23, 1, -28 },
  { 2443, 24, 28, 23, 1, -28 },
  { 2527, 17, 28, 23, 2, -28 },
  { 2587, 23, 28, 23, 1, -28 },
  { 2668, 23, 28, 23, 1, -28 },
  { 2749, 20, 29, 23, 2, -29 },
  { 2822, 21, 28, 23, 2, -28 },
  { 2896, 20, 34, 23, 2, -29 },
  { 2981, 21, 28, 23, 1, -28 },
  { 3055, 21, 29, 23, 2, -29 },
  { 3132, 21, 28, 23, 4, -28 },
  { 3206, 22, 28, 23, 2, -28 },
  { 3283, 21, 28, 23, 4, -28 },
  { 3357, 22, 28, 23, 3, -28 },
  { 3434, 25, 28, 23, 0, -28 },
  { 3522, 21, 28, 23, 4, -28 },
  { 3596, 23, 28, 23, 0, -28 },
  { 3677, 14, 39, 23, 5, -33 },
  { 3746, 10, 30, 23, 7, -28 },
  { 3784, 13, 39, 23, 5, -33 },
  { 3848, 14, 15, 23, 5, -28 },
  { 3875, 18, 3, 23, 0, 0 },
  { 3882, 6, 5, 23, 11, -29 },
  { 3886, 18, 22, 23, 2, -22 },
  { 3936, 20, 30, 23, 1, -30 },
  { 4011, 19, 22, 23, 2, -22 },
  { 4064, 21, 30, 23, 2, -30 },
  { 4143, 19, 22, 23, 2, -22 },
  { 4196, 21, 31, 23, 4, -31 },
  { 4278, 21, 30, 23, 1, -22 },
  { 4357, 20, 30, 23, 1, -30 },
  { 4432, 18, 29, 23, 2, -29 },
  { 4498, 18, 38, 23, 1, -29 },
  { 4584, 21, 30, 23, 1, -30 },
  { 4663, 18, 30, 23, 2, -30 },
  { 4731, 22, 22, 23, 0, -22 },
  { 4792, 20, 22, 23, 1, -22 },
  { 4847, 19, 22, 23, 2, -22 },
  { 4900, 21, 30, 23, 0, -22 },
  { 4979, 20, 30, 23, 2, -22 },
  { 5054, 18, 22, 23, 4, -22 },
  { 5104, 19, 22, 23, 2, -22 },
  { 5157, 17, 26, 23, 4, -26 },
  { 5213, 19, 21, 23, 3, -21 },
  { 5263, 20, 21, 23, 3, -21 },
  { 5316, 21, 21, 23, 3, -21 },
  { 5372, 23, 21, 23, 0, -21 },
  { 5433, 25, 30, 23, -1, -21 },
  { 5527, 20, 21, 23, 1, -21 },
  { 5580, 16, 38, 23, 6, -31 },
  { 5656, 9, 36, 23, 7, -28 },
  { 5697, 16, 38, 23, 3, -31 },
  { 5773, 22, 8, 23, 1, -16 },
};

const GFXfont RobotoMono_Italic40pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic40pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _ROBOTOMONO_ITALIC40PT7B_H_
