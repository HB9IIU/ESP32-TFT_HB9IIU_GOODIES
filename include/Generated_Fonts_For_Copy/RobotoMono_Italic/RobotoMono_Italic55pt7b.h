#ifndef _ROBOTOMONO_ITALIC55PT7B_H_
#define _ROBOTOMONO_ITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x78, 0x00,
  0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0xF7, 0x81, 0xEF, 0x03, 0x9E,
  0x0F, 0x3C, 0x1E, 0x70, 0x3C, 0xE0, 0x7B, 0xC0, 0xE7, 0x81, 0xCF, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x3E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0,
  0x70, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x3C, 0x0F,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0, 0x3C,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0xC3, 0xF0, 0x03, 0xF0, 0x3F, 0x01, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0x3C, 0x04, 0x1E, 0x07, 0x80, 0xC3, 0xC0, 0xF0, 0x3C, 0x70, 0x1E, 0x0F,
  0x0E, 0x03, 0xC3, 0xE1, 0xC0, 0x78, 0x78, 0x38, 0x0E, 0x1E, 0x07, 0x83,
  0xC7, 0x80, 0xF0, 0xF8, 0xF0, 0x1F, 0xFE, 0x3C, 0x01, 0xFF, 0x8F, 0x00,
  0x1F, 0xE1, 0xE0, 0x00, 0x60, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0xE0, 0x00, 0x78, 0xFF, 0x00, 0x1E, 0x3F, 0xF0, 0x03, 0xCF,
  0xFF, 0x00, 0xF3, 0xE1, 0xE0, 0x3C, 0x78, 0x1C, 0x0F, 0x0E, 0x03, 0xC1,
  0xE3, 0xC0, 0x78, 0x78, 0x78, 0x0E, 0x1E, 0x0F, 0x01, 0xC3, 0xC1, 0xE0,
  0x38, 0x10, 0x3C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0x1E,
  0x0F, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0xF1, 0xF8, 0xF8,
  0x0F, 0x3F, 0x0F, 0x81, 0xF7, 0xE0, 0x7C, 0x1F, 0x7C, 0x07, 0xE1, 0xEF,
  0xC0, 0x3E, 0x3E, 0xF8, 0x03, 0xF3, 0xCF, 0x80, 0x1F, 0x7C, 0xF8, 0x01,
  0xFF, 0x8F, 0x80, 0x0F, 0xF8, 0xF8, 0x00, 0x7F, 0x0F, 0x80, 0x07, 0xE0,
  0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0xF8, 0x1F, 0xFF, 0x8F, 0xC0, 0x7F, 0xE0, 0x7C, 0x00, 0x20, 0x00,
  0x00, 0x3C, 0xF7, 0xDE, 0x79, 0xE7, 0x9C, 0xF3, 0xCF, 0x3C, 0xE0, 0x00,
  0x00, 0x80, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x06, 0x00, 0x00, 0x80, 0x00, 0x00, 0x40, 0x00, 0x0C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x40, 0x3C,
  0x02, 0x78, 0x1E, 0x07, 0x3F, 0x0F, 0x1F, 0xBF, 0xE7, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF3, 0xE0, 0x01,
  0xF8, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x1F, 0x01, 0xF8, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x04, 0x00, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC1, 0xF0,
  0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF0,
  0x7C, 0x3E, 0x03, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xE7, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F,
  0xCF, 0x80, 0x07, 0xF9, 0xF0, 0x01, 0xFF, 0x3E, 0x00, 0xFF, 0xE7, 0xC0,
  0x3F, 0x78, 0xF8, 0x1F, 0xDF, 0x1E, 0x07, 0xF3, 0xE7, 0xC3, 0xF8, 0x7C,
  0xF8, 0xFE, 0x0F, 0x9F, 0x3F, 0x01, 0xF3, 0xFF, 0xC0, 0x3C, 0x7F, 0xE0,
  0x0F, 0x8F, 0xF8, 0x01, 0xF3, 0xFC, 0x00, 0x3E, 0x7F, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x01, 0xFE, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x00, 0x1F,
  0x00, 0xFF, 0x03, 0xFE, 0x1F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xFE, 0x3E,
  0xF0, 0x3E, 0xC0, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0x3F, 0xC0, 0x1F, 0x80, 0x7E, 0x03,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x1F, 0xE3, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC0,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x20, 0x00, 0x0F,
  0xBF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x03, 0xFD, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0x00,
  0x1E, 0x3F, 0xE0, 0x3E, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC,
  0x7F, 0xC0, 0x7E, 0x7F, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xFC,
  0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xF3, 0xFC, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0x7F, 0x0F, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x1F, 0x80,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x07,
  0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xFE, 0xFF, 0xC0, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0xFB, 0xFC, 0x0F, 0xC0, 0x7C, 0x1F, 0x80, 0x3E, 0x3F, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00,
  0x7E, 0x7C, 0x00, 0xFE, 0x3E, 0x01, 0xFE, 0x3F, 0x87, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xBC, 0x07, 0xFE, 0x7C, 0x01, 0xF8, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xC0, 0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0,
  0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x07, 0xE0, 0xFE, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01,
  0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xF0,
  0x0F, 0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x87, 0xF0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0xF0, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0xF8, 0x01, 0xE0,
  0x07, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x81, 0xF8, 0x38, 0x3C, 0x1F, 0xF0, 0xE0, 0xE0, 0xFF, 0xE3, 0x87, 0x87,
  0xC3, 0x8E, 0x1C, 0x3E, 0x1C, 0x38, 0xF0, 0xF0, 0x70, 0xE3, 0x87, 0x81,
  0xC3, 0x9E, 0x1C, 0x07, 0x0E, 0x70, 0x70, 0x38, 0x39, 0xC3, 0xC0, 0xE0,
  0xE7, 0x0E, 0x03, 0x83, 0xBC, 0x38, 0x0E, 0x0E, 0xF0, 0xE0, 0x70, 0x3B,
  0x87, 0x81, 0xC0, 0xCE, 0x1E, 0x07, 0x07, 0x38, 0x78, 0x1C, 0x1C, 0xE1,
  0xE0, 0xF0, 0x63, 0x87, 0x87, 0x83, 0x8E, 0x1E, 0x3F, 0x1C, 0x38, 0x3F,
  0xDF, 0xF0, 0xE0, 0xFE, 0x7F, 0x83, 0xC1, 0xF0, 0xFC, 0x0F, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x04, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3E, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0,
  0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0xC0, 0x3C,
  0x00, 0x3E, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0x78, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x07,
  0x81, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x3E, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xFE,
  0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F,
  0x81, 0xF0, 0x03, 0xF8, 0x0F, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x0F, 0xC0, 0x78, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF8, 0x3E, 0x00, 0x7F,
  0x81, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFE, 0x3F, 0x80, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xEF,
  0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x3F, 0xC0, 0x0F,
  0x80, 0x1F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x78, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0xF8, 0x3E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x0F, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x7F, 0x01, 0xF0, 0x03, 0xF8, 0x07,
  0xC0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x80, 0x3F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xE0,
  0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x2F, 0x80, 0x3F, 0xFC, 0xF8, 0x03, 0xFF, 0xCF, 0x80, 0x3F,
  0xFC, 0xF8, 0x03, 0xFF, 0xCF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x78, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0xC0,
  0xF8, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x00, 0x3E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xE0, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0xC0,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x03, 0xE0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x07, 0xC0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x0F, 0xBF, 0x80, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x1F, 0xE7, 0xC0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x2F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC, 0x01, 0xF8,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xBC, 0x07, 0xBC, 0x0F, 0xFC, 0x07, 0xBC, 0x0F, 0x7C, 0x07, 0x9E,
  0x1F, 0x78, 0x0F, 0x9E, 0x1E, 0x78, 0x0F, 0x9E, 0x3C, 0x78, 0x0F, 0x9E,
  0x7C, 0xF8, 0x0F, 0x9E, 0x78, 0xF8, 0x0F, 0x1E, 0xF8, 0xF8, 0x0F, 0x1E,
  0xF0, 0xF0, 0x1F, 0x0F, 0xF0, 0xF0, 0x1F, 0x0F, 0xE1, 0xF0, 0x1F, 0x0F,
  0xE1, 0xF0, 0x1F, 0x0F, 0xC1, 0xF0, 0x1E, 0x0F, 0xC1, 0xF0, 0x1E, 0x0F,
  0x81, 0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0x03, 0xE0, 0x3E, 0x07,
  0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0xC0,
  0x01, 0xF0, 0x3F, 0x80, 0x03, 0xE0, 0x7F, 0x00, 0x0F, 0x80, 0xFF, 0x00,
  0x1F, 0x03, 0xFE, 0x00, 0x3E, 0x07, 0xFC, 0x00, 0x7C, 0x0F, 0xFC, 0x00,
  0xF8, 0x1F, 0xF8, 0x01, 0xE0, 0x3E, 0xF0, 0x07, 0xC0, 0x7D, 0xF0, 0x0F,
  0x81, 0xF3, 0xE0, 0x1F, 0x03, 0xE3, 0xC0, 0x3E, 0x07, 0xC7, 0xC0, 0x7C,
  0x0F, 0x8F, 0x81, 0xF0, 0x1F, 0x0F, 0x03, 0xE0, 0x7C, 0x1F, 0x07, 0xC0,
  0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x3C, 0x1F, 0x03, 0xE0, 0x7C, 0x3E, 0x07,
  0xC0, 0xF8, 0xF8, 0x0F, 0x80, 0xF1, 0xF0, 0x3E, 0x01, 0xF3, 0xE0, 0x7C,
  0x03, 0xE7, 0xC0, 0xF8, 0x03, 0xCF, 0x81, 0xF0, 0x07, 0xDF, 0x03, 0xE0,
  0x0F, 0xFC, 0x07, 0xC0, 0x0F, 0xF8, 0x1F, 0x00, 0x1F, 0xF0, 0x3E, 0x00,
  0x3F, 0xE0, 0x7C, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x00,
  0xFE, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07,
  0xF0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x03,
  0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1E, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0xC1, 0xF8, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x07, 0xE0,
  0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFE,
  0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xE1,
  0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x11, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x00,
  0xFE, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x78, 0x00, 0x7E,
  0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01,
  0xFE, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0,
  0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0x80, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xE0, 0x00,
  0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x0F, 0x00, 0x3E, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF0, 0x3E,
  0x00, 0x07, 0x81, 0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x3D, 0xF0,
  0x1F, 0x01, 0xF7, 0xC0, 0x7C, 0x07, 0xDF, 0x01, 0xF0, 0x1E, 0x7C, 0x0F,
  0xC0, 0x79, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x07, 0xF0,
  0x3C, 0x7C, 0x1F, 0xC0, 0xF1, 0xF0, 0x7F, 0x07, 0xC7, 0x83, 0xDC, 0x1F,
  0x1E, 0x0F, 0x70, 0x78, 0x78, 0x3D, 0xC1, 0xE1, 0xE1, 0xE7, 0x0F, 0x87,
  0x87, 0x9C, 0x3C, 0x1E, 0x1E, 0x70, 0xF0, 0x78, 0xF1, 0xC7, 0xC1, 0xE3,
  0xC7, 0x1F, 0x07, 0x8F, 0x1C, 0x78, 0x1E, 0x78, 0x71, 0xE0, 0x79, 0xE1,
  0xCF, 0x81, 0xE7, 0x87, 0x3E, 0x07, 0xBC, 0x1C, 0xF0, 0x1E, 0xF0, 0x73,
  0xC0, 0x7B, 0xC1, 0xDF, 0x01, 0xFE, 0x07, 0x78, 0x0F, 0xF8, 0x1D, 0xE0,
  0x3F, 0xE0, 0x77, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00,
  0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x03, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x78, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x00, 0xF0, 0x07,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x07, 0xFF, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1E, 0x7C, 0x03, 0xE3, 0xC0, 0x3C,
  0x3C, 0x07, 0xC3, 0xC0, 0xF8, 0x3E, 0x0F, 0x81, 0xE1, 0xF0, 0x1E, 0x1E,
  0x01, 0xE3, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0xC0, 0x0F, 0xF8, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3E, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x00, 0x07, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x9F, 0xE0,
  0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x3F, 0xC0,
  0x1F, 0x3F, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x01, 0xF8, 0xF8,
  0x01, 0xFC, 0x7E, 0x03, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xE7, 0xC0, 0x7F, 0xC3, 0xE0, 0x03, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x07, 0x00,
  0x07, 0x8F, 0xF8, 0x01, 0xE7, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xF0, 0x1F, 0x83, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x7E,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xC7,
  0xE0, 0x03, 0xF1, 0xFC, 0x01, 0xF8, 0x7F, 0x80, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xBF, 0xFF, 0x83, 0xE7, 0xFF, 0xC0, 0xF0, 0xFF, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xFC, 0xFF, 0x03, 0xF8, 0x0F, 0xC0, 0xF8, 0x00,
  0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F,
  0xC0, 0x7F, 0x01, 0xFE, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x1C, 0x07, 0xC0, 0x07, 0xFC, 0x3E, 0x00, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0xFC, 0x00, 0xFE,
  0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x83, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x1F,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x80, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFE, 0xF0, 0x01, 0xFF, 0xEF, 0x80, 0x07, 0xFC, 0x7C, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xF8, 0x0F, 0xC0,
  0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xE3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBE,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x60, 0x7E, 0x00,
  0x3E, 0x0F, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0xFC, 0x01, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF,
  0x87, 0xC0, 0x1F, 0xFF, 0x3C, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x01, 0xFC, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x78, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x80, 0x7E, 0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFD, 0xF0, 0x00, 0xFF, 0x8F, 0x80, 0x00, 0x60, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0x00, 0x01, 0xF0, 0x0C, 0x00, 0x1F,
  0x00, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x03, 0x80, 0x07, 0x87, 0xFC, 0x03, 0xE3, 0xFF,
  0xC0, 0xFB, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xF0, 0x1F, 0xC3, 0xF8,
  0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xC3, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x07, 0xF0, 0x78, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x03,
  0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0x83, 0xF8, 0x00,
  0xF0, 0x7F, 0x00, 0x1F, 0x0F, 0xE0, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0x80, 0x03, 0xF0,
  0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0x78,
  0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x03, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x07, 0x00, 0xC0, 0x0F, 0x3F, 0x8F, 0xE0, 0x3F, 0xFF,
  0xBF, 0xE0, 0x7B, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xF0, 0x7F,
  0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x87, 0x80, 0xF0, 0x1F, 0x1F, 0x01, 0xE0,
  0x3C, 0x3E, 0x07, 0xC0, 0x78, 0x7C, 0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0x03,
  0xE1, 0xE0, 0x3E, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x8F, 0x80, 0xF0, 0x1E,
  0x1F, 0x03, 0xE0, 0x3C, 0x3E, 0x07, 0xC0, 0x78, 0x78, 0x0F, 0x81, 0xF0,
  0xF0, 0x1E, 0x03, 0xE3, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x0F,
  0x81, 0xF0, 0x1E, 0x1F, 0x03, 0xE0, 0x3C, 0x3C, 0x07, 0xC0, 0xF8, 0x78,
  0x0F, 0x01, 0xF1, 0xF0, 0x1E, 0x03, 0xE3, 0xE0, 0x3C, 0x07, 0x87, 0xC0,
  0xF8, 0x0F, 0x0F, 0x81, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0x00, 0xE0, 0x01, 0xE1, 0xFF, 0x00, 0xF9, 0xFF, 0xF0, 0x3E, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00,
  0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xC7, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF3, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF0, 0x07, 0xFD, 0xFE, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00,
  0x7D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xFE, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x3F,
  0xE0, 0x03, 0xEF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xFC, 0x03,
  0xF0, 0x3F, 0xFB, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3E, 0x7F, 0xFC, 0x03,
  0xE3, 0xFF, 0x00, 0x3E, 0x03, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFC,
  0x7C, 0x07, 0xFF, 0xCF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xDF, 0xFC, 0x1F,
  0xC0, 0x7F, 0x87, 0xE0, 0x07, 0xF0, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07,
  0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x80, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xF7, 0xC0, 0x0F, 0xF8, 0xF8, 0x00,
  0x18, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x38, 0x07, 0x83, 0xFF, 0x07, 0x8F, 0xFF, 0x0F, 0x9F,
  0xFF, 0x0F, 0xBF, 0xFE, 0x0F, 0xFF, 0x0E, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03,
  0xF8, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x71, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0xFC, 0x7C, 0x00, 0x3E, 0x1F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x10,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0x0C, 0x00, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xE0, 0x00,
  0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0x7C, 0x07, 0xF8,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xF7, 0x80, 0x7F, 0xF1, 0xE0, 0x0F, 0xF8,
  0xF8, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7E, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0x00,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x1E, 0x01, 0xF0, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x07, 0x80,
  0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0x80, 0x78, 0x07, 0xFC,
  0x03, 0xC0, 0x3D, 0xE0, 0x3E, 0x01, 0xEF, 0x01, 0xF0, 0x1F, 0x78, 0x1F,
  0x80, 0xF3, 0xC0, 0xFC, 0x07, 0x9E, 0x07, 0xE0, 0x78, 0xF0, 0x7F, 0x03,
  0xC7, 0x83, 0xBC, 0x1E, 0x3C, 0x3D, 0xE1, 0xE1, 0xE1, 0xEF, 0x0F, 0x0F,
  0x0E, 0x78, 0x78, 0x78, 0xF3, 0xC7, 0x83, 0xC7, 0x1E, 0x3C, 0x1E, 0x78,
  0xF1, 0xC0, 0xF3, 0xC3, 0x9E, 0x07, 0xBC, 0x1C, 0xF0, 0x3D, 0xE0, 0xE7,
  0x01, 0xEE, 0x07, 0x78, 0x0F, 0xF0, 0x3B, 0xC0, 0x7F, 0x01, 0xDC, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF0,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00,
  0x1E, 0xF8, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07, 0x80,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xCF, 0xFF, 0xC0, 0x0F, 0x7F,
  0xFF, 0x80, 0x3D, 0xF0, 0x7F, 0x01, 0xEF, 0x80, 0xFF, 0x1F, 0xBC, 0x00,
  0xFF, 0xFC, 0xF0, 0x01, 0xFF, 0xE1, 0x80, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00,
};

const GFXglyph RobotoMono_Italic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 12, 39, 32, 10, -39 },
  { 60, 15, 13, 32, 11, -41 },
  { 85, 32, 39, 32, 1, -39 },
  { 241, 27, 51, 32, 3, -45 },
  { 414, 27, 41, 32, 3, -40 },
  { 553, 28, 41, 32, 2, -40 },
  { 697, 6, 13, 32, 15, -41 },
  { 707, 18, 57, 32, 9, -44 },
  { 836, 19, 57, 32, 4, -44 },
  { 972, 25, 26, 32, 6, -39 },
  { 1054, 27, 28, 32, 3, -32 },
  { 1149, 10, 15, 32, 5, -6 },
  { 1168, 21, 4, 32, 5, -19 },
  { 1179, 7, 8, 32, 11, -7 },
  { 1186, 28, 42, 32, 3, -39 },
  { 1333, 27, 41, 32, 3, -40 },
  { 1472, 16, 39, 32, 8, -39 },
  { 1550, 28, 40, 32, 0, -40 },
  { 1690, 27, 41, 32, 1, -40 },
  { 1829, 28, 39, 32, 1, -39 },
  { 1966, 28, 40, 32, 4, -39 },
  { 2106, 24, 40, 32, 3, -39 },
  { 2226, 27, 39, 32, 5, -39 },
  { 2358, 27, 41, 32, 3, -40 },
  { 2497, 24, 40, 32, 5, -40 },
  { 2617, 12, 32, 32, 12, -31 },
  { 2665, 14, 40, 32, 9, -31 },
  { 2735, 25, 25, 32, 4, -30 },
  { 2814, 26, 15, 32, 3, -25 },
  { 2863, 25, 24, 32, 3, -29 },
  { 2938, 23, 40, 32, 7, -40 },
  { 3053, 30, 39, 32, 2, -39 },
  { 3200, 29, 39, 32, -1, -39 },
  { 3342, 29, 39, 32, 2, -39 },
  { 3484, 28, 41, 32, 3, -40 },
  { 3628, 30, 39, 32, 1, -39 },
  { 3775, 30, 39, 32, 2, -39 },
  { 3922, 30, 39, 32, 2, -39 },
  { 4069, 28, 41, 32, 3, -40 },
  { 4213, 31, 39, 32, 1, -39 },
  { 4365, 29, 39, 32, 2, -39 },
  { 4507, 29, 40, 32, 2, -39 },
  { 4652, 32, 39, 32, 2, -39 },
  { 4808, 25, 39, 32, 2, -39 },
  { 4930, 32, 39, 32, 1, -39 },
  { 5086, 31, 39, 32, 1, -39 },
  { 5238, 27, 41, 32, 3, -40 },
  { 5377, 30, 39, 32, 2, -39 },
  { 5524, 29, 47, 32, 2, -40 },
  { 5695, 29, 39, 32, 2, -39 },
  { 5837, 29, 41, 32, 2, -40 },
  { 5986, 29, 39, 32, 5, -39 },
  { 6128, 29, 40, 32, 3, -39 },
  { 6273, 29, 39, 32, 5, -39 },
  { 6415, 30, 39, 32, 4, -39 },
  { 6562, 34, 39, 32, 0, -39 },
  { 6728, 28, 39, 32, 6, -39 },
  { 6865, 30, 39, 32, 1, -39 },
  { 7012, 19, 53, 32, 7, -45 },
  { 7138, 13, 42, 32, 10, -39 },
  { 7207, 18, 53, 32, 7, -45 },
  { 7327, 20, 21, 32, 6, -39 },
  { 7380, 24, 4, 32, 1, 0 },
  { 7392, 9, 7, 32, 15, -40 },
  { 7400, 25, 31, 32, 3, -30 },
  { 7497, 26, 42, 32, 2, -41 },
  { 7634, 26, 31, 32, 3, -30 },
  { 7735, 29, 42, 32, 3, -41 },
  { 7888, 26, 31, 32, 3, -30 },
  { 7989, 29, 42, 32, 5, -42 },
  { 8142, 29, 42, 32, 1, -30 },
  { 8295, 26, 41, 32, 2, -41 },
  { 8429, 25, 40, 32, 2, -40 },
  { 8554, 25, 52, 32, 1, -40 },
  { 8717, 28, 41, 32, 2, -41 },
  { 8861, 25, 41, 32, 2, -41 },
  { 8990, 31, 30, 32, 0, -30 },
  { 9107, 26, 30, 32, 2, -30 },
  { 9205, 26, 31, 32, 3, -30 },
  { 9306, 28, 41, 32, 0, -30 },
  { 9450, 27, 41, 32, 3, -30 },
  { 9589, 24, 30, 32, 6, -30 },
  { 9679, 26, 31, 32, 3, -30 },
  { 9780, 24, 37, 32, 5, -36 },
  { 9891, 26, 30, 32, 4, -29 },
  { 9989, 26, 29, 32, 5, -29 },
  { 10084, 29, 29, 32, 4, -29 },
  { 10190, 32, 29, 32, 0, -29 },
  { 10306, 34, 41, 32, -1, -29 },
  { 10481, 27, 29, 32, 2, -29 },
  { 10579, 22, 53, 32, 8, -43 },
  { 10725, 12, 50, 32, 10, -39 },
  { 10800, 21, 53, 32, 5, -43 },
  { 10940, 30, 11, 32, 1, -22 },
};

const GFXfont RobotoMono_Italic55pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic55pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic55pt7bGlyphs,
  0x20, 0x7E, 73
};

#endif // _ROBOTOMONO_ITALIC55PT7B_H_
