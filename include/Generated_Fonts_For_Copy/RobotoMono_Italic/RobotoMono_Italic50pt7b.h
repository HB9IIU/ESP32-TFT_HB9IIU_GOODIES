#ifndef _ROBOTOMONO_ITALIC50PT7B_H_
#define _ROBOTOMONO_ITALIC50PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x1F, 0x83,
  0xF0, 0x3C, 0x00, 0x3C, 0x3C, 0xE0, 0xF3, 0x83, 0xDE, 0x0F, 0x78, 0x39,
  0xE0, 0xE7, 0x07, 0x9C, 0x1E, 0x70, 0x71, 0xC1, 0xCF, 0x07, 0x38, 0x1C,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x3C,
  0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x38,
  0x00, 0x07, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x41, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70,
  0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x0E, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0xC0, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0x38, 0x1E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x01,
  0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFE, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0x1E, 0x07, 0xC0, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7E,
  0x03, 0xF8, 0x3F, 0x8F, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x38, 0x78, 0x00, 0x78, 0x38, 0x00, 0x70, 0x38, 0x18, 0xF0,
  0x38, 0x1E, 0xF0, 0x38, 0x3C, 0xF0, 0x38, 0x78, 0xF0, 0x38, 0x70, 0xF0,
  0x78, 0xF0, 0x70, 0x71, 0xE0, 0x7D, 0xF3, 0xC0, 0x3F, 0xE3, 0x80, 0x1F,
  0xC7, 0x80, 0x06, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF1, 0xF8, 0x01,
  0xE3, 0xFC, 0x01, 0xC7, 0xFE, 0x03, 0xCF, 0x0E, 0x07, 0x8E, 0x0F, 0x07,
  0x1E, 0x0F, 0x0F, 0x1C, 0x0F, 0x1E, 0x1C, 0x0F, 0x3C, 0x1C, 0x0F, 0x18,
  0x1C, 0x0F, 0x00, 0x1C, 0x0E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x7C, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0xF8, 0x3C,
  0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xE0,
  0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x01,
  0xE1, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xDF, 0x03, 0xC7, 0xE3, 0xC0, 0xF3, 0xF0, 0xF8, 0x3C, 0xF8,
  0x1F, 0x0F, 0x7C, 0x07, 0xC7, 0x9F, 0x00, 0xF9, 0xE7, 0x80, 0x3E, 0xF1,
  0xE0, 0x07, 0xFC, 0x78, 0x01, 0xFE, 0x1E, 0x00, 0x3F, 0x07, 0xC0, 0x0F,
  0xC1, 0xF0, 0x07, 0xF0, 0x3F, 0x0F, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF,
  0xF9, 0xF0, 0x1F, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0xCF,
  0x39, 0xE7, 0x9E, 0x79, 0xC7, 0x3C, 0x00, 0x01, 0x00, 0x03, 0x80, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x80, 0x00, 0x60, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x10, 0x0E, 0x02, 0x38, 0x1C, 0x1E,
  0xFC, 0x79, 0xFD, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xDE, 0x00, 0x0F,
  0x9E, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x07, 0x00, 0xF0, 0x04, 0x01, 0x80, 0x00, 0x02, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x07, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0xF8, 0x7C, 0x3C, 0x3E,
  0x3E, 0x1E, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00,
  0x00, 0xFB, 0xF7, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x3E,
  0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x7F,
  0x3C, 0x00, 0xFF, 0x3C, 0x01, 0xFF, 0x7C, 0x07, 0xFF, 0x7C, 0x0F, 0xDF,
  0x7C, 0x3F, 0x1E, 0x78, 0x7E, 0x1E, 0x79, 0xF8, 0x1E, 0x7B, 0xF0, 0x1E,
  0xFF, 0xE0, 0x3E, 0xFF, 0x80, 0x3E, 0xFF, 0x00, 0x3C, 0xFC, 0x00, 0x3C,
  0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0x0F, 0xC0,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x02, 0x00, 0x1C, 0x01, 0xF8, 0x1F, 0xE1, 0xFF, 0xCF, 0xFF, 0xBF,
  0xEF, 0x7E, 0x3E, 0xF0, 0x79, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x0F, 0x80,
  0x07, 0xC3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0x03, 0xF0, 0x3E, 0x00, 0xF8,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3F, 0x87, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xCF, 0x80,
  0x03, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xF0,
  0x01, 0xE0, 0x78, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1E,
  0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xCF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x07, 0xE0, 0x7F, 0x00, 0x70, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x08, 0x00, 0x03, 0xC1, 0xE0, 0x01,
  0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x3F, 0x07, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1F,
  0xC0, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF1, 0xFE, 0x03, 0xDF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x7F, 0xE7, 0xF1, 0xFC, 0x07, 0xE7, 0xE0, 0x0F, 0x9F,
  0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x1E,
  0xF8, 0x00, 0xF9, 0xE0, 0x03, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0xF8, 0x3F,
  0x0F, 0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x20,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0x03, 0xE0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xE0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x0F, 0xC3, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xF8, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xC1, 0xF0,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3F, 0x07, 0xF0, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x1F, 0x00,
  0xF8, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xDF, 0x00, 0xFE, 0xFC,
  0x0F, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0x78, 0x7F, 0xF7, 0xC0, 0xFE, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x03,
  0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F,
  0x07, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x07, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xFC, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xFC,
  0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x01, 0x80, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0x07, 0xE7,
  0xC0, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x00, 0xF8, 0x07, 0x80,
  0x07, 0x01, 0xE0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x0E, 0x07, 0xE1, 0xC3,
  0xC3, 0xFE, 0x18, 0x70, 0xFF, 0xE3, 0x1E, 0x1E, 0x18, 0x73, 0x87, 0x07,
  0x0E, 0x71, 0xE0, 0xE1, 0xDC, 0x38, 0x18, 0x3B, 0x87, 0x03, 0x06, 0x71,
  0xC0, 0xE0, 0xDC, 0x38, 0x1C, 0x1B, 0x87, 0x03, 0x87, 0x70, 0xE0, 0x60,
  0xEE, 0x3C, 0x1C, 0x19, 0xC7, 0x03, 0x83, 0x38, 0xE0, 0x70, 0xE7, 0x1C,
  0x1C, 0x18, 0xE3, 0xCF, 0xC7, 0x1C, 0x3F, 0xFF, 0xC3, 0x87, 0xF7, 0xF0,
  0x70, 0x78, 0x7C, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0xC0, 0x04, 0x00, 0x3E, 0x03, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x3E,
  0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78,
  0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0x80, 0x7F, 0x01, 0xE0, 0x07, 0xE0,
  0x78, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01,
  0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x0F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0x7E,
  0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x8F, 0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xE0,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78,
  0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x07, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xF0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFE, 0x00, 0x3C, 0x0F, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xC0,
  0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x00,
  0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x3F, 0xF9, 0xE0, 0x1F,
  0xFE, 0x78, 0x07, 0xFF, 0xBE, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0xF3, 0xE0,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x03,
  0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0xC3, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07,
  0x80, 0x00, 0xF0, 0x78, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01,
  0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x0F,
  0xC0, 0x7F, 0x1F, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x40, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xF8,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x0F,
  0x80, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xC0, 0xFC, 0x00, 0x1E, 0x0F,
  0xC0, 0x00, 0xF0, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0xFC, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1E, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFD, 0xF0, 0x00, 0x1F, 0xC7,
  0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0xC0,
  0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x07,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x0F,
  0x81, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xC0, 0xFE, 0x03,
  0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0x03, 0xDE, 0x0F, 0x78,
  0x1E, 0xF0, 0xF3, 0xC0, 0xF3, 0x87, 0x9E, 0x07, 0x9C, 0x79, 0xE0, 0x3C,
  0xE3, 0xCF, 0x01, 0xE7, 0xBC, 0x78, 0x1F, 0x3D, 0xE3, 0xC0, 0xF1, 0xFE,
  0x1E, 0x07, 0x8F, 0xF1, 0xF0, 0x3C, 0x3F, 0x0F, 0x01, 0xE1, 0xF8, 0x78,
  0x1F, 0x0F, 0x83, 0xC0, 0xF8, 0x7C, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x3C,
  0x1E, 0x0F, 0x81, 0xE0, 0xE0, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00,
  0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3E,
  0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xF0, 0x01,
  0xF0, 0x7F, 0x00, 0x1F, 0x07, 0xF0, 0x01, 0xE0, 0x7F, 0x80, 0x1E, 0x07,
  0xF8, 0x03, 0xE0, 0xFF, 0x80, 0x3E, 0x0F, 0xFC, 0x03, 0xE0, 0xFB, 0xC0,
  0x3C, 0x0F, 0x3C, 0x03, 0xC0, 0xF3, 0xE0, 0x3C, 0x0F, 0x1E, 0x07, 0xC1,
  0xF1, 0xE0, 0x7C, 0x1F, 0x1F, 0x07, 0xC1, 0xF0, 0xF0, 0x78, 0x1E, 0x0F,
  0x07, 0x81, 0xE0, 0xF8, 0x78, 0x1E, 0x07, 0x8F, 0x83, 0xE0, 0x78, 0xF8,
  0x3E, 0x07, 0xCF, 0x83, 0xE0, 0x3C, 0xF0, 0x3C, 0x03, 0xCF, 0x03, 0xC0,
  0x3F, 0xF0, 0x7C, 0x01, 0xFF, 0x07, 0xC0, 0x1F, 0xF0, 0x7C, 0x01, 0xFE,
  0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07,
  0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x1F, 0xCF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3C,
  0x3E, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x83,
  0xE0, 0x0F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x03, 0xF8, 0x3F, 0x01, 0xF8, 0x07, 0xC0,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0xC0, 0x01,
  0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDE,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3C, 0xF8, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x0F, 0x80, 0xF8, 0x07, 0xC0,
  0x1F, 0xCF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x04, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xC0,
  0x7F, 0x01, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1F, 0x07,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x3F, 0x07, 0x80, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x03, 0xC0, 0x3C, 0x00,
  0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x07, 0x80,
  0x0F, 0x81, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0x81, 0xF8,
  0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0x3F, 0xC7, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x10, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xF1,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01,
  0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x1E,
  0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E,
  0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0xF8, 0xF0, 0x00,
  0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x3F, 0x9F, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1E, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x0F,
  0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xC0,
  0x07, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x1E, 0x0F,
  0x00, 0x07, 0x87, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x78, 0x00, 0x0F,
  0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x0F, 0x01, 0xEF, 0x01, 0xE0, 0x3D, 0xE0, 0x7C, 0x07,
  0xBC, 0x0F, 0x81, 0xE7, 0x81, 0xF0, 0x3C, 0xF0, 0x7E, 0x07, 0x9E, 0x0F,
  0xC0, 0xF3, 0xC1, 0xF8, 0x3C, 0x78, 0x3F, 0x07, 0x8F, 0x0F, 0xE0, 0xF1,
  0xE1, 0xDC, 0x3E, 0x3C, 0x3B, 0x87, 0x87, 0x8F, 0x70, 0xF0, 0xE1, 0xEE,
  0x1E, 0x3C, 0x39, 0xC7, 0x87, 0x8F, 0x38, 0xF0, 0xF1, 0xE7, 0x1E, 0x1E,
  0x38, 0xE3, 0xC3, 0xCF, 0x1C, 0xF0, 0x79, 0xE3, 0x9E, 0x0F, 0x38, 0x73,
  0xC1, 0xEF, 0x0E, 0x78, 0x3D, 0xE1, 0xDE, 0x07, 0xB8, 0x3B, 0xC0, 0xFF,
  0x07, 0x78, 0x1F, 0xE0, 0xEE, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x03, 0xF8,
  0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8,
  0x07, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00,
  0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF0, 0xFC, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3E, 0x78,
  0x00, 0x00, 0xF8, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8,
  0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x3E, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0xF8,
  0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0xF0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x00,
  0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x03, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xF8, 0x03, 0xCE, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x3C, 0x0F,
  0x0F, 0x07, 0x81, 0xE1, 0xE0, 0x78, 0xF0, 0x1E, 0x7C, 0x07, 0x9E, 0x00,
  0xEF, 0x80, 0x3C, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0xFC, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x00, 0x1F, 0x80,
  0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFC, 0x07, 0xC1,
  0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xF0, 0x0F, 0x1F, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00,
  0xF9, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x3F,
  0x1F, 0x00, 0xFE, 0x3F, 0xCF, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F, 0xFD, 0xF0,
  0x3F, 0xE1, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x0F, 0xC0, 0x0F, 0x3F, 0xF0, 0x0F, 0x7F, 0xF8, 0x0F, 0xFF, 0xFC,
  0x1F, 0xE0, 0xFC, 0x1F, 0xC0, 0x3E, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C,
  0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFE, 0x01, 0xF8, 0xFF, 0xCF, 0xF0,
  0xF7, 0xFF, 0xE0, 0xF3, 0xFF, 0xC0, 0xF1, 0xFF, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFC, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x03, 0xC7, 0x80, 0x0F,
  0x8F, 0x80, 0x1E, 0x1F, 0x00, 0xFC, 0x1F, 0x87, 0xF0, 0x1F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x01, 0xF8, 0x7C,
  0x01, 0xFF, 0x9F, 0x01, 0xFF, 0xF7, 0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0x03,
  0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x7C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3,
  0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07,
  0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x0F, 0x80,
  0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xFC, 0x03,
  0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFC, 0xF0, 0x01, 0xFE, 0x78,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x0F, 0x87, 0xC0, 0x0F,
  0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x02, 0x0F, 0x80, 0x0E, 0x1F, 0x80, 0x7E, 0x1F, 0xC3,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x7F, 0xFE, 0x00, 0x3F, 0xC3, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xF8, 0xF0, 0x1F, 0xFF, 0x7C, 0x0F, 0xFF, 0xFF, 0x03, 0xF0, 0x3F,
  0x81, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x9F, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xDF, 0x00, 0x3F, 0xE7, 0xC0,
  0x00, 0x81, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x0F,
  0x01, 0xC0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x87, 0xF8, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xE0,
  0x0F, 0x1F, 0xF8, 0x0F, 0x3F, 0xFC, 0x0F, 0x7F, 0xFC, 0x1F, 0xF0, 0x7E,
  0x1F, 0xC0, 0x3E, 0x1F, 0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F,
  0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C,
  0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC,
  0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x01, 0xF8, 0x78, 0x03, 0xF0, 0x3C, 0x03, 0xF0,
  0x1E, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0x83, 0xF0, 0x07, 0x83, 0xF0,
  0x03, 0xC3, 0xF0, 0x01, 0xE3, 0xE0, 0x01, 0xF7, 0xE0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xEF,
  0x80, 0x0F, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xE0,
  0x3F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E,
  0x00, 0x7C, 0x1E, 0x00, 0x3F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1E, 0x0F,
  0x80, 0xF7, 0xF9, 0xFC, 0x0F, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0x87, 0xE1, 0xF1, 0xF0, 0x7C, 0x1F, 0x1E, 0x07, 0xC0, 0xF1, 0xE0, 0x78,
  0x0F, 0x1E, 0x07, 0x81, 0xF1, 0xE0, 0x78, 0x1E, 0x1E, 0x07, 0x81, 0xE3,
  0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x81, 0xE3, 0xC0, 0xF0, 0x1E, 0x3C, 0x0F,
  0x03, 0xE3, 0xC0, 0xF0, 0x3C, 0x7C, 0x0F, 0x03, 0xC7, 0xC0, 0xF0, 0x3C,
  0x78, 0x1F, 0x03, 0xC7, 0x81, 0xE0, 0x7C, 0x78, 0x1E, 0x07, 0xC7, 0x81,
  0xE0, 0x78, 0xF8, 0x1E, 0x07, 0x8F, 0x01, 0xE0, 0x78, 0xF0, 0x3E, 0x07,
  0x8F, 0x03, 0xC0, 0xF8, 0xF0, 0x3C, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x0F,
  0x1F, 0xF8, 0x0F, 0x7F, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xF0, 0x7E, 0x1F,
  0xC0, 0x3E, 0x1F, 0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E,
  0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x7C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78,
  0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xE0, 0x7C, 0x0F, 0x80, 0x3E, 0x1F,
  0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x7C,
  0x00, 0x0F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78,
  0x00, 0x3E, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x3E,
  0x01, 0xF8, 0x1F, 0x87, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xF3, 0xFF, 0x00,
  0x3D, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x3F, 0x01, 0xF8, 0x07,
  0xE0, 0x7C, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xF8, 0x07, 0xC0, 0xFF, 0x07, 0xF0, 0x3F,
  0xFF, 0xF8, 0x0F, 0x3F, 0xFC, 0x03, 0xC7, 0xFC, 0x01, 0xF0, 0x18, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x8F,
  0x07, 0xFF, 0xDF, 0x0F, 0xFF, 0xFE, 0x0F, 0xC0, 0xFE, 0x1F, 0x00, 0x7E,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x7C,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x7C, 0x03, 0xF0, 0x3F, 0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0,
  0x07, 0xF9, 0xE0, 0x00, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFC,
  0x1E, 0x3F, 0xF0, 0xF9, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0,
  0xFC, 0x0F, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x80, 0x07,
  0x9F, 0x00, 0x1F, 0x1F, 0x00, 0x7E, 0x3F, 0x83, 0xF8, 0x3F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF9, 0xE0, 0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F,
  0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x3E,
  0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C,
  0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF8,
  0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0x7C, 0x07, 0xF0, 0x7F, 0x1F, 0xF0,
  0x3F, 0xFE, 0xF0, 0x1F, 0xFC, 0xF0, 0x0F, 0xF1, 0xF0, 0x00, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0xBC, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0x8F, 0x00, 0x07,
  0x87, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x01,
  0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF8, 0x03, 0xC0,
  0x78, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0E,
  0x01, 0xFE, 0x03, 0xC0, 0x3F, 0xC0, 0x78, 0x0F, 0x78, 0x0F, 0x01, 0xEF,
  0x03, 0xE0, 0x39, 0xE0, 0x7E, 0x0F, 0x3C, 0x1D, 0xC1, 0xE7, 0x83, 0xB8,
  0x38, 0x70, 0x77, 0x0F, 0x0E, 0x1C, 0xE1, 0xE1, 0xC3, 0x9C, 0x38, 0x38,
  0xF3, 0x8F, 0x07, 0x1C, 0x71, 0xC0, 0xE7, 0x8E, 0x38, 0x1C, 0xE1, 0xCF,
  0x03, 0x9C, 0x39, 0xC0, 0x77, 0x87, 0x38, 0x0E, 0xE0, 0xEF, 0x01, 0xFC,
  0x1D, 0xC0, 0x3F, 0x03, 0xB8, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00,
  0x70, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xE1, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7D, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x00,
  0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x1E, 0x1F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x80, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x00,
  0x00, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x06, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0x9F, 0xFF,
  0x00, 0x77, 0xEF, 0xF0, 0x1F, 0xF0, 0x3F, 0x07, 0xBC, 0x03, 0xFF, 0xF7,
  0x00, 0x3F, 0xFC, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
};

const GFXglyph RobotoMono_Italic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 36, 29, 9, -36 },
  { 51, 14, 12, 29, 10, -38 },
  { 72, 29, 36, 29, 1, -36 },
  { 203, 24, 46, 29, 3, -41 },
  { 341, 24, 37, 29, 3, -36 },
  { 452, 26, 37, 29, 1, -36 },
  { 573, 6, 12, 29, 13, -38 },
  { 582, 17, 51, 29, 8, -40 },
  { 691, 17, 52, 29, 4, -40 },
  { 802, 23, 25, 29, 5, -36 },
  { 874, 24, 25, 29, 3, -29 },
  { 949, 9, 13, 29, 5, -5 },
  { 964, 19, 3, 29, 5, -17 },
  { 972, 7, 7, 29, 10, -7 },
  { 979, 25, 39, 29, 3, -36 },
  { 1101, 24, 37, 29, 3, -36 },
  { 1212, 15, 36, 29, 7, -36 },
  { 1280, 26, 36, 29, 0, -36 },
  { 1397, 25, 37, 29, 1, -36 },
  { 1513, 25, 36, 29, 1, -36 },
  { 1626, 26, 37, 29, 3, -36 },
  { 1747, 22, 37, 29, 3, -36 },
  { 1849, 24, 36, 29, 5, -36 },
  { 1957, 25, 37, 29, 3, -36 },
  { 2073, 21, 36, 29, 5, -36 },
  { 2168, 11, 28, 29, 11, -28 },
  { 2207, 13, 36, 29, 8, -28 },
  { 2266, 22, 22, 29, 4, -27 },
  { 2327, 24, 14, 29, 3, -23 },
  { 2369, 24, 22, 29, 2, -27 },
  { 2435, 20, 36, 29, 7, -36 },
  { 2525, 27, 36, 29, 2, -36 },
  { 2647, 26, 36, 29, -1, -36 },
  { 2764, 26, 36, 29, 2, -36 },
  { 2881, 26, 37, 29, 2, -36 },
  { 3002, 27, 36, 29, 1, -36 },
  { 3124, 27, 36, 29, 2, -36 },
  { 3246, 27, 36, 29, 2, -36 },
  { 3368, 26, 37, 29, 2, -36 },
  { 3489, 28, 36, 29, 1, -36 },
  { 3615, 27, 36, 29, 2, -36 },
  { 3737, 26, 37, 29, 2, -36 },
  { 3858, 29, 36, 29, 2, -36 },
  { 3989, 22, 36, 29, 2, -36 },
  { 4088, 29, 36, 29, 1, -36 },
  { 4219, 28, 36, 29, 1, -36 },
  { 4345, 26, 37, 29, 2, -36 },
  { 4466, 27, 36, 29, 2, -36 },
  { 4588, 26, 42, 29, 2, -36 },
  { 4725, 26, 36, 29, 2, -36 },
  { 4842, 26, 37, 29, 2, -36 },
  { 4963, 26, 36, 29, 5, -36 },
  { 5080, 26, 37, 29, 3, -36 },
  { 5201, 26, 36, 29, 5, -36 },
  { 5318, 27, 36, 29, 4, -36 },
  { 5440, 31, 36, 29, 0, -36 },
  { 5580, 26, 36, 29, 5, -36 },
  { 5697, 28, 36, 29, 0, -36 },
  { 5823, 17, 49, 29, 7, -41 },
  { 5928, 12, 39, 29, 9, -36 },
  { 5987, 17, 49, 29, 6, -41 },
  { 6092, 18, 19, 29, 6, -36 },
  { 6135, 23, 4, 29, 0, 0 },
  { 6147, 8, 6, 29, 13, -36 },
  { 6153, 23, 27, 29, 2, -27 },
  { 6231, 24, 39, 29, 2, -38 },
  { 6348, 23, 28, 29, 3, -27 },
  { 6429, 26, 39, 29, 3, -38 },
  { 6556, 23, 28, 29, 3, -27 },
  { 6637, 26, 39, 29, 5, -39 },
  { 6764, 26, 38, 29, 1, -27 },
  { 6888, 24, 38, 29, 2, -38 },
  { 7002, 22, 36, 29, 2, -36 },
  { 7101, 23, 47, 29, 1, -36 },
  { 7237, 25, 38, 29, 2, -38 },
  { 7356, 22, 38, 29, 2, -38 },
  { 7461, 28, 27, 29, 0, -27 },
  { 7556, 24, 27, 29, 2, -27 },
  { 7637, 24, 28, 29, 2, -27 },
  { 7721, 26, 37, 29, 0, -27 },
  { 7842, 24, 37, 29, 3, -27 },
  { 7953, 22, 27, 29, 5, -27 },
  { 8028, 23, 28, 29, 3, -27 },
  { 8109, 21, 34, 29, 5, -33 },
  { 8199, 24, 27, 29, 3, -26 },
  { 8280, 25, 26, 29, 4, -26 },
  { 8362, 27, 26, 29, 3, -26 },
  { 8450, 29, 26, 29, 0, -26 },
  { 8545, 31, 37, 29, -1, -26 },
  { 8689, 26, 26, 29, 1, -26 },
  { 8774, 19, 48, 29, 8, -39 },
  { 8888, 11, 46, 29, 9, -36 },
  { 8952, 20, 48, 29, 4, -39 },
  { 9072, 27, 10, 29, 1, -20 },
};

const GFXfont RobotoMono_Italic50pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic50pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic50pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _ROBOTOMONO_ITALIC50PT7B_H_
