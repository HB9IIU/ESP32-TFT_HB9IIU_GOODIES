#ifndef _ROBOTOMONO_ITALIC56PT7B_H_
#define _ROBOTOMONO_ITALIC56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x0F, 0xE0, 0x7C, 0x07,
  0xC0, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x3C, 0x1E, 0x3C, 0x1E, 0x38,
  0x1E, 0x78, 0x1E, 0x78, 0x1C, 0x78, 0x1C, 0x78, 0x3C, 0x70, 0x3C, 0x70,
  0x3C, 0xF0, 0x38, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x0F, 0x01, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x70, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F,
  0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C,
  0x07, 0x80, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80,
  0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87,
  0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x0F, 0x01, 0x8F, 0x03, 0xC0, 0x7B, 0xC0, 0xF0, 0x3C, 0xF0,
  0x3C, 0x1E, 0x38, 0x0F, 0x0F, 0x8E, 0x03, 0xC3, 0xC3, 0xC0, 0xF1, 0xE0,
  0xF0, 0x78, 0xF0, 0x3E, 0x3E, 0x3C, 0x07, 0xFF, 0x1E, 0x00, 0xFF, 0x8F,
  0x00, 0x1F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE1, 0xF0, 0x00, 0xF1, 0xFF, 0x00, 0x78, 0xFF, 0xE0, 0x1E, 0x7E,
  0xF8, 0x0F, 0x1E, 0x0F, 0x07, 0x8F, 0x03, 0xC3, 0xC3, 0xC0, 0xF0, 0xF0,
  0xF0, 0x3C, 0x78, 0x38, 0x0F, 0x3C, 0x0E, 0x03, 0xC7, 0x07, 0x80, 0xF0,
  0x80, 0xE0, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x7C,
  0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8,
  0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x7F, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x1F, 0x1F, 0x8F, 0x80, 0xF9, 0xF8, 0x3E, 0x07, 0x9F, 0x81, 0xF0,
  0x7C, 0xF8, 0x07, 0xC3, 0xEF, 0xC0, 0x3F, 0x3E, 0x7C, 0x00, 0xF9, 0xF3,
  0xE0, 0x07, 0xFF, 0x1F, 0x00, 0x1F, 0xF8, 0xF8, 0x00, 0xFF, 0x87, 0xC0,
  0x03, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xFE, 0x07, 0xE0, 0x3F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xBF, 0x01, 0xFF, 0xF8, 0xF8,
  0x07, 0xFF, 0x07, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x3C, 0xF3, 0xCF, 0x7D,
  0xE7, 0x9E, 0x79, 0xEF, 0x3C, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x40, 0x00, 0x0C, 0x00, 0x01, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x08, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x30, 0x0E, 0x01, 0xBE, 0x0F, 0x07, 0xDF, 0xC7, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFC,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0E, 0x00, 0xE0, 0x02, 0x00, 0x20, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x01, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC1, 0xF0, 0xFC, 0x3F, 0x0F,
  0xC3, 0xE0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x3E, 0x03,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0x00, 0x7C, 0x7E, 0xFF, 0xFF, 0xFF, 0xFE, 0x7C, 0x10, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x07,
  0xC0, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xF0,
  0x00, 0x3E, 0x3C, 0x00, 0x1F, 0xCF, 0x80, 0x07, 0xF9, 0xF0, 0x03, 0xFF,
  0x3E, 0x00, 0xFF, 0xE7, 0xC0, 0x7F, 0x7C, 0xF8, 0x1F, 0xCF, 0x9E, 0x07,
  0xE1, 0xF7, 0xC3, 0xF8, 0x7C, 0xF8, 0xFC, 0x0F, 0x9F, 0x7F, 0x01, 0xF3,
  0xFF, 0xC0, 0x3E, 0x7F, 0xE0, 0x07, 0xCF, 0xF8, 0x00, 0xF9, 0xFC, 0x00,
  0x3E, 0x7F, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x1F, 0x1E,
  0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x0F, 0x00, 0x3F, 0x01, 0xFF, 0x0F, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xBE, 0xFC, 0x3E, 0xE0, 0x3E, 0x80, 0x3E, 0x00,
  0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x7E, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x80,
  0xF8, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x07, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0xC0,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x7F, 0x80, 0x3C, 0xFF, 0xE0, 0x3E, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFE, 0x0F, 0xFC, 0x3F, 0x8F, 0xF8, 0x07, 0xE7, 0xF0, 0x01, 0xF3,
  0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xF7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x3E, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x07, 0xE0, 0x3F, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x7F, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xFE, 0x0F, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x3E,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x0F, 0xCF, 0x80,
  0x0F, 0xE7, 0xE0, 0x0F, 0xF1, 0xF8, 0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xBE, 0x03, 0xFF, 0x1E, 0x00, 0x1C, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0,
  0x7F, 0x07, 0xE0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07,
  0xF0, 0x7E, 0x00, 0x80, 0x00, 0x78, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x04, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x08, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x81,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x7F, 0x83, 0xF9, 0xF8, 0x03, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x0E, 0x07, 0x80, 0x70, 0x38, 0x1C, 0x0F, 0xF0, 0xF0, 0xF0, 0x7F,
  0xE1, 0xC7, 0x83, 0xFF, 0x87, 0x1C, 0x1F, 0x0E, 0x1C, 0xF0, 0xF0, 0x38,
  0x73, 0xC3, 0xC1, 0xC1, 0xCE, 0x1E, 0x07, 0x07, 0x78, 0x70, 0x1C, 0x1D,
  0xC1, 0xC0, 0x70, 0x77, 0x0F, 0x03, 0x81, 0xDC, 0x3C, 0x0E, 0x07, 0xF0,
  0xE0, 0x38, 0x3B, 0xC3, 0x80, 0xE0, 0xEE, 0x1E, 0x07, 0x03, 0xB8, 0x78,
  0x1C, 0x0E, 0xE1, 0xE0, 0x70, 0x73, 0x87, 0x83, 0xC1, 0xCE, 0x1E, 0x1F,
  0x0E, 0x38, 0x3D, 0xFC, 0x78, 0xE0, 0xFF, 0x7F, 0xC3, 0x83, 0xF9, 0xFE,
  0x0F, 0x07, 0xC3, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0F, 0xBC, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x3C,
  0x78, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF8, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x7C, 0x07, 0x80, 0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x01,
  0xE3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xF0, 0x01,
  0xF8, 0x0F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x3F, 0xC0, 0x7C,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0xE1, 0xF0, 0x03,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x7C, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0,
  0x03, 0xE0, 0x7F, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0x3E, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x87,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xFE,
  0x7C, 0x01, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0x9F, 0x00, 0x7F, 0xFC, 0xF8,
  0x00, 0x03, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x0F,
  0xC0, 0x07, 0xE0, 0x7F, 0x00, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x1E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7F, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x81, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0x3F, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x3F, 0x80, 0x0F, 0x80,
  0x3F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x03, 0xE0,
  0x1F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F,
  0x1F, 0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x07,
  0xDF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x9F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x3F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x07, 0xE0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03,
  0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0x01,
  0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x03,
  0xFC, 0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07,
  0xFC, 0x07, 0xFE, 0x07, 0xFC, 0x07, 0xBC, 0x07, 0xDE, 0x0F, 0xBC, 0x07,
  0x9E, 0x0F, 0x3C, 0x07, 0x9E, 0x1F, 0x7C, 0x07, 0x9E, 0x1E, 0x7C, 0x0F,
  0x9E, 0x3E, 0x7C, 0x0F, 0x9E, 0x3C, 0x78, 0x0F, 0x9E, 0x7C, 0x78, 0x0F,
  0x0F, 0x78, 0xF8, 0x0F, 0x0F, 0xF8, 0xF8, 0x1F, 0x0F, 0xF0, 0xF8, 0x1F,
  0x0F, 0xF0, 0xF8, 0x1F, 0x0F, 0xE0, 0xF0, 0x1F, 0x0F, 0xE1, 0xF0, 0x1F,
  0x0F, 0xC1, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E,
  0x07, 0x81, 0xF0, 0x3E, 0x07, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C,
  0x00, 0x03, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x3E, 0x03,
  0xF8, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3E, 0x07,
  0xFC, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x7C, 0x07,
  0xDE, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x7C, 0x0F,
  0x8F, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0x0F,
  0x87, 0x80, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x87, 0xC1, 0xF8, 0x1F,
  0x03, 0xC1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x1F, 0x03, 0xE1, 0xF0, 0x1F,
  0x01, 0xE1, 0xF0, 0x1F, 0x01, 0xF1, 0xF0, 0x3E, 0x01, 0xF3, 0xF0, 0x3E,
  0x00, 0xF3, 0xE0, 0x3E, 0x00, 0xFB, 0xE0, 0x3E, 0x00, 0xFB, 0xE0, 0x3E,
  0x00, 0x7B, 0xE0, 0x3E, 0x00, 0x7F, 0xE0, 0x7C, 0x00, 0x7F, 0xC0, 0x7C,
  0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0xC0, 0x7C,
  0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFC, 0x1F,
  0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x1F,
  0x80, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0xFF, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFC, 0x1F, 0xC0,
  0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80,
  0x01, 0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F,
  0x3E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00,
  0x3E, 0xF0, 0x00, 0x07, 0xCF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x31, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x08, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x01, 0xFE, 0x01, 0xF0, 0x01,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0,
  0x3E, 0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFE, 0x0F, 0xF0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x1E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xC1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1E, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00,
  0x01, 0xF0, 0x78, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x3F, 0x01,
  0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0,
  0x7C, 0x00, 0x7E, 0x03, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x1F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x3E, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x3E, 0x78, 0x07, 0x80, 0x7C, 0xF0, 0x1F,
  0x00, 0xF3, 0xE0, 0x3E, 0x03, 0xE7, 0xC0, 0x7C, 0x07, 0xCF, 0x81, 0xFC,
  0x0F, 0x9F, 0x03, 0xF8, 0x1E, 0x3E, 0x07, 0xF0, 0x7C, 0x7C, 0x1F, 0xE0,
  0xF8, 0xF8, 0x3F, 0xC1, 0xF1, 0xF0, 0x7F, 0x83, 0xC3, 0xE1, 0xEF, 0x0F,
  0x87, 0xC3, 0xDE, 0x1F, 0x0F, 0x87, 0xBC, 0x3C, 0x1E, 0x1E, 0x78, 0x78,
  0x3C, 0x3C, 0xF1, 0xF0, 0x78, 0x79, 0xE3, 0xE0, 0xF1, 0xE3, 0xC7, 0x81,
  0xE3, 0xC7, 0x8F, 0x03, 0xC7, 0x8F, 0x3E, 0x07, 0x9F, 0x1E, 0x7C, 0x0F,
  0x3C, 0x3C, 0xF0, 0x1E, 0x78, 0x79, 0xE0, 0x3D, 0xF0, 0xF7, 0xC0, 0x7B,
  0xC1, 0xEF, 0x00, 0xF7, 0x83, 0xDE, 0x01, 0xFF, 0x07, 0xBC, 0x03, 0xFC,
  0x0F, 0xF8, 0x07, 0xF8, 0x1F, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC0,
  0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x03, 0xF8, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x07,
  0xE0, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xF0, 0xFC, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x7C,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x01, 0xFF,
  0xC0, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0xC0,
  0x7C, 0x3E, 0x03, 0xE0, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x01,
  0xF0, 0xF0, 0x0F, 0x8F, 0x80, 0x3C, 0xF8, 0x01, 0xEF, 0xC0, 0x0F, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xE0, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFE,
  0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE,
  0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0xFC, 0xFC, 0x01, 0xFE, 0x7F, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0x87, 0xFF,
  0xF7, 0xC1, 0xFF, 0xF3, 0xE0, 0x7F, 0xE1, 0xF0, 0x03, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x3F, 0x80, 0x0F, 0x1F, 0xFC, 0x01, 0xEF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F, 0x81, 0xFE, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x01, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xDF,
  0xFF, 0xC0, 0xF9, 0xFF, 0xF0, 0x1F, 0x0F, 0xF8, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x07, 0xE0, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0xC0,
  0x3F, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x03, 0xFC, 0x3E, 0x00, 0x7F, 0xF9, 0xF0, 0x07, 0xFF, 0xEF,
  0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0xE0, 0x7E, 0x00, 0xFE, 0x07,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x3C, 0x00, 0x1F,
  0xF1, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0x03, 0xF8,
  0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x3F, 0x00, 0x07, 0xCF,
  0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x81, 0xF8, 0x00, 0x30,
  0x3E, 0x00, 0x3F, 0x0F, 0xE0, 0x1F, 0x81, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0x00, 0x1F, 0xE0, 0x70, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x78, 0x01, 0xFF,
  0xE7, 0xC0, 0x3F, 0xFF, 0xBE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xC1, 0xFF,
  0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x03, 0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3F,
  0x80, 0x7E, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xDF, 0x00,
  0x3F, 0xFC, 0xF0, 0x00, 0xFF, 0xCF, 0x80, 0x00, 0x60, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x01, 0xF0, 0x0C, 0x00, 0x1F,
  0x80, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0xE7, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x0F,
  0x0F, 0xFC, 0x01, 0xE7, 0xFF, 0xE0, 0x7D, 0xFF, 0xFC, 0x0F, 0xFC, 0x3F,
  0xC1, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x81, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x83, 0xE0, 0x03, 0xF8, 0x1F,
  0x00, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x07,
  0xF0, 0x03, 0xE0, 0x7F, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0xF8, 0x7F, 0x00,
  0x0F, 0x87, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x1F,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0x00,
  0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0x8F, 0x81, 0xF0, 0x0F, 0x7F, 0xCF, 0xF0, 0x3F, 0xFF, 0xBF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0xFE, 0x3F, 0xC7, 0xE1, 0xF0, 0x3F, 0x07, 0xC3, 0xC0,
  0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x1F, 0x1F, 0x01, 0xE0, 0x3E, 0x3E, 0x03,
  0xC0, 0x7C, 0x7C, 0x0F, 0x80, 0xF8, 0xF8, 0x1F, 0x01, 0xE1, 0xE0, 0x3E,
  0x03, 0xC7, 0xC0, 0x7C, 0x0F, 0x8F, 0x80, 0xF0, 0x1F, 0x1F, 0x01, 0xE0,
  0x3E, 0x3E, 0x07, 0xC0, 0x7C, 0x78, 0x0F, 0x80, 0xF0, 0xF0, 0x1F, 0x01,
  0xE3, 0xE0, 0x3E, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x8F, 0x80, 0xF0, 0x1F,
  0x1F, 0x03, 0xE0, 0x3E, 0x3C, 0x07, 0xC0, 0x78, 0x78, 0x0F, 0x80, 0xF1,
  0xF0, 0x1F, 0x03, 0xE3, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x0F, 0x8F,
  0x81, 0xF0, 0x1F, 0x1E, 0x03, 0xE0, 0x3C, 0x00, 0x07, 0x83, 0xFC, 0x00,
  0xF1, 0xFF, 0xC0, 0x1E, 0x7F, 0xFE, 0x07, 0xDF, 0xFF, 0xC0, 0xFF, 0xC1,
  0xFC, 0x1F, 0xE0, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x07, 0xF0, 0x7F, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xCF, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x0F,
  0xC0, 0x7F, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE1, 0xFE, 0x00, 0x0F,
  0x3F, 0xFC, 0x00, 0xFB, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x1F, 0x80, 0xFE, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x7D, 0xFF, 0xFC,
  0x03, 0xE7, 0xFF, 0xC0, 0x1F, 0x1F, 0xF8, 0x00, 0xF8, 0x0E, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC1, 0xE0, 0x1F, 0xFE, 0x7C, 0x0F, 0xFF, 0xEF, 0x83, 0xFF,
  0xFF, 0xF0, 0x7F, 0x03, 0xFE, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00,
  0x1E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0xFE,
  0x07, 0xE0, 0x3F, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xF3, 0xC0, 0x07, 0xFC, 0xF8, 0x00, 0x18, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC1, 0xFF, 0x83, 0xE3,
  0xFF, 0x81, 0xE3, 0xFF, 0xC1, 0xF7, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xE0, 0x08, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F, 0x83, 0xF0, 0x03,
  0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x10, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x06, 0x00, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x01,
  0xFC, 0x1F, 0x81, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFD, 0xF0, 0x1F,
  0xFE, 0x78, 0x03, 0xFE, 0x1E, 0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xC7, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0x3C, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00,
  0xF8, 0x1F, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x7F, 0xC0, 0x1C, 0x01, 0xFF, 0x00,
  0xF0, 0x07, 0xBC, 0x03, 0xC0, 0x3E, 0xF0, 0x1F, 0x80, 0xF3, 0xC0, 0x7E,
  0x03, 0xCF, 0x01, 0xF8, 0x1F, 0x3C, 0x0F, 0xE0, 0x78, 0xF0, 0x3B, 0x81,
  0xE3, 0xC1, 0xEE, 0x0F, 0x8F, 0x07, 0xF8, 0x3C, 0x3C, 0x3D, 0xE0, 0xF0,
  0xF0, 0xF3, 0x87, 0x83, 0xC3, 0x8E, 0x1E, 0x0F, 0x1E, 0x38, 0x78, 0x3C,
  0x78, 0xE3, 0xC0, 0xF3, 0xC3, 0x8F, 0x03, 0xCF, 0x0E, 0x38, 0x0F, 0x78,
  0x39, 0xE0, 0x3D, 0xE0, 0xF7, 0x80, 0xF7, 0x03, 0xDC, 0x03, 0xFC, 0x0F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x78, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x07, 0xE0, 0x1F, 0x00,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x3F, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x07, 0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x00, 0x1E, 0x7C,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x11, 0xFC, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x00,
  0xF0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x30, 0x7F, 0xF8, 0x00, 0x79, 0xFF, 0xF8, 0x00, 0xE7, 0xF7,
  0xFC, 0x03, 0xCF, 0x81, 0xFC, 0x0F, 0xBE, 0x01, 0xFE, 0x7E, 0x78, 0x01,
  0xFF, 0xFC, 0xF0, 0x01, 0xFF, 0xF0, 0x20, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x7E, 0x00,
};

const GFXglyph RobotoMono_Italic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 12, 40, 33, 10, -40 },
  { 61, 16, 13, 33, 11, -42 },
  { 87, 32, 40, 33, 1, -40 },
  { 247, 28, 52, 33, 3, -46 },
  { 429, 26, 41, 33, 4, -40 },
  { 563, 29, 42, 33, 2, -41 },
  { 716, 6, 13, 33, 15, -42 },
  { 726, 18, 58, 33, 9, -45 },
  { 857, 19, 58, 33, 4, -45 },
  { 995, 25, 27, 33, 6, -40 },
  { 1080, 28, 29, 33, 3, -33 },
  { 1182, 10, 15, 33, 5, -6 },
  { 1201, 21, 5, 33, 6, -20 },
  { 1215, 8, 8, 33, 11, -7 },
  { 1223, 28, 43, 33, 3, -40 },
  { 1374, 27, 41, 33, 3, -40 },
  { 1513, 16, 40, 33, 8, -40 },
  { 1593, 29, 40, 33, 0, -40 },
  { 1738, 28, 41, 33, 1, -40 },
  { 1882, 28, 40, 33, 1, -40 },
  { 2022, 28, 41, 33, 4, -40 },
  { 2166, 25, 41, 33, 3, -40 },
  { 2295, 28, 40, 33, 5, -40 },
  { 2435, 28, 41, 33, 3, -40 },
  { 2579, 25, 40, 33, 5, -40 },
  { 2704, 12, 32, 33, 12, -31 },
  { 2752, 15, 40, 33, 9, -31 },
  { 2827, 25, 25, 33, 4, -30 },
  { 2906, 27, 16, 33, 3, -26 },
  { 2960, 26, 25, 33, 3, -30 },
  { 3042, 22, 40, 33, 8, -40 },
  { 3152, 30, 40, 33, 2, -40 },
  { 3302, 29, 40, 33, -1, -40 },
  { 3447, 29, 40, 33, 2, -40 },
  { 3592, 29, 41, 33, 3, -40 },
  { 3741, 30, 40, 33, 1, -40 },
  { 3891, 30, 40, 33, 2, -40 },
  { 4041, 31, 40, 33, 2, -40 },
  { 4196, 29, 41, 33, 3, -40 },
  { 4345, 32, 40, 33, 1, -40 },
  { 4505, 30, 40, 33, 2, -40 },
  { 4655, 30, 41, 33, 2, -40 },
  { 4809, 33, 40, 33, 2, -40 },
  { 4974, 25, 40, 33, 2, -40 },
  { 5099, 32, 40, 33, 1, -40 },
  { 5259, 32, 40, 33, 1, -40 },
  { 5419, 28, 41, 33, 3, -40 },
  { 5563, 31, 40, 33, 2, -40 },
  { 5718, 28, 47, 33, 3, -40 },
  { 5883, 29, 40, 33, 2, -40 },
  { 6028, 30, 41, 33, 2, -40 },
  { 6182, 30, 40, 33, 5, -40 },
  { 6332, 30, 41, 33, 3, -40 },
  { 6486, 28, 40, 33, 6, -40 },
  { 6626, 31, 40, 33, 4, -40 },
  { 6781, 35, 40, 33, 0, -40 },
  { 6956, 29, 40, 33, 6, -40 },
  { 7101, 31, 40, 33, 1, -40 },
  { 7256, 19, 55, 33, 7, -46 },
  { 7387, 13, 43, 33, 10, -40 },
  { 7457, 19, 55, 33, 7, -46 },
  { 7588, 21, 21, 33, 6, -40 },
  { 7644, 25, 4, 33, 1, 0 },
  { 7657, 9, 8, 33, 15, -41 },
  { 7666, 25, 31, 33, 3, -30 },
  { 7763, 27, 43, 33, 2, -42 },
  { 7909, 26, 31, 33, 3, -30 },
  { 8010, 29, 43, 33, 3, -42 },
  { 8166, 26, 31, 33, 3, -30 },
  { 8267, 28, 43, 33, 6, -43 },
  { 8418, 29, 42, 33, 1, -30 },
  { 8571, 27, 42, 33, 2, -42 },
  { 8713, 24, 40, 33, 3, -40 },
  { 8833, 25, 52, 33, 1, -40 },
  { 8996, 29, 42, 33, 2, -42 },
  { 9149, 24, 42, 33, 3, -42 },
  { 9275, 31, 30, 33, 0, -30 },
  { 9392, 27, 30, 33, 2, -30 },
  { 9494, 26, 31, 33, 3, -30 },
  { 9595, 29, 41, 33, 0, -30 },
  { 9744, 27, 41, 33, 3, -30 },
  { 9883, 25, 30, 33, 6, -30 },
  { 9977, 26, 31, 33, 3, -30 },
  { 10078, 24, 38, 33, 5, -37 },
  { 10192, 26, 31, 33, 4, -30 },
  { 10293, 27, 30, 33, 5, -30 },
  { 10395, 30, 30, 33, 4, -30 },
  { 10508, 32, 30, 33, 0, -30 },
  { 10628, 34, 42, 33, -1, -30 },
  { 10807, 28, 30, 33, 2, -30 },
  { 10912, 22, 54, 33, 8, -44 },
  { 11061, 12, 51, 33, 10, -40 },
  { 11138, 22, 54, 33, 5, -44 },
  { 11287, 31, 11, 33, 1, -22 },
};

const GFXfont RobotoMono_Italic56pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic56pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic56pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _ROBOTOMONO_ITALIC56PT7B_H_
