#ifndef _ROBOTOMONO_ITALIC25PT7B_H_
#define _ROBOTOMONO_ITALIC25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic25pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCE, 0x63, 0x18, 0xC6, 0x73, 0x18, 0xC0, 0x00, 0x08, 0xC6,
  0x00, 0x66, 0xCD, 0x1E, 0x2C, 0x59, 0x80, 0x00, 0xCC, 0x03, 0x18, 0x06,
  0x30, 0x08, 0xC0, 0x31, 0x83, 0xFF, 0xCF, 0xFF, 0x83, 0x18, 0x06, 0x20,
  0x18, 0xC0, 0x31, 0x83, 0xFF, 0xCF, 0xFF, 0x83, 0x18, 0x04, 0x60, 0x18,
  0xC0, 0x31, 0x00, 0xC6, 0x00, 0x00, 0xC0, 0x04, 0x00, 0x20, 0x07, 0x80,
  0xFF, 0x0E, 0x18, 0x60, 0xC3, 0x07, 0x38, 0x38, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0x80, 0x0E, 0x60, 0x63, 0x03, 0x1C, 0x38,
  0xFF, 0x81, 0xF8, 0x06, 0x00, 0x30, 0x01, 0x80, 0x78, 0x1F, 0x83, 0x31,
  0x46, 0x38, 0xCD, 0x1B, 0x3E, 0x43, 0x98, 0x06, 0x01, 0x80, 0x32, 0x0D,
  0xF3, 0x66, 0x4C, 0x59, 0x8A, 0x31, 0x06, 0x60, 0x78, 0x07, 0x80, 0x7E,
  0x07, 0x38, 0x30, 0xC1, 0x8E, 0x0C, 0x60, 0x6E, 0x03, 0xE0, 0x0E, 0x01,
  0xF0, 0x1D, 0xC7, 0xC6, 0x6C, 0x3B, 0x60, 0xFB, 0x07, 0x9C, 0x3C, 0x7F,
  0xE1, 0xF3, 0x80, 0x7B, 0x6D, 0x80, 0x01, 0x03, 0x06, 0x0C, 0x18, 0x18,
  0x30, 0x30, 0x60, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x18, 0x10, 0x08, 0x0C, 0x04, 0x06,
  0x06, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0x80, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x0E, 0x4F, 0xFF, 0xC7, 0xC0, 0xF0, 0x3E, 0x0E, 0x63,
  0x8E, 0x20, 0x80, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x3F,
  0xFD, 0xFF, 0xDF, 0xFE, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0,
  0x00, 0x39, 0xCC, 0x67, 0x33, 0x00, 0x7F, 0xFF, 0xF0, 0xFF, 0x80, 0x00,
  0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xFC, 0x38,
  0x67, 0x06, 0x60, 0x76, 0x07, 0xE0, 0xFC, 0x3E, 0xC7, 0x6C, 0xE6, 0xF8,
  0x6F, 0x06, 0xC0, 0xEC, 0x0C, 0xC0, 0xCC, 0x18, 0x7F, 0x83, 0xE0, 0x01,
  0x0F, 0x7F, 0x76, 0xC6, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x0C, 0x0C, 0x0C,
  0x1C, 0x1C, 0x18, 0x18, 0x18, 0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x73,
  0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x07,
  0xC1, 0xFE, 0x38, 0x63, 0x07, 0x70, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x0F,
  0x80, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0xEC, 0x0E, 0xC0, 0xCC, 0x1C, 0x7F,
  0x83, 0xF0, 0x00, 0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1B, 0x01, 0x98,
  0x1C, 0xC0, 0xCE, 0x0C, 0x60, 0xC3, 0x0C, 0x18, 0xE0, 0xC7, 0xFF, 0xFF,
  0xFC, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x1F, 0xF1, 0xFF, 0x18,
  0x01, 0x80, 0x30, 0x03, 0x00, 0x36, 0x03, 0xF8, 0x7B, 0xC2, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x6C, 0x0E, 0xC0, 0xCE, 0x1C, 0x7F, 0x83, 0xF0, 0x00,
  0xE0, 0x7C, 0x3C, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0xC3, 0x7E, 0x78, 0xEE,
  0x0D, 0x81, 0xB0, 0x3E, 0x06, 0xC0, 0xD8, 0x3B, 0x86, 0x3F, 0x83, 0xE0,
  0x7F, 0xFB, 0xFF, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x00, 0x07, 0x81, 0xFE, 0x38, 0x63, 0x07,
  0x30, 0x77, 0x07, 0x30, 0x63, 0x8C, 0x1F, 0x83, 0xF8, 0x60, 0xCC, 0x0C,
  0xC0, 0xEC, 0x0E, 0xC0, 0xCC, 0x1C, 0x7F, 0x83, 0xF0, 0x0F, 0x83, 0xF8,
  0xE3, 0xB8, 0x36, 0x06, 0xC0, 0xF8, 0x1F, 0x03, 0x60, 0xEE, 0x3D, 0xFF,
  0x8F, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x78, 0x7E, 0x0F, 0x00, 0x18, 0xF1,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0xF1, 0xC0, 0x0C, 0x3C, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x83, 0x06, 0x1C, 0x30, 0xE1,
  0x80, 0x00, 0x60, 0x7C, 0x3E, 0x1F, 0x0F, 0x01, 0xC0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x30, 0x01, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xBF, 0xF0, 0x30, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x0F,
  0x07, 0xC1, 0xF0, 0x7C, 0x0E, 0x00, 0x80, 0x00, 0x1F, 0x07, 0xF9, 0xC3,
  0x30, 0x78, 0x0C, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x80, 0x30, 0x06, 0x00, 0x03, 0xC0, 0x7F,
  0x87, 0x04, 0x20, 0x33, 0x3C, 0xB3, 0x25, 0x31, 0x29, 0x19, 0xC8, 0x8E,
  0xC4, 0x66, 0x27, 0x33, 0x29, 0xFB, 0x47, 0x73, 0x00, 0x08, 0x00, 0x7F,
  0x00, 0xF8, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x36, 0x01,
  0xB0, 0x19, 0x80, 0xCC, 0x0C, 0x60, 0x63, 0x06, 0x1C, 0x3F, 0xE3, 0xFF,
  0x18, 0x19, 0xC0, 0xCC, 0x06, 0xE0, 0x36, 0x01, 0xC0, 0x1F, 0xC0, 0xFF,
  0x0E, 0x1C, 0x60, 0x73, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x1C, 0x7F, 0xC3,
  0xFF, 0x18, 0x18, 0xC0, 0x66, 0x03, 0x30, 0x3B, 0x81, 0x98, 0x1C, 0xFF,
  0xC7, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x73, 0x01, 0xB8,
  0x0D, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00,
  0x70, 0x39, 0x81, 0x8C, 0x1C, 0x3F, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xFE,
  0x0C, 0x38, 0x60, 0x63, 0x03, 0x98, 0x0C, 0xC0, 0x6E, 0x03, 0x60, 0x1B,
  0x01, 0xD8, 0x0C, 0xC0, 0x66, 0x03, 0x70, 0x33, 0x03, 0x98, 0x38, 0xFF,
  0x87, 0xF0, 0x00, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x70, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x3F, 0xE3, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x1F, 0xFC, 0x7F,
  0xE1, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x3F,
  0xE1, 0xFF, 0x87, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x73,
  0x01, 0xB8, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x0F, 0xB0, 0x7D, 0x80,
  0x6C, 0x03, 0x70, 0x19, 0x81, 0xCE, 0x0C, 0x3F, 0xE0, 0xFC, 0x00, 0x1C,
  0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0x8C, 0x03,
  0x18, 0x0C, 0x3F, 0xF8, 0x7F, 0xF0, 0xC0, 0x61, 0x80, 0xC6, 0x03, 0x8C,
  0x06, 0x18, 0x0C, 0x30, 0x18, 0x60, 0x31, 0xC0, 0x60, 0x1F, 0xF8, 0xFF,
  0xC0, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0xFF,
  0xE7, 0xFE, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x60, 0x33, 0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF8, 0x00, 0x18, 0x1E, 0x30,
  0x70, 0xE0, 0xC1, 0xC3, 0x03, 0x0E, 0x06, 0x38, 0x0C, 0xE0, 0x1B, 0x80,
  0x7E, 0x00, 0xFE, 0x01, 0xEC, 0x03, 0x9C, 0x06, 0x18, 0x0C, 0x38, 0x38,
  0x30, 0x60, 0x70, 0xC0, 0xE1, 0x80, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x03, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x0C, 0x0E, 0x38, 0x3C,
  0x78, 0x70, 0xF1, 0xE1, 0xE3, 0xC3, 0xCD, 0x8F, 0x9B, 0x1B, 0x66, 0x32,
  0xD8, 0x67, 0x30, 0xCE, 0x61, 0x98, 0xC7, 0x31, 0x8C, 0x07, 0x18, 0x0C,
  0x30, 0x18, 0x60, 0x31, 0xC0, 0x60, 0x1C, 0x0E, 0x38, 0x18, 0x70, 0x30,
  0xF0, 0x61, 0xE0, 0xC3, 0xC1, 0x8E, 0xC7, 0x1D, 0x8C, 0x33, 0x18, 0x63,
  0x30, 0xC6, 0x61, 0x8D, 0xC7, 0x0F, 0x8C, 0x1E, 0x18, 0x3C, 0x30, 0x38,
  0x60, 0x71, 0xC0, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x70, 0x63, 0x03,
  0xB8, 0x0D, 0x80, 0x6C, 0x03, 0x60, 0x3F, 0x01, 0xB0, 0x0D, 0x80, 0x6C,
  0x03, 0x70, 0x31, 0x81, 0x8E, 0x18, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0xC1, 0x83, 0x8E, 0x06, 0x38, 0x18, 0xC0, 0x63, 0x01, 0x8C, 0x0E,
  0x30, 0x71, 0xFF, 0x87, 0xF8, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x07, 0xC0, 0x7F, 0x07, 0x1C, 0x70,
  0x63, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0D,
  0x80, 0x6C, 0x03, 0x60, 0x39, 0x81, 0x8C, 0x18, 0x3F, 0x80, 0xFC, 0x00,
  0x70, 0x01, 0xC0, 0x04, 0x00, 0x1F, 0x80, 0xFF, 0x06, 0x1C, 0x70, 0x73,
  0x01, 0x98, 0x0C, 0xC0, 0xE6, 0x06, 0x30, 0xF3, 0xFE, 0x1F, 0xE0, 0xC3,
  0x06, 0x1C, 0x30, 0x63, 0x83, 0x1C, 0x1C, 0xC0, 0xE6, 0x03, 0x00, 0x07,
  0xC0, 0x7F, 0x87, 0x0C, 0x70, 0x73, 0x01, 0x98, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x60, 0x1B, 0x81, 0xCC,
  0x1C, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x00, 0x38, 0x0C, 0xC0, 0x63, 0x01, 0x8C, 0x06, 0x30, 0x18, 0xC0, 0x67,
  0x03, 0x98, 0x0C, 0x60, 0x31, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0xE0, 0x73,
  0x81, 0x86, 0x06, 0x18, 0x30, 0x3F, 0xC0, 0x7C, 0x00, 0xE0, 0x1B, 0x01,
  0xD8, 0x0C, 0xC0, 0xE6, 0x06, 0x38, 0x31, 0xC3, 0x06, 0x18, 0x31, 0x81,
  0x8C, 0x0C, 0xE0, 0x66, 0x03, 0x70, 0x1F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x00, 0xE3, 0x1F, 0x8C, 0x6C, 0x71, 0xB1, 0xC6, 0xC7, 0x33,
  0x3C, 0xCC, 0xF3, 0x33, 0xCC, 0xDB, 0x63, 0x6D, 0x8D, 0xB6, 0x3C, 0xD8,
  0xF3, 0xC3, 0xCF, 0x0E, 0x3C, 0x38, 0xE0, 0xE1, 0x83, 0x06, 0x00, 0x18,
  0x0E, 0x38, 0x18, 0x30, 0x70, 0x71, 0xC0, 0x63, 0x00, 0xCE, 0x01, 0xF8,
  0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x36, 0x00, 0xCC, 0x03,
  0x9C, 0x0E, 0x18, 0x18, 0x38, 0x70, 0x31, 0xC0, 0x70, 0xC0, 0x3C, 0x07,
  0xE0, 0xE6, 0x0C, 0x61, 0xC6, 0x18, 0x33, 0x03, 0x70, 0x36, 0x03, 0xC0,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x1F, 0xFC, 0x7F, 0xF0, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0x87, 0x83, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xE1, 0xF0, 0xC6,
  0x31, 0x8C, 0x31, 0x8C, 0x63, 0x0C, 0x63, 0x18, 0xC3, 0x18, 0xC6, 0x30,
  0x0F, 0x87, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x01, 0x80,
  0xC3, 0xE1, 0xF0, 0x06, 0x03, 0x03, 0x83, 0x61, 0xB1, 0x98, 0xCC, 0xC6,
  0x61, 0xE0, 0xC0, 0xFF, 0xFF, 0xFC, 0xC6, 0x30, 0x1F, 0xC3, 0xCE, 0x30,
  0x60, 0x07, 0x00, 0x61, 0xFE, 0x3F, 0xE6, 0x06, 0xE0, 0x6C, 0x0E, 0xE1,
  0xC7, 0xFC, 0x3E, 0xE0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x37, 0xC3, 0xFE, 0x38, 0x77, 0x07, 0x60, 0x36, 0x03, 0x60, 0x36,
  0x07, 0x60, 0x6E, 0x06, 0xE0, 0xCF, 0xFC, 0xDF, 0x80, 0x0F, 0xC1, 0xCE,
  0x30, 0x77, 0x03, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0x60, 0x06, 0x06,
  0x70, 0xE3, 0xFC, 0x1F, 0x00, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x1C, 0x3E, 0xC7, 0xBE, 0x30, 0x73, 0x81, 0x98, 0x1C, 0xC0,
  0xE6, 0x06, 0x70, 0x33, 0x81, 0x8C, 0x0C, 0x60, 0xE3, 0xFE, 0x0F, 0xB0,
  0x0F, 0xC1, 0xCE, 0x38, 0x77, 0x03, 0x60, 0x37, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x63, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC1,
  0xC0, 0x0C, 0x00, 0x60, 0x07, 0x09, 0xFF, 0x9F, 0xFC, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x0F, 0xB9, 0xEF, 0x8C, 0x1C, 0xE0, 0x66, 0x07, 0x30,
  0x39, 0x81, 0x9C, 0x0C, 0xE0, 0x63, 0x03, 0x18, 0x38, 0xFF, 0x83, 0xEC,
  0x00, 0x60, 0x07, 0x18, 0x30, 0xFF, 0x83, 0xF0, 0x00, 0x18, 0x01, 0x80,
  0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x37, 0xE3, 0xFE, 0x38, 0x77, 0x03,
  0x60, 0x36, 0x07, 0x60, 0x66, 0x06, 0x60, 0x6E, 0x06, 0xC0, 0x6C, 0x0E,
  0xC0, 0xC0, 0x01, 0x80, 0x38, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30,
  0xFF, 0xFF, 0xFC, 0x00, 0x70, 0x07, 0x00, 0x20, 0x00, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x07, 0xE0,
  0xFC, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x18, 0x04,
  0xC1, 0xC6, 0x1C, 0x31, 0xC3, 0x9C, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B,
  0x81, 0x8C, 0x1C, 0x70, 0xC1, 0xC6, 0x06, 0x30, 0x38, 0x1F, 0xC3, 0xF8,
  0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFF, 0xFF, 0x80,
  0x3F, 0xF8, 0xEF, 0x73, 0x18, 0xDC, 0x63, 0x63, 0x8D, 0x8C, 0x66, 0x31,
  0x98, 0xC6, 0x63, 0x1B, 0x8C, 0x6C, 0x61, 0xB1, 0x8C, 0xC6, 0x30, 0x37,
  0xE3, 0xFE, 0x38, 0x77, 0x03, 0x60, 0x36, 0x07, 0x60, 0x66, 0x06, 0x60,
  0x6E, 0x06, 0xC0, 0x6C, 0x0E, 0xC0, 0xC0, 0x0F, 0xC3, 0xCE, 0x30, 0x77,
  0x03, 0x60, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x6E, 0x06, 0x60, 0xC7,
  0xFC, 0x1F, 0x00, 0x1B, 0xE0, 0xFF, 0x86, 0x0C, 0x70, 0x73, 0x01, 0x98,
  0x0C, 0xC0, 0x66, 0x07, 0x30, 0x33, 0x83, 0x9C, 0x18, 0xFF, 0xC6, 0xF8,
  0x30, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0xB3, 0xCF,
  0x30, 0x77, 0x03, 0x60, 0x76, 0x06, 0x60, 0x6E, 0x06, 0xE0, 0x66, 0x06,
  0x60, 0xE7, 0xFC, 0x3E, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18,
  0x37, 0xE7, 0xF9, 0xE0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xE0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x1F, 0x87, 0x39, 0x83, 0xB0, 0x36,
  0x00, 0x78, 0x07, 0xE0, 0x1E, 0x00, 0xD8, 0x1B, 0x07, 0x7F, 0xC3, 0xF0,
  0x0E, 0x01, 0xC0, 0x30, 0x3F, 0xFF, 0xFE, 0x18, 0x07, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0xE0, 0x7C, 0x60, 0x76,
  0x06, 0x60, 0x66, 0x06, 0xE0, 0xEC, 0x0E, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC,
  0x1C, 0xC1, 0xCF, 0xFC, 0x7D, 0x80, 0xC0, 0x36, 0x06, 0x60, 0x66, 0x0C,
  0x60, 0xC7, 0x18, 0x33, 0x83, 0x30, 0x36, 0x03, 0x60, 0x1C, 0x01, 0xC0,
  0x18, 0x00, 0xC6, 0x1E, 0x30, 0xF3, 0x8D, 0x9C, 0x6C, 0xA2, 0x6D, 0x33,
  0x6D, 0x9E, 0x68, 0xF3, 0xC7, 0x1C, 0x38, 0xE1, 0x87, 0x0C, 0x30, 0x00,
  0x38, 0x1C, 0x70, 0xE0, 0xC7, 0x01, 0xB8, 0x06, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0xC0, 0x73, 0x03, 0x8E, 0x1C, 0x18, 0xE0, 0x30, 0x30,
  0x0E, 0x70, 0x38, 0x60, 0x60, 0xC1, 0xC1, 0x83, 0x03, 0x8C, 0x03, 0x38,
  0x06, 0x60, 0x0D, 0xC0, 0x1B, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x3F, 0xF3, 0xFF,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x70, 0x0F, 0xFE, 0xFF, 0xE0, 0x00, 0x40, 0x70, 0x30, 0x18, 0x0E, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x81, 0xC0, 0xE0, 0x3C, 0x03, 0x00,
  0xE0, 0x38, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C,
  0x30, 0x82, 0x18, 0x61, 0x86, 0x18, 0x43, 0x0C, 0x30, 0xC3, 0x08, 0x61,
  0x86, 0x18, 0x61, 0x0C, 0x00, 0x0C, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x38, 0x07, 0x07, 0x83, 0x80, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x0E, 0x02, 0x00, 0x1C,
  0x01, 0xF8, 0x36, 0x78, 0xF0, 0x7E, 0x00, 0xF0,
};

const GFXglyph RobotoMono_Italic25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 7, 6, 15, 5, -19 },
  { 19, 15, 18, 15, 0, -18 },
  { 53, 13, 24, 15, 1, -21 },
  { 92, 11, 18, 15, 2, -18 },
  { 117, 13, 18, 15, 1, -18 },
  { 147, 3, 6, 15, 7, -19 },
  { 150, 8, 26, 15, 4, -20 },
  { 176, 8, 26, 15, 2, -20 },
  { 202, 11, 12, 15, 3, -18 },
  { 219, 13, 13, 15, 1, -15 },
  { 241, 5, 7, 15, 2, -3 },
  { 246, 10, 2, 15, 2, -9 },
  { 249, 3, 3, 15, 5, -3 },
  { 251, 13, 20, 15, 1, -18 },
  { 284, 12, 18, 15, 2, -18 },
  { 311, 8, 18, 15, 3, -18 },
  { 329, 13, 18, 15, 0, -18 },
  { 359, 12, 18, 15, 1, -18 },
  { 386, 13, 18, 15, 0, -18 },
  { 416, 12, 18, 15, 2, -18 },
  { 443, 11, 18, 15, 1, -18 },
  { 468, 13, 18, 15, 2, -18 },
  { 498, 12, 18, 15, 2, -18 },
  { 525, 11, 18, 15, 2, -18 },
  { 550, 6, 14, 15, 5, -14 },
  { 561, 7, 18, 15, 4, -14 },
  { 577, 11, 11, 15, 2, -13 },
  { 593, 11, 7, 15, 2, -11 },
  { 603, 12, 11, 15, 1, -13 },
  { 620, 11, 18, 15, 3, -18 },
  { 645, 13, 18, 15, 1, -18 },
  { 675, 13, 18, 15, 0, -18 },
  { 705, 13, 18, 15, 1, -18 },
  { 735, 13, 18, 15, 1, -18 },
  { 765, 13, 18, 15, 1, -18 },
  { 795, 13, 18, 15, 1, -18 },
  { 825, 14, 18, 15, 1, -18 },
  { 857, 13, 18, 15, 1, -18 },
  { 887, 15, 18, 15, 0, -18 },
  { 921, 13, 18, 15, 1, -18 },
  { 951, 13, 18, 15, 1, -18 },
  { 981, 15, 18, 15, 1, -18 },
  { 1015, 11, 18, 15, 1, -18 },
  { 1040, 15, 18, 15, 0, -18 },
  { 1074, 15, 18, 15, 0, -18 },
  { 1108, 13, 18, 15, 1, -18 },
  { 1138, 14, 18, 15, 1, -18 },
  { 1170, 13, 21, 15, 1, -18 },
  { 1205, 13, 18, 15, 1, -18 },
  { 1235, 13, 18, 15, 1, -18 },
  { 1265, 14, 18, 15, 2, -18 },
  { 1297, 14, 18, 15, 1, -18 },
  { 1329, 13, 18, 15, 2, -18 },
  { 1359, 14, 18, 15, 2, -18 },
  { 1391, 15, 18, 15, 0, -18 },
  { 1425, 12, 18, 15, 3, -18 },
  { 1452, 14, 18, 15, 0, -18 },
  { 1484, 9, 24, 15, 3, -20 },
  { 1511, 5, 20, 15, 5, -18 },
  { 1524, 9, 24, 15, 3, -20 },
  { 1551, 9, 10, 15, 3, -18 },
  { 1563, 11, 2, 15, 0, 0 },
  { 1566, 4, 3, 15, 7, -18 },
  { 1568, 12, 13, 15, 1, -13 },
  { 1588, 12, 19, 15, 1, -19 },
  { 1617, 12, 13, 15, 1, -13 },
  { 1637, 13, 19, 15, 1, -19 },
  { 1668, 12, 13, 15, 1, -13 },
  { 1688, 13, 19, 15, 2, -19 },
  { 1719, 13, 18, 15, 1, -13 },
  { 1749, 12, 19, 15, 1, -19 },
  { 1778, 11, 18, 15, 1, -18 },
  { 1803, 12, 23, 15, 0, -18 },
  { 1838, 13, 19, 15, 1, -19 },
  { 1869, 11, 19, 15, 1, -19 },
  { 1896, 14, 13, 15, 0, -13 },
  { 1919, 12, 13, 15, 1, -13 },
  { 1939, 12, 13, 15, 1, -13 },
  { 1959, 13, 18, 15, 0, -13 },
  { 1989, 12, 18, 15, 1, -13 },
  { 2016, 11, 13, 15, 3, -13 },
  { 2034, 11, 13, 15, 2, -13 },
  { 2052, 11, 16, 15, 2, -16 },
  { 2074, 12, 13, 15, 2, -13 },
  { 2094, 12, 13, 15, 2, -13 },
  { 2114, 13, 13, 15, 2, -13 },
  { 2136, 14, 13, 15, 0, -13 },
  { 2159, 15, 18, 15, 0, -13 },
  { 2193, 12, 13, 15, 1, -13 },
  { 2213, 10, 24, 15, 4, -20 },
  { 2243, 6, 23, 15, 4, -18 },
  { 2261, 10, 24, 15, 2, -19 },
  { 2291, 14, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_Italic25pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic25pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic25pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _ROBOTOMONO_ITALIC25PT7B_H_
