#ifndef _ROBOTOMONO_ITALIC29PT7B_H_
#define _ROBOTOMONO_ITALIC29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic29pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x18, 0x30, 0xE1, 0xC3, 0x87, 0x0C, 0x18, 0x70, 0xE1, 0xC3,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x87, 0x86, 0x00, 0x63, 0x63, 0x67, 0xC6,
  0xC6, 0xC6, 0xC6, 0x00, 0x61, 0x80, 0x31, 0x80, 0x30, 0xC0, 0x18, 0xC0,
  0x1C, 0x60, 0x0C, 0x30, 0x7F, 0xFE, 0x3F, 0xFF, 0x03, 0x0C, 0x01, 0x8C,
  0x01, 0x86, 0x00, 0xC3, 0x00, 0x63, 0x03, 0xFF, 0xF3, 0xFF, 0xF8, 0x18,
  0xC0, 0x18, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x06, 0x18, 0x07, 0x18, 0x00,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0xF8, 0x0F, 0xF0, 0x79, 0xE1, 0xC1,
  0x8E, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x80, 0x07, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xEC, 0x03, 0xB8, 0x0C, 0xE0,
  0x73, 0xC3, 0xC7, 0xFE, 0x0F, 0xE0, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00,
  0x3C, 0x01, 0xF8, 0x0E, 0x60, 0x31, 0x86, 0xC6, 0x33, 0x19, 0xCC, 0x66,
  0x3F, 0x30, 0x79, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x06, 0x70, 0x37,
  0xE1, 0x99, 0x8E, 0xC3, 0x33, 0x0D, 0x8C, 0x60, 0x31, 0x80, 0xEE, 0x01,
  0xF0, 0x03, 0xE0, 0x0F, 0xE0, 0x38, 0xC0, 0x61, 0xC1, 0xC3, 0x83, 0x86,
  0x07, 0x1C, 0x06, 0x70, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xF8, 0x37,
  0xB8, 0xEE, 0x39, 0xF8, 0x73, 0x70, 0x7E, 0xE0, 0xF9, 0xC0, 0xE3, 0x83,
  0xE3, 0xFF, 0xC3, 0xF9, 0xC0, 0x6D, 0xED, 0xB0, 0x01, 0x81, 0xC1, 0xC1,
  0xC0, 0xC0, 0xE0, 0xE0, 0x70, 0x30, 0x38, 0x18, 0x0C, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x0C, 0x07, 0x01, 0x80, 0x40, 0x04, 0x03, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x18, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x38,
  0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x20, 0x00, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x04, 0x30, 0xB9, 0x9F, 0xFF, 0xE3, 0xFC, 0x07, 0x00, 0x7C,
  0x06, 0x60, 0x73, 0x87, 0x0E, 0x10, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x39, 0xCC,
  0xE7, 0x33, 0x88, 0xFF, 0xFF, 0xFC, 0x6F, 0xFE, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x01, 0xC0,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00,
  0x00, 0x03, 0xE0, 0x3F, 0xC1, 0xE7, 0x8E, 0x06, 0x30, 0x1D, 0xC0, 0x77,
  0x01, 0xD8, 0x0F, 0x60, 0xFF, 0x87, 0x6E, 0x79, 0xBB, 0x86, 0xFC, 0x3B,
  0xE0, 0xEE, 0x03, 0xB0, 0x0C, 0xC0, 0x73, 0x81, 0x86, 0x0E, 0x1F, 0xF0,
  0x3F, 0x80, 0x00, 0x83, 0x87, 0xDF, 0xEF, 0x74, 0x38, 0x1C, 0x0C, 0x06,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0x01, 0xF0, 0x0F, 0xF0, 0x3C, 0xF0, 0xE0, 0x71, 0x80, 0xE7,
  0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xC1, 0xE3, 0x8E,
  0x07, 0x38, 0x1C, 0xC0, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x1F, 0xC0,
  0x7C, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0xC0, 0x33,
  0x81, 0xCE, 0x0E, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xE0, 0x06, 0xC0, 0x1F, 0x80, 0x77, 0x01, 0xCE, 0x07, 0x18,
  0x0C, 0x30, 0x38, 0x60, 0xE1, 0xC3, 0x83, 0x8E, 0x07, 0x1F, 0xFF, 0xFF,
  0xFF, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0F,
  0xFE, 0x1F, 0xF8, 0x3F, 0xF0, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0xE1, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0xE0, 0x31, 0xC0, 0xE1, 0xC3, 0x83, 0xFE,
  0x01, 0xF8, 0x00, 0x00, 0x30, 0x3E, 0x07, 0xE0, 0xE0, 0x1C, 0x03, 0x80,
  0x30, 0x07, 0x10, 0x6F, 0xC7, 0xFE, 0xF0, 0x7E, 0x07, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x06, 0x71, 0xE7, 0xFC, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x00,
  0x03, 0xE0, 0x3F, 0xC1, 0xE3, 0x87, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x81,
  0xCE, 0x06, 0x18, 0x38, 0x7F, 0xC0, 0xFC, 0x0F, 0x78, 0x70, 0x73, 0x80,
  0xCE, 0x03, 0xB8, 0x0E, 0xE0, 0x33, 0x81, 0xCF, 0x0E, 0x1F, 0xF8, 0x3F,
  0x80, 0x07, 0x81, 0xFE, 0x3C, 0xE7, 0x07, 0x60, 0x7E, 0x03, 0xE0, 0x3C,
  0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x77, 0x1F, 0x7F, 0xE3, 0xE6, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x38, 0x1F, 0x07, 0xE0, 0x78, 0x00, 0x0C, 0x73, 0xC7,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63, 0xCF, 0x1C, 0x0C, 0x3C, 0x78,
  0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x0C, 0x38, 0x70,
  0xE3, 0x86, 0x04, 0x00, 0x00, 0x08, 0x00, 0xC0, 0x3E, 0x07, 0xE1, 0xF8,
  0x3F, 0x03, 0xC0, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xC0,
  0x02, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xDF, 0xFE, 0x20, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x01, 0xC0, 0x1F, 0x03, 0xF0, 0x7F, 0x07, 0xE0, 0x1E, 0x00,
  0xC0, 0x00, 0x0F, 0x83, 0xFC, 0x79, 0xEE, 0x07, 0xE0, 0x70, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x01, 0xC0, 0x18,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x07, 0x80, 0x30, 0x00, 0x00, 0xE0,
  0x03, 0xF8, 0x07, 0x1C, 0x0C, 0x06, 0x18, 0x06, 0x31, 0xF2, 0x33, 0xB3,
  0x66, 0x33, 0x66, 0x23, 0x4C, 0x22, 0xCC, 0x62, 0xCC, 0x62, 0xCC, 0x66,
  0xCC, 0xC4, 0xCD, 0xCC, 0xCF, 0x78, 0xC0, 0x20, 0x60, 0x00, 0x60, 0x40,
  0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3E, 0x00, 0x6E, 0x01, 0xDC, 0x03, 0x18, 0x0E, 0x30, 0x18,
  0x60, 0x70, 0xC0, 0xC1, 0x83, 0xFF, 0x87, 0xFF, 0x1F, 0xFE, 0x30, 0x0C,
  0xE0, 0x19, 0x80, 0x37, 0x00, 0x6C, 0x00, 0xE0, 0x1F, 0xC0, 0x3F, 0xF0,
  0x7F, 0xF0, 0xC0, 0x71, 0x80, 0xE3, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x38,
  0x3C, 0x7F, 0xF0, 0xFF, 0xC1, 0x83, 0xC7, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x30, 0x0E, 0x60, 0x1D, 0xC0, 0x73, 0x83, 0xC7, 0xFF, 0x0F, 0xF8, 0x00,
  0x01, 0xF0, 0x0F, 0xF0, 0x3C, 0xF0, 0xE0, 0x71, 0x80, 0xE7, 0x00, 0xCC,
  0x01, 0xB8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x30, 0x0E, 0x60, 0x18, 0xE0, 0x70, 0xE1, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x7F, 0xE0, 0xC0, 0xE1,
  0x80, 0xC7, 0x01, 0xCE, 0x03, 0x9C, 0x03, 0x30, 0x06, 0x60, 0x0D, 0xC0,
  0x3B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0x98, 0x07, 0x30, 0x0E, 0xE0, 0x39,
  0xC0, 0xE3, 0x87, 0x87, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x1F, 0xFF,
  0x1F, 0xFE, 0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x3F, 0xF8, 0x3F, 0xF8, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xFF, 0xF8,
  0xFF, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0x1F, 0xFF, 0x1C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0xF8,
  0x3F, 0xF8, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0xF0,
  0x3C, 0xF0, 0xE0, 0x71, 0x80, 0xE7, 0x00, 0xCC, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x07, 0xFE, 0x0F, 0xDC, 0x01, 0xB8, 0x03,
  0x30, 0x0E, 0x60, 0x1C, 0xE0, 0x38, 0xE0, 0xE1, 0xFF, 0x80, 0xFC, 0x00,
  0x0C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x30, 0xE0,
  0x18, 0x60, 0x0C, 0x30, 0x0E, 0x18, 0x07, 0x1F, 0xFF, 0x0F, 0xFF, 0x87,
  0x00, 0xC3, 0x00, 0x61, 0x80, 0x70, 0xC0, 0x38, 0xE0, 0x18, 0x70, 0x0C,
  0x30, 0x06, 0x18, 0x07, 0x0C, 0x03, 0x8E, 0x01, 0xC0, 0x1F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xFE, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0xFF,
  0xF0, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x60, 0x1C, 0xE0, 0x39, 0xC0,
  0xE1, 0xC3, 0x83, 0xFE, 0x01, 0xF8, 0x00, 0x1C, 0x03, 0x8E, 0x03, 0x87,
  0x03, 0x83, 0x83, 0x81, 0x83, 0x80, 0xC3, 0x80, 0xE3, 0x80, 0x73, 0x80,
  0x3B, 0x80, 0x1B, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0x9C, 0x03, 0x8E,
  0x01, 0xC3, 0x80, 0xC1, 0xC0, 0x60, 0x70, 0x70, 0x38, 0x38, 0x0E, 0x1C,
  0x07, 0x0E, 0x01, 0xC0, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x1C, 0x07, 0x1C, 0x0F, 0x1E, 0x0F, 0x1E, 0x1F, 0x3E,
  0x1F, 0x3E, 0x3E, 0x36, 0x36, 0x36, 0x76, 0x36, 0x6E, 0x37, 0xEE, 0x73,
  0xCC, 0x73, 0xCC, 0x73, 0x8C, 0x63, 0x9C, 0x63, 0x1C, 0x60, 0x1C, 0xE0,
  0x18, 0xE0, 0x18, 0xC0, 0x18, 0xC0, 0x38, 0xC0, 0x38, 0x0E, 0x03, 0x87,
  0x01, 0xC3, 0x80, 0xE1, 0xE0, 0x61, 0xF0, 0x30, 0xF8, 0x18, 0x7E, 0x1C,
  0x37, 0x0E, 0x19, 0x87, 0x1C, 0xE3, 0x0E, 0x71, 0x87, 0x19, 0xC3, 0x8E,
  0xE1, 0x87, 0x70, 0xC1, 0xB8, 0xE0, 0xF8, 0x70, 0x7C, 0x38, 0x1E, 0x1C,
  0x0F, 0x0C, 0x07, 0x8E, 0x01, 0xC0, 0x01, 0xE0, 0x0F, 0xF0, 0x3D, 0xF0,
  0xE0, 0xE1, 0x80, 0xE7, 0x01, 0xCC, 0x03, 0xB8, 0x03, 0x70, 0x0E, 0xC0,
  0x1D, 0x80, 0x3B, 0x00, 0x76, 0x00, 0xDC, 0x01, 0xB8, 0x07, 0x30, 0x0E,
  0x60, 0x38, 0xE0, 0x60, 0xE3, 0xC1, 0xFF, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x0F, 0xFC, 0x1F, 0xFE, 0x1C, 0x0E, 0x1C, 0x07, 0x18, 0x07, 0x18, 0x07,
  0x38, 0x07, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x7C, 0x3F, 0xF8, 0x3F, 0xC0,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x3D, 0xF0, 0xE0, 0x61,
  0x80, 0xE7, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0xC0, 0x0D, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xB8, 0x07, 0x70, 0x0E, 0x60, 0x18,
  0xE0, 0x71, 0xE3, 0xC1, 0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x18, 0x0F, 0xC0, 0x3F, 0xF0, 0x7F, 0xF0, 0xE0, 0x71, 0x80, 0xE3, 0x00,
  0xC6, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x38, 0xFF, 0xE1, 0xFF, 0x87,
  0xFE, 0x0E, 0x1C, 0x1C, 0x18, 0x38, 0x38, 0x60, 0x70, 0xC0, 0xE3, 0x80,
  0xE7, 0x01, 0xCE, 0x03, 0x80, 0x01, 0xF0, 0x07, 0xF8, 0x0F, 0x3C, 0x1C,
  0x0E, 0x18, 0x0E, 0x38, 0x06, 0x38, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0x70, 0x1C, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x00, 0x18, 0x03, 0x18, 0x07, 0x18, 0x07, 0x38, 0x07, 0x38,
  0x06, 0x38, 0x06, 0x30, 0x06, 0x30, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x0C, 0x70, 0x0C, 0x60, 0x1C, 0x60, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0x60,
  0x38, 0x70, 0x38, 0x78, 0xF0, 0x3F, 0xE0, 0x1F, 0x80, 0xE0, 0x0F, 0xC0,
  0x3B, 0x80, 0x77, 0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x38, 0x30,
  0x70, 0xE0, 0xE1, 0xC1, 0xC7, 0x01, 0x8E, 0x03, 0x18, 0x06, 0x70, 0x0C,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x00, 0x61, 0xC3, 0x61, 0xC7, 0x61, 0xC7, 0x63, 0xC6, 0x63, 0xC6, 0x63,
  0xCE, 0x66, 0xCC, 0x66, 0xCC, 0x66, 0xCC, 0x6C, 0xDC, 0x6C, 0xD8, 0xEC,
  0xD8, 0xFC, 0xD8, 0xF8, 0xF8, 0xF8, 0xF0, 0xF8, 0xF0, 0xF0, 0xF0, 0xF0,
  0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x1C, 0x01, 0xC3, 0x80, 0xE0,
  0xE0, 0x70, 0x18, 0x1C, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0x33, 0x80, 0x0E,
  0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x01, 0xDC, 0x00, 0x67, 0x00, 0x38, 0xC0, 0x1C, 0x38, 0x0E, 0x0E, 0x03,
  0x81, 0xC1, 0xC0, 0x70, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xC0, 0x39, 0x80,
  0x73, 0x81, 0xC7, 0x07, 0x06, 0x0E, 0x0C, 0x38, 0x1C, 0xE0, 0x39, 0xC0,
  0x37, 0x00, 0x6C, 0x00, 0xF8, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x00, 0x0F,
  0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x0F, 0xC3, 0xE0, 0xF8, 0x30, 0x0C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0x38, 0x0F, 0xC3, 0xE0, 0xE0, 0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30,
  0x60, 0xE0, 0xC1, 0x83, 0x06, 0x0E, 0x0C, 0x18, 0x30, 0x60, 0xE0, 0xC1,
  0x80, 0x0F, 0x87, 0xC3, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80,
  0xC0, 0x60, 0x30, 0x38, 0x1C, 0x0C, 0x3E, 0x1F, 0x00, 0x01, 0x00, 0x70,
  0x1E, 0x03, 0xC0, 0xF8, 0x1B, 0x87, 0x70, 0xC6, 0x30, 0xCE, 0x1B, 0x83,
  0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0xE6, 0x33, 0x01, 0x80, 0x3F, 0xC1, 0xFF,
  0x8E, 0x06, 0x38, 0x1C, 0x00, 0x70, 0x01, 0x83, 0xFE, 0x3F, 0xF9, 0xC0,
  0xE6, 0x03, 0xB8, 0x0E, 0xE0, 0x71, 0xC3, 0xC7, 0xFF, 0x0F, 0xCC, 0x0C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x8C, 0x0E,
  0xFC, 0x3F, 0xF8, 0xF0, 0xE3, 0x81, 0xCC, 0x07, 0x30, 0x1D, 0xC0, 0x77,
  0x01, 0xDC, 0x07, 0x60, 0x19, 0x80, 0xE7, 0x03, 0xBE, 0x1C, 0xFF, 0xE3,
  0x3F, 0x00, 0x03, 0x00, 0x7F, 0x0F, 0xFC, 0x70, 0x77, 0x03, 0xB0, 0x0F,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x6E, 0x07, 0x38,
  0x71, 0xFF, 0x07, 0xF0, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0xC7, 0x0F, 0xEE, 0x3F, 0xF8, 0xF0, 0x71, 0xC0,
  0xE7, 0x01, 0xCE, 0x03, 0x98, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x71,
  0x80, 0xE3, 0x81, 0xC7, 0x8F, 0x07, 0xFE, 0x07, 0xEC, 0x00, 0x03, 0x00,
  0x7F, 0x0F, 0xFC, 0x70, 0x67, 0x03, 0xF0, 0x0F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x02, 0x38, 0x39, 0xFF, 0x83, 0xF0,
  0x00, 0xFE, 0x07, 0xF8, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x80, 0x7F, 0xFC, 0xFF, 0xF0, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xDC, 0x7F, 0xF1,
  0xE0, 0xE3, 0x81, 0xCE, 0x03, 0x9C, 0x07, 0x30, 0x0E, 0x60, 0x18, 0xC0,
  0x31, 0x80, 0xE3, 0x01, 0xC7, 0x03, 0x8F, 0x1E, 0x0F, 0xFC, 0x0F, 0xD8,
  0x00, 0x70, 0x00, 0xE3, 0x03, 0x87, 0x0F, 0x07, 0xFC, 0x07, 0xE0, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x8C,
  0x0E, 0xFE, 0x3F, 0xF8, 0xF0, 0x73, 0x81, 0xCC, 0x07, 0x30, 0x1D, 0xC0,
  0x77, 0x01, 0x9C, 0x06, 0x60, 0x19, 0x80, 0xE6, 0x03, 0xB8, 0x0E, 0xE0,
  0x33, 0x80, 0xC0, 0x00, 0x60, 0x07, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x7F, 0x03, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x18, 0x00, 0x70, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x81, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x81, 0xFC, 0x0F,
  0xE0, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x9C, 0x0E, 0x38, 0x78, 0x71, 0xE0, 0xE7, 0x81, 0x9E,
  0x03, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x3D, 0xC0, 0x71, 0xC0, 0xC3, 0x81,
  0x83, 0x87, 0x07, 0x0E, 0x07, 0x1C, 0x07, 0x00, 0x0F, 0xF0, 0x7F, 0x03,
  0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0x04, 0x3F, 0xDE,
  0x3F, 0xFF, 0x38, 0xE3, 0x30, 0xC3, 0x30, 0xC7, 0x71, 0xC7, 0x71, 0xC7,
  0x71, 0x86, 0x61, 0x86, 0x61, 0x86, 0x61, 0x8E, 0xE3, 0x8E, 0xE3, 0x8E,
  0xE3, 0x0C, 0xC3, 0x0C, 0x00, 0xC0, 0xEF, 0xC3, 0xFF, 0x8F, 0x07, 0x38,
  0x1C, 0xC0, 0x73, 0x01, 0xDC, 0x07, 0x70, 0x19, 0xC0, 0x66, 0x01, 0x98,
  0x0E, 0x60, 0x3B, 0x80, 0xEE, 0x03, 0x38, 0x0C, 0x01, 0x80, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0E, 0x38, 0x1D, 0xC0, 0x77, 0x00, 0xD8, 0x03, 0x60, 0x1F,
  0x80, 0x7E, 0x01, 0xD8, 0x0E, 0x70, 0x39, 0xC1, 0xC3, 0xFE, 0x07, 0xF0,
  0x00, 0x60, 0x3B, 0xF0, 0x7F, 0xF0, 0xF0, 0xE1, 0xC0, 0xE3, 0x01, 0xC6,
  0x03, 0x9C, 0x07, 0x38, 0x0E, 0x70, 0x1C, 0xC0, 0x31, 0x80, 0xE3, 0x01,
  0xCF, 0x0F, 0x1F, 0xFC, 0x3B, 0xF0, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x00, 0x7F, 0x73, 0xFF, 0x9E,
  0x0E, 0x70, 0x3B, 0x80, 0xEE, 0x03, 0xB0, 0x0C, 0xC0, 0x33, 0x00, 0xCC,
  0x07, 0x30, 0x1C, 0xE0, 0x73, 0xC3, 0x87, 0xFE, 0x0F, 0xD8, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x00, 0x70, 0xDF,
  0xCF, 0xFC, 0x7C, 0x03, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x03,
  0x00, 0xFF, 0x0F, 0xFC, 0x70, 0x77, 0x03, 0xB8, 0x00, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x0F, 0x80, 0x1D, 0x80, 0x6E, 0x07, 0x70, 0x79, 0xFF, 0x87,
  0xF0, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x01, 0xFC, 0x0F, 0xC0, 0x30, 0x1D, 0xC0, 0x67, 0x01, 0x9C,
  0x0E, 0x60, 0x39, 0x80, 0xE6, 0x03, 0xB8, 0x0C, 0xE0, 0x33, 0x81, 0xCE,
  0x07, 0x38, 0x1C, 0xE1, 0xE1, 0xFF, 0x83, 0xE6, 0x00, 0xE0, 0x1E, 0xC0,
  0x39, 0xC0, 0xE3, 0x81, 0x83, 0x07, 0x06, 0x0C, 0x0C, 0x38, 0x1C, 0x60,
  0x19, 0xC0, 0x33, 0x00, 0x6E, 0x00, 0xD8, 0x00, 0xF0, 0x01, 0xC0, 0x03,
  0x00, 0x00, 0xC3, 0x87, 0xC3, 0x86, 0xC3, 0x8E, 0xC7, 0x8C, 0xC7, 0x8C,
  0xCD, 0x98, 0xCD, 0x98, 0xCD, 0x98, 0xD9, 0xB0, 0xD9, 0xB0, 0xF1, 0xA0,
  0xF1, 0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xC0, 0x1C, 0x07, 0x87, 0x07,
  0x03, 0x87, 0x00, 0xE7, 0x00, 0x37, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xF0, 0x03, 0x9C, 0x03, 0x86, 0x03, 0x83, 0x83,
  0xC0, 0xC3, 0xC0, 0x70, 0x38, 0x03, 0x8C, 0x03, 0x87, 0x01, 0x83, 0x81,
  0xC1, 0xC1, 0xC0, 0x60, 0xE0, 0x38, 0xE0, 0x1C, 0x60, 0x06, 0x70, 0x03,
  0x30, 0x01, 0xB8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xFF, 0xEF, 0xFF, 0x80, 0x00, 0x30, 0x0F, 0x01, 0xC0, 0x38, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0F, 0x00, 0x70, 0x0C, 0x30,
  0xC3, 0x0C, 0x31, 0x86, 0x18, 0x61, 0x86, 0x30, 0xC3, 0x0C, 0x30, 0xC7,
  0x18, 0x61, 0x86, 0x18, 0x63, 0x0C, 0x00, 0x08, 0x03, 0x80, 0x18, 0x03,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x38, 0x07, 0xC0, 0x78, 0x3C, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x03, 0xC0, 0x60, 0x00, 0x3F, 0x01,
  0x7F, 0x83, 0x61, 0xC7, 0x60, 0xFE, 0xA0, 0x7C,
};

const GFXglyph RobotoMono_Italic29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 7, 21, 17, 5, -21 },
  { 20, 8, 7, 17, 6, -22 },
  { 27, 17, 21, 17, 0, -21 },
  { 72, 14, 27, 17, 2, -24 },
  { 120, 14, 21, 17, 2, -21 },
  { 157, 15, 21, 17, 1, -21 },
  { 197, 3, 7, 17, 8, -22 },
  { 200, 9, 30, 17, 5, -23 },
  { 234, 10, 30, 17, 2, -23 },
  { 272, 13, 14, 17, 3, -21 },
  { 295, 14, 15, 17, 2, -17 },
  { 322, 5, 8, 17, 3, -3 },
  { 327, 11, 2, 17, 3, -10 },
  { 330, 4, 4, 17, 6, -4 },
  { 332, 14, 23, 17, 2, -21 },
  { 373, 14, 21, 17, 2, -21 },
  { 410, 9, 21, 17, 4, -21 },
  { 434, 15, 21, 17, 0, -21 },
  { 474, 14, 21, 17, 1, -21 },
  { 511, 15, 21, 17, 0, -21 },
  { 551, 15, 21, 17, 2, -21 },
  { 591, 12, 21, 17, 2, -21 },
  { 623, 14, 21, 17, 3, -21 },
  { 660, 14, 21, 17, 2, -21 },
  { 697, 12, 21, 17, 3, -21 },
  { 729, 6, 16, 17, 6, -16 },
  { 741, 7, 21, 17, 5, -16 },
  { 760, 13, 13, 17, 2, -16 },
  { 782, 13, 8, 17, 2, -13 },
  { 795, 14, 13, 17, 1, -16 },
  { 818, 12, 21, 17, 4, -21 },
  { 850, 16, 21, 17, 1, -21 },
  { 892, 15, 21, 17, 0, -21 },
  { 932, 15, 21, 17, 1, -21 },
  { 972, 15, 21, 17, 1, -21 },
  { 1012, 15, 21, 17, 1, -21 },
  { 1052, 16, 21, 17, 1, -21 },
  { 1094, 16, 21, 17, 1, -21 },
  { 1136, 15, 21, 17, 1, -21 },
  { 1176, 17, 21, 17, 0, -21 },
  { 1221, 16, 21, 17, 1, -21 },
  { 1263, 15, 21, 17, 1, -21 },
  { 1303, 17, 21, 17, 1, -21 },
  { 1348, 13, 21, 17, 1, -21 },
  { 1383, 16, 21, 17, 1, -21 },
  { 1425, 17, 21, 17, 0, -21 },
  { 1470, 15, 21, 17, 1, -21 },
  { 1510, 16, 21, 17, 1, -21 },
  { 1552, 15, 24, 17, 1, -21 },
  { 1597, 15, 21, 17, 1, -21 },
  { 1637, 16, 21, 17, 1, -21 },
  { 1679, 15, 21, 17, 3, -21 },
  { 1719, 16, 21, 17, 1, -21 },
  { 1761, 15, 21, 17, 3, -21 },
  { 1801, 16, 21, 17, 2, -21 },
  { 1843, 18, 21, 17, 0, -21 },
  { 1891, 15, 21, 17, 3, -21 },
  { 1931, 16, 21, 17, 0, -21 },
  { 1973, 10, 28, 17, 4, -24 },
  { 2008, 7, 23, 17, 5, -21 },
  { 2029, 9, 28, 17, 4, -24 },
  { 2061, 11, 11, 17, 3, -21 },
  { 2077, 13, 2, 17, 0, 0 },
  { 2081, 4, 4, 17, 8, -21 },
  { 2083, 14, 16, 17, 1, -16 },
  { 2111, 14, 22, 17, 1, -22 },
  { 2150, 13, 16, 17, 2, -16 },
  { 2176, 15, 22, 17, 2, -22 },
  { 2218, 13, 16, 17, 2, -16 },
  { 2244, 15, 22, 17, 3, -22 },
  { 2286, 15, 22, 17, 1, -16 },
  { 2328, 14, 22, 17, 1, -22 },
  { 2367, 13, 21, 17, 1, -21 },
  { 2402, 14, 27, 17, 0, -21 },
  { 2450, 15, 22, 17, 1, -22 },
  { 2492, 13, 22, 17, 1, -22 },
  { 2528, 16, 16, 17, 0, -16 },
  { 2560, 14, 16, 17, 1, -16 },
  { 2588, 14, 16, 17, 1, -16 },
  { 2616, 15, 22, 17, 0, -16 },
  { 2658, 14, 22, 17, 2, -16 },
  { 2697, 13, 16, 17, 3, -16 },
  { 2723, 13, 16, 17, 2, -16 },
  { 2749, 12, 19, 17, 3, -19 },
  { 2778, 14, 15, 17, 2, -15 },
  { 2805, 15, 15, 17, 2, -15 },
  { 2834, 16, 15, 17, 2, -15 },
  { 2864, 17, 15, 17, 0, -15 },
  { 2896, 17, 21, 17, 0, -15 },
  { 2941, 14, 15, 17, 1, -15 },
  { 2968, 12, 28, 17, 4, -23 },
  { 3010, 6, 27, 17, 5, -21 },
  { 3031, 11, 28, 17, 3, -23 },
  { 3070, 16, 5, 17, 0, -11 },
};

const GFXfont RobotoMono_Italic29pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic29pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _ROBOTOMONO_ITALIC29PT7B_H_
