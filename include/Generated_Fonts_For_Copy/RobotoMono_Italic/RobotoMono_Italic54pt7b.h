#ifndef _ROBOTOMONO_ITALIC54PT7B_H_
#define _ROBOTOMONO_ITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0x80, 0x3C, 0x1E,
  0x78, 0x3C, 0xE0, 0x7B, 0xC0, 0xE7, 0x83, 0xCF, 0x07, 0x9E, 0x0F, 0x3C,
  0x1E, 0x70, 0x39, 0xE0, 0x73, 0xC1, 0xE7, 0x83, 0xCE, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x38, 0x0F, 0x00, 0x00, 0xF0, 0x1C, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x07, 0x80, 0x00,
  0x78, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x07, 0xF8, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F,
  0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE3, 0xE0, 0x00,
  0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0x83, 0xF0, 0x03, 0xF0, 0x3F, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xF9, 0xF0, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x87,
  0x81, 0xE0, 0x79, 0xC0, 0x78, 0x3C, 0x70, 0x1C, 0x1E, 0x1C, 0x07, 0x07,
  0x8F, 0x01, 0xC3, 0xC1, 0xC0, 0xF1, 0xE0, 0x78, 0x3C, 0x78, 0x1F, 0x3E,
  0x3C, 0x03, 0xFF, 0x1E, 0x00, 0x7F, 0x87, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE3, 0xF8, 0x00, 0xF1,
  0xFF, 0x00, 0x78, 0xFF, 0xE0, 0x1E, 0x7C, 0x7C, 0x0F, 0x1E, 0x0F, 0x07,
  0x8F, 0x03, 0xC1, 0xE3, 0xC0, 0xF0, 0xF0, 0xF0, 0x3C, 0x78, 0x3C, 0x0F,
  0x1C, 0x0F, 0x03, 0xC1, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C,
  0x1E, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x7E, 0x0F, 0x80,
  0x03, 0xE0, 0x3C, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x0F, 0x00, 0x0F,
  0x80, 0x78, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x78, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x7C, 0x3F, 0x3E,
  0x03, 0xE3, 0xF0, 0xF8, 0x1E, 0x3F, 0x07, 0xC0, 0xF1, 0xF0, 0x1F, 0x0F,
  0x9F, 0x80, 0xFC, 0x78, 0xF8, 0x03, 0xE7, 0xC7, 0xC0, 0x1F, 0xBE, 0x3E,
  0x00, 0x7F, 0xE1, 0xF0, 0x01, 0xFE, 0x0F, 0x80, 0x0F, 0xF0, 0x7C, 0x00,
  0x3F, 0x03, 0xE0, 0x03, 0xF8, 0x0F, 0x80, 0x7F, 0xC0, 0x7F, 0xDF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xE3, 0xE0, 0x0F, 0xFC, 0x1F, 0x80,
  0x06, 0x00, 0x00, 0x1E, 0x78, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xF1,
  0xE3, 0x8F, 0x00, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x00, 0x40, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x60, 0x1E, 0x03, 0x7C, 0x1C, 0x1F, 0x7F, 0x1C, 0x7F, 0xFF, 0xDF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xEE, 0x00, 0x07, 0xCF, 0x00, 0x07, 0x8F,
  0x80, 0x0F, 0x87, 0x80, 0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x7E, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x08, 0x01, 0x80, 0x00, 0x01, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xF0, 0x78, 0x3E, 0x02, 0x00,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x3C,
  0x7E, 0x7F, 0xFF, 0x7F, 0x7F, 0x7E, 0x08, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xF8, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x00,
  0x78, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xF3,
  0xE0, 0x03, 0xFC, 0xF8, 0x03, 0xFF, 0x3E, 0x01, 0xFF, 0xCF, 0x00, 0xFD,
  0xF3, 0xC0, 0xFE, 0x7D, 0xF0, 0x7E, 0x1E, 0x7C, 0x7F, 0x07, 0x9F, 0x3F,
  0x03, 0xE7, 0xFF, 0x80, 0xF9, 0xFF, 0x80, 0x3E, 0x7F, 0xC0, 0x0F, 0xBF,
  0xE0, 0x03, 0xCF, 0xE0, 0x00, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0xFF, 0x3F, 0xC0, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x0F, 0x80, 0x3F, 0xC0, 0x7F, 0xE1, 0xFF, 0xF3, 0xFF,
  0xF9, 0xFE, 0x78, 0xFC, 0x3C, 0x70, 0x3E, 0x40, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01,
  0xFC, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x07, 0xF0,
  0x1F, 0xF7, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0,
  0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x81, 0xF0,
  0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x7F,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFC, 0x7F, 0x80, 0x7C, 0x03, 0xF8, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F,
  0x0F, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0xFF, 0x3F, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x1F, 0xC0, 0x3E, 0x7F, 0xF0, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xC0, 0xFC, 0x7F, 0x80, 0x7E, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x7F,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xC1,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0x83, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xE3, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0, 0x00,
  0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F, 0xE3, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F,
  0xE1, 0xFC, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x7E,
  0x01, 0xFE, 0x3F, 0x03, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFE, 0x7C, 0x03, 0xF8, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F,
  0x87, 0xF0, 0xFE, 0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x7E, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE0,
  0xF8, 0x04, 0x00, 0x00, 0x78, 0x01, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x1F, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x08, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0xC7, 0xF8, 0xFC,
  0x03, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0x80, 0x78,
  0x00, 0x0E, 0x07, 0x80, 0x40, 0x70, 0x78, 0x1F, 0xC3, 0x83, 0x83, 0xFF,
  0x0E, 0x3C, 0x3F, 0xF8, 0x71, 0xC1, 0xE1, 0xC3, 0x9E, 0x1E, 0x0E, 0x1C,
  0xE1, 0xE0, 0x60, 0xE7, 0x0E, 0x07, 0x07, 0x70, 0x70, 0x38, 0x3B, 0x87,
  0x81, 0xC1, 0xDC, 0x38, 0x0E, 0x0F, 0xE1, 0xC0, 0xE0, 0x6E, 0x1E, 0x07,
  0x07, 0x70, 0xF0, 0x38, 0x3B, 0x87, 0x01, 0xC1, 0xDC, 0x38, 0x1C, 0x0C,
  0xE1, 0xC0, 0xE0, 0xE7, 0x0E, 0x0F, 0x06, 0x38, 0x78, 0xF8, 0x71, 0xC3,
  0xFF, 0xE7, 0x0E, 0x0F, 0xEF, 0xF8, 0x70, 0x7E, 0x3F, 0x03, 0xC0, 0x80,
  0x60, 0x0E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x10, 0x00, 0x3F, 0x07, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x07, 0x8F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xF0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0x78, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0x7C,
  0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x1F,
  0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x07, 0xC0,
  0x0F, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0xC0, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1E, 0x00, 0x7F, 0x01, 0xE0, 0x01,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x78, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0,
  0x78, 0x00, 0x7F, 0x0F, 0x80, 0x1F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xF8, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE3,
  0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x13, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x03,
  0xFC, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x3E, 0x01, 0xFC, 0x01,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0,
  0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0xE0, 0x7C, 0x00, 0xFE, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x08, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0x00,
  0xFC, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x03, 0xFF, 0xCF, 0x80, 0x3F, 0xFC, 0xF8, 0x03, 0xFF,
  0xCF, 0x00, 0x7F, 0xFC, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xF8, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03,
  0xC0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3E,
  0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF0, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0xFC, 0x03, 0xF0, 0x1F,
  0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x03, 0xE0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xC0, 0x03, 0xF0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80,
  0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0x80, 0xFC, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x0F, 0x3F, 0x80, 0x00,
  0x1F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0xEF, 0xC0, 0x00,
  0x3F, 0xC7, 0xC0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0x80, 0xFE, 0x00,
  0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xBC, 0x0F, 0xFC, 0x0F, 0x78, 0x1E,
  0xF0, 0x1E, 0xF0, 0x7D, 0xE0, 0x3D, 0xE0, 0xF3, 0xC0, 0xFB, 0xC3, 0xEF,
  0x81, 0xF3, 0x87, 0x9F, 0x03, 0xE7, 0x9F, 0x3C, 0x07, 0x8F, 0x3C, 0x78,
  0x0F, 0x1E, 0xF8, 0xF0, 0x1E, 0x3D, 0xE3, 0xE0, 0x7C, 0x7F, 0xC7, 0xC0,
  0xF8, 0xFF, 0x0F, 0x81, 0xF0, 0xFE, 0x1E, 0x03, 0xC1, 0xF8, 0x3C, 0x07,
  0x83, 0xF0, 0xF8, 0x0F, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0x7C,
  0x1E, 0x07, 0xC0, 0xF8, 0x3C, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x03, 0xC0,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x78, 0x0F, 0xC0,
  0x01, 0xF0, 0x1F, 0xC0, 0x03, 0xE0, 0x3F, 0x80, 0x07, 0xC0, 0x7F, 0x00,
  0x0F, 0x81, 0xFF, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x7C, 0x07, 0xFC, 0x00,
  0xF8, 0x0F, 0xFC, 0x01, 0xF0, 0x1F, 0xF8, 0x03, 0xE0, 0x7C, 0xF0, 0x07,
  0xC0, 0xF9, 0xF0, 0x0F, 0x01, 0xF3, 0xE0, 0x3E, 0x03, 0xE3, 0xC0, 0x7C,
  0x07, 0xC7, 0xC0, 0xF8, 0x0F, 0x8F, 0x81, 0xF0, 0x3E, 0x0F, 0x03, 0xE0,
  0x7C, 0x1F, 0x07, 0x80, 0xF8, 0x3E, 0x1F, 0x01, 0xF0, 0x3C, 0x3E, 0x03,
  0xE0, 0x7C, 0x7C, 0x07, 0x80, 0xF8, 0xF8, 0x1F, 0x00, 0xF1, 0xF0, 0x3E,
  0x01, 0xF3, 0xC0, 0x7C, 0x03, 0xEF, 0x80, 0xF8, 0x03, 0xDF, 0x01, 0xF0,
  0x07, 0xFE, 0x03, 0xC0, 0x0F, 0xFC, 0x0F, 0x80, 0x0F, 0xF8, 0x1F, 0x00,
  0x1F, 0xE0, 0x3E, 0x00, 0x3F, 0xC0, 0x7C, 0x00, 0x3F, 0x80, 0xF8, 0x00,
  0x7F, 0x03, 0xE0, 0x00, 0xFE, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xE7, 0xF0, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xC3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x3E, 0x78, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F,
  0x7C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7C, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F,
  0x00, 0xFC, 0x0F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x3E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x0F, 0x00, 0x01, 0xF0, 0x78, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x78,
  0x00, 0x7F, 0x03, 0xC0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x3F, 0x80, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xE0, 0xF8,
  0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x3C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3C, 0xF8, 0x00,
  0x07, 0xC7, 0x80, 0x00, 0x7C, 0x78, 0x00, 0x07, 0x87, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x81, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xC0, 0x0F, 0xE0, 0x3C,
  0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00,
  0x7E, 0x0F, 0x00, 0x0F, 0xC1, 0xF0, 0x03, 0xF8, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x1E, 0x01,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x3C, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xE1, 0xFC,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x0F, 0x80,
  0x01, 0xF0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x1F,
  0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x3C,
  0x1E, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3C, 0x1F, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1F, 0x07, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF8, 0x3C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x0F, 0x07, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x00, 0xFC,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x83,
  0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x07, 0xBE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x7D, 0xF0, 0x1F, 0x01, 0xE7, 0xC0, 0x7C, 0x0F, 0x9F,
  0x03, 0xF0, 0x3E, 0x7C, 0x0F, 0xC0, 0xF1, 0xF0, 0x3F, 0x03, 0xC7, 0xC1,
  0xFC, 0x1F, 0x1E, 0x07, 0xF0, 0x7C, 0x78, 0x1F, 0xC1, 0xE1, 0xE0, 0xFF,
  0x07, 0x87, 0x83, 0xFC, 0x3E, 0x1E, 0x0E, 0xF0, 0xF8, 0x78, 0x7B, 0xC3,
  0xC1, 0xE1, 0xEF, 0x0F, 0x07, 0x87, 0x3C, 0x7C, 0x1E, 0x3C, 0xF1, 0xE0,
  0x78, 0xF3, 0xC7, 0x81, 0xE3, 0xCF, 0x1E, 0x07, 0x9E, 0x3C, 0xF8, 0x1E,
  0x78, 0xF3, 0xC0, 0x79, 0xE3, 0xCF, 0x01, 0xEF, 0x0F, 0x3C, 0x07, 0xBC,
  0x3D, 0xF0, 0x3E, 0xF0, 0xF7, 0x80, 0xFF, 0x83, 0xDE, 0x03, 0xDE, 0x0F,
  0x78, 0x0F, 0x78, 0x3F, 0xC0, 0x3F, 0xC0, 0xFF, 0x00, 0xFF, 0x03, 0xFC,
  0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00,
  0xFE, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0xC0,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x3F,
  0x0F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F,
  0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x81,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xFC, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x81, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x03,
  0xE1, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0x9F, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x1F, 0x78,
  0x01, 0xE7, 0x80, 0x3E, 0x78, 0x03, 0xC7, 0xC0, 0x7C, 0x3C, 0x0F, 0x83,
  0xC0, 0xF8, 0x3C, 0x1F, 0x03, 0xE1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3, 0xC0,
  0x1E, 0x7C, 0x01, 0xEF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x1F, 0x0F, 0x83, 0xE0, 0xF0,
  0x38, 0x1E, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07,
  0xFF, 0xFE, 0x0F, 0xE0, 0x7E, 0x1F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x1E,
  0x00, 0x1F, 0x20, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F,
  0xC0, 0x3E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8,
  0x01, 0xFC, 0xFC, 0x07, 0xFC, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0x7C, 0x3F,
  0xFE, 0x7C, 0x0F, 0xF8, 0x7C, 0x00, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x87, 0xF0, 0x03, 0xE7, 0xFF, 0x00, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC,
  0x0F, 0xF8, 0x3F, 0x03, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0x3E, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xE3, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xE0,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0xFF, 0x81, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F,
  0xBF, 0xFF, 0x03, 0xE7, 0xFF, 0x80, 0xF0, 0xFF, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x7F,
  0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xF7, 0xFC, 0x07, 0xFF,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x3F, 0x87, 0xC0, 0x0F, 0xFE, 0x7C,
  0x03, 0xFF, 0xF7, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFC,
  0x03, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00,
  0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xF7, 0x80, 0x07, 0xFC, 0x78, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00,
  0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x7C,
  0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x60, 0xFC, 0x00, 0x78, 0x3F, 0x00, 0xFE, 0x0F, 0xFB, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xF9, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0xF0, 0x03, 0xFF, 0x9F, 0x00, 0xFF,
  0xFD, 0xF0, 0x1F, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8,
  0x00, 0x3E, 0x1F, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07,
  0xC1, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFD, 0xF0, 0x01, 0xFF, 0x1E, 0x00, 0x01, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x20, 0x00, 0x7C, 0x03, 0x00,
  0x0F, 0xC0, 0x78, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x83, 0xF8, 0x03, 0xE3, 0xFF, 0x80, 0xF9, 0xFF, 0xF0,
  0x3E, 0xFF, 0xFC, 0x0F, 0x78, 0x3F, 0x83, 0xF8, 0x03, 0xE0, 0xFC, 0x00,
  0xF8, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x07, 0xF0, 0x78, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0x80,
  0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0x01,
  0xF8, 0x01, 0xF0, 0x7F, 0x00, 0x1F, 0x0F, 0xE0, 0x01, 0xF1, 0xFC, 0x00,
  0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1E, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xDF, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C,
  0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0x80, 0x1F,
  0x80, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x7E, 0x0F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x9F,
  0x83, 0xE0, 0x3E, 0xFF, 0x3F, 0xC0, 0xF7, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC7, 0xF8, 0xFC, 0x3E, 0x0F, 0xC1, 0xF0, 0xF0, 0x3E, 0x07,
  0xC7, 0xC0, 0xF8, 0x1F, 0x1F, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0x81, 0xF1,
  0xE0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x1E, 0x3E, 0x03, 0xC0, 0x78, 0xF8,
  0x1F, 0x03, 0xE3, 0xE0, 0x7C, 0x0F, 0x8F, 0x81, 0xF0, 0x3E, 0x3C, 0x07,
  0x80, 0xF0, 0xF0, 0x1E, 0x03, 0xC7, 0xC0, 0x78, 0x0F, 0x1F, 0x03, 0xE0,
  0x7C, 0x7C, 0x0F, 0x81, 0xF1, 0xE0, 0x3E, 0x07, 0xC7, 0x80, 0xF0, 0x1E,
  0x1E, 0x03, 0xC0, 0x78, 0xF8, 0x1F, 0x01, 0xE3, 0xE0, 0x7C, 0x0F, 0x8F,
  0x81, 0xF0, 0x3E, 0x3C, 0x07, 0xC0, 0xF8, 0xF0, 0x1E, 0x03, 0xC0, 0x07,
  0x83, 0xF8, 0x03, 0xE3, 0xFF, 0x80, 0xFB, 0xFF, 0xF0, 0x3D, 0xFF, 0xFC,
  0x0F, 0xF8, 0x3F, 0x83, 0xF8, 0x03, 0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF1, 0xE0, 0x00, 0x78, 0xF8, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFE,
  0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3E,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x01,
  0xF8, 0x3E, 0x01, 0xF8, 0x1F, 0xE7, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xE1, 0xFC, 0x00,
  0x3E, 0x7F, 0xF0, 0x03, 0xEF, 0xFF, 0x80, 0x3D, 0xFF, 0xFC, 0x03, 0xFE,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x78,
  0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x7F, 0x03,
  0xFF, 0x9F, 0xE0, 0x3F, 0xFF, 0xFC, 0x03, 0xEF, 0xFF, 0x80, 0x3E, 0x3F,
  0xE0, 0x03, 0xC0, 0x30, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x83, 0xC0, 0x3F, 0xF9, 0xF0, 0x3F,
  0xFF, 0x7C, 0x1F, 0xFF, 0xFF, 0x0F, 0xE0, 0x7F, 0x83, 0xF0, 0x07, 0xE1,
  0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03,
  0xE7, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00,
  0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1E, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x3E,
  0x1E, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x01,
  0xFC, 0x0F, 0xF3, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xE0, 0x07,
  0xFC, 0x78, 0x00, 0x18, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x07, 0x81, 0xFF, 0x0F, 0x8F, 0xFE, 0x0F, 0x9F, 0xFE, 0x0F,
  0xBF, 0xFE, 0x0F, 0x7F, 0xFE, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x00, 0xF8,
  0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE7, 0xC0,
  0x00, 0xF1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x1F,
  0xF3, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x1F,
  0x00, 0x0F, 0x8F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0x8F, 0x80, 0x03,
  0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7C, 0xF8, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xF0, 0x7C, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xBE, 0x07,
  0xFF, 0x9F, 0x00, 0xFF, 0x0F, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x7C, 0x78, 0x00,
  0x1F, 0x1E, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x3C,
  0x00, 0x78, 0x0F, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xE0, 0x07, 0x80, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1F,
  0x00, 0x1F, 0x07, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x7D,
  0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x78, 0x07, 0x9E, 0x03, 0xE0, 0x3E, 0x78,
  0x0F, 0x80, 0xF1, 0xE0, 0x7E, 0x03, 0xC7, 0x81, 0xF8, 0x1E, 0x1E, 0x07,
  0xE0, 0x78, 0x78, 0x3B, 0x81, 0xE1, 0xE0, 0xEE, 0x0F, 0x07, 0x87, 0xB8,
  0x3C, 0x1E, 0x1E, 0xE0, 0xF0, 0x78, 0xF3, 0x87, 0x81, 0xE3, 0xCE, 0x1E,
  0x07, 0x8E, 0x38, 0x70, 0x1E, 0x78, 0xF3, 0xC0, 0x79, 0xC3, 0xCF, 0x01,
  0xEF, 0x0F, 0x38, 0x07, 0xBC, 0x3D, 0xE0, 0x1E, 0xE0, 0xF7, 0x80, 0x7F,
  0x81, 0xDC, 0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x1F,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00,
  0x00, 0x1E, 0x1F, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xF3, 0xFF, 0xE0, 0x03, 0x8F,
  0xFF, 0xC0, 0x1E, 0x7C, 0x3F, 0x80, 0x7B, 0xE0, 0x3F, 0x83, 0xCF, 0x00,
  0x7F, 0xFF, 0x3C, 0x00, 0xFF, 0xF8, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x00,
};

const GFXglyph RobotoMono_Italic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 12, 38, 32, 10, -38 },
  { 58, 15, 13, 32, 11, -41 },
  { 83, 31, 38, 32, 1, -38 },
  { 231, 27, 50, 32, 3, -45 },
  { 400, 26, 40, 32, 3, -39 },
  { 530, 29, 40, 32, 1, -39 },
  { 675, 7, 13, 32, 14, -41 },
  { 687, 17, 55, 32, 9, -43 },
  { 804, 18, 55, 32, 4, -43 },
  { 928, 24, 26, 32, 6, -38 },
  { 1006, 26, 28, 32, 3, -32 },
  { 1097, 10, 15, 32, 5, -6 },
  { 1116, 21, 4, 32, 5, -19 },
  { 1127, 8, 8, 32, 10, -7 },
  { 1135, 27, 41, 32, 3, -38 },
  { 1274, 26, 40, 32, 3, -39 },
  { 1404, 17, 38, 32, 7, -38 },
  { 1485, 28, 39, 32, 0, -39 },
  { 1622, 27, 40, 32, 1, -39 },
  { 1757, 27, 38, 32, 1, -38 },
  { 1886, 27, 39, 32, 4, -38 },
  { 2018, 24, 39, 32, 3, -38 },
  { 2135, 27, 38, 32, 5, -38 },
  { 2264, 27, 40, 32, 3, -39 },
  { 2399, 24, 39, 32, 5, -39 },
  { 2516, 11, 31, 32, 12, -30 },
  { 2559, 15, 39, 32, 8, -30 },
  { 2633, 24, 24, 32, 4, -29 },
  { 2705, 26, 15, 32, 3, -25 },
  { 2754, 25, 24, 32, 3, -29 },
  { 2829, 22, 39, 32, 7, -39 },
  { 2937, 29, 39, 32, 2, -39 },
  { 3079, 28, 38, 32, -1, -38 },
  { 3212, 28, 38, 32, 2, -38 },
  { 3345, 28, 40, 32, 3, -39 },
  { 3485, 29, 38, 32, 1, -38 },
  { 3623, 29, 38, 32, 2, -38 },
  { 3761, 30, 38, 32, 2, -38 },
  { 3904, 28, 40, 32, 3, -39 },
  { 4044, 31, 38, 32, 1, -38 },
  { 4192, 29, 38, 32, 2, -38 },
  { 4330, 29, 39, 32, 2, -38 },
  { 4472, 32, 38, 32, 2, -38 },
  { 4624, 24, 38, 32, 2, -38 },
  { 4738, 31, 38, 32, 1, -38 },
  { 4886, 31, 38, 32, 1, -38 },
  { 5034, 27, 40, 32, 3, -39 },
  { 5169, 29, 38, 32, 2, -38 },
  { 5307, 28, 45, 32, 2, -39 },
  { 5465, 28, 38, 32, 2, -38 },
  { 5598, 29, 40, 32, 2, -39 },
  { 5743, 29, 38, 32, 5, -38 },
  { 5881, 29, 39, 32, 3, -38 },
  { 6023, 28, 38, 32, 5, -38 },
  { 6156, 30, 38, 32, 4, -38 },
  { 6299, 33, 38, 32, 0, -38 },
  { 6456, 27, 38, 32, 6, -38 },
  { 6585, 30, 38, 32, 0, -38 },
  { 6728, 18, 52, 32, 7, -44 },
  { 6845, 12, 41, 32, 10, -38 },
  { 6907, 18, 52, 32, 7, -44 },
  { 7024, 20, 20, 32, 6, -38 },
  { 7074, 24, 4, 32, 1, 0 },
  { 7086, 9, 7, 32, 14, -39 },
  { 7094, 24, 30, 32, 3, -29 },
  { 7184, 26, 42, 32, 2, -41 },
  { 7321, 25, 30, 32, 3, -29 },
  { 7415, 28, 42, 32, 3, -41 },
  { 7562, 25, 30, 32, 3, -29 },
  { 7656, 28, 42, 32, 5, -42 },
  { 7803, 28, 40, 32, 1, -29 },
  { 7943, 26, 41, 32, 2, -41 },
  { 8077, 24, 39, 32, 2, -39 },
  { 8194, 24, 51, 32, 1, -39 },
  { 8347, 28, 41, 32, 2, -41 },
  { 8491, 24, 41, 32, 2, -41 },
  { 8614, 30, 29, 32, 0, -29 },
  { 8723, 26, 29, 32, 2, -29 },
  { 8818, 25, 30, 32, 3, -29 },
  { 8912, 28, 40, 32, 0, -29 },
  { 9052, 26, 40, 32, 3, -29 },
  { 9182, 24, 29, 32, 6, -29 },
  { 9269, 25, 30, 32, 3, -29 },
  { 9363, 23, 36, 32, 5, -35 },
  { 9467, 25, 30, 32, 4, -29 },
  { 9561, 26, 29, 32, 5, -29 },
  { 9656, 30, 29, 32, 3, -29 },
  { 9765, 31, 29, 32, 0, -29 },
  { 9878, 33, 41, 32, -1, -29 },
  { 10048, 27, 29, 32, 2, -29 },
  { 10146, 21, 52, 32, 8, -42 },
  { 10283, 11, 49, 32, 10, -38 },
  { 10351, 21, 52, 32, 5, -42 },
  { 10488, 30, 10, 32, 1, -21 },
};

const GFXfont RobotoMono_Italic54pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic54pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic54pt7bGlyphs,
  0x20, 0x7E, 71
};

#endif // _ROBOTOMONO_ITALIC54PT7B_H_
