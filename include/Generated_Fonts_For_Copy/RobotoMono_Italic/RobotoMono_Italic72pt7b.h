#ifndef _ROBOTOMONO_ITALIC72PT7B_H_
#define _ROBOTOMONO_ITALIC72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic72pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x3E, 0x03, 0xF3, 0xE0, 0x3E,
  0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3E, 0x03, 0xE7, 0xC0, 0x3E, 0x7C, 0x07,
  0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x78, 0x07, 0xCF, 0x80,
  0x78, 0xF8, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0xF0,
  0x0F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x20, 0xF8, 0x03, 0xC0, 0x1E, 0x3E, 0x00, 0xF0, 0x0F, 0xCF, 0x80, 0x7C,
  0x03, 0xE3, 0xE0, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xC0, 0xF8, 0x3E, 0x01,
  0xF0, 0x7E, 0x0F, 0x80, 0x7C, 0x1F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8,
  0x0F, 0x87, 0xE0, 0x3F, 0x07, 0xE1, 0xF0, 0x07, 0xFF, 0xF0, 0xF8, 0x01,
  0xFF, 0xF8, 0x7C, 0x00, 0x3F, 0xFC, 0x3F, 0x00, 0x03, 0xFE, 0x0F, 0x80,
  0x00, 0x1C, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0xF0, 0x00, 0x3E, 0x1F, 0xFE, 0x00,
  0x1F, 0x8F, 0xFF, 0xC0, 0x07, 0xC7, 0xF3, 0xF8, 0x03, 0xE1, 0xF0, 0x3E,
  0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0x3E, 0x0F, 0x00,
  0x7C, 0x1F, 0x07, 0xC0, 0x1F, 0x0F, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0x7C,
  0x01, 0xF1, 0xF0, 0x1F, 0x00, 0x78, 0x7C, 0x07, 0xC0, 0x3E, 0x06, 0x01,
  0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xE7, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xCF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFC, 0x1F, 0xF7, 0xF0, 0x03, 0xE0,
  0xFF, 0x8F, 0xE0, 0x0F, 0x87, 0xFC, 0x3F, 0x80, 0x7E, 0x1F, 0xE0, 0x7F,
  0x01, 0xF8, 0xFF, 0x01, 0xFC, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0x3F, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE1, 0xF8, 0x00, 0x3F,
  0x9F, 0x8F, 0xE0, 0x00, 0xFE, 0xFC, 0x3F, 0x80, 0x01, 0xFF, 0xF0, 0xFE,
  0x00, 0x07, 0xFF, 0x83, 0xF8, 0x00, 0x0F, 0xFC, 0x07, 0xE0, 0x00, 0x3F,
  0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x03, 0xFE, 0x01, 0xFE,
  0x00, 0x1F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x7F, 0x00, 0x3F,
  0xFF, 0xC1, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x1F, 0x1F, 0x3F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x10, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x20, 0x01, 0xF0, 0x01, 0x38, 0x01, 0xE0, 0x07, 0x7E, 0x03, 0xE0, 0x3F,
  0x7F, 0x83, 0xE0, 0xFF, 0xFF, 0xE3, 0xE7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFC, 0xF8, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x0E, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x1F, 0x81, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F,
  0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x1E, 0x00, 0x20, 0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xE3,
  0xF8, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x01, 0xFF, 0x8F, 0xC0, 0x00, 0x7F,
  0xF1, 0xF8, 0x00, 0x3F, 0xFE, 0x3F, 0x00, 0x0F, 0xFF, 0xCF, 0xE0, 0x07,
  0xFF, 0xF9, 0xFC, 0x01, 0xFF, 0x7E, 0x3F, 0x00, 0xFF, 0x8F, 0xC7, 0xE0,
  0x3F, 0xE1, 0xF8, 0xFC, 0x0F, 0xF0, 0x3F, 0x1F, 0x87, 0xFC, 0x0F, 0xE7,
  0xF1, 0xFE, 0x01, 0xFC, 0xFE, 0xFF, 0x80, 0x3F, 0x1F, 0xBF, 0xC0, 0x07,
  0xE3, 0xFF, 0xF0, 0x00, 0xFC, 0x7F, 0xFC, 0x00, 0x1F, 0x8F, 0xFE, 0x00,
  0x07, 0xF1, 0xFF, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFB,
  0xF3, 0xFF, 0x1F, 0xBF, 0xC1, 0xFD, 0xF0, 0x0F, 0xCC, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xFF, 0x00, 0x00, 0x7E,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0xF8, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0x40, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x30, 0x00, 0x1F, 0xC3, 0xFF, 0x00, 0x1F, 0x8F, 0xFF, 0xC0, 0x1F,
  0xBF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFC, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFC, 0x3F, 0xE0, 0x01, 0xFC, 0x7F,
  0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x7E, 0x7F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x9F, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x0F,
  0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xF7,
  0xFE, 0x03, 0xFE, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x7F, 0xE3, 0xFC, 0x03, 0xFF, 0xC7, 0xFF, 0x7F, 0xFF, 0x07, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xF3, 0xF0, 0x03, 0xFF,
  0xC7, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1,
  0xFF, 0x81, 0xFE, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x7F, 0x81, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE0, 0x3F, 0x80, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xE0, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x40, 0x0F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x04, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x80,
  0x7F, 0xCF, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xF0,
  0x1E, 0x03, 0xE0, 0x3F, 0xFC, 0x1E, 0x07, 0xC0, 0x7F, 0xFC, 0x1E, 0x07,
  0x80, 0xFF, 0xFC, 0x1E, 0x0F, 0x81, 0xF8, 0x3C, 0x1E, 0x0F, 0x03, 0xE0,
  0x3C, 0x1E, 0x0F, 0x03, 0xE0, 0x38, 0x1E, 0x1F, 0x07, 0xC0, 0x78, 0x1E,
  0x1E, 0x07, 0x80, 0x78, 0x1E, 0x3E, 0x0F, 0x80, 0x78, 0x1E, 0x3C, 0x0F,
  0x00, 0x78, 0x1E, 0x3C, 0x1F, 0x00, 0xF0, 0x1E, 0x3C, 0x1F, 0x00, 0xF0,
  0x1E, 0x7C, 0x1E, 0x00, 0xF0, 0x1E, 0x78, 0x1E, 0x00, 0xF0, 0x1C, 0x78,
  0x1E, 0x01, 0xE0, 0x1C, 0x78, 0x3E, 0x01, 0xE0, 0x3C, 0x78, 0x3E, 0x01,
  0xE0, 0x3C, 0x78, 0x3C, 0x01, 0xE0, 0x38, 0xF8, 0x3C, 0x03, 0xC0, 0x78,
  0xF8, 0x3C, 0x03, 0xC0, 0x78, 0xF8, 0x3C, 0x07, 0xC0, 0x70, 0xF8, 0x3E,
  0x0F, 0xC0, 0xF0, 0xF8, 0x3E, 0x1F, 0xC1, 0xE0, 0xF8, 0x3F, 0xFF, 0xE3,
  0xE0, 0x78, 0x1F, 0xFB, 0xFF, 0xC0, 0x78, 0x1F, 0xF1, 0xFF, 0x80, 0x78,
  0x0F, 0xE0, 0xFF, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x03, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC,
  0x7C, 0x00, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x07, 0xF8,
  0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x0F,
  0xE3, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x7F, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x0F,
  0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x01,
  0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xF8, 0x01, 0xF8, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFC, 0x7E, 0x00, 0x1F, 0xFF, 0xE1,
  0xF8, 0x00, 0x7F, 0xFF, 0x87, 0xE0, 0x01, 0xFF, 0xFE, 0x1F, 0x80, 0x07,
  0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F,
  0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0xE0,
  0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x00, 0x7E,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xBF, 0x80, 0x00, 0x00, 0xFF, 0xE7,
  0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFB, 0xE0, 0x1F, 0xBF, 0x00, 0x7E,
  0xF8, 0x07, 0xEF, 0x80, 0x1F, 0xBE, 0x03, 0xF7, 0xE0, 0x07, 0xCF, 0x80,
  0xF9, 0xF8, 0x03, 0xF3, 0xE0, 0x7E, 0x7E, 0x00, 0xFC, 0xF8, 0x1F, 0x1F,
  0x80, 0x3F, 0x3F, 0x0F, 0xC7, 0xE0, 0x0F, 0xC7, 0xC3, 0xE3, 0xF0, 0x03,
  0xF1, 0xF1, 0xF8, 0xFC, 0x01, 0xF8, 0x7C, 0x7C, 0x3F, 0x00, 0x7E, 0x1F,
  0x3F, 0x0F, 0xC0, 0x1F, 0x87, 0xCF, 0x83, 0xF0, 0x07, 0xE1, 0xF7, 0xE1,
  0xF8, 0x01, 0xF8, 0x7F, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xFC, 0x1F, 0x80,
  0x3F, 0x83, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0xFF, 0x81, 0xF8, 0x03, 0xF0,
  0x3F, 0xC0, 0xFE, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xF8,
  0x0F, 0xC0, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xE0, 0x1F, 0xC0, 0x1F,
  0x80, 0x78, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x07,
  0xE0, 0x0F, 0xDF, 0x80, 0x07, 0xF0, 0x07, 0xEF, 0xC0, 0x03, 0xF8, 0x07,
  0xF7, 0xF0, 0x01, 0xFC, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0xFC,
  0x00, 0x7E, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F,
  0x80, 0x7F, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x87, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC1, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7F,
  0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0xFE,
  0x01, 0xFC, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x01, 0xF8, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0x80, 0x1F,
  0x8F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC7, 0xF0, 0x0F, 0xE0, 0x07, 0xF3, 0xF0,
  0x07, 0xF0, 0x01, 0xF9, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0xFC, 0x01, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0xFE, 0x00, 0x0F,
  0xFF, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x01, 0xFF, 0xC0,
  0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xFF, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x7E, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x01,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x00, 0xFF, 0x01, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x06, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x3F, 0x3F, 0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x78, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x0F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xF8, 0x07, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xE1,
  0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0x7F, 0x00, 0x7E,
  0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x3F, 0x00, 0xFF, 0x00, 0x7E, 0x3F, 0x00,
  0xFF, 0x00, 0xFC, 0x3F, 0x00, 0xFF, 0x00, 0xFC, 0x3F, 0x01, 0xFF, 0x00,
  0xFC, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x3F,
  0x03, 0xFF, 0x01, 0xF8, 0x3E, 0x03, 0xFF, 0x01, 0xF8, 0x3E, 0x03, 0xFF,
  0x03, 0xF0, 0x3E, 0x07, 0xFF, 0x03, 0xF0, 0x3E, 0x07, 0xDF, 0x03, 0xF0,
  0x3E, 0x07, 0xDF, 0x03, 0xF0, 0x3E, 0x0F, 0xDF, 0x07, 0xE0, 0x7E, 0x0F,
  0x9F, 0x07, 0xE0, 0x7E, 0x0F, 0x9F, 0x07, 0xE0, 0x7E, 0x0F, 0x9F, 0x07,
  0xC0, 0x7E, 0x1F, 0x1F, 0x0F, 0xC0, 0x7E, 0x1F, 0x1F, 0x0F, 0xC0, 0x7E,
  0x1F, 0x1F, 0x0F, 0xC0, 0x7E, 0x3E, 0x1F, 0x0F, 0x80, 0x7E, 0x3E, 0x1F,
  0x1F, 0x80, 0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0x7E, 0x7C, 0x1F, 0x1F, 0x80,
  0x7E, 0x7C, 0x1F, 0x1F, 0x00, 0x7E, 0x7C, 0x1F, 0x3F, 0x00, 0x7E, 0xF8,
  0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x1F, 0x3E, 0x00, 0x7C, 0xF8, 0x1F, 0x3E,
  0x00, 0x7D, 0xF0, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x1F, 0x7E, 0x00, 0x7D,
  0xF0, 0x1F, 0x7C, 0x00, 0x7F, 0xF0, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x1F,
  0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00,
  0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF3, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x1F,
  0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7E, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0xC3, 0xF0,
  0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x01,
  0xF0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x87, 0xF0, 0x03, 0xE1, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFF,
  0xE0, 0x00, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x07,
  0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8,
  0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x0F, 0xC1, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0xC1, 0xFC, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x0F, 0xFC, 0x1F, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF,
  0xFC, 0xFC, 0x01, 0xFF, 0xFC, 0x3F, 0x00, 0x3F, 0xFC, 0x0F, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x01, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0x3F, 0xFF, 0x80, 0x0F, 0xEF,
  0xFF, 0xF8, 0x01, 0xFB, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFE,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xFF, 0x00, 0x1F, 0xE0, 0x7F, 0xF8, 0x0F,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0x3F,
  0xFF, 0xF0, 0x07, 0xE3, 0xFF, 0xFC, 0x01, 0xF8, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x1F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8,
  0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x0F,
  0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0xFC, 0xFC,
  0x00, 0x7F, 0xFF, 0xFB, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8,
  0x07, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F,
  0xC0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x7E,
  0x00, 0x03, 0xFF, 0xF1, 0xF8, 0x00, 0x07, 0xFF, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xC1, 0xFC,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x1F, 0x9F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x08, 0x07,
  0xF0, 0x00, 0x07, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x01, 0xFC,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07,
  0xFE, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x0F, 0xC0, 0x03,
  0xFF, 0xF8, 0x7E, 0x00, 0x7F, 0xFF, 0xE7, 0xE0, 0x07, 0xFF, 0xFF, 0xBF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xC0,
  0x07, 0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00,
  0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x7F, 0x00, 0x01, 0xFF, 0xC3,
  0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x20, 0x00, 0x07, 0xF0,
  0x03, 0x00, 0x00, 0x3F, 0x80, 0x3C, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0xE1, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x01, 0xF8, 0x3F,
  0xF8, 0x00, 0x3F, 0x0F, 0xFF, 0xC0, 0x0F, 0xE7, 0xFF, 0xFC, 0x01, 0xF9,
  0xFF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0xFF, 0x80,
  0xFF, 0xC0, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x02,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x07, 0xE0,
  0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x7E, 0x07, 0xFC, 0x00, 0x01, 0xF8, 0x3F,
  0xE0, 0x00, 0x07, 0xE1, 0xFF, 0x00, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x00,
  0xFE, 0x7F, 0x80, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFD, 0xFC, 0x00, 0x00, 0x7F, 0xE7, 0xF8,
  0x00, 0x01, 0xFF, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x07, 0xE0,
  0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xFC, 0xFF, 0x83, 0xFE, 0x00, 0x7C, 0xFF, 0xE3, 0xFF, 0x80, 0x3E, 0xFF,
  0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x0F, 0xF0, 0x7F, 0xE0, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x3F,
  0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x0F, 0xC1, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x1F, 0x83, 0xF8, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x08, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xFF, 0x00, 0x07,
  0xC3, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xFF, 0xF8,
  0x07, 0xEF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xF0, 0x1F, 0xF8, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x01, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0xFF, 0xE0, 0x00, 0x1F, 0x1F,
  0xFF, 0xC0, 0x01, 0xF9, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0xFF, 0x80, 0x1F, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xF8, 0x01, 0xF9,
  0xFF, 0xFF, 0x80, 0x1F, 0xC7, 0xFF, 0xF0, 0x00, 0xFE, 0x0F, 0xFF, 0x00,
  0x07, 0xF0, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xFF, 0x3F, 0x80,
  0x7F, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xC0, 0x03, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F,
  0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xDF, 0x80, 0x07, 0xFF, 0xE7, 0xE0, 0x00, 0x7F, 0xF8, 0xFC,
  0x00, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xE0, 0x7F, 0xFC, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0x3F,
  0x3F, 0xFF, 0xE0, 0xFC, 0xFF, 0xFF, 0x81, 0xFB, 0xFF, 0xFF, 0x03, 0xFF,
  0xE0, 0x02, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0xFF,
  0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x07, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x1F,
  0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF8,
  0x7E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x07, 0xE0, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0x00, 0x7F,
  0xFF, 0xCF, 0xC0, 0x0F, 0xFF, 0xC3, 0xF0, 0x01, 0xFF, 0xE0, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x03, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0xF0, 0x01, 0xF0, 0x01,
  0xFB, 0xE0, 0x03, 0xE0, 0x03, 0xF7, 0xC0, 0x0F, 0xC0, 0x07, 0xCF, 0x80,
  0x1F, 0x80, 0x1F, 0x9F, 0x00, 0x3F, 0x00, 0x3F, 0x3E, 0x00, 0xFE, 0x00,
  0x7C, 0x7C, 0x01, 0xFE, 0x01, 0xF8, 0xF8, 0x07, 0xFC, 0x03, 0xE1, 0xF0,
  0x0F, 0x78, 0x07, 0xC3, 0xE0, 0x1E, 0xF0, 0x1F, 0x87, 0xC0, 0x7D, 0xE0,
  0x3E, 0x0F, 0x80, 0xF3, 0xC0, 0x7C, 0x1F, 0x03, 0xEF, 0x81, 0xF8, 0x3E,
  0x07, 0xDF, 0x03, 0xE0, 0x7C, 0x1F, 0x1E, 0x07, 0xC0, 0xF8, 0x3E, 0x3C,
  0x1F, 0x01, 0xF0, 0x7C, 0x78, 0x3E, 0x03, 0xE1, 0xF0, 0xF0, 0x7C, 0x07,
  0xC3, 0xE1, 0xE1, 0xF0, 0x0F, 0x8F, 0x83, 0xC3, 0xE0, 0x1F, 0x1F, 0x07,
  0xC7, 0x80, 0x3E, 0x3C, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x1F, 0x3E, 0x00,
  0xF9, 0xF0, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x7D, 0xF0, 0x01, 0xEF, 0x80,
  0xFB, 0xE0, 0x03, 0xDE, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x87, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x10, 0x0F,
  0xFF, 0xE0, 0x00, 0x1F, 0x1F, 0xFF, 0xF8, 0x00, 0x1E, 0x3F, 0xFF, 0xFC,
  0x00, 0x3E, 0x3F, 0xFF, 0xFE, 0x00, 0x3E, 0x7F, 0x01, 0xFF, 0x00, 0x7E,
  0x7E, 0x00, 0xFF, 0xC1, 0xFC, 0x7C, 0x00, 0x7F, 0xFF, 0xFC, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x78, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
};

const GFXglyph RobotoMono_Italic72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 16, 51, 42, 13, -51 },
  { 103, 20, 17, 42, 15, -54 },
  { 146, 42, 51, 42, 1, -51 },
  { 414, 36, 66, 42, 4, -59 },
  { 711, 34, 53, 42, 5, -52 },
  { 937, 38, 53, 42, 2, -52 },
  { 1189, 8, 17, 42, 19, -54 },
  { 1206, 24, 75, 42, 11, -58 },
  { 1431, 24, 75, 42, 6, -58 },
  { 1656, 32, 34, 42, 8, -51 },
  { 1792, 35, 37, 42, 4, -42 },
  { 1954, 13, 20, 42, 7, -8 },
  { 1987, 27, 5, 42, 7, -25 },
  { 2004, 10, 10, 42, 14, -9 },
  { 2017, 36, 55, 42, 4, -51 },
  { 2265, 35, 53, 42, 4, -52 },
  { 2497, 21, 51, 42, 10, -51 },
  { 2631, 36, 52, 42, 1, -52 },
  { 2865, 35, 53, 42, 2, -52 },
  { 3097, 37, 51, 42, 1, -51 },
  { 3333, 36, 52, 42, 5, -51 },
  { 3567, 32, 52, 42, 4, -51 },
  { 3775, 35, 51, 42, 7, -51 },
  { 3999, 36, 53, 42, 4, -52 },
  { 4238, 31, 52, 42, 7, -52 },
  { 4440, 15, 41, 42, 16, -40 },
  { 4517, 20, 52, 42, 11, -40 },
  { 4647, 32, 32, 42, 6, -39 },
  { 4775, 34, 20, 42, 4, -33 },
  { 4860, 33, 32, 42, 4, -39 },
  { 4992, 29, 53, 42, 10, -52 },
  { 5185, 40, 51, 42, 2, -51 },
  { 5440, 37, 51, 42, -1, -51 },
  { 5676, 38, 51, 42, 2, -51 },
  { 5919, 37, 53, 42, 4, -52 },
  { 6165, 38, 51, 42, 2, -51 },
  { 6408, 39, 51, 42, 3, -51 },
  { 6657, 39, 51, 42, 3, -51 },
  { 6906, 38, 53, 42, 3, -52 },
  { 7158, 41, 51, 42, 1, -51 },
  { 7420, 39, 51, 42, 2, -51 },
  { 7669, 39, 52, 42, 2, -51 },
  { 7923, 43, 51, 42, 2, -51 },
  { 8198, 32, 51, 42, 3, -51 },
  { 8402, 42, 51, 42, 1, -51 },
  { 8670, 41, 51, 42, 1, -51 },
  { 8932, 36, 53, 42, 4, -52 },
  { 9171, 39, 51, 42, 3, -51 },
  { 9420, 37, 61, 42, 3, -52 },
  { 9703, 38, 51, 42, 2, -51 },
  { 9946, 38, 53, 42, 3, -52 },
  { 10198, 38, 51, 42, 7, -51 },
  { 10441, 38, 52, 42, 4, -51 },
  { 10688, 37, 51, 42, 7, -51 },
  { 10924, 40, 51, 42, 5, -51 },
  { 11179, 45, 51, 42, -1, -51 },
  { 11466, 37, 51, 42, 7, -51 },
  { 11702, 40, 51, 42, 1, -51 },
  { 11957, 25, 70, 42, 9, -59 },
  { 12176, 17, 55, 42, 13, -51 },
  { 12293, 24, 70, 42, 9, -59 },
  { 12503, 26, 27, 42, 8, -51 },
  { 12591, 32, 5, 42, 1, 0 },
  { 12611, 12, 9, 42, 19, -52 },
  { 12625, 34, 40, 42, 3, -39 },
  { 12795, 35, 55, 42, 2, -54 },
  { 13036, 34, 40, 42, 4, -39 },
  { 13206, 38, 55, 42, 4, -54 },
  { 13468, 34, 40, 42, 4, -39 },
  { 13638, 37, 56, 42, 7, -56 },
  { 13897, 37, 54, 42, 2, -39 },
  { 14147, 35, 54, 42, 2, -54 },
  { 14384, 32, 52, 42, 3, -52 },
  { 14592, 33, 67, 42, 1, -52 },
  { 14869, 38, 54, 42, 2, -54 },
  { 15126, 32, 54, 42, 3, -54 },
  { 15342, 41, 39, 42, -1, -39 },
  { 15542, 35, 39, 42, 2, -39 },
  { 15713, 35, 40, 42, 3, -39 },
  { 15888, 37, 54, 42, 0, -39 },
  { 16138, 35, 54, 42, 4, -39 },
  { 16375, 31, 39, 42, 8, -39 },
  { 16527, 33, 40, 42, 4, -39 },
  { 16692, 31, 48, 42, 7, -47 },
  { 16878, 34, 39, 42, 5, -38 },
  { 17044, 35, 38, 42, 6, -38 },
  { 17211, 39, 38, 42, 5, -38 },
  { 17397, 41, 38, 42, 0, -38 },
  { 17592, 44, 53, 42, -1, -38 },
  { 17884, 36, 38, 42, 2, -38 },
  { 18055, 28, 69, 42, 11, -56 },
  { 18297, 15, 65, 42, 13, -51 },
  { 18419, 28, 69, 42, 6, -56 },
  { 18661, 40, 14, 42, 1, -28 },
};

const GFXfont RobotoMono_Italic72pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic72pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic72pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _ROBOTOMONO_ITALIC72PT7B_H_
