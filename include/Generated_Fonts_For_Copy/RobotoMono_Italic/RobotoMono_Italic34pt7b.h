#ifndef _ROBOTOMONO_ITALIC34PT7B_H_
#define _ROBOTOMONO_ITALIC34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic34pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF0,
  0x70, 0x71, 0xB0, 0xD8, 0x6C, 0x76, 0x3F, 0x1B, 0x0D, 0x86, 0x00, 0x38,
  0x60, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x07, 0x0C, 0x00, 0x61, 0xC0, 0x0E,
  0x18, 0x00, 0xE1, 0x81, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x18, 0x30, 0x01,
  0x87, 0x00, 0x38, 0x60, 0x03, 0x0E, 0x00, 0x30, 0xE0, 0x07, 0x0C, 0x07,
  0xFF, 0xFC, 0x7F, 0xFF, 0x88, 0xE1, 0x80, 0x0C, 0x38, 0x01, 0xC3, 0x00,
  0x18, 0x30, 0x01, 0x87, 0x00, 0x38, 0x60, 0x03, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x3C,
  0x3C, 0x3C, 0x0E, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xE3, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0,
  0x3C, 0x70, 0x1C, 0x3E, 0x3E, 0x0F, 0xFE, 0x03, 0xFC, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x04, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x61, 0x80,
  0xE1, 0x86, 0xE1, 0x8E, 0xE1, 0x8C, 0xE3, 0x98, 0xE3, 0x38, 0x7F, 0x30,
  0x3E, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x07, 0x3E,
  0x06, 0x7F, 0x0C, 0xE3, 0x1C, 0xC3, 0x38, 0xC3, 0x31, 0xC3, 0x11, 0xC3,
  0x00, 0xC7, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x20, 0x00, 0x7E, 0x00, 0x3F,
  0xC0, 0x1E, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x78,
  0x0E, 0x3C, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x07,
  0xF0, 0x03, 0xDC, 0x1D, 0xE3, 0x86, 0x70, 0xF3, 0xBC, 0x1C, 0xEE, 0x07,
  0xF3, 0x80, 0xFC, 0xE0, 0x1E, 0x3C, 0x0F, 0x87, 0x8F, 0xE0, 0xFF, 0xFC,
  0x1F, 0xC7, 0x80, 0x77, 0x76, 0x66, 0xEE, 0x00, 0x20, 0x0F, 0x01, 0xE0,
  0x3C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x04, 0x00,
  0x04, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x02, 0x00,
  0x00, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x04, 0x18, 0x3C, 0x31,
  0xFF, 0xFF, 0xBF, 0xFF, 0x0F, 0xE0, 0x0F, 0x00, 0x3F, 0x00, 0xEE, 0x03,
  0x8E, 0x0E, 0x1C, 0x3C, 0x1C, 0x10, 0x20, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x71,
  0xCF, 0x3C, 0xE7, 0x9C, 0xE0, 0x80, 0x7F, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x00, 0x00, 0x40, 0x03,
  0xFC, 0x07, 0xFE, 0x0F, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x38, 0x03, 0x38,
  0x03, 0x70, 0x07, 0x70, 0x1F, 0x70, 0x3F, 0x70, 0xFF, 0x71, 0xE7, 0x77,
  0xC7, 0xEF, 0x07, 0xFE, 0x0E, 0xF8, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0x70, 0x38, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00,
  0xC1, 0xF3, 0xFB, 0xFE, 0xF3, 0xB0, 0xE0, 0x38, 0x0E, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x00, 0x20, 0x00, 0xFF, 0x01, 0xFF, 0xC1,
  0xE0, 0xF0, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x00, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x00, 0x00,
  0x60, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xE1, 0xE1, 0xC0, 0x70, 0xE0, 0x38,
  0xE0, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x7F,
  0x80, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x81, 0xE1, 0xE1, 0xE0,
  0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0x70, 0x03, 0x9C, 0x01,
  0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x0E, 0x07, 0x03,
  0x83, 0x80, 0xE0, 0xE0, 0x38, 0x7F, 0xFF, 0xDF, 0xFF, 0xF8, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xF8, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1D, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xC0,
  0xF0, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x8E, 0x00, 0xE1, 0xC0, 0x78, 0x70, 0x3C, 0x1E, 0x1E,
  0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x39, 0xE0, 0xEF, 0xF1,
  0xFF, 0xF3, 0xE1, 0xE7, 0x01, 0xDE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x77, 0x80, 0xE7, 0x03, 0x8F, 0x1F, 0x0F, 0xFC,
  0x0F, 0xE0, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x01, 0xFF, 0x81,
  0xE1, 0xE0, 0xE0, 0x70, 0xE0, 0x3C, 0x70, 0x0E, 0x38, 0x0F, 0x1C, 0x07,
  0x0E, 0x03, 0x87, 0x83, 0x81, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xC0, 0xF0,
  0x70, 0xF0, 0x1C, 0x70, 0x0E, 0x78, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x01, 0xE3, 0x80, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0, 0x1F, 0xE0, 0x00, 0x00,
  0x80, 0x0F, 0xE0, 0x7F, 0xE1, 0xF1, 0xE3, 0x81, 0xCE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xF7, 0x01, 0xEF,
  0x07, 0x8F, 0xFF, 0x1F, 0xEE, 0x0F, 0x98, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x7C, 0x1F, 0xE0, 0x3F, 0x80, 0x7C, 0x00, 0x1E, 0x1F,
  0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF8, 0xF8, 0x78, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0x03, 0x80, 0x20,
  0x00, 0x00, 0x06, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x3E, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x0F, 0x80, 0x06, 0x00, 0x02, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFE,
  0xFF, 0xFE, 0x30, 0x00, 0x78, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0x07, 0xF8,
  0x0F, 0x80, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x01, 0x00, 0xFF, 0x0F, 0xFC,
  0xF0, 0xFF, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x38, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1E, 0x0E, 0x07, 0x00, 0xE0, 0xC0, 0x0C,
  0x30, 0xF9, 0x8E, 0x3F, 0x31, 0x8C, 0x62, 0x73, 0x0C, 0x4C, 0x61, 0x89,
  0x98, 0x61, 0x33, 0x0C, 0x6C, 0x61, 0x8D, 0x8C, 0x31, 0xB1, 0x8C, 0x26,
  0x31, 0x8C, 0xC7, 0xF3, 0x18, 0xFB, 0xE3, 0x8C, 0x30, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x40, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1D, 0xC0, 0x07,
  0x70, 0x01, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x30, 0x07, 0x0C,
  0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xE1, 0xC0, 0x38, 0x70, 0x06, 0x38, 0x01, 0xCE, 0x00, 0x77, 0x00,
  0x1F, 0xC0, 0x07, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xE1, 0xF8, 0x38, 0x0E,
  0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x0E, 0x1C, 0x03, 0x87,
  0x03, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xFE, 0x0E, 0x03, 0xC3, 0x80,
  0x70, 0xE0, 0x1C, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x3C,
  0x70, 0x1E, 0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x20, 0x01,
  0xFE, 0x01, 0xFF, 0x81, 0xE1, 0xE1, 0xC0, 0x71, 0xC0, 0x1C, 0xE0, 0x0E,
  0xE0, 0x07, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x81, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x01, 0xE3, 0xF0, 0x70, 0x1C,
  0x1C, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x1C, 0x70, 0x07, 0x3C, 0x01, 0xCE,
  0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x39, 0xC0, 0x0E, 0x70, 0x07, 0x9C, 0x01, 0xC7, 0x00, 0xE1, 0xC0, 0x78,
  0xE0, 0x3C, 0x38, 0xFE, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xE1,
  0xFF, 0xF8, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0x03, 0xFF,
  0xE0, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x20, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xE1, 0xE1,
  0xC0, 0x71, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x03, 0xFB, 0x83, 0xFD, 0xC1,
  0xFE, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCF, 0x00, 0xE3,
  0x80, 0xF1, 0xF1, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x0E, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0, 0x1C, 0x38, 0x03, 0x86,
  0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0xFF, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0xE0, 0x07, 0x1C, 0x00, 0xC3, 0x80, 0x38, 0x70,
  0x07, 0x0C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x61, 0xC0,
  0x1C, 0x38, 0x03, 0x86, 0x00, 0x70, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF,
  0xFC, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0xC0, 0x78, 0x70, 0x3C, 0x1F,
  0x3E, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E,
  0x03, 0xC0, 0xE0, 0x78, 0x1C, 0x0F, 0x01, 0xC1, 0xE0, 0x1C, 0x3C, 0x01,
  0xC7, 0x80, 0x1C, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x03, 0xFC, 0x00,
  0x3F, 0xE0, 0x03, 0xEE, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x70, 0x78,
  0x07, 0x03, 0x80, 0x70, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x0F, 0x00,
  0xE0, 0xE0, 0x0F, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x83,
  0xF1, 0xF0, 0x7C, 0x3E, 0x1D, 0x86, 0xC3, 0xF0, 0xDC, 0xEE, 0x3B, 0x9D,
  0xC7, 0x77, 0x38, 0xE6, 0xE6, 0x1C, 0xF9, 0xC3, 0x9F, 0x38, 0xE3, 0xC7,
  0x1C, 0x78, 0xE3, 0x8E, 0x18, 0x71, 0xC7, 0x0E, 0x00, 0xE1, 0xC0, 0x1C,
  0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0C, 0x38, 0x03, 0x87, 0x00, 0x70,
  0x0E, 0x00, 0xE3, 0xC0, 0x1C, 0x7C, 0x07, 0x8F, 0x80, 0xE1, 0xF0, 0x1C,
  0x3F, 0x03, 0x87, 0xE0, 0x71, 0xFC, 0x0E, 0x39, 0xC3, 0x87, 0x38, 0x70,
  0xE7, 0x0E, 0x1C, 0x71, 0xC3, 0x8E, 0x38, 0xE1, 0xC7, 0x1C, 0x1D, 0xC3,
  0x83, 0xB8, 0x70, 0x77, 0x0E, 0x07, 0xE1, 0xC0, 0xFC, 0x70, 0x1F, 0x8E,
  0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0x70, 0x00, 0x20, 0x01,
  0xFC, 0x01, 0xFF, 0x81, 0xE3, 0xC1, 0xC0, 0x71, 0xE0, 0x38, 0xE0, 0x0E,
  0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x37, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x07, 0x38,
  0x03, 0x9C, 0x03, 0xCE, 0x01, 0xC3, 0x81, 0xC1, 0xF3, 0xE0, 0x7F, 0xE0,
  0x1F, 0xC0, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF0, 0x38, 0x3E, 0x07, 0x00,
  0xE0, 0xE0, 0x1C, 0x1C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0E, 0x07, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x20, 0x01, 0xFE, 0x01, 0xFF, 0x81, 0xE3, 0xC1, 0xC0, 0x71, 0xC0,
  0x38, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0x70, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC3, 0x81, 0xC1, 0xF3,
  0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xE0, 0xF8, 0x38, 0x0E, 0x0E,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0xE1, 0xC0, 0x78, 0xE0, 0xFC, 0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x70,
  0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x3C, 0x00, 0x10, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3E, 0x1E, 0x0E, 0x03, 0xC7, 0x80, 0x71, 0xC0, 0x1C,
  0x70, 0x07, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xEE, 0x00, 0x7B, 0xC0, 0x1C, 0x70, 0x07, 0x1E, 0x03, 0xC3, 0xE3, 0xE0,
  0x7F, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x01, 0xC7, 0x00, 0x71,
  0xC0, 0x1C, 0x60, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0xE0,
  0x0E, 0x38, 0x03, 0x8E, 0x01, 0xE3, 0x80, 0x70, 0x70, 0x3C, 0x1E, 0x3E,
  0x03, 0xFF, 0x00, 0x7F, 0x00, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x79,
  0xC0, 0x1C, 0x70, 0x0F, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x3C,
  0x01, 0x8E, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x70,
  0x70, 0xEE, 0x1E, 0x1D, 0xC3, 0xC3, 0xB8, 0x78, 0xE7, 0x1F, 0x1C, 0xE3,
  0xE3, 0x9C, 0x7C, 0x63, 0x9F, 0x9C, 0x73, 0xF3, 0x8E, 0x6E, 0x71, 0xDD,
  0xCC, 0x3B, 0xBB, 0x87, 0x67, 0x70, 0xCC, 0xEE, 0x1B, 0x8D, 0x83, 0x61,
  0xF0, 0x6C, 0x3E, 0x0F, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83,
  0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0x0E, 0x00, 0x78, 0x38,
  0x07, 0x81, 0xC0, 0x78, 0x0F, 0x03, 0x80, 0x38, 0x3C, 0x01, 0xC3, 0xC0,
  0x07, 0x1C, 0x00, 0x39, 0xC0, 0x01, 0xDE, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x73, 0x80, 0x07, 0x9C, 0x00, 0x78, 0xE0, 0x03, 0x83, 0x80, 0x3C, 0x1C,
  0x03, 0xC0, 0xF0, 0x1C, 0x03, 0x81, 0xE0, 0x1E, 0x1E, 0x00, 0x70, 0xE0,
  0x07, 0xF0, 0x07, 0xBC, 0x03, 0x8E, 0x03, 0xC7, 0x01, 0xC3, 0x81, 0xC0,
  0xE1, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0xF0, 0x07, 0x70, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF8, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE0, 0xFE,
  0x00, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30, 0x30, 0x38, 0x38, 0x38,
  0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x06,
  0x07, 0x07, 0x07, 0x07, 0xF0, 0x7F, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x30,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0x80, 0x3C, 0x03, 0xC0, 0x7C, 0x06,
  0xC0, 0xEE, 0x1C, 0xE1, 0xCE, 0x38, 0x63, 0x87, 0x70, 0x77, 0x07, 0xE0,
  0x30, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xF1, 0xC3, 0x8E, 0x1C, 0x07,
  0xF0, 0x3F, 0xF8, 0xF8, 0xF9, 0xC0, 0x77, 0x80, 0xE0, 0x01, 0xC0, 0x03,
  0x83, 0xFF, 0x1F, 0xFE, 0xFC, 0x1B, 0xC0, 0x77, 0x00, 0xEE, 0x01, 0xDC,
  0x07, 0xB8, 0x1F, 0x7C, 0xFE, 0x7F, 0xDC, 0x7E, 0x38, 0x07, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0xFC, 0x0F, 0xFF, 0x07, 0xE7, 0xC3, 0xC1, 0xE3, 0xC0,
  0x71, 0xC0, 0x38, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0xF3, 0x80, 0x71, 0xE0, 0x78, 0xF8, 0xF8,
  0xEF, 0xF8, 0x73, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xFC, 0x1E, 0x3E, 0x3C,
  0x0E, 0x38, 0x07, 0x70, 0x07, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x3C, 0x78,
  0x78, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x07,
  0xE7, 0x03, 0xFF, 0xC1, 0xE3, 0xF0, 0xF0, 0x3C, 0x78, 0x0F, 0x1C, 0x03,
  0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x70, 0xE0, 0x1C, 0x38, 0x07, 0x07, 0x03, 0xC1, 0xF3, 0xF0, 0x3F,
  0xD8, 0x07, 0xEE, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1E, 0x3C, 0x3C, 0x0E,
  0x78, 0x0E, 0x70, 0x07, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x08, 0x70, 0x1C, 0x7C, 0x7C,
  0x3F, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x0F, 0x18, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x7F, 0xFE,
  0x1F, 0xFF, 0x88, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xF3, 0x83, 0xFF, 0xC3, 0xC7, 0xE3, 0xC0, 0xF3,
  0xC0, 0x79, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03,
  0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x70, 0xE0, 0x78, 0x7C,
  0xFC, 0x1F, 0xEE, 0x07, 0xEE, 0x00, 0x07, 0x00, 0x03, 0x84, 0x03, 0xC7,
  0x03, 0xC3, 0xE7, 0xC0, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0xFC, 0x0E, 0xFF, 0x07, 0xE7, 0xC3, 0xC0, 0xE3, 0xC0,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C,
  0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x39, 0xE0, 0x1C,
  0xE0, 0x0E, 0x70, 0x0F, 0x00, 0x00, 0x20, 0x00, 0xE0, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFC, 0x00, 0x04, 0x00, 0x1C, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x10, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x07,
  0xC7, 0x03, 0xC1, 0xC1, 0xE0, 0x70, 0xF0, 0x38, 0x78, 0x0E, 0x7C, 0x03,
  0xBC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xDE, 0x01, 0xE3,
  0x80, 0x70, 0x70, 0x1C, 0x1E, 0x07, 0x03, 0x81, 0xC0, 0xF0, 0xE0, 0x1C,
  0x38, 0x07, 0x80, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x83, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFD, 0xFF, 0xF8, 0x1F, 0xE7, 0xC3, 0xFF, 0xF8, 0xF3, 0xE7, 0x9C,
  0x38, 0x73, 0x87, 0x0E, 0x70, 0xE1, 0xCE, 0x1C, 0x39, 0x83, 0x06, 0x70,
  0xE1, 0xCE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0x70, 0xE7, 0x0E, 0x1C, 0xC1,
  0x83, 0x38, 0x70, 0xE7, 0x0E, 0x1C, 0xE1, 0xC3, 0x9C, 0x38, 0x70, 0x1C,
  0xFC, 0x0E, 0xFF, 0x07, 0xE7, 0xC3, 0xC0, 0xE3, 0xC0, 0x71, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xE7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E, 0x70,
  0x0F, 0x00, 0x07, 0xF0, 0x0F, 0xFC, 0x1E, 0x3C, 0x38, 0x0E, 0x78, 0x0E,
  0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0x70, 0x3C, 0x78, 0xF8, 0x3F, 0xF0,
  0x1F, 0xC0, 0x0E, 0xFE, 0x07, 0xFF, 0x83, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x3C, 0xFC, 0x7C,
  0x77, 0xFC, 0x39, 0xFC, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xF7, 0x0F, 0xFF,
  0x1E, 0x3F, 0x3C, 0x0F, 0x78, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0x70, 0x3C, 0x78, 0xFC, 0x3F, 0xF8, 0x1F, 0xB8, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x1C, 0xFE,
  0x77, 0xF8, 0xFF, 0xF1, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x07, 0xF8, 0x0F, 0xFC,
  0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x0F, 0x38, 0x00, 0x38, 0x00, 0x1F, 0x00,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1C, 0xE0, 0x0E, 0xE0, 0x1C,
  0xF0, 0x1C, 0x78, 0x7C, 0x3F, 0xF8, 0x1F, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x80, 0xFF, 0x80,
  0xFE, 0x00, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x3C, 0x78, 0xFC, 0x3F, 0xDC,
  0x1F, 0x98, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0x70, 0x1E, 0x70, 0x1C,
  0x70, 0x38, 0x70, 0x38, 0x30, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x38, 0xE0,
  0x19, 0xC0, 0x19, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0xE0, 0xC0, 0xFC, 0x18, 0x3B, 0x87, 0x07, 0x70, 0xF0, 0xCE,
  0x3E, 0x39, 0xC6, 0xC7, 0x38, 0xD8, 0xC7, 0x3B, 0x38, 0xE6, 0x66, 0x1D,
  0xCC, 0xC1, 0xB1, 0xB8, 0x36, 0x36, 0x07, 0x86, 0xC0, 0xF0, 0xF8, 0x1E,
  0x1E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x0C, 0x0E, 0x00, 0x1E, 0x01, 0xF0,
  0xE0, 0x1C, 0x07, 0x03, 0x80, 0x70, 0x70, 0x03, 0x8F, 0x00, 0x39, 0xE0,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3B, 0x80, 0x07, 0xBC, 0x00, 0xF1, 0xC0, 0x1E, 0x1E, 0x03, 0xC0,
  0xE0, 0x78, 0x07, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x1C,
  0x01, 0xE1, 0xE0, 0x1C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00,
  0x70, 0xF0, 0x07, 0x0E, 0x00, 0x71, 0xC0, 0x07, 0x1C, 0x00, 0x3B, 0x80,
  0x03, 0xB8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0xBE, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x8F,
  0xFF, 0xC7, 0xFF, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x7F, 0xFF, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0x80, 0x06, 0x0C, 0x38, 0x70, 0xE1, 0x83,
  0x06, 0x0C, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0x83,
  0x06, 0x1C, 0x38, 0x60, 0xC1, 0x83, 0x0E, 0x1C, 0x38, 0x00, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0xE0, 0x0F,
  0x00, 0xF8, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x03, 0xC0,
  0x1C, 0x00, 0x1F, 0x80, 0x47, 0xF8, 0x0D, 0xE7, 0x83, 0xB8, 0x7C, 0xE6,
  0x03, 0xFD, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_Italic34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 8, 24, 20, 6, -24 },
  { 25, 9, 8, 20, 7, -26 },
  { 34, 20, 24, 20, 0, -24 },
  { 94, 17, 31, 20, 2, -28 },
  { 160, 16, 25, 20, 2, -25 },
  { 210, 18, 25, 20, 1, -25 },
  { 267, 4, 8, 20, 9, -26 },
  { 271, 12, 35, 20, 5, -27 },
  { 324, 11, 35, 20, 3, -27 },
  { 373, 15, 16, 20, 4, -24 },
  { 403, 17, 18, 20, 2, -20 },
  { 442, 6, 10, 20, 3, -4 },
  { 450, 13, 3, 20, 3, -12 },
  { 455, 4, 4, 20, 7, -4 },
  { 457, 17, 26, 20, 2, -24 },
  { 513, 16, 25, 20, 2, -25 },
  { 563, 10, 24, 20, 5, -24 },
  { 593, 17, 25, 20, 0, -25 },
  { 647, 17, 25, 20, 1, -25 },
  { 701, 18, 24, 20, 0, -24 },
  { 755, 18, 24, 20, 2, -24 },
  { 809, 15, 24, 20, 2, -24 },
  { 854, 17, 24, 20, 3, -24 },
  { 905, 17, 25, 20, 2, -25 },
  { 959, 15, 25, 20, 3, -25 },
  { 1006, 8, 19, 20, 7, -19 },
  { 1025, 10, 25, 20, 5, -19 },
  { 1057, 15, 15, 20, 3, -18 },
  { 1086, 16, 10, 20, 2, -16 },
  { 1106, 15, 15, 20, 2, -18 },
  { 1135, 13, 25, 20, 5, -25 },
  { 1176, 19, 24, 20, 1, -24 },
  { 1233, 18, 24, 20, -1, -24 },
  { 1287, 18, 24, 20, 1, -24 },
  { 1341, 17, 25, 20, 2, -25 },
  { 1395, 18, 24, 20, 1, -24 },
  { 1449, 19, 24, 20, 1, -24 },
  { 1506, 19, 24, 20, 1, -24 },
  { 1563, 17, 25, 20, 2, -25 },
  { 1617, 19, 24, 20, 1, -24 },
  { 1674, 18, 24, 20, 1, -24 },
  { 1728, 18, 24, 20, 1, -24 },
  { 1782, 20, 24, 20, 1, -24 },
  { 1842, 15, 24, 20, 1, -24 },
  { 1887, 19, 24, 20, 1, -24 },
  { 1944, 19, 24, 20, 1, -24 },
  { 2001, 17, 25, 20, 2, -25 },
  { 2055, 19, 24, 20, 1, -24 },
  { 2112, 17, 29, 20, 2, -25 },
  { 2174, 18, 24, 20, 1, -24 },
  { 2228, 18, 25, 20, 1, -25 },
  { 2285, 18, 24, 20, 3, -24 },
  { 2339, 18, 24, 20, 2, -24 },
  { 2393, 18, 24, 20, 3, -24 },
  { 2447, 19, 24, 20, 2, -24 },
  { 2504, 21, 24, 20, 0, -24 },
  { 2567, 17, 24, 20, 4, -24 },
  { 2618, 19, 24, 20, 0, -24 },
  { 2675, 12, 33, 20, 4, -28 },
  { 2725, 8, 26, 20, 6, -24 },
  { 2751, 12, 33, 20, 4, -28 },
  { 2801, 12, 13, 20, 4, -24 },
  { 2821, 16, 3, 20, 0, 0 },
  { 2827, 6, 5, 20, 9, -25 },
  { 2831, 15, 18, 20, 2, -18 },
  { 2865, 17, 26, 20, 1, -26 },
  { 2921, 16, 18, 20, 2, -18 },
  { 2957, 18, 26, 20, 2, -26 },
  { 3016, 16, 18, 20, 2, -18 },
  { 3052, 18, 26, 20, 3, -26 },
  { 3111, 17, 25, 20, 1, -18 },
  { 3165, 17, 26, 20, 1, -26 },
  { 3221, 15, 25, 20, 2, -25 },
  { 3268, 15, 32, 20, 1, -25 },
  { 3328, 18, 26, 20, 1, -26 },
  { 3387, 15, 26, 20, 2, -26 },
  { 3436, 19, 18, 20, 0, -18 },
  { 3479, 17, 18, 20, 1, -18 },
  { 3518, 16, 18, 20, 2, -18 },
  { 3554, 17, 25, 20, 0, -18 },
  { 3608, 16, 25, 20, 2, -18 },
  { 3658, 15, 18, 20, 4, -18 },
  { 3692, 16, 18, 20, 2, -18 },
  { 3728, 15, 22, 20, 3, -22 },
  { 3770, 16, 18, 20, 2, -18 },
  { 3806, 16, 18, 20, 3, -18 },
  { 3842, 19, 18, 20, 2, -18 },
  { 3885, 20, 18, 20, 0, -18 },
  { 3930, 20, 25, 20, 0, -18 },
  { 3993, 17, 18, 20, 1, -18 },
  { 4032, 13, 33, 20, 5, -27 },
  { 4086, 7, 31, 20, 6, -24 },
  { 4114, 13, 32, 20, 3, -26 },
  { 4166, 19, 6, 20, 0, -13 },
};

const GFXfont RobotoMono_Italic34pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic34pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _ROBOTOMONO_ITALIC34PT7B_H_
