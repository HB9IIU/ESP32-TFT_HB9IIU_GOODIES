#ifndef _ROBOTOMONO_ITALIC8PT7B_H_
#define _ROBOTOMONO_ITALIC8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic8pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x20, 0xF0, 0x29, 0x96, 0xAE, 0x50, 0x13, 0x54, 0x39, 0x74,
  0x9F, 0x2E, 0xC0, 0x25, 0x67, 0xB7, 0xC0, 0x2A, 0x49, 0x22, 0x55, 0x5A,
  0x5D, 0x50, 0x22, 0xF2, 0xC0, 0xE0, 0x80, 0x11, 0x22, 0x4C, 0x35, 0x57,
  0x96, 0x39, 0x24, 0x80, 0x25, 0x12, 0x4F, 0x35, 0x13, 0x9E, 0x13, 0x55,
  0xF2, 0x78, 0xC2, 0xAE, 0x34, 0x69, 0x96, 0xF2, 0x24, 0x48, 0x35, 0x57,
  0x97, 0x76, 0xF3, 0x80, 0x90, 0x41, 0x80, 0x71, 0x80, 0x70, 0xF0, 0x61,
  0xE0, 0x74, 0xA1, 0x00, 0x33, 0x77, 0xDD, 0x30, 0x22, 0x55, 0x79, 0x75,
  0x57, 0x9F, 0x32, 0x61, 0x09, 0x30, 0x65, 0x59, 0x9E, 0x7A, 0x10, 0xE8,
  0x78, 0x7A, 0x10, 0xE8, 0x40, 0x32, 0x61, 0x69, 0x38, 0x4A, 0x55, 0x69,
  0x48, 0x79, 0x08, 0x42, 0x78, 0x08, 0x84, 0x29, 0x30, 0x4A, 0x98, 0xCA,
  0x48, 0x44, 0x44, 0x8F, 0x4A, 0xD5, 0x69, 0x48, 0x4A, 0x5D, 0x69, 0x48,
  0x35, 0x99, 0x96, 0x72, 0x52, 0xE8, 0x40, 0x35, 0x99, 0x96, 0x10, 0x72,
  0x54, 0xC9, 0x48, 0x32, 0x50, 0x69, 0x38, 0xF4, 0x44, 0x44, 0x4A, 0x55,
  0x29, 0x30, 0x9A, 0xAA, 0xC4, 0xDD, 0xDE, 0xAA, 0x4A, 0x88, 0x45, 0x48,
  0x9A, 0xA4, 0x48, 0x78, 0x88, 0x44, 0x78, 0x69, 0x29, 0x26, 0x95, 0x50,
  0x64, 0xA4, 0x96, 0x4A, 0x80, 0xF0, 0x80, 0x77, 0x97, 0x44, 0x75, 0x9E,
  0x78, 0x87, 0x08, 0x9D, 0x29, 0x38, 0x7F, 0x87, 0x74, 0xE4, 0x88, 0x79,
  0x97, 0x96, 0x44, 0x75, 0x99, 0x10, 0x62, 0x2F, 0x10, 0x72, 0x22, 0x2C,
  0x44, 0x56, 0xA9, 0x72, 0x22, 0x2F, 0xFB, 0xBB, 0x75, 0x99, 0x79, 0x96,
  0x75, 0x9E, 0x88, 0x79, 0x97, 0x12, 0xF2, 0x40, 0x76, 0x97, 0x5E, 0x46,
  0xB6, 0xF0, 0xBA, 0xC4, 0xDE, 0xAA, 0x59, 0x19, 0x20, 0x5A, 0x98, 0x44,
  0x40, 0x72, 0x4F, 0x29, 0x44, 0x90, 0x55, 0x5A, 0x49, 0x14, 0xA0, 0xF8,
};

const GFXglyph RobotoMono_Italic8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 1, -6 },
  { 3, 2, 2, 5, 2, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 0, -7 },
  { 12, 3, 6, 5, 1, -6 },
  { 15, 4, 6, 5, 0, -6 },
  { 18, 1, 2, 5, 2, -6 },
  { 19, 3, 8, 5, 1, -6 },
  { 22, 2, 8, 5, 1, -6 },
  { 24, 3, 4, 5, 1, -6 },
  { 26, 4, 4, 5, 0, -5 },
  { 28, 1, 2, 5, 1, -1 },
  { 29, 3, 1, 5, 1, -3 },
  { 30, 1, 1, 5, 2, -1 },
  { 31, 4, 6, 5, 0, -6 },
  { 34, 4, 6, 5, 0, -6 },
  { 37, 3, 6, 5, 1, -6 },
  { 40, 4, 6, 5, 0, -6 },
  { 43, 4, 6, 5, 0, -6 },
  { 46, 4, 6, 5, 0, -6 },
  { 49, 4, 6, 5, 1, -6 },
  { 52, 4, 6, 5, 0, -6 },
  { 55, 4, 6, 5, 1, -6 },
  { 58, 4, 6, 5, 0, -6 },
  { 61, 3, 6, 5, 1, -6 },
  { 64, 1, 4, 5, 2, -4 },
  { 65, 2, 5, 5, 1, -4 },
  { 67, 3, 3, 5, 1, -4 },
  { 69, 4, 3, 5, 0, -4 },
  { 71, 4, 3, 5, 0, -4 },
  { 73, 3, 6, 5, 1, -6 },
  { 76, 5, 6, 5, 0, -6 },
  { 80, 4, 6, 5, 0, -6 },
  { 83, 4, 6, 5, 0, -6 },
  { 86, 5, 6, 5, 0, -6 },
  { 90, 4, 6, 5, 0, -6 },
  { 93, 5, 6, 5, 0, -6 },
  { 97, 5, 6, 5, 0, -6 },
  { 101, 5, 6, 5, 0, -6 },
  { 105, 5, 6, 5, 0, -6 },
  { 109, 5, 6, 5, 0, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 5, 6, 5, 0, -6 },
  { 121, 4, 6, 5, 0, -6 },
  { 124, 5, 6, 5, 0, -6 },
  { 128, 5, 6, 5, 0, -6 },
  { 132, 4, 6, 5, 0, -6 },
  { 135, 5, 6, 5, 0, -6 },
  { 139, 4, 7, 5, 0, -6 },
  { 143, 5, 6, 5, 0, -6 },
  { 147, 5, 6, 5, 0, -6 },
  { 151, 4, 6, 5, 1, -6 },
  { 154, 5, 6, 5, 0, -6 },
  { 158, 4, 6, 5, 1, -6 },
  { 161, 4, 6, 5, 1, -6 },
  { 164, 5, 6, 5, 0, -6 },
  { 168, 4, 6, 5, 1, -6 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 3, 8, 5, 1, -7 },
  { 178, 2, 6, 5, 1, -6 },
  { 180, 3, 8, 5, 1, -7 },
  { 183, 3, 3, 5, 1, -6 },
  { 185, 4, 1, 5, 0, 0 },
  { 186, 1, 1, 5, 2, -6 },
  { 187, 4, 4, 5, 0, -4 },
  { 189, 4, 6, 5, 0, -6 },
  { 192, 4, 4, 5, 0, -4 },
  { 194, 5, 6, 5, 0, -6 },
  { 198, 4, 4, 5, 0, -4 },
  { 200, 4, 6, 5, 1, -6 },
  { 203, 4, 6, 5, 0, -4 },
  { 206, 4, 6, 5, 0, -6 },
  { 209, 4, 6, 5, 0, -6 },
  { 212, 4, 8, 5, 0, -6 },
  { 216, 4, 6, 5, 0, -6 },
  { 219, 4, 6, 5, 0, -6 },
  { 222, 4, 4, 5, 0, -4 },
  { 224, 4, 4, 5, 0, -4 },
  { 226, 4, 4, 5, 0, -4 },
  { 228, 4, 6, 5, 0, -4 },
  { 231, 4, 6, 5, 0, -4 },
  { 234, 3, 4, 5, 1, -4 },
  { 236, 4, 4, 5, 0, -4 },
  { 238, 3, 5, 5, 1, -5 },
  { 240, 3, 4, 5, 1, -4 },
  { 242, 4, 4, 5, 1, -4 },
  { 244, 4, 4, 5, 1, -4 },
  { 246, 5, 4, 5, 0, -4 },
  { 249, 5, 6, 5, 0, -4 },
  { 253, 4, 4, 5, 0, -4 },
  { 255, 3, 7, 5, 1, -6 },
  { 258, 2, 8, 5, 1, -6 },
  { 260, 3, 7, 5, 1, -6 },
  { 263, 5, 1, 5, 0, -3 },
};

const GFXfont RobotoMono_Italic8pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic8pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _ROBOTOMONO_ITALIC8PT7B_H_
