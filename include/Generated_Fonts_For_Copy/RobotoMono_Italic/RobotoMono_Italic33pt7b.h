#ifndef _ROBOTOMONO_ITALIC33PT7B_H_
#define _ROBOTOMONO_ITALIC33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic33pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x1C, 0x30, 0xE1, 0xC3,
  0x87, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x1E, 0x38, 0x00, 0x63, 0xB1,
  0xD8, 0xDC, 0x6C, 0x36, 0x1B, 0x1D, 0x8C, 0x00, 0x38, 0xE0, 0x03, 0x0C,
  0x00, 0x61, 0xC0, 0x06, 0x18, 0x00, 0xE1, 0x80, 0x0C, 0x38, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x01, 0x87, 0x00, 0x18, 0x60, 0x03, 0x86, 0x00, 0x30,
  0xE0, 0x03, 0x0C, 0x00, 0x60, 0xC0, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0x8C,
  0x38, 0x00, 0xC3, 0x00, 0x1C, 0x30, 0x01, 0x87, 0x00, 0x18, 0x60, 0x03,
  0x86, 0x00, 0x30, 0xE0, 0x00, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00,
  0xF0, 0x03, 0xFC, 0x0F, 0xFE, 0x0E, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x1C,
  0x07, 0x1C, 0x07, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x1C, 0xF0, 0x3C, 0x78, 0xF8, 0x3F, 0xF0, 0x1F, 0xE0, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x73, 0x00, 0x63,
  0x84, 0xE3, 0x8E, 0xC3, 0x8C, 0xC3, 0x98, 0xE3, 0x38, 0x77, 0x30, 0x7E,
  0x60, 0x08, 0xE0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x07, 0x3C, 0x06,
  0x7E, 0x0C, 0xC6, 0x1D, 0xC7, 0x39, 0x87, 0x71, 0x87, 0x21, 0x86, 0x01,
  0xC6, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00,
  0xE3, 0x80, 0xE0, 0xE0, 0x70, 0x70, 0x38, 0x70, 0x1C, 0x78, 0x0E, 0x78,
  0x03, 0xF8, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x01, 0xFE, 0x1C, 0xE7,
  0x0E, 0xE1, 0xC7, 0xF0, 0xF7, 0x70, 0x3B, 0xB8, 0x0F, 0x9C, 0x07, 0xCE,
  0x03, 0xC3, 0xC7, 0xF0, 0xFF, 0xF8, 0x3F, 0x8E, 0x76, 0x66, 0xEE, 0xCC,
  0x00, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C,
  0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0C, 0x01,
  0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x80, 0x04,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xC0, 0x10, 0x00, 0x00, 0xE0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x06, 0x1C, 0x2F, 0x33, 0xFF, 0xFF, 0x87,
  0xFC, 0x03, 0x80, 0x0F, 0x80, 0x3B, 0x80, 0xE7, 0x03, 0x87, 0x0F, 0x0E,
  0x04, 0x08, 0x00, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE7, 0x1C, 0xE0, 0x7F, 0xFF, 0xFF, 0x80,
  0x77, 0xFE, 0xE0, 0x00, 0x07, 0x80, 0x03, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x38, 0x07, 0x70,
  0x07, 0x70, 0x0F, 0x70, 0x3F, 0x70, 0x7F, 0x71, 0xE6, 0x63, 0xCE, 0xEF,
  0x0E, 0xFE, 0x0E, 0xF8, 0x0E, 0xF0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0x70, 0x38, 0x78, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x03, 0x87, 0xDF,
  0xFF, 0xFE, 0x3C, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x00,
  0xF0, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xE1, 0xE0, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x40, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x0B, 0xFF, 0xF9,
  0xFF, 0xFC, 0x00, 0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x1C, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x78, 0x78, 0x3F, 0xF0,
  0x1F, 0xC0, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xB8, 0x03, 0x9C, 0x03, 0x8C, 0x03, 0x8E, 0x01, 0xC7, 0x01,
  0xC3, 0x81, 0xC1, 0xC1, 0xC0, 0xE1, 0xC0, 0x60, 0xE0, 0x70, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x07, 0xFF, 0x83, 0xFF, 0xC3, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1B, 0xF0, 0x0F, 0xFC,
  0x0F, 0x9F, 0x03, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x70, 0x0E, 0x18, 0x07, 0x0E, 0x07, 0x87, 0x87, 0x81,
  0xFF, 0x80, 0x7F, 0x00, 0x00, 0x04, 0x03, 0xE0, 0x3F, 0x81, 0xF0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xDF, 0xC7, 0xFF, 0x9F,
  0x0E, 0xF8, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0E, 0x70, 0x39, 0xE3, 0xC3, 0xFE, 0x07, 0xF0, 0x7F, 0xFF,
  0x7F, 0xFF, 0x80, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x03, 0xFC,
  0x0F, 0xFE, 0x0E, 0x0F, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x1C, 0x0F, 0x1C, 0x0E, 0x0F, 0x3C, 0x07, 0xF8, 0x0F, 0xF8, 0x3C, 0x38,
  0x78, 0x1C, 0x70, 0x0C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C,
  0xF0, 0x3C, 0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0xC0, 0x3F, 0xC1,
  0xFF, 0x8F, 0x0F, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x01, 0xFC, 0x07, 0x70, 0x3D, 0xE3, 0xF3, 0xFD, 0x87, 0xEE,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x03, 0xC1, 0xFE, 0x07, 0xF0,
  0x1E, 0x00, 0x1E, 0x3C, 0x78, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x7C, 0xF8, 0xE0, 0x07, 0x83, 0xC3, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x38,
  0x1C, 0x1E, 0x0E, 0x07, 0x07, 0x03, 0x83, 0x80, 0x00, 0x04, 0x00, 0x70,
  0x07, 0xC0, 0x7F, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x38, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x01, 0x00, 0x3F,
  0xFF, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x20, 0x00, 0x70, 0x00, 0xF8, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x7E, 0x07, 0xF0,
  0x7F, 0x03, 0xF8, 0x0F, 0xC0, 0x1C, 0x00, 0x20, 0x00, 0x00, 0x07, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0x70, 0x1D, 0xC0, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70,
  0x03, 0xC0, 0x06, 0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1C,
  0x0E, 0x0C, 0x01, 0x86, 0x0C, 0x21, 0x8F, 0xCC, 0xC7, 0x33, 0x33, 0x88,
  0xD8, 0xC6, 0x36, 0x61, 0x8D, 0x98, 0x63, 0xC6, 0x18, 0xB1, 0x8C, 0x2C,
  0xE3, 0x1B, 0x18, 0xC6, 0xC6, 0xF3, 0x31, 0xFF, 0x8C, 0x31, 0xC1, 0x80,
  0x00, 0x60, 0x00, 0x0E, 0x08, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60, 0x03,
  0x30, 0x03, 0x98, 0x01, 0x8E, 0x01, 0xC7, 0x00, 0xC3, 0x80, 0xE1, 0xC0,
  0x70, 0xE0, 0x70, 0x30, 0x3F, 0xF8, 0x3F, 0xFE, 0x1F, 0xFF, 0x1C, 0x03,
  0x8E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x77, 0x00, 0x1B, 0x80, 0x0E, 0x0F,
  0xFC, 0x07, 0xFF, 0x83, 0x03, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x1C,
  0x70, 0x0E, 0x38, 0x07, 0x18, 0x07, 0x1C, 0x1F, 0x0F, 0xFE, 0x07, 0xFF,
  0x83, 0x81, 0xE1, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38,
  0x03, 0x9C, 0x03, 0x8E, 0x03, 0xCF, 0xFF, 0xC7, 0xFF, 0xC3, 0xFF, 0x80,
  0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE1, 0xC0, 0x71, 0xC0,
  0x39, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x07, 0x38, 0x07, 0x1C, 0x03, 0x87, 0x03, 0x83, 0xC3, 0xC0, 0xFF,
  0xC0, 0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xFE, 0x07, 0x07, 0x83, 0x80, 0xE1,
  0xC0, 0x78, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01,
  0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x07, 0x18, 0x07, 0x1C, 0x0F, 0x8E, 0x3F, 0x07,
  0xFF, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x7F, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x3F,
  0xFE, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF0, 0x03, 0xFE, 0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x71, 0xC0,
  0x39, 0xC0, 0x0E, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x0F, 0xF7, 0x07, 0xFB, 0x83, 0xF9, 0x80, 0x1C, 0xE0, 0x0E,
  0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xE3, 0xE3, 0xE0, 0xFF,
  0xE0, 0x3F, 0xC0, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07,
  0x18, 0x01, 0xC6, 0x00, 0x63, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x8E,
  0x00, 0xE3, 0xFF, 0xF8, 0xFF, 0xFC, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x00,
  0x71, 0xC0, 0x1C, 0x60, 0x06, 0x38, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x03, 0x8C, 0x00, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0xE0,
  0x0E, 0x38, 0x07, 0x8E, 0x01, 0xC1, 0xC0, 0xF0, 0x78, 0xF8, 0x0F, 0xFC,
  0x01, 0xFC, 0x00, 0x0E, 0x01, 0xF0, 0xE0, 0x3C, 0x0E, 0x07, 0x81, 0xC0,
  0xF0, 0x1C, 0x1E, 0x01, 0xC3, 0xC0, 0x1C, 0x78, 0x01, 0xCF, 0x00, 0x19,
  0xE0, 0x03, 0xBC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3E, 0xE0, 0x03,
  0xCE, 0x00, 0x78, 0x70, 0x07, 0x07, 0x00, 0x70, 0x78, 0x07, 0x03, 0x80,
  0x70, 0x3C, 0x07, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x03, 0xE3,
  0xE0, 0x78, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xB0, 0xFC, 0x36, 0x1F, 0x8E,
  0xC7, 0x61, 0xD8, 0xCC, 0x3B, 0xBB, 0x87, 0x76, 0x70, 0xEF, 0xCE, 0x18,
  0xF1, 0xC7, 0x1E, 0x30, 0xE3, 0x8E, 0x1C, 0x71, 0xC3, 0x8C, 0x38, 0x70,
  0x07, 0x0C, 0x00, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x1C, 0x38, 0x03, 0x80, 0x1E, 0x01, 0xC7, 0x80, 0x71, 0xE0, 0x1C, 0x7C,
  0x07, 0x1F, 0x01, 0xC7, 0xC0, 0xE3, 0xB8, 0x38, 0xEE, 0x0E, 0x39, 0x83,
  0x8E, 0x70, 0xE3, 0x9C, 0x30, 0xE3, 0x1C, 0x70, 0xE7, 0x1C, 0x39, 0xC7,
  0x06, 0x71, 0xC1, 0xDC, 0x70, 0x7E, 0x38, 0x0F, 0x8E, 0x03, 0xE3, 0x80,
  0xF8, 0xE0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xC0, 0x01, 0xE0, 0x07, 0xF8,
  0x0F, 0xFC, 0x1E, 0x0E, 0x1C, 0x0F, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07,
  0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C,
  0x70, 0x38, 0x7C, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xFE, 0x03, 0xFF,
  0xC0, 0xE0, 0x78, 0x38, 0x0F, 0x1C, 0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C,
  0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE3, 0x80, 0xF0, 0xFF, 0xFC, 0x3F,
  0xFC, 0x0F, 0xF0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0xC1, 0xE0, 0xE1, 0xE0, 0x38, 0xE0,
  0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0xEE,
  0x00, 0x77, 0x00, 0x3B, 0x80, 0x1D, 0x80, 0x0F, 0xC0, 0x06, 0x60, 0x07,
  0x30, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xC7, 0x81, 0xC1, 0xF3, 0xC0, 0x7F,
  0xC0, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0x80,
  0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0xE0, 0x78, 0x30, 0x0E, 0x1C, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0x8E, 0x01, 0xC3, 0x81,
  0xF0, 0xFF, 0xF8, 0x3F, 0xF8, 0x0E, 0x1C, 0x03, 0x83, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0F, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x60, 0x1C, 0x38,
  0x03, 0x8E, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3C,
  0x1E, 0x1E, 0x03, 0x87, 0x00, 0xF1, 0xC0, 0x1C, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x38, 0x01, 0xCF, 0x00, 0x71, 0xC0,
  0x1C, 0x78, 0x0E, 0x0F, 0x0F, 0x81, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0x80, 0x19,
  0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCC, 0x00,
  0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0C, 0x70,
  0x0E, 0x38, 0x07, 0x1E, 0x07, 0x07, 0x8F, 0x01, 0xFF, 0x00, 0x7F, 0x00,
  0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x78, 0x30, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07,
  0x0E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0x67, 0x00, 0x33, 0x80, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x70, 0xE0, 0xEE, 0x1C, 0x39, 0xC3, 0x87, 0x38, 0xF0, 0xE7, 0x1E,
  0x18, 0xE3, 0xC7, 0x1C, 0xF8, 0xE3, 0x9B, 0x18, 0x73, 0x63, 0x0C, 0xEC,
  0xE1, 0x99, 0x9C, 0x33, 0x33, 0x06, 0xE6, 0x60, 0xD8, 0xDC, 0x1B, 0x1B,
  0x83, 0xE3, 0x60, 0x7C, 0x7C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C,
  0x07, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x00, 0x0E, 0x00, 0xF0, 0x70,
  0x1E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x03, 0x87, 0x80, 0x38, 0x70, 0x01,
  0xCE, 0x00, 0x1D, 0xE0, 0x01, 0xDC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xB8, 0x00, 0x79, 0xC0,
  0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x1E, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0F,
  0x07, 0x00, 0x70, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xB8, 0x03, 0x9C, 0x03,
  0x87, 0x03, 0xC3, 0x81, 0xC1, 0xC1, 0xC0, 0x60, 0xE0, 0x38, 0xE0, 0x1C,
  0xF0, 0x0E, 0x70, 0x03, 0x70, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x3F,
  0xFF, 0x80, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x70, 0x06, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7E,
  0x0F, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x70, 0x70, 0x30, 0x30, 0x38,
  0x38, 0x38, 0x18, 0x18, 0x1C, 0x1C, 0x1C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E,
  0x06, 0x06, 0x07, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x70, 0x0E, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x3F, 0x07, 0xE0, 0x03,
  0x80, 0x38, 0x07, 0xC0, 0x7C, 0x0F, 0xC1, 0xCC, 0x1C, 0xE3, 0x8E, 0x38,
  0xE7, 0x06, 0x60, 0x6E, 0x07, 0x7F, 0xFF, 0xFF, 0xFC, 0xE3, 0x8C, 0x70,
  0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xC0, 0xE3, 0x80, 0xE8, 0x01, 0xC0,
  0x03, 0x81, 0xFE, 0x1F, 0xFC, 0xFF, 0xF9, 0xC0, 0x77, 0x00, 0xEE, 0x01,
  0xDC, 0x07, 0x38, 0x1E, 0x78, 0xFC, 0x7F, 0xF8, 0x7E, 0x70, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x70, 0x1D, 0xFC, 0x1F, 0xFE, 0x1E, 0x0E, 0x3C, 0x0F, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x07, 0x70, 0x07, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0xFC, 0x7C, 0xEF, 0xF8, 0xE7, 0xE0,
  0x01, 0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xEE, 0x01, 0xDC,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x01,
  0xFC, 0x03, 0x9C, 0x0E, 0x3C, 0x3C, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x07, 0x8E, 0x0F, 0xF7, 0x0F, 0xFF, 0x0F, 0x07, 0x8F, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x73, 0x80, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x70, 0x0E,
  0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x81, 0xC1, 0xE3, 0xE0, 0x7F,
  0xF0, 0x1F, 0xB8, 0x00, 0x01, 0xE0, 0x0F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE3,
  0x80, 0xEE, 0x01, 0xDC, 0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x06, 0x3C, 0x3E, 0x3F, 0xF0,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x78, 0x20, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xFD,
  0xC3, 0xFF, 0xE3, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x1C, 0xE0,
  0x0E, 0x70, 0x06, 0x38, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0x71, 0xE0, 0x70, 0x78, 0xF8, 0x1F, 0xFC, 0x07, 0xEE, 0x00, 0x07,
  0x00, 0x07, 0x04, 0x03, 0x87, 0x03, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x1F,
  0x00, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x78, 0x1D, 0xFC, 0x1F, 0xFE, 0x1E, 0x0F,
  0x3C, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x30, 0x06,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0C,
  0xE0, 0x1C, 0xE0, 0x1C, 0x00, 0x10, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0xF0, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x0F, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x00, 0x01, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x08, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x01, 0x1C, 0x0F, 0x0E, 0x0F, 0x07, 0x0F, 0x07,
  0x0F, 0x03, 0x8F, 0x01, 0xCE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x3E, 0xE0, 0x1E, 0x38, 0x0E, 0x1E, 0x07, 0x07, 0x03, 0x83, 0xC3, 0x80,
  0xE1, 0xC0, 0x38, 0xE0, 0x1E, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F,
  0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x01, 0xC3, 0x06, 0xFB, 0xF3, 0xFF, 0xFC,
  0xE1, 0xC7, 0x38, 0x70, 0xCE, 0x18, 0x73, 0x8E, 0x1C, 0xC3, 0x87, 0x70,
  0xE1, 0xDC, 0x38, 0x77, 0x0E, 0x19, 0xC3, 0x0E, 0x71, 0xC3, 0x98, 0x70,
  0xEE, 0x1C, 0x3B, 0x87, 0x0E, 0xE1, 0xC3, 0x38, 0x61, 0xC0, 0x00, 0x78,
  0x1D, 0xFC, 0x1B, 0xFE, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x03, 0xC0,
  0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xE7, 0x80, 0xEE, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDC, 0x03,
  0xB8, 0x0E, 0x3C, 0x78, 0x3F, 0xE0, 0x3F, 0x80, 0x00, 0x78, 0x07, 0xFF,
  0x03, 0xFF, 0xC1, 0xE0, 0xE1, 0xE0, 0x78, 0xE0, 0x1C, 0x70, 0x0E, 0x38,
  0x07, 0x1C, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x78, 0xE0, 0x38, 0xFC, 0x7C, 0x7F, 0xFC, 0x39, 0xF8, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x0F, 0xF7, 0x1F, 0xFE, 0x3C, 0x1E, 0x78, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x78, 0xF8, 0x3F, 0xF8,
  0x1F, 0xB8, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x39, 0xFC, 0x77, 0xF8, 0xFC, 0x11,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x01, 0xC0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE0, 0xF3, 0x80, 0xE7,
  0x01, 0xCE, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x01,
  0xE0, 0x01, 0xDC, 0x03, 0xBC, 0x07, 0x3C, 0x3C, 0x3F, 0xF0, 0x3F, 0xC0,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x84, 0x0F,
  0xF0, 0x1F, 0xC0, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x3C, 0x70, 0x38, 0x78, 0xF8, 0x7F, 0xF8, 0x3F,
  0x38, 0xE0, 0x0F, 0xE0, 0x0E, 0x60, 0x1C, 0x60, 0x1C, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x70, 0x30, 0x70, 0x38, 0xE0, 0x38, 0xC0, 0x39, 0xC0, 0x19,
  0x80, 0x1B, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xE0,
  0xC1, 0xF8, 0x70, 0x6E, 0x1C, 0x3B, 0x8F, 0x0E, 0xE3, 0xC3, 0x38, 0xF1,
  0xCE, 0x6C, 0x63, 0x9B, 0x18, 0xEE, 0xEE, 0x3B, 0x1B, 0x0F, 0xC6, 0xC1,
  0xE1, 0xE0, 0x78, 0x78, 0x1C, 0x1E, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x60,
  0x70, 0x00, 0x1E, 0x01, 0xE1, 0xC0, 0x70, 0x1C, 0x1C, 0x03, 0x87, 0x00,
  0x39, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0x9C, 0x00, 0xF1, 0xC0, 0x3C, 0x38, 0x0F,
  0x03, 0x83, 0xC0, 0x70, 0xF0, 0x07, 0x00, 0x3C, 0x00, 0xF1, 0xC0, 0x1C,
  0x1C, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x0E,
  0x00, 0x70, 0xE0, 0x07, 0x1C, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0x37,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1C, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0x9F, 0xFF, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xFF, 0xFC, 0xFF, 0xFE, 0x00, 0x00, 0x18, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x1F, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87, 0x0E, 0x1C, 0x30, 0x60, 0xC1, 0x87,
  0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0x60, 0xC3, 0x87,
  0x0C, 0x00, 0x04, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x18, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x1D, 0xFF,
  0x83, 0x38, 0x78, 0xE6, 0x07, 0xF9, 0xC0, 0x7E, 0x00, 0x01, 0x00,
};

const GFXglyph RobotoMono_Italic33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 9, 8, 19, 7, -25 },
  { 31, 20, 23, 19, 0, -23 },
  { 89, 16, 30, 19, 2, -27 },
  { 149, 16, 24, 19, 2, -24 },
  { 197, 17, 24, 19, 1, -24 },
  { 248, 4, 8, 19, 9, -25 },
  { 252, 11, 34, 19, 5, -26 },
  { 299, 11, 34, 19, 3, -26 },
  { 346, 15, 15, 19, 3, -23 },
  { 375, 16, 17, 19, 2, -19 },
  { 409, 6, 9, 19, 3, -4 },
  { 416, 13, 2, 19, 3, -11 },
  { 420, 5, 4, 19, 6, -4 },
  { 423, 17, 25, 19, 2, -23 },
  { 477, 16, 24, 19, 2, -24 },
  { 525, 9, 23, 19, 5, -23 },
  { 551, 17, 24, 19, 0, -24 },
  { 602, 16, 24, 19, 1, -24 },
  { 650, 17, 23, 19, 0, -23 },
  { 699, 17, 23, 19, 2, -23 },
  { 748, 14, 24, 19, 2, -24 },
  { 790, 16, 23, 19, 3, -23 },
  { 836, 16, 24, 19, 2, -24 },
  { 884, 14, 24, 19, 3, -24 },
  { 926, 7, 18, 19, 7, -18 },
  { 942, 9, 23, 19, 5, -18 },
  { 968, 14, 15, 19, 3, -18 },
  { 995, 16, 9, 19, 2, -15 },
  { 1013, 15, 15, 19, 2, -18 },
  { 1042, 14, 24, 19, 4, -24 },
  { 1084, 18, 24, 19, 1, -24 },
  { 1138, 17, 23, 19, 0, -23 },
  { 1187, 17, 23, 19, 1, -23 },
  { 1236, 17, 24, 19, 2, -24 },
  { 1287, 17, 23, 19, 1, -23 },
  { 1336, 18, 23, 19, 1, -23 },
  { 1388, 18, 23, 19, 1, -23 },
  { 1440, 17, 24, 19, 2, -24 },
  { 1491, 18, 23, 19, 1, -23 },
  { 1543, 18, 23, 19, 1, -23 },
  { 1595, 18, 23, 19, 1, -23 },
  { 1647, 20, 23, 19, 1, -23 },
  { 1705, 15, 23, 19, 1, -23 },
  { 1749, 19, 23, 19, 1, -23 },
  { 1804, 18, 23, 19, 1, -23 },
  { 1856, 16, 24, 19, 2, -24 },
  { 1904, 18, 23, 19, 1, -23 },
  { 1956, 17, 28, 19, 1, -24 },
  { 2016, 18, 23, 19, 1, -23 },
  { 2068, 18, 24, 19, 1, -24 },
  { 2122, 17, 23, 19, 3, -23 },
  { 2171, 17, 23, 19, 2, -23 },
  { 2220, 17, 23, 19, 3, -23 },
  { 2269, 19, 23, 19, 2, -23 },
  { 2324, 20, 23, 19, 0, -23 },
  { 2382, 17, 23, 19, 3, -23 },
  { 2431, 19, 23, 19, 0, -23 },
  { 2486, 12, 32, 19, 4, -27 },
  { 2534, 8, 25, 19, 6, -23 },
  { 2559, 11, 32, 19, 4, -27 },
  { 2603, 12, 12, 19, 4, -23 },
  { 2621, 15, 2, 19, 0, 0 },
  { 2625, 5, 4, 19, 9, -24 },
  { 2628, 15, 18, 19, 2, -18 },
  { 2662, 16, 25, 19, 1, -25 },
  { 2712, 15, 18, 19, 2, -18 },
  { 2746, 17, 25, 19, 2, -25 },
  { 2800, 15, 18, 19, 2, -18 },
  { 2834, 17, 25, 19, 3, -25 },
  { 2888, 17, 25, 19, 1, -18 },
  { 2942, 16, 25, 19, 1, -25 },
  { 2992, 15, 24, 19, 1, -24 },
  { 3037, 15, 31, 19, 1, -24 },
  { 3096, 17, 25, 19, 1, -25 },
  { 3150, 15, 25, 19, 1, -25 },
  { 3197, 18, 18, 19, 0, -18 },
  { 3238, 16, 18, 19, 1, -18 },
  { 3274, 15, 18, 19, 2, -18 },
  { 3308, 17, 25, 19, 0, -18 },
  { 3362, 16, 25, 19, 2, -18 },
  { 3412, 15, 18, 19, 3, -18 },
  { 3446, 15, 18, 19, 2, -18 },
  { 3480, 14, 22, 19, 3, -22 },
  { 3519, 16, 17, 19, 2, -17 },
  { 3553, 16, 17, 19, 3, -17 },
  { 3587, 18, 17, 19, 2, -17 },
  { 3626, 19, 17, 19, 0, -17 },
  { 3667, 20, 24, 19, 0, -17 },
  { 3727, 17, 17, 19, 1, -17 },
  { 3764, 13, 32, 19, 5, -26 },
  { 3816, 7, 29, 19, 6, -23 },
  { 3842, 13, 32, 19, 3, -26 },
  { 3894, 19, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_Italic33pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic33pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic33pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _ROBOTOMONO_ITALIC33PT7B_H_
