#ifndef _ROBOTOMONO_ITALIC49PT7B_H_
#define _ROBOTOMONO_ITALIC49PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3E, 0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0xFC, 0x1F, 0x01,
  0xE0, 0x00, 0x38, 0x3C, 0xE0, 0xE7, 0x83, 0x9E, 0x0E, 0x78, 0x79, 0xC1,
  0xE7, 0x07, 0x1C, 0x1C, 0xF0, 0x73, 0x81, 0xCE, 0x0F, 0x38, 0x38, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x38, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x70,
  0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x0E, 0x07, 0x80,
  0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0x07, 0x81, 0xC0,
  0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0x80, 0x00, 0xF0, 0x38, 0x00, 0x0E,
  0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0,
  0x00, 0x3C, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x38,
  0x00, 0x0E, 0x07, 0x80, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xC0, 0xF0, 0x00, 0x3C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x38, 0x1E,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x3E, 0x0F,
  0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x0F,
  0x00, 0x1F, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0x3F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x07, 0x81, 0x0E, 0x07, 0x03, 0xBC, 0x0E,
  0x0F, 0x78, 0x1C, 0x3C, 0xF0, 0x78, 0x71, 0xE0, 0xE1, 0xC3, 0xC1, 0xC7,
  0x83, 0x87, 0x9E, 0x07, 0xFE, 0x38, 0x07, 0xF8, 0xF0, 0x07, 0xE3, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x1F, 0x00, 0x3C, 0x7F, 0x00, 0x71, 0xFF, 0x01,
  0xE7, 0x8F, 0x07, 0x9E, 0x0E, 0x0E, 0x38, 0x1C, 0x38, 0x70, 0x38, 0xF0,
  0xE0, 0x73, 0xC1, 0xC0, 0xE3, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E,
  0x0E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x04,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xF3, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x0F, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0x87, 0xC0, 0x01, 0xE7, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0x78, 0x0F, 0x1F, 0x9F, 0x03, 0xCF, 0xC3, 0xC1,
  0xE3, 0xE0, 0xF8, 0x79, 0xF0, 0x1F, 0x1E, 0x7C, 0x07, 0xCF, 0x1E, 0x00,
  0xFB, 0xC7, 0x80, 0x3F, 0xE1, 0xE0, 0x07, 0xF8, 0x78, 0x00, 0xFC, 0x1E,
  0x00, 0x3E, 0x07, 0xC0, 0x3F, 0xC0, 0xFC, 0x3F, 0xF0, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xC7, 0x80, 0x7F, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0xE3,
  0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xCF, 0x38, 0x00, 0x03, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x0C, 0x0F,
  0x03, 0x7C, 0x38, 0x7D, 0xFC, 0xE7, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE,
  0x01, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x00, 0x07,
  0xDE, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x81, 0xE0, 0x7E, 0x07,
  0xC0, 0xF0, 0x1F, 0x01, 0x80, 0x30, 0x00, 0x00, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x1F, 0x1F, 0x1F, 0x1F, 0x1E, 0x3E, 0x3E, 0x7C,
  0x7C, 0xF8, 0xF0, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7B, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0xFC,
  0x07, 0xC0, 0x3C, 0x0F, 0x80, 0x1E, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x3F,
  0x3C, 0x00, 0xFF, 0x3C, 0x01, 0xFE, 0x7C, 0x07, 0xFE, 0x7C, 0x0F, 0xDE,
  0x78, 0x1F, 0x9E, 0x78, 0x7E, 0x3E, 0x78, 0xFC, 0x3E, 0x7B, 0xF0, 0x3C,
  0xFF, 0xE0, 0x3C, 0xFF, 0x80, 0x3C, 0xFF, 0x00, 0x3C, 0xFC, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8,
  0x78, 0x00, 0xF0, 0x78, 0x01, 0xF0, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0xC0,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC1, 0xFF, 0x3F, 0xFF, 0xFF, 0xEF, 0xF7,
  0xBE, 0x1E, 0xC0, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0x8F, 0xE0, 0x3E, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x3E,
  0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x1F, 0x0F, 0x80,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xBE, 0x00, 0x07, 0x9E, 0x00,
  0x07, 0x8F, 0x00, 0x07, 0xC7, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xE0,
  0x03, 0xC1, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x3C,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xE0, 0x0F, 0x01, 0xF0, 0x07,
  0x81, 0xF0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x0F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC3, 0xE0, 0x1E, 0x7F, 0xC0,
  0xF7, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0x83, 0xF3, 0xF0, 0x07, 0x9F, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xE7, 0x80, 0x1F, 0x3E, 0x00, 0xF1, 0xF0, 0x1F, 0x87, 0xE1, 0xF8, 0x1F,
  0xFF, 0x80, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0x3E, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x1F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x0F, 0x80, 0x3E, 0x07, 0x80,
  0x7C, 0x07, 0xC0, 0xF8, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0x81, 0xF0, 0x3E, 0x00, 0xF8, 0x3C, 0x00,
  0x78, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0x78, 0x00,
  0xF8, 0x7C, 0x03, 0xF0, 0x3F, 0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFC,
  0x03, 0xFF, 0xF0, 0x3F, 0x8F, 0xC3, 0xF0, 0x1F, 0x1F, 0x00, 0xF9, 0xF0,
  0x03, 0xCF, 0x00, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x9F, 0x01, 0xFC, 0xFE, 0x3F, 0xE3,
  0xFF, 0xFE, 0x0F, 0xFE, 0xF0, 0x3F, 0xC7, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x83, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x07,
  0xC0, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x03, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x18, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x00, 0x40, 0x3F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x00, 0x0C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFD, 0xFC,
  0x7E, 0x03, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFF, 0xE0, 0x03, 0xF0, 0x7C, 0x01, 0xE0, 0x07, 0x00, 0xF0,
  0x00, 0xE0, 0x78, 0x00, 0x38, 0x3C, 0x0E, 0x06, 0x0E, 0x0F, 0xE1, 0xC7,
  0x07, 0xFC, 0x71, 0xC3, 0xC7, 0x1C, 0xE1, 0xE1, 0xC7, 0x38, 0xF0, 0x61,
  0xDC, 0x38, 0x18, 0x77, 0x0E, 0x0E, 0x1D, 0xC7, 0x03, 0x87, 0xE1, 0xC0,
  0xC1, 0xF8, 0x70, 0x70, 0x6E, 0x38, 0x1C, 0x1B, 0x8E, 0x07, 0x06, 0xE3,
  0x81, 0x83, 0xB8, 0xE0, 0xE0, 0xCC, 0x38, 0x38, 0x73, 0x8F, 0x1E, 0x18,
  0xE3, 0xFF, 0xCE, 0x38, 0x7F, 0x7F, 0x0E, 0x1F, 0x1F, 0x83, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x0C, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3C, 0x70, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xE1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x0F,
  0x81, 0xE0, 0x03, 0xC0, 0x38, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xE3, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x7C, 0x00, 0x07, 0x9F,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7C, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xC0, 0x1F, 0x80, 0xF0,
  0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0x83, 0xE0, 0x07, 0xC0, 0xF0, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xF8, 0x1E,
  0x00, 0x1E, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0xC1, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xF1,
  0xF8, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C,
  0x00, 0x1E, 0x1F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x7C,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x06, 0x1E, 0x00, 0x07,
  0x87, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x00,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xC0,
  0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3E, 0x07,
  0x80, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x7C, 0x78,
  0x00, 0x1F, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0xF8,
  0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC3, 0xC0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x1E, 0x00, 0x7E, 0x07, 0x80,
  0x7F, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFB, 0xFC, 0x03, 0xF0, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x1E, 0x1F, 0x00,
  0x07, 0xC7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x7F, 0xF1, 0xE0, 0x1F,
  0xFC, 0xF8, 0x07, 0xFF, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0x78, 0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1,
  0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xF0, 0x07,
  0xC0, 0x7F, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x0F,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x81, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x83,
  0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x3E,
  0x07, 0x80, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xFC,
  0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x10, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xC0,
  0x3E, 0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x0F,
  0x00, 0x7C, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x1E, 0x07, 0xE0, 0x00, 0x78, 0x3F, 0x00, 0x01, 0xE1, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xF3, 0xF0, 0x00,
  0x03, 0xDF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFB, 0xE0, 0x00, 0x1F, 0xCF, 0x80, 0x00, 0x7E,
  0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3F,
  0x03, 0xF0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x0F, 0xE0, 0x7F,
  0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xFE, 0x07, 0x70, 0x3D,
  0xE0, 0xF7, 0x83, 0xDC, 0x0F, 0x78, 0x7B, 0xC0, 0xF7, 0x87, 0xBC, 0x0F,
  0x78, 0xF3, 0xC0, 0xF3, 0x8F, 0x3C, 0x1F, 0x39, 0xE3, 0xC1, 0xE3, 0x9E,
  0x78, 0x1E, 0x3F, 0xC7, 0x81, 0xE3, 0xFC, 0x78, 0x1E, 0x3F, 0x87, 0x81,
  0xE3, 0xF8, 0x78, 0x3E, 0x1F, 0x0F, 0x83, 0xC1, 0xF0, 0xF0, 0x3C, 0x1E,
  0x0F, 0x03, 0xC1, 0xE0, 0xF0, 0x3C, 0x1C, 0x0F, 0x03, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E,
  0x0F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xE0, 0x7E, 0x00, 0x1E, 0x07, 0xF0,
  0x01, 0xE0, 0x7F, 0x00, 0x3E, 0x07, 0xF0, 0x03, 0xE0, 0x7F, 0x80, 0x3E,
  0x0F, 0xF8, 0x03, 0xC0, 0xFF, 0x80, 0x3C, 0x0F, 0xFC, 0x03, 0xC0, 0xF3,
  0xC0, 0x7C, 0x0F, 0x3C, 0x07, 0xC0, 0xF3, 0xE0, 0x78, 0x1F, 0x1E, 0x07,
  0x81, 0xF1, 0xE0, 0x78, 0x1E, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0xF8, 0x1E,
  0x0F, 0x0F, 0x83, 0xE0, 0xF8, 0xF0, 0x3E, 0x07, 0x8F, 0x03, 0xE0, 0x78,
  0xF0, 0x3C, 0x07, 0xDF, 0x03, 0xC0, 0x3D, 0xF0, 0x3C, 0x03, 0xDF, 0x07,
  0xC0, 0x3F, 0xE0, 0x7C, 0x01, 0xFE, 0x07, 0xC0, 0x1F, 0xE0, 0x78, 0x01,
  0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00, 0xFE, 0x0F, 0x80, 0x0F, 0xC0,
  0xF8, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0,
  0x3F, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00,
  0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0xC0, 0xF8, 0x0F, 0xC0,
  0x3F, 0x9F, 0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x04, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0x00, 0x0F,
  0x81, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x78, 0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C,
  0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1E, 0x00,
  0x3F, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00,
  0x3C, 0x1E, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xCF, 0x80,
  0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x1F,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0x3F, 0x9F, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0x80, 0x3F, 0x01, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x3E,
  0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0x78,
  0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0x78, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0xE0, 0x0F, 0xFB, 0xFC, 0x07, 0xE0, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC3,
  0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00,
  0xF8, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x0F, 0xC0, 0xFE,
  0x1F, 0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0x83,
  0xC0, 0x00, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00,
  0xF8, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x78, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF0,
  0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0xFC, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x10, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xC7, 0x80, 0x03, 0xE3, 0xC0,
  0x01, 0xF1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78, 0x00, 0x78, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x07, 0x80, 0x3E, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x80, 0x3E, 0x07, 0x80,
  0x1F, 0x03, 0xC0, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x7C,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x0F, 0x03,
  0xEF, 0x03, 0xE0, 0x79, 0xE0, 0x7C, 0x0F, 0x3C, 0x0F, 0x81, 0xE7, 0x83,
  0xF0, 0x7C, 0xF0, 0x7E, 0x0F, 0x1E, 0x0F, 0xC1, 0xE3, 0xC3, 0xF8, 0x3C,
  0x78, 0x7F, 0x0F, 0x0E, 0x0E, 0xE1, 0xE1, 0xC3, 0xDC, 0x3C, 0x78, 0x7B,
  0x87, 0x8F, 0x0E, 0x71, 0xE1, 0xE3, 0xCE, 0x3C, 0x3C, 0x79, 0xC7, 0x87,
  0x8E, 0x38, 0xE0, 0xF3, 0xC7, 0x3C, 0x1E, 0x78, 0xE7, 0x83, 0xCE, 0x1C,
  0xF0, 0x79, 0xC3, 0x9C, 0x0F, 0x78, 0x77, 0x81, 0xEE, 0x0E, 0xF0, 0x3D,
  0xC1, 0xDE, 0x07, 0xF8, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0xFE,
  0x03, 0xF8, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8,
  0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xE0, 0x1E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xC3,
  0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x07,
  0x80, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0x80, 0x7E, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC1,
  0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x78,
  0x00, 0x78, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0xBE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFC,
  0x03, 0xFE, 0x03, 0xFF, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0xFC, 0x07, 0xFE, 0x03,
  0xFE, 0x00, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x07, 0xBC, 0x07, 0xDE, 0x03, 0xC7, 0x03,
  0xC3, 0xC1, 0xE1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0xF0, 0x1C, 0xF8, 0x0F,
  0x78, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0xE0, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x3C, 0x3C, 0x1E, 0x0E, 0x07,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x0F, 0xE0,
  0xF8, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xFF, 0x07, 0x8F, 0xC0, 0x1F, 0x3E, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x8F, 0x80, 0xFE, 0x1F, 0xC7, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFC, 0xF8,
  0x1F, 0xF1, 0xF0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0xFF, 0x00, 0xF7, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFE, 0xFF, 0x0F, 0xE0,
  0x3E, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xFE,
  0x01, 0xF1, 0xFF, 0x1F, 0xC3, 0xDF, 0xFF, 0x87, 0x9F, 0xFC, 0x0F, 0x1F,
  0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xC0, 0x1F,
  0xFF, 0xC0, 0x7F, 0x0F, 0xC1, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x8F, 0x80,
  0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xE7,
  0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0xC3, 0xF8, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0xE3,
  0xC0, 0x3F, 0xF9, 0xE0, 0x3F, 0xFE, 0xF0, 0x3F, 0x8F, 0xF8, 0x3F, 0x01,
  0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x80,
  0x07, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xE0,
  0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1E,
  0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x07, 0xC0,
  0xF0, 0x03, 0xE0, 0x7C, 0x07, 0xF0, 0x3F, 0x8F, 0xF8, 0x0F, 0xFF, 0xF8,
  0x03, 0xFF, 0xBC, 0x00, 0xFF, 0x9E, 0x00, 0x04, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xC1, 0xF8, 0x0F,
  0x83, 0xE0, 0x0F, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E, 0x7C, 0x00, 0x3C,
  0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x02, 0x07, 0xC0, 0x06, 0x0F, 0x80,
  0x3E, 0x0F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x03, 0xF0, 0x10, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC7, 0x80, 0x7F, 0xF3, 0xC0, 0x7F, 0xFD,
  0xE0, 0x7F, 0x1F, 0xF0, 0x7E, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00,
  0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x8F, 0x80,
  0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F,
  0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF8, 0x0F, 0xE0,
  0x7F, 0x1F, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0x78, 0x01, 0xFF, 0x3C,
  0x00, 0x08, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x01, 0x00, 0x0F,
  0x81, 0xC0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x7F, 0x3F, 0xC0, 0x1F, 0xFF,
  0xC0, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x7F, 0x00, 0xF3, 0xFF, 0x81, 0xEF, 0xFF,
  0x87, 0xFE, 0x7F, 0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0x3E, 0x3E, 0x00, 0x3C,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xF0,
  0x00, 0xF3, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x9E, 0x00,
  0x1E, 0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03,
  0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x02, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00,
  0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x03, 0xF0, 0xF0, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07,
  0x87, 0xE0, 0x03, 0xC7, 0xE0, 0x03, 0xE7, 0xC0, 0x01, 0xF7, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xDF, 0x00,
  0x1F, 0xCF, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x7C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF0, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x3F, 0x1F, 0x81, 0xFF, 0xF7, 0xF8,
  0x3F, 0xFF, 0xFF, 0x87, 0xEF, 0xFB, 0xF1, 0xF0, 0x7C, 0x1E, 0x3C, 0x0F,
  0x03, 0xC7, 0x81, 0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xE3,
  0xC0, 0xF0, 0x3C, 0xF0, 0x3C, 0x0F, 0x9E, 0x07, 0x81, 0xE3, 0xC0, 0xF0,
  0x3C, 0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xF3, 0xE0, 0x78, 0x1E, 0x78,
  0x1E, 0x07, 0xCF, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x1E, 0x3C, 0x0F, 0x03,
  0xC7, 0x81, 0xE0, 0x79, 0xF0, 0x7C, 0x0F, 0x3C, 0x0F, 0x03, 0xE7, 0x81,
  0xE0, 0x78, 0xF0, 0x3C, 0x0F, 0x1E, 0x07, 0x81, 0xE0, 0x0F, 0x0F, 0xE0,
  0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xF0, 0xF7, 0xCF, 0xE1, 0xFC, 0x07, 0xE3,
  0xF0, 0x07, 0xC7, 0xC0, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x7C,
  0x00, 0x3C, 0xF8, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0x80,
  0x07, 0x8F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00,
  0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xF1, 0xF8,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x3E, 0x1E, 0x00, 0x3E, 0x3E, 0x00, 0x1E,
  0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0x78, 0x00, 0x78,
  0x7C, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3F, 0x07, 0xE0, 0x1F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x20, 0x00, 0x03, 0xC7, 0xF8,
  0x01, 0xEF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0x9F, 0xE0, 0x7F, 0x01,
  0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80,
  0x07, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1E,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0xC3, 0xC0, 0x07, 0xC3,
  0xF0, 0x03, 0xE1, 0xF8, 0x07, 0xE0, 0xFF, 0x07, 0xE0, 0x7F, 0xFF, 0xF0,
  0x3D, 0xFF, 0xE0, 0x1E, 0x3F, 0xE0, 0x1F, 0x01, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x1E, 0x07, 0xFF, 0xBC, 0x1F, 0xFF, 0x78, 0x7F,
  0x0F, 0xF1, 0xF8, 0x0F, 0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x0F, 0x3E, 0x00,
  0x1E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x7C,
  0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0x87,
  0x80, 0x1F, 0x0F, 0x80, 0x7E, 0x1F, 0xC3, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F,
  0xFD, 0xE0, 0x1F, 0xF3, 0xC0, 0x02, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x07, 0x87,
  0xFC, 0x3E, 0x7F, 0xF0, 0xF3, 0xFF, 0x83, 0xDF, 0xFE, 0x0F, 0xF8, 0x08,
  0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x83, 0xF8, 0xFE, 0x1F, 0x80, 0x7C,
  0x7C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xEF,
  0x00, 0x07, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xF9, 0xF0, 0x07, 0xC7, 0xF0,
  0x7F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x38, 0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x78, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF8, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7E, 0x1F,
  0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFD, 0xE0, 0x0F, 0xF1, 0xE0, 0x01, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x3C, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x0F, 0x1F,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x3C, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0E, 0x01, 0xFE, 0x03,
  0xC0, 0x7B, 0xC0, 0x78, 0x0F, 0x78, 0x0F, 0x01, 0xCF, 0x03, 0xE0, 0x79,
  0xE0, 0x7C, 0x0F, 0x3C, 0x1F, 0x81, 0xC7, 0x83, 0xF0, 0x78, 0xF0, 0xFE,
  0x0F, 0x1E, 0x1D, 0xC1, 0xC3, 0xC3, 0xB8, 0x78, 0x38, 0xF7, 0x8E, 0x07,
  0x1C, 0xF1, 0xC0, 0xE7, 0x8E, 0x78, 0x1C, 0xE1, 0xCE, 0x03, 0xBC, 0x39,
  0xC0, 0x77, 0x07, 0x70, 0x0E, 0xE0, 0xEE, 0x01, 0xFC, 0x1D, 0xC0, 0x3F,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00,
  0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0x8F, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0x9E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0xF8, 0x07, 0x80, 0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x03, 0xE0, 0x7E,
  0x00, 0x1E, 0x0F, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x00, 0x7C, 0x1F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03,
  0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0x78, 0x01, 0xF0,
  0x01, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3C, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0xF0, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE7,
  0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x4F, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x10, 0x00, 0x01, 0xC0, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C,
  0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xFF, 0x00, 0x1C, 0xFF, 0xF0, 0x07, 0xBF, 0xFF, 0x00, 0xE7,
  0x83, 0xF0, 0x3D, 0xE0, 0x3F, 0xFF, 0x38, 0x03, 0xFF, 0xE7, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFE, 0x00,
};

const GFXglyph RobotoMono_Italic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 11, 35, 29, 9, -35 },
  { 50, 14, 12, 29, 10, -37 },
  { 71, 28, 35, 29, 1, -35 },
  { 194, 24, 45, 29, 3, -40 },
  { 329, 23, 36, 29, 3, -35 },
  { 433, 26, 36, 29, 1, -35 },
  { 550, 6, 12, 29, 13, -37 },
  { 559, 16, 50, 29, 8, -39 },
  { 659, 16, 50, 29, 4, -39 },
  { 759, 22, 24, 29, 5, -35 },
  { 825, 24, 26, 29, 3, -29 },
  { 903, 8, 13, 29, 5, -5 },
  { 916, 18, 4, 29, 5, -17 },
  { 925, 6, 6, 29, 10, -6 },
  { 930, 24, 38, 29, 3, -35 },
  { 1044, 24, 36, 29, 3, -35 },
  { 1152, 14, 35, 29, 7, -35 },
  { 1214, 25, 35, 29, 0, -35 },
  { 1324, 24, 36, 29, 1, -35 },
  { 1432, 25, 35, 29, 1, -35 },
  { 1542, 25, 36, 29, 3, -35 },
  { 1655, 21, 36, 29, 3, -35 },
  { 1750, 24, 35, 29, 5, -35 },
  { 1855, 24, 36, 29, 3, -35 },
  { 1963, 21, 35, 29, 5, -35 },
  { 2055, 10, 27, 29, 11, -27 },
  { 2089, 13, 35, 29, 8, -27 },
  { 2146, 22, 21, 29, 4, -26 },
  { 2204, 23, 14, 29, 3, -23 },
  { 2245, 23, 21, 29, 2, -26 },
  { 2306, 20, 35, 29, 7, -35 },
  { 2394, 26, 35, 29, 2, -35 },
  { 2508, 26, 35, 29, -1, -35 },
  { 2622, 26, 35, 29, 1, -35 },
  { 2736, 26, 36, 29, 2, -35 },
  { 2853, 26, 35, 29, 1, -35 },
  { 2967, 26, 35, 29, 2, -35 },
  { 3081, 27, 35, 29, 2, -35 },
  { 3200, 26, 36, 29, 2, -35 },
  { 3317, 28, 35, 29, 1, -35 },
  { 3440, 26, 35, 29, 2, -35 },
  { 3554, 27, 36, 29, 1, -35 },
  { 3676, 30, 35, 29, 1, -35 },
  { 3808, 22, 35, 29, 2, -35 },
  { 3905, 28, 35, 29, 1, -35 },
  { 4028, 28, 35, 29, 1, -35 },
  { 4151, 25, 36, 29, 2, -35 },
  { 4264, 27, 35, 29, 2, -35 },
  { 4383, 25, 41, 29, 2, -35 },
  { 4512, 26, 35, 29, 2, -35 },
  { 4626, 26, 36, 29, 2, -35 },
  { 4743, 25, 35, 29, 5, -35 },
  { 4853, 27, 36, 29, 2, -35 },
  { 4975, 25, 35, 29, 5, -35 },
  { 5085, 27, 35, 29, 4, -35 },
  { 5204, 30, 35, 29, 0, -35 },
  { 5336, 25, 35, 29, 5, -35 },
  { 5446, 28, 35, 29, 0, -35 },
  { 5569, 17, 47, 29, 6, -40 },
  { 5669, 11, 38, 29, 9, -35 },
  { 5722, 17, 47, 29, 6, -40 },
  { 5822, 17, 19, 29, 6, -35 },
  { 5863, 22, 4, 29, 0, 0 },
  { 5874, 8, 6, 29, 13, -35 },
  { 5880, 23, 26, 29, 2, -26 },
  { 5955, 23, 38, 29, 2, -37 },
  { 6065, 23, 27, 29, 3, -26 },
  { 6143, 25, 38, 29, 3, -37 },
  { 6262, 23, 27, 29, 3, -26 },
  { 6340, 25, 38, 29, 5, -38 },
  { 6459, 25, 36, 29, 1, -26 },
  { 6572, 23, 37, 29, 2, -37 },
  { 6679, 22, 35, 29, 2, -35 },
  { 6776, 22, 46, 29, 1, -35 },
  { 6903, 25, 37, 29, 2, -37 },
  { 7019, 22, 37, 29, 2, -37 },
  { 7121, 27, 26, 29, 0, -26 },
  { 7209, 23, 26, 29, 2, -26 },
  { 7284, 24, 27, 29, 2, -26 },
  { 7365, 25, 36, 29, 0, -26 },
  { 7478, 23, 36, 29, 3, -26 },
  { 7582, 22, 26, 29, 5, -26 },
  { 7654, 22, 27, 29, 3, -26 },
  { 7729, 21, 33, 29, 5, -32 },
  { 7816, 24, 27, 29, 3, -26 },
  { 7897, 24, 26, 29, 4, -26 },
  { 7975, 27, 26, 29, 3, -26 },
  { 8063, 28, 26, 29, 0, -26 },
  { 8154, 30, 37, 29, -1, -26 },
  { 8293, 25, 26, 29, 1, -26 },
  { 8375, 20, 47, 29, 7, -38 },
  { 8493, 10, 45, 29, 9, -35 },
  { 8550, 19, 47, 29, 4, -38 },
  { 8662, 27, 9, 29, 1, -19 },
};

const GFXfont RobotoMono_Italic49pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic49pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic49pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _ROBOTOMONO_ITALIC49PT7B_H_
