#ifndef _ROBOTOMONO_ITALIC16PT7B_H_
#define _ROBOTOMONO_ITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xB6, 0x90, 0x13, 0x00, 0x5A, 0xB5, 0x20, 0x04, 0x82, 0x40,
  0x95, 0xFE, 0x12, 0x04, 0x83, 0x23, 0xFC, 0x24, 0x1B, 0x04, 0x80, 0x04,
  0x0C, 0x3E, 0x63, 0x63, 0x60, 0x30, 0x1C, 0x06, 0x02, 0x86, 0xC6, 0x7C,
  0x30, 0x20, 0x20, 0x50, 0x92, 0x94, 0xF4, 0x08, 0x10, 0x36, 0x2B, 0x59,
  0x5A, 0x0E, 0x04, 0x0F, 0x04, 0xC6, 0x41, 0x60, 0xC0, 0xE0, 0xDB, 0x45,
  0x23, 0x91, 0x87, 0xE0, 0x5E, 0x08, 0x88, 0xC4, 0x63, 0x10, 0x84, 0x21,
  0x08, 0x43, 0x08, 0x20, 0x10, 0x40, 0x82, 0x08, 0x30, 0xC3, 0x08, 0x20,
  0x86, 0x10, 0xC2, 0x10, 0x80, 0x18, 0x23, 0x5B, 0xE3, 0x09, 0x33, 0x00,
  0x08, 0x18, 0x18, 0xFF, 0x10, 0x10, 0x10, 0x30, 0x5E, 0x80, 0xFF, 0xE0,
  0xF0, 0x03, 0x02, 0x04, 0x04, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40,
  0x80, 0x08, 0x3E, 0x62, 0x43, 0x43, 0xCF, 0xDA, 0xE2, 0xC2, 0x86, 0xC4,
  0x78, 0x3F, 0xE6, 0x21, 0x08, 0xC6, 0x21, 0x08, 0x04, 0x3F, 0x21, 0x61,
  0x03, 0x02, 0x06, 0x0C, 0x10, 0x20, 0x41, 0xFE, 0x04, 0x1F, 0x21, 0x61,
  0x03, 0x06, 0x1E, 0x02, 0x02, 0xC2, 0x46, 0x7C, 0x03, 0x07, 0x0F, 0x0A,
  0x12, 0x22, 0x62, 0xFF, 0x06, 0x04, 0x04, 0x3F, 0x20, 0x20, 0x60, 0x7C,
  0x26, 0x02, 0x02, 0xC6, 0xC4, 0x78, 0x1E, 0x61, 0x82, 0x0F, 0xD8, 0xE1,
  0xC3, 0xC7, 0x99, 0xE0, 0x7F, 0x03, 0x02, 0x04, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x60, 0xC0, 0x08, 0x3E, 0x23, 0x63, 0x63, 0x36, 0x3C, 0x46, 0xC2,
  0x82, 0xC6, 0x7C, 0x11, 0xFC, 0x61, 0x86, 0x18, 0xDD, 0x0C, 0x63, 0x38,
  0x33, 0x00, 0x00, 0x06, 0xE0, 0x33, 0x00, 0x00, 0x04, 0x4C, 0x88, 0x02,
  0x0C, 0xF7, 0x0E, 0x07, 0x03, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x40, 0xC0,
  0xE0, 0x30, 0xEF, 0x30, 0x40, 0x10, 0xFB, 0x18, 0x30, 0x41, 0x86, 0x18,
  0x20, 0x01, 0x03, 0x00, 0x3E, 0x61, 0x5D, 0x95, 0xA5, 0xA5, 0xA9, 0xBA,
  0xA4, 0x80, 0x78, 0x06, 0x0E, 0x0A, 0x1A, 0x12, 0x32, 0x22, 0x7F, 0x43,
  0xC3, 0x81, 0x3F, 0x18, 0xC8, 0x64, 0x33, 0xF3, 0xF1, 0x84, 0xC2, 0x41,
  0x23, 0xBF, 0x00, 0x08, 0x3E, 0x63, 0x41, 0xC0, 0xC0, 0x80, 0x80, 0x80,
  0x86, 0xC4, 0x78, 0x3E, 0x10, 0x88, 0x64, 0x36, 0x1B, 0x0D, 0x86, 0x82,
  0x43, 0x23, 0x3E, 0x00, 0x7F, 0x60, 0x40, 0x40, 0x40, 0x7E, 0xC0, 0xC0,
  0x80, 0x82, 0xFC, 0x7F, 0x60, 0x60, 0x40, 0x40, 0x7E, 0xC0, 0xC0, 0x80,
  0x80, 0x80, 0x08, 0x3E, 0x63, 0x41, 0xC0, 0x80, 0x8F, 0x8E, 0x82, 0x82,
  0xC6, 0x7C, 0x30, 0x90, 0x48, 0x24, 0x36, 0x1B, 0xF9, 0x04, 0x82, 0x41,
  0x21, 0xB0, 0xC0, 0x3F, 0x82, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x20, 0x10,
  0x08, 0x0C, 0x3F, 0x80, 0x00, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x08, 0x0D,
  0x06, 0x42, 0x33, 0x0F, 0x00, 0x31, 0xCC, 0xC2, 0x60, 0xB0, 0x28, 0x1F,
  0x06, 0xC1, 0x98, 0x46, 0x10, 0x8C, 0x30, 0x20, 0xC1, 0x82, 0x04, 0x08,
  0x30, 0x60, 0xC1, 0x03, 0xF8, 0x31, 0xCC, 0x63, 0x38, 0xEA, 0x6F, 0x9B,
  0x44, 0xD1, 0x24, 0x41, 0x10, 0xCC, 0x30, 0x30, 0x98, 0x4E, 0x65, 0x36,
  0x9B, 0x69, 0x14, 0x8A, 0x47, 0x21, 0xB0, 0xC0, 0x08, 0x3E, 0x62, 0x43,
  0xC3, 0xC3, 0x83, 0x82, 0x82, 0x86, 0xCC, 0x78, 0x7E, 0x63, 0x61, 0x41,
  0x43, 0x7E, 0xC0, 0xC0, 0x80, 0x80, 0x80, 0x08, 0x3E, 0x63, 0x43, 0xC1,
  0x83, 0x83, 0x83, 0x82, 0x86, 0xCC, 0x78, 0x0C, 0x06, 0x7E, 0x63, 0x41,
  0x43, 0x42, 0x7C, 0xC8, 0xCC, 0x84, 0x84, 0x86, 0x08, 0x3E, 0x63, 0x41,
  0x40, 0x70, 0x1C, 0x06, 0x02, 0x82, 0xC6, 0x7C, 0xFF, 0x10, 0x10, 0x30,
  0x30, 0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x61, 0x41, 0x41, 0x43, 0xC3,
  0xC2, 0x82, 0x82, 0x86, 0xCC, 0x78, 0x83, 0x86, 0x84, 0xC4, 0xCC, 0xC8,
  0x58, 0x50, 0x70, 0x60, 0x60, 0x49, 0xA4, 0xF6, 0x5B, 0x2D, 0xB7, 0x53,
  0xB9, 0xDC, 0xCE, 0x66, 0x33, 0x00, 0x30, 0xC4, 0x41, 0x30, 0x78, 0x0C,
  0x03, 0x01, 0xC0, 0xD8, 0x22, 0x18, 0x8C, 0x30, 0x83, 0xC6, 0x4C, 0x48,
  0x58, 0x70, 0x20, 0x20, 0x20, 0x60, 0x60, 0x3F, 0x80, 0x80, 0xC0, 0xC0,
  0xC0, 0x40, 0x40, 0x60, 0x60, 0x20, 0x3F, 0xC0, 0x3C, 0xC2, 0x08, 0x20,
  0x82, 0x18, 0x61, 0x04, 0x10, 0x43, 0x0E, 0x00, 0x8C, 0x44, 0x44, 0x62,
  0x22, 0x23, 0x38, 0x42, 0x31, 0x8C, 0x42, 0x10, 0x8C, 0x62, 0x13, 0x80,
  0x10, 0xA2, 0x92, 0x4A, 0x30, 0xFE, 0xC8, 0x80, 0x18, 0xFD, 0x08, 0x17,
  0xF8, 0xE1, 0xE6, 0x74, 0x20, 0xC1, 0x82, 0x47, 0xE8, 0x70, 0xE1, 0xC3,
  0x0F, 0x35, 0xC0, 0x18, 0x7D, 0x0E, 0x08, 0x10, 0x21, 0xE2, 0x78, 0x01,
  0x01, 0x03, 0x1B, 0x7E, 0x42, 0xC2, 0x82, 0x86, 0x86, 0xCC, 0x7C, 0x18,
  0x7D, 0x0E, 0x1F, 0xF0, 0x20, 0x63, 0x7C, 0x1F, 0x10, 0x30, 0x22, 0xFC,
  0x20, 0x20, 0x60, 0x60, 0x40, 0x40, 0x40, 0x0C, 0x9F, 0x88, 0x4C, 0x24,
  0x12, 0x19, 0x0C, 0xCC, 0x3E, 0x01, 0x31, 0x8F, 0x80, 0x10, 0x30, 0x30,
  0x26, 0x3F, 0x21, 0x61, 0x61, 0x63, 0x43, 0x43, 0xC2, 0x04, 0x18, 0x00,
  0x07, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x47, 0xF0, 0x02, 0x03, 0x00, 0x00,
  0x1E, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0xF0, 0x20,
  0x60, 0x60, 0x41, 0x46, 0x4C, 0xD0, 0xF0, 0xD8, 0x88, 0x8C, 0x86, 0x3C,
  0x18, 0x30, 0x40, 0x81, 0x06, 0x0C, 0x18, 0x20, 0x47, 0xF0, 0x19, 0x3F,
  0xD3, 0x29, 0x34, 0x9E, 0x4B, 0x25, 0x32, 0x9B, 0x00, 0x06, 0x3F, 0x21,
  0x61, 0x61, 0x63, 0x43, 0x43, 0xC2, 0x18, 0xFD, 0x0E, 0x18, 0x30, 0x61,
  0xE2, 0x78, 0x04, 0x3F, 0x23, 0x61, 0x61, 0x61, 0x43, 0x66, 0x7C, 0xC0,
  0xC0, 0x80, 0x19, 0x7E, 0x42, 0xC2, 0x82, 0x86, 0x86, 0xCC, 0x7C, 0x04,
  0x04, 0x0C, 0x0C, 0xBD, 0x82, 0x0C, 0x18, 0x30, 0x40, 0x80, 0x18, 0xFD,
  0x0A, 0x03, 0x81, 0xE1, 0xE3, 0x7C, 0x30, 0x82, 0x3F, 0x21, 0x86, 0x10,
  0x41, 0x83, 0x80, 0x43, 0x42, 0x42, 0xC2, 0xC6, 0xC6, 0xCC, 0x74, 0xC3,
  0x42, 0x46, 0x64, 0x28, 0x28, 0x30, 0x30, 0x99, 0xCC, 0xA6, 0xD5, 0x4A,
  0xA6, 0x63, 0x31, 0x98, 0x31, 0x89, 0x07, 0x81, 0x81, 0xC1, 0xA1, 0x89,
  0x86, 0x61, 0x90, 0x88, 0xC6, 0x41, 0x60, 0xE0, 0x60, 0x30, 0x10, 0x18,
  0x38, 0x00, 0x3F, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFE, 0x02,
  0x18, 0x20, 0xC1, 0x82, 0x04, 0x30, 0xE0, 0x40, 0xC1, 0x02, 0x04, 0x0C,
  0x0C, 0x24, 0x96, 0x92, 0x4B, 0x49, 0x00, 0x18, 0x10, 0x20, 0x40, 0x81,
  0x03, 0x07, 0x18, 0x20, 0x41, 0x83, 0x0C, 0x30, 0x00, 0x78, 0xE6, 0xC1,
  0xC0,
};

const GFXglyph RobotoMono_Italic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 4, 9, 3, -12 },
  { 9, 10, 11, 9, 0, -11 },
  { 23, 8, 15, 9, 1, -13 },
  { 38, 8, 12, 9, 1, -12 },
  { 50, 9, 12, 9, 0, -12 },
  { 64, 2, 4, 9, 4, -12 },
  { 65, 5, 17, 9, 3, -13 },
  { 76, 6, 17, 9, 1, -13 },
  { 89, 7, 7, 9, 2, -11 },
  { 96, 8, 8, 9, 1, -9 },
  { 104, 2, 5, 9, 2, -2 },
  { 106, 6, 2, 9, 2, -6 },
  { 108, 2, 2, 9, 3, -2 },
  { 109, 8, 12, 9, 1, -11 },
  { 121, 8, 12, 9, 1, -12 },
  { 133, 5, 11, 9, 2, -11 },
  { 140, 8, 12, 9, 0, -12 },
  { 152, 8, 12, 9, 0, -12 },
  { 164, 8, 11, 9, 0, -11 },
  { 175, 8, 11, 9, 1, -11 },
  { 186, 7, 11, 9, 1, -11 },
  { 196, 8, 11, 9, 1, -11 },
  { 207, 8, 12, 9, 1, -12 },
  { 219, 6, 12, 9, 2, -12 },
  { 228, 4, 9, 9, 3, -9 },
  { 233, 4, 12, 9, 3, -9 },
  { 239, 7, 7, 9, 1, -9 },
  { 246, 8, 4, 9, 1, -7 },
  { 250, 7, 8, 9, 1, -9 },
  { 257, 7, 12, 9, 2, -12 },
  { 268, 8, 11, 9, 1, -11 },
  { 279, 8, 11, 9, 0, -11 },
  { 290, 9, 11, 9, 0, -11 },
  { 303, 8, 12, 9, 1, -12 },
  { 315, 9, 11, 9, 0, -11 },
  { 328, 8, 11, 9, 1, -11 },
  { 339, 8, 11, 9, 1, -11 },
  { 350, 8, 12, 9, 1, -12 },
  { 362, 9, 11, 9, 0, -11 },
  { 375, 9, 11, 9, 0, -11 },
  { 388, 9, 11, 9, 0, -11 },
  { 401, 10, 11, 9, 0, -11 },
  { 415, 7, 11, 9, 1, -11 },
  { 425, 10, 11, 9, 0, -11 },
  { 439, 9, 11, 9, 0, -11 },
  { 452, 8, 12, 9, 1, -12 },
  { 464, 8, 11, 9, 1, -11 },
  { 475, 8, 14, 9, 1, -12 },
  { 489, 8, 11, 9, 1, -11 },
  { 500, 8, 12, 9, 1, -12 },
  { 512, 8, 11, 9, 2, -11 },
  { 523, 8, 11, 9, 1, -11 },
  { 534, 8, 11, 9, 2, -11 },
  { 545, 9, 11, 9, 1, -11 },
  { 558, 10, 11, 9, 0, -11 },
  { 572, 8, 11, 9, 2, -11 },
  { 583, 9, 11, 9, 0, -11 },
  { 596, 6, 15, 9, 2, -13 },
  { 608, 4, 12, 9, 3, -11 },
  { 614, 5, 15, 9, 2, -13 },
  { 624, 6, 6, 9, 2, -11 },
  { 629, 7, 1, 9, 0, 0 },
  { 630, 3, 3, 9, 4, -12 },
  { 632, 7, 9, 9, 1, -9 },
  { 640, 7, 12, 9, 1, -12 },
  { 651, 7, 9, 9, 1, -9 },
  { 659, 8, 12, 9, 1, -12 },
  { 671, 7, 9, 9, 1, -9 },
  { 679, 8, 12, 9, 2, -12 },
  { 691, 9, 12, 9, 0, -9 },
  { 705, 8, 12, 9, 0, -12 },
  { 717, 7, 12, 9, 1, -12 },
  { 728, 8, 15, 9, 0, -12 },
  { 743, 8, 12, 9, 1, -12 },
  { 755, 7, 12, 9, 1, -12 },
  { 766, 9, 9, 9, 0, -9 },
  { 777, 8, 9, 9, 0, -9 },
  { 786, 7, 9, 9, 1, -9 },
  { 794, 8, 12, 9, 0, -9 },
  { 806, 8, 12, 9, 1, -9 },
  { 818, 7, 9, 9, 2, -9 },
  { 826, 7, 9, 9, 1, -9 },
  { 834, 6, 11, 9, 2, -11 },
  { 843, 8, 8, 9, 1, -8 },
  { 851, 8, 8, 9, 1, -8 },
  { 859, 9, 8, 9, 1, -8 },
  { 868, 9, 8, 9, 0, -8 },
  { 877, 9, 11, 9, 0, -8 },
  { 890, 9, 8, 9, 0, -8 },
  { 899, 7, 16, 9, 2, -13 },
  { 913, 3, 14, 9, 3, -11 },
  { 919, 7, 15, 9, 1, -12 },
  { 933, 9, 3, 9, 0, -6 },
};

const GFXfont RobotoMono_Italic16pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic16pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _ROBOTOMONO_ITALIC16PT7B_H_
