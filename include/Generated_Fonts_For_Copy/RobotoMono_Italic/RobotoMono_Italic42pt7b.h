#ifndef _ROBOTOMONO_ITALIC42PT7B_H_
#define _ROBOTOMONO_ITALIC42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic42pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0xC1, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x1E, 0x0F, 0x07, 0x80, 0x38,
  0x73, 0x87, 0x38, 0x73, 0x87, 0x70, 0x67, 0x0E, 0x70, 0xE7, 0x0E, 0x60,
  0xEE, 0x0C, 0x00, 0x0E, 0x0E, 0x00, 0x0C, 0x0E, 0x00, 0x1C, 0x1C, 0x00,
  0x1C, 0x1C, 0x00, 0x38, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00,
  0x70, 0x70, 0x00, 0x70, 0x70, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x00, 0xC0, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80, 0x07, 0x07, 0x00, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x0E, 0x0E, 0x00, 0x0E,
  0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0x80, 0x7F, 0xFC, 0x07, 0xE1, 0xF0, 0x3C, 0x07, 0x83, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0xC7, 0x80, 0x1E,
  0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x81, 0xF8, 0x3F, 0xFF, 0x80, 0xFF,
  0xF8, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x71, 0xC0, 0x0E, 0x0C,
  0x00, 0xE0, 0xE0, 0xCE, 0x0E, 0x1C, 0xE0, 0xE3, 0x8E, 0x0C, 0x38, 0xE1,
  0xC7, 0x0E, 0x1C, 0xE0, 0xFF, 0x9E, 0x07, 0xF1, 0xC0, 0x1E, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x70,
  0x03, 0x9F, 0xC0, 0x73, 0xFE, 0x0F, 0x38, 0xE0, 0xE7, 0x06, 0x1C, 0x70,
  0x73, 0x87, 0x07, 0x78, 0x70, 0x61, 0x06, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x0E, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x38, 0xF0,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF8, 0x1C, 0x7D, 0xE0, 0x73, 0xC3, 0xC3, 0xDF, 0x0F,
  0x8E, 0x78, 0x1E, 0x79, 0xC0, 0x3D, 0xEF, 0x00, 0xFF, 0x3C, 0x01, 0xF8,
  0xF0, 0x07, 0xE1, 0xE0, 0x1F, 0x07, 0xC0, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFC, 0xF0, 0x3F, 0xC3, 0xE0, 0x39, 0xCE, 0xF7, 0x39, 0xCE, 0x67, 0x00,
  0x00, 0x08, 0x00, 0x60, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x60, 0x00, 0x80, 0x01, 0x00, 0x06, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x06, 0x00, 0x20, 0x00, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x30, 0x70, 0x67, 0xC7, 0x1E, 0x7F, 0x6F, 0xEB, 0xFF, 0xFF, 0x07,
  0xFF, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7B, 0x80, 0x07, 0x38, 0x00,
  0xF1, 0xC0, 0x1E, 0x1E, 0x07, 0xC1, 0xE0, 0x38, 0x0F, 0x01, 0x80, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x3C,
  0x78, 0xF3, 0xE7, 0x8F, 0x3C, 0x79, 0xE0, 0x80, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7B, 0xFF, 0xFF, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8,
  0x3E, 0x1E, 0x01, 0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38,
  0x00, 0xF7, 0x80, 0x1F, 0x78, 0x03, 0xF7, 0x80, 0xFF, 0x70, 0x1F, 0xF7,
  0x03, 0xEE, 0xF0, 0xF9, 0xEF, 0x1F, 0x1E, 0xF7, 0xC1, 0xEF, 0xF8, 0x1E,
  0xFE, 0x01, 0xEF, 0xC0, 0x1C, 0xF8, 0x03, 0xCE, 0x00, 0x3C, 0xE0, 0x03,
  0xCE, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0, 0x78, 0x1E, 0x07, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF1, 0xFF,
  0xFF, 0xFF, 0xEE, 0xF0, 0xE8, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01,
  0xF0, 0x3E, 0x07, 0x80, 0x78, 0x3C, 0x01, 0xE0, 0xE0, 0x03, 0x87, 0x80,
  0x0E, 0x1E, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83,
  0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF3,
  0xC0, 0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x3C, 0x1F, 0x03,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7B, 0x80, 0x07, 0x9C, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00,
  0x3C, 0x78, 0x03, 0xC3, 0x80, 0x3C, 0x1C, 0x01, 0xC1, 0xE0, 0x1E, 0x0F,
  0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x1C, 0x0E, 0x00, 0xE0, 0xF0,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xF8, 0x3F, 0x01, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0xE3, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x07, 0x83, 0x80, 0x3C,
  0x1E, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xC0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0xE0, 0x1E, 0x7F, 0x03, 0xBF, 0xF8, 0x7F, 0xFF, 0x1F, 0xC1, 0xF3, 0xE0,
  0x1E, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00, 0xF7, 0x00,
  0x1E, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0xF0, 0xF0, 0x3C, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFB, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xFC, 0x07,
  0xFF, 0xE0, 0xFC, 0x3E, 0x0F, 0x01, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0xF1,
  0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x1E,
  0x0F, 0x07, 0xC0, 0x7F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x1F,
  0x83, 0xC0, 0x78, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xCF, 0x00,
  0x1C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x78,
  0x1F, 0x07, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E, 0x3C, 0x07, 0x9E, 0x00, 0xF7, 0x80,
  0x3D, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7D, 0xE0, 0x3E, 0x7C, 0x3F, 0x8F,
  0xFE, 0xE1, 0xFF, 0x78, 0x3F, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0xFF, 0x01, 0xFF, 0x80,
  0x7F, 0x80, 0x1F, 0x00, 0x00, 0x0F, 0x0F, 0xC7, 0xE3, 0xF0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x1F, 0x8F, 0xC7, 0xE1, 0xE0, 0x03, 0xC0, 0xFC, 0x1F, 0x83,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x0E, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x04, 0x00, 0x3F,
  0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF,
  0xFF, 0x7F, 0xFF, 0xC0, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x08, 0x00,
  0x00, 0x07, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0x8F, 0x83, 0xEF, 0x80, 0xF7,
  0x80, 0x3F, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x0F, 0x01, 0xC0, 0x38, 0x01, 0xC0, 0xE0, 0x01, 0x83, 0x81,
  0xC3, 0x86, 0x0F, 0xC7, 0x1C, 0x7F, 0xC6, 0x30, 0xE3, 0x8C, 0xE3, 0x86,
  0x19, 0x86, 0x0C, 0x37, 0x1C, 0x18, 0x6E, 0x30, 0x70, 0xD8, 0x60, 0xC3,
  0xB1, 0xC1, 0x86, 0x63, 0x83, 0x0D, 0xC7, 0x0E, 0x1B, 0x8E, 0x18, 0x77,
  0x1C, 0x70, 0xCE, 0x39, 0xE3, 0x9C, 0x7F, 0xFE, 0x18, 0x7C, 0xF8, 0x30,
  0x00, 0x40, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x10, 0x00, 0xFD,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80,
  0x03, 0xCE, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x0F,
  0x07, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x70, 0x0F, 0x01, 0xC0, 0x3C, 0x07,
  0x80, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xF0, 0x03, 0x83,
  0x80, 0x0E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xE3, 0xC0, 0x03, 0xCE, 0x00,
  0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x01, 0xE0, 0xFE, 0x07, 0x00, 0x7C, 0x1C, 0x00, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0,
  0x07, 0x87, 0x80, 0x3E, 0x1E, 0x03, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x1C, 0x03, 0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x1E, 0x3C, 0x00, 0x78, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x1E, 0x00,
  0x3C, 0x78, 0x01, 0xF1, 0xE0, 0x0F, 0x87, 0x80, 0xFC, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00,
  0x3F, 0xFE, 0x01, 0xF0, 0x7C, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE1, 0xE0,
  0x03, 0x87, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0x8F, 0x00, 0x1E, 0x1C, 0x00, 0x78,
  0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xFC, 0x01, 0xC1, 0xFC, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0xF0, 0x07,
  0x83, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x01, 0xC7,
  0x80, 0x07, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x71, 0xC0, 0x03, 0xCF, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0x8F, 0x00, 0x1E,
  0x38, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x78, 0x78,
  0x03, 0xC1, 0xE0, 0x3F, 0x07, 0x03, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFC,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xF0, 0x7C, 0x0F, 0x80, 0x78,
  0x3C, 0x01, 0xE1, 0xE0, 0x03, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x07, 0xFE, 0xF0, 0x1F, 0xF3, 0xC0, 0x7F, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00,
  0x0E, 0x1C, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xF0, 0x07, 0x83, 0xE0, 0x7E,
  0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0x07, 0x00, 0x0E, 0x0F, 0x00, 0x0E, 0x0F, 0x00, 0x0E,
  0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1E, 0x0E, 0x00, 0x1C,
  0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x1C, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x3C,
  0x1C, 0x00, 0x3C, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8,
  0x3C, 0x00, 0x78, 0x38, 0x00, 0x78, 0x38, 0x00, 0x78, 0x78, 0x00, 0x70,
  0x78, 0x00, 0x70, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0x70, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0,
  0xE0, 0x01, 0xE0, 0xE0, 0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x80,
  0xF0, 0x3E, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00,
  0x07, 0x80, 0x0F, 0x83, 0xC0, 0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x0F,
  0x80, 0x70, 0x0F, 0x80, 0x38, 0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x0F,
  0x80, 0x0F, 0x0F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0x87, 0x80, 0x03, 0xC7,
  0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x87, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xE0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x0F, 0x00, 0x3C, 0x07, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x3F, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0xFE,
  0x0F, 0xC0, 0xEE, 0x0E, 0xE1, 0xFE, 0x0E, 0xE1, 0xDC, 0x1E, 0xE3, 0xDC,
  0x1E, 0xE3, 0x9C, 0x1C, 0xE7, 0x9C, 0x1C, 0xE7, 0x3C, 0x1C, 0xEF, 0x3C,
  0x3C, 0xFE, 0x38, 0x3C, 0x7E, 0x38, 0x3C, 0x7C, 0x38, 0x3C, 0x7C, 0x78,
  0x38, 0x78, 0x78, 0x38, 0x78, 0x78, 0x78, 0x70, 0x70, 0x78, 0x70, 0x70,
  0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x70, 0x00, 0xF0, 0x70, 0x00, 0xF0,
  0xF0, 0x00, 0xE0, 0xF0, 0x00, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x07, 0x80, 0x0E, 0x0F, 0x80, 0x0E, 0x0F, 0xC0, 0x1E,
  0x0F, 0xC0, 0x1E, 0x0F, 0xC0, 0x1E, 0x0F, 0xE0, 0x1E, 0x0F, 0xE0, 0x1C,
  0x1E, 0xE0, 0x3C, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x3C, 0x1E, 0x70, 0x3C,
  0x1E, 0x78, 0x3C, 0x1C, 0x78, 0x38, 0x3C, 0x38, 0x78, 0x3C, 0x3C, 0x78,
  0x3C, 0x3C, 0x78, 0x3C, 0x1C, 0x78, 0x38, 0x1E, 0x70, 0x38, 0x1E, 0xF0,
  0x78, 0x0E, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x07, 0xF0,
  0x70, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xF8, 0x0F, 0x87, 0xC0, 0xF8, 0x0F, 0x07, 0x80, 0x38, 0x78, 0x01,
  0xE3, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xF0,
  0x00, 0x77, 0x80, 0x07, 0xB8, 0x00, 0x3D, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x78, 0x03, 0xC3,
  0xC0, 0x3C, 0x0F, 0x07, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xC0, 0x7E,
  0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x1E,
  0x00, 0x1C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1C, 0x00,
  0x78, 0x70, 0x03, 0xE3, 0xC0, 0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x83, 0xE0, 0xF8,
  0x0F, 0x0F, 0x80, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x39,
  0xC0, 0x01, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00,
  0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x73, 0xC0, 0x07,
  0x9E, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x3C, 0x0F, 0x07, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x40, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3C, 0x0F, 0xC0, 0x78, 0x07, 0xC0, 0xE0,
  0x07, 0x81, 0xC0, 0x07, 0x07, 0x80, 0x0E, 0x0F, 0x00, 0x1C, 0x1E, 0x00,
  0x38, 0x3C, 0x00, 0xF0, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x1F,
  0x07, 0x81, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xFE, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF0, 0x7C, 0x0F, 0x80,
  0x78, 0x7C, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE1, 0xE0, 0x0F, 0x87, 0xC0,
  0x7C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x1E,
  0x1C, 0x00, 0x38, 0x78, 0x00, 0x70, 0xF0, 0x00, 0xE1, 0xE0, 0x03, 0xC3,
  0x80, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x00,
  0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xE0, 0x01,
  0xE1, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x00,
  0xF0, 0x3E, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xE7, 0x00, 0x07, 0x9E, 0x00, 0x3C, 0x78,
  0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x78, 0x03,
  0xC0, 0xE0, 0x1E, 0x03, 0x80, 0x78, 0x0F, 0x01, 0xC0, 0x3C, 0x0F, 0x00,
  0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x1C, 0x3C, 0x00, 0x70,
  0xF0, 0x01, 0xC7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0xC0,
  0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x3C, 0x0E, 0xF0, 0x78, 0x3D, 0xE0, 0xF0, 0x7B, 0xC3, 0xE0, 0xE7, 0x07,
  0xC1, 0xCE, 0x0F, 0x87, 0x9C, 0x3F, 0x0F, 0x38, 0x7E, 0x1C, 0x70, 0xFC,
  0x38, 0xE1, 0xF8, 0xF1, 0xC7, 0x71, 0xC3, 0x8E, 0xE3, 0x87, 0x1D, 0xC7,
  0x0E, 0x73, 0x9E, 0x1C, 0xE7, 0x38, 0x39, 0xCE, 0x70, 0x77, 0x1C, 0xE0,
  0xEE, 0x3B, 0xC3, 0xDC, 0x77, 0x07, 0xF0, 0xEE, 0x0F, 0xE1, 0xFC, 0x1F,
  0xC3, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF0,
  0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x1E, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF8,
  0x3E, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x0F,
  0x1E, 0x00, 0x7C, 0x3C, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x07,
  0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xE1, 0xE0, 0x03, 0x87,
  0x80, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x7F, 0x81, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x77, 0x01, 0xEE, 0x03, 0x9C, 0x0F, 0x38,
  0x1C, 0x78, 0x78, 0x71, 0xE0, 0xE3, 0x81, 0xCF, 0x03, 0x9C, 0x07, 0xF8,
  0x07, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x70, 0xF0,
  0xE0, 0xE0, 0x00, 0x38, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xE7, 0xE1,
  0xF0, 0x3E, 0x3C, 0x03, 0xCF, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x1F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x1C, 0xF8, 0x03, 0x9E,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x3E, 0x7C,
  0x0F, 0xC7, 0xFF, 0xF8, 0x7F, 0xEF, 0x07, 0xF8, 0xE0, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x70, 0x03,
  0xDF, 0xE0, 0x1D, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xC0, 0xF8, 0x7C, 0x03,
  0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x38,
  0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x38, 0xF0, 0x03, 0xC7, 0x80, 0x1E,
  0x38, 0x00, 0xF3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF8, 0x07, 0x87, 0xE0,
  0x7C, 0x3F, 0xFF, 0xC1, 0xDF, 0xFC, 0x1E, 0x3F, 0x80, 0x00, 0x38, 0x00,
  0x1F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x01, 0xE1, 0xE0, 0x0E,
  0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0xF8, 0x1F,
  0xFF, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0xC1, 0xE0, 0x3F,
  0xE7, 0x81, 0xFF, 0xDC, 0x0F, 0xFF, 0xF0, 0x7C, 0x0F, 0xC1, 0xE0, 0x1F,
  0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0x87, 0x80, 0x1E, 0x1E,
  0x00, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x8F, 0x00, 0x1C, 0x3C, 0x00,
  0x70, 0x70, 0x03, 0xC1, 0xC0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x01, 0xF0,
  0x3C, 0x1F, 0x80, 0xFF, 0xFE, 0x01, 0xFF, 0xB8, 0x03, 0xF9, 0xE0, 0x00,
  0x38, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80, 0xFF, 0xFC, 0x0F, 0x03, 0xE1,
  0xE0, 0x1E, 0x3C, 0x00, 0xE3, 0xC0, 0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F,
  0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x10, 0x78, 0x01, 0x83, 0xE0,
  0x7C, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0x02, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0xF0, 0x3F, 0xFB, 0x81, 0xFF, 0xFE,
  0x0F, 0x81, 0xF8, 0x3C, 0x03, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1E, 0x3C,
  0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0E, 0x0E, 0x00, 0x78, 0x38, 0x01, 0xE0,
  0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x07, 0x83, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F,
  0xF7, 0x00, 0x7F, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x06, 0x00, 0x78, 0x3C, 0x07, 0xC0, 0xFC, 0x7E, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x30, 0x03, 0xCF, 0xF0, 0x1C, 0xFF,
  0xC0, 0xEF, 0xFF, 0x07, 0xE0, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1C, 0x78, 0x00, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xE3, 0xC0,
  0x07, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xF1,
  0xC0, 0x07, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x02,
  0x01, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x41, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xC3, 0xC0, 0x7C, 0x0E,
  0x03, 0xE0, 0x38, 0x1F, 0x01, 0xE0, 0xF8, 0x07, 0x87, 0xC0, 0x1E, 0x3E,
  0x00, 0x7B, 0xE0, 0x01, 0xDF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xF7, 0x80, 0x0F, 0x8F, 0x00, 0x38, 0x3E, 0x01, 0xE0,
  0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1F,
  0x07, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F,
  0xFC, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x30,
  0x30, 0x3D, 0xF9, 0xF8, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xE1, 0xF0,
  0xE3, 0x83, 0xC1, 0xC7, 0x07, 0x83, 0x9E, 0x0F, 0x07, 0x3C, 0x1C, 0x1E,
  0x78, 0x38, 0x3C, 0xE0, 0xF0, 0x79, 0xC1, 0xE0, 0xE3, 0x83, 0xC1, 0xCF,
  0x07, 0x03, 0x9E, 0x0E, 0x0F, 0x3C, 0x1C, 0x1E, 0x70, 0x78, 0x3C, 0xE0,
  0xF0, 0x73, 0xC1, 0xE0, 0xE7, 0x83, 0x81, 0xCF, 0x07, 0x07, 0x9E, 0x0E,
  0x0F, 0x38, 0x3C, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x71, 0xFE, 0x03, 0x9F,
  0xF8, 0x1F, 0xFF, 0xE0, 0xFC, 0x0F, 0x0F, 0x80, 0x78, 0x78, 0x01, 0xC3,
  0xC0, 0x0F, 0x1E, 0x00, 0x70, 0xE0, 0x03, 0x8F, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x78,
  0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1C,
  0x38, 0x00, 0xE3, 0xC0, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x80, 0xFF, 0xFC, 0x1F, 0x03, 0xE3, 0xE0, 0x1E, 0x3C, 0x00, 0xE7,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xE7, 0x00, 0x3C, 0x78, 0x07, 0x83, 0xC0, 0xF8, 0x3F, 0xFF, 0x01, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x86, 0x00, 0x1C, 0xFF, 0x00, 0x77, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xC0, 0xF8, 0x3E, 0x01, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x0E, 0x0F, 0x00, 0x3C, 0x38, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0E, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1E,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x0F, 0xC0, 0xF8, 0x3F,
  0xFF, 0xC0, 0xEF, 0xFE, 0x07, 0x8F, 0xE0, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F,
  0xF3, 0xC1, 0xFF, 0xDC, 0x1F, 0xFF, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0xF8,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x0E,
  0x00, 0x78, 0x70, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xF0, 0x78, 0x1F,
  0x03, 0xFF, 0xF8, 0x0F, 0xFD, 0xC0, 0x3F, 0xDE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x81, 0xE3,
  0xFC, 0x39, 0xFF, 0x87, 0x7F, 0xE0, 0xFE, 0x04, 0x3F, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xE1, 0xE0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0xC0, 0x1E,
  0x7C, 0x07, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xE0, 0x0F,
  0xF8, 0x3C, 0x00, 0xF3, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x1E, 0x38,
  0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C, 0x78, 0x03, 0xC7,
  0x00, 0x3C, 0x70, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x38,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0x78, 0x3F,
  0x07, 0xFF, 0xF0, 0x3F, 0xE7, 0x01, 0xFC, 0x70, 0xE0, 0x00, 0xFF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0x70, 0x03, 0x87, 0x00, 0x78, 0x78,
  0x07, 0x07, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0x81, 0xE0, 0x38, 0x1C, 0x03,
  0xC3, 0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0xF0, 0x01, 0xEE, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0xE0, 0x30, 0x1F, 0x81, 0xC0, 0x7E, 0x07, 0x03, 0xB8,
  0x3C, 0x0E, 0xE0, 0xF8, 0x7B, 0x87, 0xE1, 0xCE, 0x1F, 0x87, 0x38, 0x6E,
  0x3C, 0xE3, 0xB8, 0xE3, 0x8E, 0xE3, 0x8E, 0x73, 0x9C, 0x39, 0xCE, 0x70,
  0xEE, 0x39, 0xC3, 0xB8, 0xEE, 0x0E, 0xE1, 0xB8, 0x3F, 0x06, 0xE0, 0xFC,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x70, 0x00, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x3E, 0x03, 0xC0,
  0x7C, 0x03, 0xC0, 0xF8, 0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0xF3,
  0xC0, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF,
  0x00, 0x03, 0xC7, 0x80, 0x07, 0x83, 0x80, 0x0F, 0x83, 0xC0, 0x1F, 0x01,
  0xE0, 0x3E, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0xF8, 0x00, 0xF8, 0x0F, 0x00,
  0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x07,
  0x80, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x01, 0xE0,
  0x03, 0xC0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xE3, 0xC0, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xDC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF0, 0x00, 0x01, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x01, 0xC0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0E, 0x0E, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0x38, 0x38, 0x38, 0x38, 0x70, 0x70, 0x70, 0x70, 0x70, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0x02, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7F,
  0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0x80, 0x00, 0x1F, 0xC0, 0x08, 0x7F, 0xC0, 0x1D, 0xFF, 0xC0, 0x77, 0x87,
  0xE0, 0xEE, 0x03, 0xFF, 0xDC, 0x03, 0xFF, 0x10, 0x03, 0xFC, 0x00, 0x01,
  0xE0,
};

const GFXglyph RobotoMono_Italic42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 9, 30, 25, 8, -30 },
  { 35, 12, 10, 25, 8, -32 },
  { 50, 24, 30, 25, 1, -30 },
  { 140, 21, 39, 25, 2, -35 },
  { 243, 20, 30, 25, 3, -30 },
  { 318, 22, 30, 25, 1, -30 },
  { 401, 5, 10, 25, 11, -32 },
  { 408, 14, 44, 25, 7, -34 },
  { 485, 14, 44, 25, 3, -34 },
  { 562, 20, 20, 25, 4, -30 },
  { 612, 21, 22, 25, 2, -25 },
  { 670, 7, 11, 25, 4, -4 },
  { 680, 16, 4, 25, 4, -15 },
  { 688, 6, 5, 25, 8, -5 },
  { 692, 22, 33, 25, 2, -30 },
  { 783, 20, 30, 25, 3, -30 },
  { 858, 12, 30, 25, 6, -30 },
  { 903, 22, 30, 25, 0, -30 },
  { 986, 21, 30, 25, 1, -30 },
  { 1065, 21, 30, 25, 1, -30 },
  { 1144, 21, 30, 25, 3, -30 },
  { 1223, 19, 30, 25, 2, -30 },
  { 1295, 21, 30, 25, 4, -30 },
  { 1374, 20, 30, 25, 3, -30 },
  { 1449, 18, 30, 25, 4, -30 },
  { 1517, 9, 23, 25, 9, -23 },
  { 1543, 11, 30, 25, 7, -23 },
  { 1585, 19, 19, 25, 3, -23 },
  { 1631, 19, 12, 25, 3, -19 },
  { 1660, 20, 18, 25, 2, -22 },
  { 1705, 17, 30, 25, 6, -30 },
  { 1769, 23, 30, 25, 1, -30 },
  { 1856, 22, 30, 25, -1, -30 },
  { 1939, 22, 30, 25, 1, -30 },
  { 2022, 22, 30, 25, 2, -30 },
  { 2105, 22, 30, 25, 1, -30 },
  { 2188, 23, 30, 25, 1, -30 },
  { 2275, 23, 30, 25, 2, -30 },
  { 2362, 22, 31, 25, 2, -30 },
  { 2448, 24, 30, 25, 1, -30 },
  { 2538, 23, 30, 25, 1, -30 },
  { 2625, 23, 30, 25, 1, -30 },
  { 2712, 25, 30, 25, 1, -30 },
  { 2806, 18, 30, 25, 2, -30 },
  { 2874, 24, 30, 25, 1, -30 },
  { 2964, 24, 30, 25, 1, -30 },
  { 3054, 21, 30, 25, 2, -30 },
  { 3133, 22, 30, 25, 2, -30 },
  { 3216, 21, 35, 25, 2, -30 },
  { 3308, 23, 30, 25, 1, -30 },
  { 3395, 22, 30, 25, 2, -30 },
  { 3478, 22, 30, 25, 4, -30 },
  { 3561, 23, 30, 25, 2, -30 },
  { 3648, 22, 30, 25, 4, -30 },
  { 3731, 23, 30, 25, 3, -30 },
  { 3818, 26, 30, 25, 0, -30 },
  { 3916, 22, 30, 25, 4, -30 },
  { 3999, 24, 30, 25, 0, -30 },
  { 4089, 14, 40, 25, 6, -34 },
  { 4159, 9, 33, 25, 8, -30 },
  { 4197, 14, 40, 25, 5, -34 },
  { 4267, 15, 16, 25, 5, -30 },
  { 4297, 19, 3, 25, 0, 0 },
  { 4305, 7, 5, 25, 11, -30 },
  { 4310, 19, 23, 25, 2, -23 },
  { 4365, 21, 32, 25, 1, -32 },
  { 4449, 20, 23, 25, 2, -23 },
  { 4507, 22, 32, 25, 2, -32 },
  { 4595, 20, 23, 25, 2, -23 },
  { 4653, 22, 32, 25, 4, -32 },
  { 4741, 22, 32, 25, 1, -23 },
  { 4829, 21, 32, 25, 1, -32 },
  { 4913, 19, 30, 25, 2, -30 },
  { 4985, 19, 39, 25, 1, -30 },
  { 5078, 22, 32, 25, 1, -32 },
  { 5166, 19, 32, 25, 2, -32 },
  { 5242, 23, 23, 25, 0, -23 },
  { 5309, 21, 23, 25, 1, -23 },
  { 5370, 20, 23, 25, 2, -23 },
  { 5428, 22, 32, 25, 0, -23 },
  { 5516, 21, 32, 25, 2, -23 },
  { 5600, 19, 23, 25, 4, -23 },
  { 5655, 19, 23, 25, 3, -23 },
  { 5710, 18, 28, 25, 4, -28 },
  { 5773, 20, 22, 25, 3, -22 },
  { 5828, 20, 22, 25, 4, -22 },
  { 5883, 22, 22, 25, 3, -22 },
  { 5944, 24, 22, 25, 0, -22 },
  { 6010, 26, 31, 25, -1, -22 },
  { 6111, 21, 22, 25, 1, -22 },
  { 6169, 17, 40, 25, 6, -33 },
  { 6254, 8, 38, 25, 8, -30 },
  { 6292, 16, 41, 25, 4, -33 },
  { 6374, 23, 8, 25, 1, -16 },
};

const GFXfont RobotoMono_Italic42pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic42pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _ROBOTOMONO_ITALIC42PT7B_H_
