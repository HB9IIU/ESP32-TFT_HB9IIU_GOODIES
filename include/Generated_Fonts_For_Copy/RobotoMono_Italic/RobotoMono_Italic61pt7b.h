#ifndef _ROBOTOMONO_ITALIC61PT7B_H_
#define _ROBOTOMONO_ITALIC61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x01, 0xF8, 0x0F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0x1E,
  0x07, 0x9F, 0x03, 0xCF, 0x81, 0xE7, 0x81, 0xF3, 0xC0, 0xF9, 0xE0, 0x78,
  0xF0, 0x3C, 0xF8, 0x1E, 0x78, 0x0F, 0x3C, 0x0F, 0x9E, 0x07, 0x8F, 0x03,
  0xC7, 0x81, 0xE7, 0x80, 0xF3, 0xC0, 0x70, 0x00, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00,
  0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x08, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x3E, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x80,
  0x01, 0xE0, 0x3C, 0x02, 0x1E, 0x01, 0xE0, 0x3C, 0xF0, 0x0F, 0x03, 0xE7,
  0x80, 0x78, 0x3E, 0x3C, 0x03, 0xC1, 0xE1, 0xE0, 0x3C, 0x1E, 0x0F, 0x01,
  0xE1, 0xF0, 0x78, 0x0F, 0x0F, 0x03, 0xE0, 0xF0, 0xF0, 0x0F, 0xFF, 0x8F,
  0x80, 0x7F, 0xF8, 0xF8, 0x01, 0xFF, 0x87, 0x80, 0x03, 0xF0, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0,
  0x20, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0xF1, 0xFF, 0xC0, 0x0F, 0x1F, 0xFF,
  0x00, 0xF8, 0xF8, 0xF8, 0x07, 0x8F, 0x83, 0xC0, 0x78, 0x78, 0x1F, 0x07,
  0xC7, 0xC0, 0x78, 0x7C, 0x3C, 0x03, 0xC3, 0xC1, 0xE0, 0x1E, 0x3E, 0x0F,
  0x00, 0xF3, 0xE0, 0x78, 0x0F, 0x06, 0x03, 0xC0, 0x78, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xE0, 0x01,
  0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x07, 0xC0, 0x01,
  0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xF8, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xC0, 0x1F, 0x0F, 0xE7, 0xE0, 0x3E, 0x1F, 0xC7, 0xE0, 0x3E, 0x3F,
  0x83, 0xF0, 0x3E, 0x7F, 0x01, 0xF0, 0x3E, 0x7E, 0x01, 0xF8, 0x7C, 0x7C,
  0x00, 0xFC, 0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0xFC, 0x00, 0x7F, 0xF8, 0xF8,
  0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0xC0, 0x7F,
  0x01, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFB, 0xF0, 0x0F,
  0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0x81, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x1E,
  0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x7C, 0xF1, 0xE3, 0xC7, 0x8F, 0x3C,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x06, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0C, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x20, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0E,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x30, 0x07, 0x80,
  0x33, 0xE0, 0x78, 0x1F, 0x3F, 0x87, 0x87, 0xF7, 0xFE, 0x7B, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1E, 0x00, 0x7C, 0x00, 0x60, 0x07, 0x00, 0x04, 0x00, 0x20, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x3F, 0x07, 0xC0, 0x30, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C,
  0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0x18, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x80,
  0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFF, 0x3E, 0x00, 0x1F,
  0xF9, 0xF0, 0x01, 0xFF, 0xDF, 0x80, 0x3F, 0xFE, 0xFC, 0x03, 0xFB, 0xF7,
  0xE0, 0x3F, 0x9F, 0x3E, 0x07, 0xF8, 0xF9, 0xF0, 0x7F, 0x07, 0xCF, 0x8F,
  0xF0, 0x3E, 0x7C, 0xFE, 0x03, 0xF7, 0xFF, 0xE0, 0x1F, 0xBF, 0xFC, 0x00,
  0xF9, 0xFF, 0xC0, 0x07, 0xCF, 0xF8, 0x00, 0x3E, 0x7F, 0x80, 0x01, 0xF3,
  0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01,
  0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0x9F, 0xFF, 0xE3,
  0xFE, 0x7C, 0x7F, 0x0F, 0x8F, 0x01, 0xF3, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xC0,
  0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0x7C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE7, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFE,
  0x03, 0xFC, 0x00, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC,
  0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x7F, 0xC0, 0x1F, 0x3F, 0xFE, 0x03, 0xEF, 0xFF, 0xE0, 0xFB, 0xFF, 0xFE,
  0x1F, 0xFC, 0x1F, 0xC3, 0xFE, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0x9F, 0xC0,
  0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xCF,
  0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x3F, 0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0x80, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x03, 0xF8, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x0F, 0x9F, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xDF, 0x00, 0x07, 0xE7, 0xE0, 0x03, 0xF9, 0xFC,
  0x03, 0xFE, 0x3F, 0x83, 0xFF, 0x8F, 0xFF, 0xFB, 0xE1, 0xFF, 0xFD, 0xF0,
  0x3F, 0xFE, 0x7C, 0x03, 0xFE, 0x1F, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0x81, 0xFE,
  0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0x7E, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0xFE, 0x07, 0xF0, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0x7F,
  0x03, 0xF0, 0x03, 0x00, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x20,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC0, 0x08, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFE, 0x03, 0xF8,
  0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xF8, 0x7F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0xF0,
  0x07, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07,
  0x03, 0xC0, 0x7F, 0x83, 0x81, 0xE0, 0x7F, 0xE1, 0xE1, 0xE0, 0xFF, 0xF0,
  0xF0, 0xF0, 0x7C, 0x38, 0x78, 0xF0, 0x78, 0x1C, 0x1C, 0x78, 0x78, 0x1E,
  0x0E, 0x78, 0x3C, 0x0E, 0x07, 0x3C, 0x3C, 0x07, 0x03, 0x9C, 0x1E, 0x03,
  0x81, 0xDE, 0x0E, 0x03, 0xC1, 0xEF, 0x0F, 0x01, 0xE0, 0xF7, 0x87, 0x80,
  0xE0, 0x73, 0x83, 0x80, 0x70, 0x3B, 0xC1, 0xC0, 0x78, 0x1D, 0xE1, 0xE0,
  0x3C, 0x0E, 0xF0, 0xF0, 0x1C, 0x0E, 0x78, 0x78, 0x0E, 0x07, 0x3C, 0x3C,
  0x0F, 0x03, 0x9E, 0x1E, 0x0F, 0x83, 0x8F, 0x0F, 0x0F, 0xC1, 0xC7, 0x87,
  0xFF, 0xE1, 0xC3, 0xC1, 0xFF, 0x7F, 0xE1, 0xE0, 0xFF, 0x3F, 0xE0, 0xF0,
  0x3F, 0x0F, 0xC0, 0x38, 0x04, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x01, 0xF9, 0xE0, 0x00, 0x01, 0xF1,
  0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3E, 0x1F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x3F, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x07,
  0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xF0, 0x7C, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3F, 0xE0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0x80, 0x0F, 0x80, 0x1F,
  0xE0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x7C, 0x1F,
  0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xFC,
  0x07, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xFC,
  0x01, 0xF8, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFE, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x80, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x7F, 0x00, 0xFE,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0xFF, 0x7E, 0x00, 0x7F, 0xFE, 0xFC, 0x00, 0xFF, 0xFD,
  0xF8, 0x01, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0xE7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01,
  0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3F, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0x0F, 0x80, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x01, 0xFC,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0x7C,
  0x3F, 0x80, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x00, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xBF, 0x00, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0x01, 0xFE, 0x1F, 0x80, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x0F,
  0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFE,
  0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3E, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x01, 0xF7, 0x81, 0xF7, 0xC0, 0x7C, 0xF0, 0x3E, 0xF8, 0x0F, 0x9E,
  0x0F, 0x9F, 0x01, 0xF3, 0xC1, 0xF3, 0xE0, 0x3E, 0x78, 0x7C, 0xF8, 0x07,
  0xCF, 0x8F, 0x9F, 0x00, 0xF9, 0xF3, 0xE3, 0xE0, 0x3E, 0x1E, 0x7C, 0x7C,
  0x07, 0xC3, 0xDF, 0x0F, 0x80, 0xF8, 0x7B, 0xE3, 0xF0, 0x1F, 0x0F, 0xF8,
  0x7C, 0x03, 0xE1, 0xFF, 0x0F, 0x80, 0x7C, 0x3F, 0xC1, 0xF0, 0x1F, 0x87,
  0xF8, 0x3E, 0x03, 0xE0, 0xFE, 0x0F, 0xC0, 0x7C, 0x0F, 0xC1, 0xF8, 0x0F,
  0x81, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0xF8,
  0x0F, 0xC0, 0xF0, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x00,
  0xFE, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x7C, 0x03, 0xFF, 0x00,
  0x0F, 0x80, 0x7F, 0xE0, 0x01, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x03, 0xF7,
  0xC0, 0x0F, 0xC0, 0x7E, 0xF8, 0x01, 0xF8, 0x0F, 0xDF, 0x00, 0x3E, 0x01,
  0xF1, 0xF0, 0x07, 0xC0, 0x3E, 0x3E, 0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x3F,
  0x01, 0xF8, 0x7C, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0xFC, 0x07, 0xE1, 0xF0,
  0x1F, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xE0,
  0x7C, 0x1F, 0x80, 0xFC, 0x07, 0xC3, 0xF0, 0x1F, 0x80, 0xF8, 0x7E, 0x03,
  0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0x3E, 0x7E,
  0x01, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x00, 0x7D, 0xF8, 0x0F, 0xC0, 0x0F,
  0xBE, 0x01, 0xF8, 0x01, 0xF7, 0xC0, 0x3E, 0x00, 0x1F, 0xF8, 0x07, 0xC0,
  0x03, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0x07, 0xFC, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x03, 0xFC,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00,
  0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB,
  0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x83, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x1F, 0xE0, 0x0F,
  0x80, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0xC0, 0xFC, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0xFE, 0x00,
  0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x7E,
  0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x07,
  0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xF0, 0xFF, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x00, 0x8F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF0,
  0x03, 0xFC, 0x01, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x03, 0xE0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF8, 0x0F, 0x80, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07,
  0xF0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF8, 0x7C, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00,
  0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0x80,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8,
  0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x07, 0xCF, 0x80, 0x7C, 0x01, 0xF3, 0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x0F,
  0xC0, 0x3E, 0x3E, 0x03, 0xF8, 0x0F, 0x8F, 0x80, 0xFE, 0x03, 0xE3, 0xE0,
  0x7F, 0x81, 0xF0, 0xF8, 0x1F, 0xE0, 0x7C, 0x3E, 0x07, 0xF8, 0x1F, 0x0F,
  0x83, 0xFE, 0x0F, 0xC3, 0xE0, 0xFF, 0x83, 0xE0, 0xF8, 0x3D, 0xE0, 0xF8,
  0x3C, 0x1F, 0x78, 0x3E, 0x0F, 0x07, 0xDE, 0x1F, 0x03, 0xC1, 0xE7, 0x87,
  0xC1, 0xF0, 0x79, 0xE1, 0xF0, 0x7C, 0x3E, 0x78, 0x7C, 0x1F, 0x0F, 0x1E,
  0x3E, 0x07, 0xC3, 0xC7, 0x8F, 0x81, 0xF1, 0xF1, 0xE3, 0xE0, 0x7C, 0x78,
  0x78, 0xF0, 0x1F, 0x1E, 0x1E, 0x7C, 0x07, 0xCF, 0x87, 0x9F, 0x01, 0xF3,
  0xC1, 0xE7, 0xC0, 0x7C, 0xF0, 0x79, 0xE0, 0x1F, 0x7C, 0x1E, 0xF8, 0x07,
  0xDE, 0x07, 0xBE, 0x01, 0xF7, 0x81, 0xEF, 0x80, 0x7F, 0xE0, 0x7B, 0xC0,
  0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xBC, 0x07, 0xFC, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xE0, 0x1F, 0xE0, 0x07, 0xF8, 0x07,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x00, 0x1F, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xC0,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F,
  0xFC, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFB,
  0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x1E, 0x00, 0xFC, 0x7C, 0x03, 0xE1, 0xF0,
  0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x03, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x7C,
  0x03, 0xE3, 0xF0, 0x0F, 0x8F, 0x80, 0x1E, 0x7E, 0x00, 0x7D, 0xF0, 0x01,
  0xFF, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0xFE, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x7E, 0x3F, 0xC0,
  0x07, 0xC7, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7C,
  0xFC, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xE0, 0x0F, 0xF8, 0x7F, 0x87, 0xFF,
  0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xCF, 0x81, 0xFF, 0xF8, 0xF8, 0x07,
  0xFE, 0x0F, 0x80, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x9F, 0xFC,
  0x00, 0xF9, 0xFF, 0xF8, 0x07, 0xDF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x01, 0xF8, 0x7F, 0x80, 0x3F, 0xC3, 0xFF,
  0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFB, 0xFF, 0xFC, 0x0F, 0x8F, 0xFF,
  0xC0, 0x7C, 0x1F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x7F, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00,
  0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0x87, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xF0, 0x3F,
  0x81, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x3F, 0x00, 0x1F, 0xFC, 0x7E, 0x00, 0xFF, 0xFC, 0xFC, 0x03, 0xFF,
  0xFD, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0xFE, 0x00,
  0x7F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0xFF, 0x00, 0xFF,
  0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0xF8, 0x00, 0xFF,
  0xF9, 0xF0, 0x00, 0xFF, 0xC7, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xBF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x0F, 0xC0, 0x01,
  0xE0, 0x7F, 0x00, 0x1F, 0x81, 0xFE, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFE, 0x00, 0x40, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x1F, 0x00, 0x3F, 0xFF, 0x3F, 0x00, 0x7F, 0xFF, 0xBE, 0x00, 0xFF,
  0xFF, 0xFE, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xF8, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFB, 0xE0, 0x01, 0xFF,
  0xF7, 0xE0, 0x00, 0xFF, 0xC7, 0xE0, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x10, 0x00,
  0x1F, 0x80, 0x38, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x1F, 0x87, 0xFE, 0x00, 0xF8, 0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xE0,
  0x3E, 0xFF, 0xFF, 0x81, 0xFF, 0x81, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E,
  0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xFC, 0x7C,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E,
  0x3F, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFE,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0x00, 0x7F, 0x00,
  0x3E, 0x01, 0xFC, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x03,
  0xE0, 0xFF, 0x00, 0x07, 0xC3, 0xFC, 0x00, 0x0F, 0x8F, 0xF0, 0x00, 0x1F,
  0x3F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F,
  0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0xF8, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x7C, 0x01, 0xF3, 0xFC, 0x7F, 0xC0, 0x7F, 0xFF, 0xBF, 0xF8, 0x1E, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF, 0x83, 0xF8, 0x7F, 0x83, 0xF0, 0xFC,
  0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x07, 0xC3,
  0xE0, 0x3E, 0x01, 0xF1, 0xF8, 0x0F, 0x80, 0xFC, 0x7C, 0x03, 0xE0, 0x3E,
  0x1F, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x7E, 0x03, 0xE1, 0xF0, 0x1F, 0x00,
  0xF8, 0x7C, 0x07, 0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0x1F, 0x8F, 0x80, 0x7C,
  0x07, 0xC3, 0xE0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0x7C, 0x3E, 0x03,
  0xE0, 0x1F, 0x0F, 0x80, 0xF8, 0x07, 0xC7, 0xE0, 0x3E, 0x03, 0xF1, 0xF0,
  0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC0, 0x7E,
  0x3E, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x01,
  0xF0, 0xF8, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3E, 0x1F,
  0xFC, 0x01, 0xF1, 0xFF, 0xF0, 0x0F, 0x9F, 0xFF, 0xC0, 0x7D, 0xFF, 0xFF,
  0x03, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC,
  0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x07,
  0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0x03,
  0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x03, 0xE3, 0xFF, 0x80, 0x07, 0xCF, 0xFF, 0x80, 0x0F, 0xBF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xE0, 0x7F, 0x80, 0xFF, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x01, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xE0, 0x1F, 0x9F,
  0xFF, 0x80, 0x3F, 0x1F, 0xFC, 0x00, 0x7C, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x87,
  0xC0, 0x7F, 0xFF, 0x7E, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x07,
  0xF8, 0x0F, 0xF8, 0x7F, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0xFE, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0xFE, 0x07, 0xF8,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x7C, 0x01, 0xFF, 0xF7,
  0xE0, 0x07, 0xFE, 0x3E, 0x00, 0x03, 0x81, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7C, 0x1F, 0xFC, 0x0F, 0x8F, 0xFF, 0x83,
  0xF3, 0xFF, 0xF0, 0x7D, 0xFF, 0xFC, 0x0F, 0xBF, 0xFF, 0x81, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0xFF,
  0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xF8,
  0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x70, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xF8, 0x7E, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x3F,
  0x83, 0xE0, 0x03, 0xFC, 0x1F, 0x80, 0x3F, 0xC0, 0xFE, 0x07, 0xFE, 0x03,
  0xFF, 0xFD, 0xF0, 0x0F, 0xFF, 0xCF, 0x80, 0x7F, 0xFC, 0x7C, 0x00, 0xFF,
  0x83, 0xE0, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0,
  0x3E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x78, 0x3F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0xFC, 0x01,
  0xE0, 0x07, 0xBE, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0xF8, 0x03, 0xEF, 0x80,
  0x7C, 0x03, 0xE7, 0xC0, 0x7E, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0xF1, 0xF0,
  0x3F, 0xC0, 0xF8, 0xF8, 0x1F, 0xE0, 0x7C, 0x7C, 0x0E, 0xF0, 0x3C, 0x3E,
  0x0F, 0x78, 0x3E, 0x1F, 0x07, 0xBC, 0x1F, 0x0F, 0x87, 0x9E, 0x0F, 0x07,
  0xC3, 0xCF, 0x0F, 0x83, 0xE3, 0xE7, 0x87, 0x81, 0xF1, 0xE3, 0xC3, 0xC0,
  0xF8, 0xF1, 0xE3, 0xE0, 0x3C, 0xF0, 0xF1, 0xE0, 0x1E, 0x78, 0x38, 0xF0,
  0x0F, 0x78, 0x1C, 0xF0, 0x07, 0xBC, 0x0E, 0x78, 0x03, 0xDE, 0x07, 0x3C,
  0x01, 0xFE, 0x03, 0xBC, 0x00, 0xFF, 0x01, 0xDE, 0x00, 0x7F, 0x00, 0xEF,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x1F,
  0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x03,
  0xE0, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x80,
  0x07, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFB,
  0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7E, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x01, 0x07, 0xFF, 0xC0, 0x00, 0xE7,
  0xFF, 0xF8, 0x00, 0xF3, 0xFF, 0xFE, 0x00, 0x7B, 0xF0, 0x7F, 0x80, 0x7D,
  0xF0, 0x1F, 0xE0, 0x7D, 0xF0, 0x03, 0xFF, 0xFE, 0xF0, 0x00, 0xFF, 0xFE,
  0x78, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00,
};

const GFXglyph RobotoMono_Italic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 13, 43, 36, 11, -43 },
  { 71, 17, 15, 36, 12, -46 },
  { 103, 35, 43, 36, 1, -43 },
  { 292, 29, 56, 36, 4, -50 },
  { 495, 29, 45, 36, 4, -44 },
  { 659, 32, 45, 36, 2, -44 },
  { 839, 7, 15, 36, 16, -46 },
  { 853, 20, 63, 36, 10, -49 },
  { 1011, 20, 63, 36, 5, -49 },
  { 1169, 28, 29, 36, 6, -43 },
  { 1271, 30, 32, 36, 3, -36 },
  { 1391, 11, 17, 36, 6, -7 },
  { 1415, 23, 4, 36, 6, -21 },
  { 1427, 8, 9, 36, 12, -8 },
  { 1436, 31, 47, 36, 3, -43 },
  { 1619, 29, 45, 36, 4, -44 },
  { 1783, 19, 43, 36, 8, -43 },
  { 1886, 31, 44, 36, 0, -44 },
  { 2057, 30, 45, 36, 1, -44 },
  { 2226, 31, 43, 36, 1, -43 },
  { 2393, 31, 44, 36, 4, -43 },
  { 2564, 27, 44, 36, 3, -43 },
  { 2713, 30, 43, 36, 6, -43 },
  { 2875, 30, 45, 36, 4, -44 },
  { 3044, 26, 44, 36, 6, -44 },
  { 3187, 13, 35, 36, 13, -34 },
  { 3244, 16, 44, 36, 10, -34 },
  { 3332, 27, 27, 36, 5, -33 },
  { 3424, 29, 17, 36, 4, -28 },
  { 3486, 28, 27, 36, 3, -33 },
  { 3581, 25, 44, 36, 8, -44 },
  { 3719, 33, 43, 36, 2, -43 },
  { 3897, 32, 43, 36, -1, -43 },
  { 4069, 32, 43, 36, 2, -43 },
  { 4241, 31, 45, 36, 3, -44 },
  { 4416, 33, 43, 36, 1, -43 },
  { 4594, 33, 43, 36, 2, -43 },
  { 4772, 34, 43, 36, 2, -43 },
  { 4955, 31, 45, 36, 3, -44 },
  { 5130, 35, 43, 36, 1, -43 },
  { 5319, 33, 43, 36, 2, -43 },
  { 5497, 33, 44, 36, 2, -43 },
  { 5679, 36, 43, 36, 2, -43 },
  { 5873, 26, 43, 36, 3, -43 },
  { 6013, 35, 43, 36, 1, -43 },
  { 6202, 35, 43, 36, 1, -43 },
  { 6391, 31, 45, 36, 3, -44 },
  { 6566, 33, 43, 36, 2, -43 },
  { 6744, 31, 51, 36, 3, -44 },
  { 6942, 32, 43, 36, 2, -43 },
  { 7114, 33, 45, 36, 2, -44 },
  { 7300, 32, 43, 36, 6, -43 },
  { 7472, 33, 44, 36, 3, -43 },
  { 7654, 31, 43, 36, 6, -43 },
  { 7821, 34, 43, 36, 4, -43 },
  { 8004, 38, 43, 36, 0, -43 },
  { 8209, 32, 43, 36, 6, -43 },
  { 8381, 33, 43, 36, 1, -43 },
  { 8559, 21, 59, 36, 8, -50 },
  { 8714, 14, 47, 36, 11, -43 },
  { 8797, 21, 59, 36, 7, -50 },
  { 8952, 22, 23, 36, 7, -43 },
  { 9016, 27, 5, 36, 1, 0 },
  { 9033, 10, 8, 36, 16, -44 },
  { 9043, 28, 34, 36, 3, -33 },
  { 9162, 29, 47, 36, 2, -46 },
  { 9333, 28, 34, 36, 4, -33 },
  { 9452, 31, 47, 36, 4, -46 },
  { 9635, 29, 34, 36, 3, -33 },
  { 9759, 31, 47, 36, 6, -47 },
  { 9942, 32, 46, 36, 1, -33 },
  { 10126, 29, 46, 36, 2, -46 },
  { 10293, 27, 44, 36, 3, -44 },
  { 10442, 28, 57, 36, 1, -44 },
  { 10642, 31, 46, 36, 2, -46 },
  { 10821, 27, 46, 36, 3, -46 },
  { 10977, 34, 33, 36, 0, -33 },
  { 11118, 29, 33, 36, 2, -33 },
  { 11238, 29, 34, 36, 3, -33 },
  { 11362, 31, 45, 36, 0, -33 },
  { 11537, 29, 45, 36, 4, -33 },
  { 11701, 27, 33, 36, 6, -33 },
  { 11813, 28, 34, 36, 4, -33 },
  { 11932, 26, 41, 36, 6, -40 },
  { 12066, 29, 33, 36, 4, -32 },
  { 12186, 30, 32, 36, 5, -32 },
  { 12306, 33, 32, 36, 4, -32 },
  { 12438, 35, 32, 36, 0, -32 },
  { 12578, 37, 45, 36, -1, -32 },
  { 12787, 31, 32, 36, 2, -32 },
  { 12911, 24, 59, 36, 9, -48 },
  { 13088, 13, 55, 36, 11, -43 },
  { 13178, 24, 59, 36, 5, -48 },
  { 13355, 33, 12, 36, 1, -24 },
};

const GFXfont RobotoMono_Italic61pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic61pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic61pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _ROBOTOMONO_ITALIC61PT7B_H_
