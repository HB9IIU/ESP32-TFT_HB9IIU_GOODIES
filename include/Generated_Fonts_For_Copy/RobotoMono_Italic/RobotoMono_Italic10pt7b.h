#ifndef _ROBOTOMONO_ITALIC10PT7B_H_
#define _ROBOTOMONO_ITALIC10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic10pt7bBitmaps[] PROGMEM = {
  0x00, 0x56, 0x88, 0xB6, 0x80, 0x14, 0xA7, 0xCA, 0xF9, 0x46, 0x00, 0x27,
  0x9C, 0x61, 0x9E, 0x40, 0xCD, 0xE2, 0x7B, 0x30, 0x39, 0x23, 0x19, 0x5A,
  0x67, 0x80, 0xE0, 0x2A, 0x49, 0x24, 0x90, 0x44, 0x92, 0x4A, 0x50, 0x25,
  0x5C, 0xC9, 0x00, 0x22, 0xF4, 0x40, 0x68, 0xF0, 0x80, 0x18, 0x88, 0x44,
  0x22, 0x10, 0x79, 0x9F, 0x99, 0xE0, 0x74, 0x92, 0x90, 0x7A, 0x42, 0x22,
  0x23, 0xE0, 0x3A, 0x42, 0x60, 0xC5, 0xC0, 0x08, 0xCA, 0x9F, 0x88, 0x40,
  0x7A, 0x39, 0x21, 0x4B, 0x80, 0x74, 0xE9, 0x99, 0xE0, 0xF8, 0x84, 0x44,
  0x22, 0x00, 0x74, 0x64, 0xC9, 0x4B, 0x80, 0x79, 0x99, 0x72, 0xC0, 0x40,
  0xC0, 0x40, 0xA8, 0x3C, 0xC3, 0xF0, 0xF0, 0x60, 0xCD, 0x80, 0x79, 0x12,
  0x40, 0x40, 0x39, 0x56, 0xED, 0xD6, 0xA7, 0x00, 0x11, 0x8A, 0x97, 0xA6,
  0x20, 0x79, 0x14, 0x9E, 0x4A, 0x2F, 0x00, 0x39, 0x14, 0x10, 0x81, 0x27,
  0x00, 0x79, 0x24, 0x51, 0x4A, 0x2F, 0x00, 0x7D, 0x04, 0x1E, 0x41, 0x0F,
  0x80, 0x3D, 0x04, 0x1E, 0x41, 0x08, 0x00, 0x39, 0x14, 0x16, 0x89, 0x27,
  0x80, 0x45, 0x14, 0x5E, 0x8A, 0x28, 0x80, 0x7C, 0x41, 0x08, 0x20, 0x8F,
  0x80, 0x04, 0x20, 0x82, 0x0A, 0x27, 0x00, 0x45, 0x25, 0x18, 0x51, 0x48,
  0x80, 0x62, 0x10, 0x84, 0x23, 0xE0, 0x65, 0xB7, 0x5E, 0x6A, 0x28, 0x80,
  0x45, 0x96, 0x96, 0x5A, 0x68, 0x80, 0x39, 0x24, 0x52, 0x89, 0x27, 0x00,
  0x39, 0x14, 0x5E, 0x41, 0x08, 0x00, 0x39, 0x14, 0x61, 0x89, 0x27, 0x02,
  0x79, 0x14, 0x9E, 0x51, 0x48, 0x80, 0x39, 0x14, 0x0C, 0x0A, 0x27, 0x00,
  0xF9, 0x08, 0x44, 0x21, 0x00, 0x8C, 0x65, 0x29, 0x4B, 0x80, 0x8C, 0xA5,
  0x46, 0x31, 0x00, 0xAD, 0x7B, 0xEB, 0x5A, 0x80, 0x44, 0xA3, 0x0C, 0x31,
  0x48, 0x80, 0x8C, 0x98, 0xC4, 0x21, 0x00, 0x7C, 0x21, 0x08, 0x21, 0x0F,
  0x80, 0x34, 0x44, 0x44, 0x44, 0x8C, 0xAA, 0x55, 0x32, 0x22, 0x22, 0x24,
  0x4C, 0x26, 0x59, 0xF8, 0x80, 0x78, 0x5F, 0x17, 0x80, 0x22, 0x10, 0xF4,
  0xA5, 0x3E, 0xF9, 0x89, 0xE0, 0x08, 0x45, 0xE9, 0x4A, 0x5E, 0xF9, 0xF8,
  0xF0, 0x19, 0x09, 0xA4, 0x21, 0x08, 0x7A, 0x52, 0x97, 0x8B, 0xC0, 0x22,
  0x10, 0xF4, 0xA5, 0x31, 0x10, 0x1C, 0x21, 0x13, 0xE0, 0x08, 0x0C, 0x21,
  0x08, 0x44, 0xE0, 0x22, 0x10, 0xB7, 0x31, 0x53, 0x30, 0x84, 0x21, 0x08,
  0x9F, 0x7E, 0x9A, 0xAA, 0xA8, 0x7A, 0x52, 0x98, 0x80, 0x7A, 0x62, 0x97,
  0x00, 0x7A, 0x53, 0x1F, 0x42, 0x00, 0xF9, 0x99, 0xF2, 0x20, 0x74, 0x88,
  0x80, 0xF8, 0x69, 0xE0, 0x24, 0xF4, 0x44, 0x70, 0x99, 0x99, 0xF0, 0x9C,
  0xA8, 0xC4, 0x00, 0xAF, 0x7D, 0x6A, 0x00, 0x4C, 0xC2, 0x14, 0xC8, 0x4D,
  0x25, 0x0C, 0x21, 0x0C, 0x00, 0x78, 0x88, 0x8F, 0x80, 0x12, 0x22, 0x4C,
  0x24, 0x42, 0x56, 0xAA, 0x80, 0x42, 0x22, 0x32, 0x44, 0x48, 0x66, 0x60,
};

const GFXglyph RobotoMono_Italic10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 7, 6, 2, -7 },
  { 3, 3, 3, 6, 2, -8 },
  { 5, 6, 7, 6, 0, -7 },
  { 11, 4, 9, 6, 1, -8 },
  { 16, 4, 7, 6, 1, -7 },
  { 20, 6, 7, 6, 0, -7 },
  { 26, 1, 3, 6, 3, -8 },
  { 27, 3, 10, 6, 2, -8 },
  { 31, 3, 10, 6, 1, -8 },
  { 35, 5, 5, 6, 1, -7 },
  { 39, 4, 5, 6, 1, -6 },
  { 42, 2, 3, 6, 1, -1 },
  { 43, 4, 1, 6, 1, -4 },
  { 44, 1, 1, 6, 2, -1 },
  { 45, 5, 8, 6, 1, -7 },
  { 50, 4, 7, 6, 1, -7 },
  { 54, 3, 7, 6, 1, -7 },
  { 57, 5, 7, 6, 0, -7 },
  { 62, 5, 7, 6, 0, -7 },
  { 67, 5, 7, 6, 0, -7 },
  { 72, 5, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 5, 7, 6, 1, -7 },
  { 86, 5, 7, 6, 1, -7 },
  { 91, 4, 7, 6, 1, -7 },
  { 95, 2, 5, 6, 2, -5 },
  { 97, 2, 7, 6, 2, -5 },
  { 99, 4, 4, 6, 1, -5 },
  { 101, 4, 3, 6, 1, -5 },
  { 103, 5, 4, 6, 0, -5 },
  { 106, 4, 7, 6, 1, -7 },
  { 110, 6, 7, 6, 0, -7 },
  { 116, 5, 7, 6, 0, -7 },
  { 121, 6, 7, 6, 0, -7 },
  { 127, 6, 7, 6, 0, -7 },
  { 133, 6, 7, 6, 0, -7 },
  { 139, 6, 7, 6, 0, -7 },
  { 145, 6, 7, 6, 0, -7 },
  { 151, 6, 7, 6, 0, -7 },
  { 157, 6, 7, 6, 0, -7 },
  { 163, 6, 7, 6, 0, -7 },
  { 169, 6, 7, 6, 0, -7 },
  { 175, 6, 7, 6, 0, -7 },
  { 181, 5, 7, 6, 0, -7 },
  { 186, 6, 7, 6, 0, -7 },
  { 192, 6, 7, 6, 0, -7 },
  { 198, 6, 7, 6, 0, -7 },
  { 204, 6, 7, 6, 0, -7 },
  { 210, 6, 8, 6, 0, -7 },
  { 216, 6, 7, 6, 0, -7 },
  { 222, 6, 7, 6, 0, -7 },
  { 228, 5, 7, 6, 1, -7 },
  { 233, 5, 7, 6, 1, -7 },
  { 238, 5, 7, 6, 1, -7 },
  { 243, 5, 7, 6, 1, -7 },
  { 248, 6, 7, 6, 0, -7 },
  { 254, 5, 7, 6, 1, -7 },
  { 259, 6, 7, 6, 0, -7 },
  { 265, 4, 10, 6, 1, -8 },
  { 270, 2, 8, 6, 2, -7 },
  { 272, 4, 10, 6, 1, -8 },
  { 277, 4, 4, 6, 1, -7 },
  { 279, 5, 1, 6, 0, 0 },
  { 280, 1, 1, 6, 3, -7 },
  { 281, 5, 5, 6, 0, -5 },
  { 285, 5, 8, 6, 0, -8 },
  { 290, 4, 5, 6, 1, -5 },
  { 293, 5, 8, 6, 1, -8 },
  { 298, 4, 5, 6, 1, -5 },
  { 301, 5, 8, 6, 1, -8 },
  { 306, 5, 7, 6, 0, -5 },
  { 311, 5, 8, 6, 0, -8 },
  { 316, 5, 7, 6, 0, -7 },
  { 321, 5, 9, 6, 0, -7 },
  { 327, 5, 8, 6, 0, -8 },
  { 332, 5, 8, 6, 0, -8 },
  { 337, 6, 5, 6, 0, -5 },
  { 341, 5, 5, 6, 0, -5 },
  { 345, 5, 5, 6, 0, -5 },
  { 349, 5, 7, 6, 0, -5 },
  { 354, 4, 7, 6, 1, -5 },
  { 358, 4, 5, 6, 1, -5 },
  { 361, 4, 5, 6, 1, -5 },
  { 364, 4, 7, 6, 1, -7 },
  { 368, 4, 5, 6, 1, -5 },
  { 371, 5, 5, 6, 1, -5 },
  { 375, 5, 5, 6, 1, -5 },
  { 379, 6, 5, 6, 0, -5 },
  { 383, 6, 7, 6, 0, -5 },
  { 389, 5, 5, 6, 0, -5 },
  { 393, 4, 10, 6, 1, -8 },
  { 398, 2, 9, 6, 2, -7 },
  { 401, 4, 10, 6, 1, -8 },
  { 406, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_Italic10pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic10pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic10pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _ROBOTOMONO_ITALIC10PT7B_H_
