#ifndef _ROBOTOMONO_ITALIC45PT7B_H_
#define _ROBOTOMONO_ITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81,
  0xE0, 0x78, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x78, 0x3E, 0x0F, 0x81, 0xE0, 0x38, 0x79, 0xC3, 0x9E, 0x1C, 0xE0, 0xE7,
  0x07, 0x38, 0x39, 0xC3, 0x8E, 0x1C, 0xE0, 0xE7, 0x07, 0x38, 0x38, 0x00,
  0x07, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x3C,
  0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0x38, 0x3C, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x00, 0xF0, 0x70, 0x00, 0x38, 0x1C, 0x00, 0x0E, 0x0F, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x01,
  0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x07, 0x00,
  0x03, 0x81, 0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF0, 0x3E, 0x03, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x03,
  0xC7, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0xF8, 0x78,
  0x07, 0xC1, 0xF8, 0x3F, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xF3,
  0xC0, 0x07, 0x0E, 0x00, 0x70, 0x38, 0x33, 0x81, 0xC3, 0xDC, 0x0E, 0x1C,
  0xE0, 0xE1, 0xC7, 0x07, 0x1E, 0x38, 0x38, 0xE1, 0xE3, 0x8E, 0x07, 0xFC,
  0xF0, 0x1F, 0xC7, 0x00, 0x38, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC3, 0x00, 0x1C, 0xFE, 0x01, 0xCF,
  0xF8, 0x1C, 0x71, 0xE0, 0xE7, 0x07, 0x0E, 0x38, 0x38, 0xE1, 0xC1, 0xCF,
  0x0E, 0x0E, 0x70, 0xE0, 0x71, 0x07, 0x83, 0x80, 0x1C, 0x38, 0x00, 0xF3,
  0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0xF0,
  0x03, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0,
  0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC7, 0xC0, 0x03, 0xCF, 0x80,
  0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xBC, 0x0F, 0x1F, 0x3C, 0x0F, 0x3E, 0x1E, 0x0E,
  0x3C, 0x1F, 0x1E, 0x78, 0x0F, 0x1E, 0x78, 0x0F, 0xBC, 0x78, 0x07, 0xBC,
  0xF0, 0x07, 0xF8, 0xF8, 0x03, 0xF8, 0x78, 0x01, 0xF0, 0x78, 0x03, 0xF0,
  0x7C, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFE, 0x78, 0x07, 0xF8, 0x3C,
  0x39, 0xDE, 0xF7, 0x39, 0xCE, 0xF7, 0x38, 0x00, 0x06, 0x00, 0x1C, 0x00,
  0x78, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x70, 0x00, 0x60, 0x00, 0x01, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x60, 0x70,
  0x37, 0x87, 0x0F, 0xFE, 0x77, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x3F,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x07, 0xB8, 0x00, 0xF3, 0xC0, 0x1E,
  0x1C, 0x03, 0xE1, 0xE0, 0x7C, 0x1F, 0x03, 0x80, 0xF0, 0x10, 0x0C, 0x00,
  0x00, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x05, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x0F, 0x0F, 0x1F, 0x1F, 0x1E, 0x1E, 0x3E, 0x3C, 0x78, 0xF8, 0x70, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF0, 0x73, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7C, 0x1F, 0x07, 0x80, 0x7C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xCF, 0x00, 0x1E, 0xF0,
  0x01, 0xF7, 0x80, 0x1F, 0xBC, 0x03, 0xFD, 0xE0, 0x3F, 0xEF, 0x07, 0xEF,
  0x78, 0x7C, 0x7B, 0x8F, 0xC3, 0xFC, 0xF8, 0x3D, 0xFF, 0x81, 0xEF, 0xF0,
  0x0F, 0x7F, 0x00, 0x7B, 0xF0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7,
  0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x3E, 0x0F,
  0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x0C, 0x01,
  0xE0, 0x3F, 0x83, 0xFE, 0x7F, 0xF9, 0xFD, 0xE7, 0xC7, 0xB8, 0x1C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x07, 0xC3, 0xC0,
  0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0x3E,
  0x0F, 0x80, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x07,
  0x8F, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE3,
  0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x38,
  0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x81,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xE0, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x73, 0xF0, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0x81, 0xF0, 0x04,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0xF0, 0x01,
  0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x3E, 0x07, 0xC0, 0xF8,
  0x07, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x3E, 0x07, 0x9F, 0xF0, 0xFF, 0xFF, 0x1F, 0xF7, 0xF3,
  0xF0, 0x1E, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x7B, 0xE0, 0x1F, 0x3C, 0x03, 0xC7, 0xC1, 0xF0, 0x7F, 0xFE, 0x07,
  0xFF, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0x01, 0xF8, 0x3E, 0x0F, 0x80,
  0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x1F,
  0x0F, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x7E, 0x1F,
  0x03, 0xE0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x3E, 0x1E, 0x00, 0xF0, 0x7C, 0x0F, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF8,
  0x7C, 0x1E, 0x03, 0xE3, 0xC0, 0x1E, 0x7C, 0x01, 0xE7, 0x80, 0x0F, 0x78,
  0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x07, 0xE3, 0xE1, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xDC, 0x07, 0xF3, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xE0, 0x00, 0x07,
  0x07, 0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x0F, 0xC7, 0xE3,
  0xF1, 0xF8, 0x78, 0x00, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x30, 0x00, 0x1E, 0x00, 0x07, 0xE0,
  0x01, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xF8, 0x00, 0x03, 0x00, 0x00, 0x08, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x00, 0x08, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x03, 0xFF, 0xC3, 0xFF, 0xF8, 0xF8, 0x3F, 0x7C, 0x07, 0xDE, 0x00, 0xFF,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3E, 0x03, 0xC0, 0x3C,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x0C, 0x1C, 0x1F, 0x86, 0x0E,
  0x1F, 0xE3, 0x8E, 0x1E, 0x31, 0xC7, 0x1C, 0x38, 0xE7, 0x0E, 0x1C, 0x73,
  0x8E, 0x0C, 0x39, 0x86, 0x06, 0x1D, 0xC7, 0x07, 0x0C, 0xE3, 0x83, 0x86,
  0x71, 0xC1, 0x83, 0x30, 0xC0, 0xC1, 0x98, 0x60, 0xE1, 0xCC, 0x70, 0x70,
  0xCE, 0x18, 0x78, 0x67, 0x0E, 0x7C, 0x61, 0x87, 0xFF, 0xF0, 0xC3, 0xF3,
  0xF0, 0x70, 0xF1, 0xF0, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0xE0, 0x20, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0x38, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFC, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0xF8,
  0x00, 0x0F, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x07,
  0x81, 0xFE, 0x07, 0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x3E, 0x0F, 0x00, 0x7C, 0x0F, 0x03, 0xF8, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x1E, 0x01, 0xF8, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x78,
  0x01, 0xF0, 0x78, 0x1F, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F,
  0x03, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00,
  0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x70,
  0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xE0,
  0x7C, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0x83,
  0xF8, 0x07, 0x80, 0xFC, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x7C, 0x00,
  0x7C, 0x78, 0x00, 0xF8, 0x78, 0x00, 0xF0, 0x78, 0x03, 0xF0, 0x78, 0x07,
  0xE0, 0x78, 0x7F, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0x07,
  0xE0, 0x7C, 0x03, 0xC1, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x0F, 0xFD, 0xE0, 0x1F, 0xFB, 0xC0, 0x3F, 0xF7, 0x80, 0x7F, 0xEF, 0x00,
  0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x83, 0xF0, 0x3F,
  0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x03, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE0, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x1E, 0x00,
  0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0,
  0x01, 0xC1, 0xE0, 0x00, 0xE0, 0xF0, 0x00, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1E, 0x00, 0x0E, 0x0F, 0x00, 0x0F, 0x07,
  0x80, 0x07, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0,
  0xF0, 0x00, 0x70, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x1E,
  0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x03, 0x83, 0xC0, 0x03,
  0xC1, 0xE0, 0x01, 0xE0, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0x78,
  0x00, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xC0, 0x07, 0xE0, 0x78, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xC0,
  0x0F, 0x80, 0x78, 0x03, 0xE0, 0x0F, 0x00, 0xF8, 0x01, 0xE0, 0x3E, 0x00,
  0x3C, 0x0F, 0x80, 0x0F, 0x03, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0xF3, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xBF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFB, 0xC0,
  0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF8, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0xC0, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x07, 0xC0, 0x0F, 0xC1,
  0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F,
  0x83, 0xF8, 0x0F, 0xE0, 0xFE, 0x07, 0xF8, 0x3F, 0x81, 0xDC, 0x0F, 0xE0,
  0xF7, 0x03, 0xBC, 0x3B, 0xC0, 0xEF, 0x1E, 0xF0, 0x79, 0xC7, 0x3C, 0x1E,
  0x73, 0xCF, 0x07, 0x9C, 0xE3, 0x81, 0xE7, 0x79, 0xE0, 0x71, 0xDC, 0x78,
  0x1C, 0x7F, 0x1E, 0x0F, 0x1F, 0x87, 0x83, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0,
  0xF0, 0x3C, 0x3C, 0x3C, 0x0F, 0x0E, 0x0F, 0x03, 0x83, 0x83, 0xC1, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xC1, 0xF0,
  0x01, 0xE0, 0xF8, 0x00, 0xF0, 0x7E, 0x00, 0x78, 0x7F, 0x00, 0x78, 0x3F,
  0x80, 0x3C, 0x1F, 0xE0, 0x1E, 0x0F, 0xF0, 0x0F, 0x07, 0xB8, 0x07, 0x87,
  0xDE, 0x03, 0xC3, 0xCF, 0x03, 0xC1, 0xE3, 0x81, 0xE0, 0xF1, 0xE0, 0xF0,
  0x78, 0xF0, 0x78, 0x3C, 0x78, 0x3C, 0x3E, 0x1E, 0x3E, 0x1E, 0x0F, 0x1E,
  0x0F, 0x07, 0x8F, 0x07, 0x81, 0xE7, 0x83, 0xC0, 0xF3, 0xC1, 0xE0, 0x79,
  0xE1, 0xE0, 0x1F, 0xF0, 0xF0, 0x0F, 0xF0, 0x78, 0x07, 0xF8, 0x3C, 0x01,
  0xFC, 0x1E, 0x00, 0xFE, 0x0F, 0x00, 0x7F, 0x0F, 0x00, 0x1F, 0x07, 0x80,
  0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x8F, 0xC0, 0x7C, 0x07, 0x81, 0xF0,
  0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x0E, 0x1E, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x78, 0x00, 0x7C, 0x78, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xE0,
  0x07, 0x81, 0xE0, 0x1E, 0x03, 0xF0, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x07, 0x80, 0xFC, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x1F, 0x0F, 0x00,
  0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x1E, 0x00,
  0x7C, 0x1E, 0x01, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF,
  0x80, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x3F, 0x87, 0xC0, 0x7C, 0x07, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F,
  0x0F, 0x00, 0x0F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x7B,
  0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80,
  0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00,
  0x3C, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x07, 0x81, 0xE0, 0x1E,
  0x03, 0xF0, 0xF8, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x0C, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x38, 0x0F, 0xE0, 0xF0, 0x07, 0xC1, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x07,
  0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x01, 0xE0, 0x78,
  0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x78, 0x03, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x78, 0x00, 0x78, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xE0, 0xFC, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1F, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0x3F,
  0x07, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x07, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x78, 0x70, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0, 0x78,
  0x00, 0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xE0, 0x7C, 0x03, 0xC0, 0x3E,
  0x0F, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xF8,
  0x00, 0x1F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C,
  0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x0E,
  0x3C, 0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x1E, 0x07, 0xBC, 0x0F, 0x03, 0xDE, 0x07, 0x81, 0xEF, 0x07, 0xC1, 0xE7,
  0x83, 0xE0, 0xF3, 0xC1, 0xF0, 0x79, 0xE1, 0xF8, 0x38, 0xF0, 0xFC, 0x3C,
  0x78, 0x7E, 0x1E, 0x3C, 0x7F, 0x0F, 0x1E, 0x3B, 0x87, 0x0F, 0x1D, 0xC7,
  0x87, 0x9E, 0xE3, 0xC3, 0xCE, 0x71, 0xC1, 0xC7, 0x38, 0xE0, 0xE7, 0x9C,
  0xF0, 0x73, 0x8E, 0x78, 0x39, 0xC7, 0x38, 0x1D, 0xE3, 0x9C, 0x0E, 0xE1,
  0xDE, 0x07, 0x70, 0xEF, 0x03, 0xB8, 0x77, 0x01, 0xF8, 0x3B, 0x80, 0xFC,
  0x1F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x3C, 0x00, 0x3E, 0x03, 0xC0,
  0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x7C, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x1E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00,
  0xF0, 0x01, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x07, 0xC0,
  0x7C, 0x00, 0x3C, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xFB, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x00, 0x3C,
  0x0F, 0x00, 0xF8, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0x3C, 0x1F, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x00, 0xE3, 0xE0, 0x01, 0xE7, 0x80, 0x03,
  0xDE, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x43, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x01, 0xFE, 0x03, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xFF, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x01, 0xFF, 0x01, 0xFF, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xDC, 0x03,
  0xDC, 0x03, 0x9C, 0x07, 0x9E, 0x0F, 0x1E, 0x0F, 0x0E, 0x1E, 0x0E, 0x1E,
  0x0E, 0x3C, 0x0F, 0x38, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0x7F, 0xFF, 0xF3,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0xF8, 0xF0, 0xF1, 0xE1, 0xC1, 0xC0, 0x00,
  0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0x07, 0xE1, 0xF0, 0x0F,
  0x0F, 0x00, 0x7C, 0x78, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFE, 0x0F, 0x1F, 0x00, 0x79,
  0xE0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00,
  0xF9, 0xF0, 0x0F, 0xC7, 0xC1, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xE7, 0x81,
  0xFE, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x71, 0xFC, 0x03, 0xDF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xC7, 0xE0, 0xFC, 0x07, 0x83, 0xE0, 0x1F, 0x1F, 0x00,
  0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x7C, 0x00, 0xF1, 0xF8, 0x07,
  0xC7, 0xF0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7B, 0xFF, 0x83, 0xC7, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xC1, 0xF8,
  0x3E, 0x1F, 0x01, 0xF3, 0xC0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x07, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x6F, 0x00, 0x1E,
  0xF0, 0x03, 0xC7, 0x80, 0x7C, 0x7C, 0x0F, 0x83, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x07,
  0xF1, 0xE0, 0x3F, 0xFB, 0xC0, 0xFF, 0xFF, 0x83, 0xF0, 0xFF, 0x0F, 0xC0,
  0x7E, 0x1E, 0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03,
  0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xF8, 0x1F, 0x07, 0xF0, 0x1F,
  0xFF, 0xE0, 0x3F, 0xFB, 0x80, 0x1F, 0xC7, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x0F, 0x0F, 0x80, 0x3C,
  0xF8, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x3B, 0xC0, 0x03, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xB8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x10, 0x78, 0x03,
  0xC3, 0xF0, 0x3E, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFE, 0x00,
  0x7E, 0x02, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x81, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7F, 0x0E, 0x03,
  0xFF, 0xBC, 0x0F, 0xFF, 0xF8, 0x3F, 0x0F, 0xF0, 0xFC, 0x07, 0xE1, 0xE0,
  0x07, 0x87, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x78, 0x00,
  0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F,
  0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0,
  0xF0, 0x03, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x7F, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xBC, 0x01, 0xFC, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x81, 0x00, 0x1E, 0x07, 0x00, 0x7C, 0x1F, 0x03, 0xF0, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0xFE, 0x03, 0xCF, 0xFC, 0x0F, 0x7F, 0xF8, 0x3F, 0xC7, 0xE0, 0xFC, 0x07,
  0xC3, 0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78,
  0x00, 0xF3, 0xC0, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x1F, 0xFE, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x3F, 0x0F, 0x00, 0x7C, 0x0F, 0x00,
  0xF8, 0x0F, 0x01, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x0F, 0xC0, 0x1E, 0x1F,
  0x80, 0x1E, 0x3F, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xBC, 0x00, 0x3F, 0x3E,
  0x00, 0x3C, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x78, 0x07,
  0x80, 0x78, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x78, 0x03, 0xE0, 0x78, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x03, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x7C, 0x3E, 0x07, 0x7F, 0x7F, 0x87,
  0xFF, 0xFF, 0xE3, 0xF3, 0xF9, 0xF1, 0xE0, 0xF0, 0x78, 0xF0, 0x78, 0x3C,
  0x78, 0x3C, 0x1E, 0x38, 0x1E, 0x0F, 0x3C, 0x0E, 0x07, 0x9E, 0x0F, 0x03,
  0x8F, 0x07, 0x83, 0xC7, 0x83, 0xC1, 0xE3, 0x81, 0xE0, 0xF3, 0xC0, 0xF0,
  0x79, 0xE0, 0x70, 0x3C, 0xF0, 0x78, 0x1C, 0x78, 0x3C, 0x1E, 0x3C, 0x1E,
  0x0F, 0x1C, 0x0F, 0x07, 0x9E, 0x07, 0x03, 0xCF, 0x03, 0x81, 0xE7, 0x83,
  0xC0, 0xE3, 0xC1, 0xE0, 0xF1, 0xE0, 0xF0, 0x78, 0x0F, 0x0F, 0xC0, 0x3C,
  0xFF, 0xC0, 0xF7, 0xFF, 0x83, 0xFC, 0x7E, 0x0F, 0xC0, 0x7C, 0x3E, 0x00,
  0xF1, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1,
  0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE3, 0xC0,
  0x07, 0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x0F, 0x3C,
  0x00, 0x7C, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF0,
  0xFC, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1E,
  0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x00,
  0xF1, 0xE0, 0x03, 0xC7, 0x80, 0x1E, 0x1F, 0x00, 0xF8, 0x3E, 0x0F, 0xC0,
  0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x8F, 0xE0, 0x0F, 0x7F, 0xE0, 0x1F, 0xFF, 0xE0, 0x3F, 0x87, 0xE0, 0x7C,
  0x07, 0xC0, 0xF0, 0x07, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C,
  0x3C, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0x83, 0xF8, 0x3F, 0x07,
  0xFF, 0xFC, 0x0F, 0x7F, 0xF0, 0x3E, 0x7F, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x38, 0x3F, 0xFB, 0xC3, 0xFF, 0xFE, 0x3F, 0x07, 0xF3, 0xE0, 0x1F, 0x9E,
  0x00, 0x79, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07,
  0xBC, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1,
  0xF0, 0x0F, 0x87, 0xC1, 0xFC, 0x1F, 0xFF, 0xE0, 0xFF, 0xEE, 0x01, 0xFC,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x0F, 0x0F, 0xF0, 0xE3, 0xFE, 0x1E, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F,
  0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xE1, 0xF8, 0x3E, 0x1E,
  0x01, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x80, 0x3C, 0x7C, 0x0F, 0xC7, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC1, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0x80, 0x1F, 0xF0, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00,
  0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x03, 0xC7,
  0x80, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01,
  0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xF0, 0xF0, 0x1F, 0x87, 0xC1, 0xFC, 0x3F,
  0xFD, 0xE0, 0xFF, 0xCE, 0x03, 0xFC, 0x70, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xEF, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x3C, 0x0E, 0x00, 0xF0, 0x38, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x07, 0x03, 0xC0, 0x1C, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE3, 0xC0,
  0x03, 0x8E, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0xE0, 0x18, 0x07, 0xE0, 0x38, 0x0F, 0xE0, 0x38, 0x0E, 0xE0, 0x7C,
  0x0E, 0xE0, 0x7C, 0x1E, 0xE0, 0x7C, 0x1C, 0xE0, 0xFC, 0x1C, 0xE0, 0xFC,
  0x3C, 0xE1, 0xDC, 0x38, 0xE1, 0xDC, 0x38, 0xE3, 0x9C, 0x70, 0xE3, 0x9C,
  0x70, 0xE3, 0x9C, 0xF0, 0xE7, 0x1C, 0xE0, 0xE7, 0x1C, 0xE0, 0xEE, 0x1D,
  0xE0, 0xEE, 0x0D, 0xC0, 0xEE, 0x0D, 0xC0, 0xFC, 0x0F, 0x80, 0x7C, 0x0F,
  0x80, 0x78, 0x0F, 0x80, 0x78, 0x0F, 0x00, 0x70, 0x0F, 0x00, 0x70, 0x0E,
  0x00, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF8, 0xF0, 0x00,
  0x7C, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x3E,
  0x07, 0xC0, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x78,
  0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x78, 0x00, 0x7C, 0x03, 0xC0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x01,
  0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x78,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F, 0x03,
  0x80, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFC, 0x00, 0x3E,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xE0, 0x02, 0x3F, 0xF0,
  0x07, 0x7F, 0xF8, 0x07, 0xF8, 0x7E, 0x0F, 0xF0, 0x3F, 0xBE, 0xE0, 0x1F,
  0xFE, 0xE0, 0x07, 0xFC, 0x00, 0x03, 0xF0,
};

const GFXglyph RobotoMono_Italic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 10, 32, 26, 8, -32 },
  { 41, 13, 11, 26, 9, -34 },
  { 59, 26, 32, 26, 1, -32 },
  { 163, 22, 42, 26, 3, -37 },
  { 279, 21, 34, 26, 3, -33 },
  { 369, 24, 33, 26, 1, -33 },
  { 468, 5, 11, 26, 12, -34 },
  { 475, 15, 46, 26, 7, -36 },
  { 562, 14, 46, 26, 4, -36 },
  { 643, 20, 22, 26, 5, -32 },
  { 698, 23, 24, 26, 2, -27 },
  { 767, 8, 12, 26, 4, -5 },
  { 779, 17, 4, 26, 4, -16 },
  { 788, 6, 6, 26, 9, -6 },
  { 793, 23, 35, 26, 2, -32 },
  { 894, 21, 33, 26, 3, -33 },
  { 981, 14, 32, 26, 6, -32 },
  { 1037, 23, 32, 26, 0, -32 },
  { 1129, 22, 32, 26, 1, -32 },
  { 1217, 23, 32, 26, 1, -32 },
  { 1309, 23, 33, 26, 3, -32 },
  { 1404, 19, 33, 26, 3, -32 },
  { 1483, 22, 32, 26, 4, -32 },
  { 1571, 22, 32, 26, 3, -32 },
  { 1659, 20, 32, 26, 4, -32 },
  { 1739, 9, 25, 26, 10, -25 },
  { 1768, 12, 32, 26, 7, -25 },
  { 1816, 20, 20, 26, 4, -24 },
  { 1866, 21, 13, 26, 3, -21 },
  { 1901, 21, 20, 26, 2, -24 },
  { 1954, 18, 32, 26, 6, -32 },
  { 2026, 25, 32, 26, 1, -32 },
  { 2126, 24, 32, 26, -1, -32 },
  { 2222, 24, 32, 26, 1, -32 },
  { 2318, 23, 33, 26, 2, -32 },
  { 2413, 24, 32, 26, 1, -32 },
  { 2509, 24, 32, 26, 2, -32 },
  { 2605, 24, 32, 26, 2, -32 },
  { 2701, 23, 33, 26, 2, -32 },
  { 2796, 25, 32, 26, 1, -32 },
  { 2896, 25, 32, 26, 1, -32 },
  { 2996, 25, 32, 26, 1, -32 },
  { 3096, 27, 32, 26, 1, -32 },
  { 3204, 20, 32, 26, 2, -32 },
  { 3284, 26, 32, 26, 1, -32 },
  { 3388, 25, 32, 26, 1, -32 },
  { 3488, 23, 32, 26, 2, -32 },
  { 3580, 24, 32, 26, 2, -32 },
  { 3676, 23, 37, 26, 2, -32 },
  { 3783, 23, 32, 26, 2, -32 },
  { 3875, 24, 32, 26, 2, -32 },
  { 3971, 24, 32, 26, 4, -32 },
  { 4067, 24, 32, 26, 2, -32 },
  { 4163, 24, 32, 26, 4, -32 },
  { 4259, 25, 32, 26, 3, -32 },
  { 4359, 28, 32, 26, 0, -32 },
  { 4471, 23, 32, 26, 5, -32 },
  { 4563, 25, 32, 26, 0, -32 },
  { 4663, 15, 44, 26, 6, -37 },
  { 4746, 11, 35, 26, 8, -32 },
  { 4795, 16, 44, 26, 5, -37 },
  { 4883, 16, 17, 26, 5, -32 },
  { 4917, 21, 3, 26, 0, 0 },
  { 4925, 7, 6, 26, 12, -33 },
  { 4931, 21, 24, 26, 2, -24 },
  { 4994, 22, 35, 26, 1, -34 },
  { 5091, 20, 25, 26, 3, -24 },
  { 5154, 23, 34, 26, 3, -34 },
  { 5252, 21, 24, 26, 2, -24 },
  { 5315, 24, 35, 26, 4, -35 },
  { 5420, 23, 33, 26, 1, -24 },
  { 5515, 22, 34, 26, 1, -34 },
  { 5609, 20, 32, 26, 2, -32 },
  { 5689, 20, 42, 26, 1, -32 },
  { 5794, 24, 34, 26, 1, -34 },
  { 5896, 20, 34, 26, 2, -34 },
  { 5981, 25, 24, 26, 0, -24 },
  { 6056, 22, 24, 26, 1, -24 },
  { 6122, 22, 25, 26, 2, -24 },
  { 6191, 23, 33, 26, 0, -24 },
  { 6286, 21, 33, 26, 3, -24 },
  { 6373, 20, 24, 26, 5, -24 },
  { 6433, 20, 24, 26, 3, -24 },
  { 6493, 20, 30, 26, 4, -30 },
  { 6568, 21, 24, 26, 3, -24 },
  { 6631, 22, 24, 26, 4, -24 },
  { 6697, 24, 24, 26, 3, -24 },
  { 6769, 26, 24, 26, 0, -24 },
  { 6847, 28, 34, 26, -1, -24 },
  { 6966, 23, 24, 26, 1, -24 },
  { 7035, 17, 43, 26, 7, -35 },
  { 7127, 10, 41, 26, 8, -32 },
  { 7179, 18, 43, 26, 4, -35 },
  { 7276, 24, 9, 26, 1, -18 },
};

const GFXfont RobotoMono_Italic45pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic45pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _ROBOTOMONO_ITALIC45PT7B_H_
