#ifndef _ROBOTOMONO_ITALIC32PT7B_H_
#define _ROBOTOMONO_ITALIC32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic32pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x30, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x70, 0xE1, 0xC3,
  0x87, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x0E, 0x1E, 0x38, 0x00, 0x31, 0xB8,
  0xDC, 0x6C, 0x36, 0x3B, 0x1B, 0x8C, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01,
  0x87, 0x00, 0x30, 0xC0, 0x0E, 0x18, 0x01, 0x86, 0x00, 0x30, 0xC0, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x30, 0xC0, 0x0C, 0x38, 0x01, 0x86, 0x00, 0x70,
  0xC0, 0x0C, 0x38, 0x1F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFF, 0x01, 0x86,
  0x00, 0x71, 0xC0, 0x0C, 0x30, 0x01, 0x86, 0x00, 0x61, 0xC0, 0x0C, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x01, 0xF0, 0x07, 0xFC, 0x0F,
  0xBE, 0x1E, 0x0E, 0x1C, 0x0E, 0x18, 0x0E, 0x38, 0x06, 0x38, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xF0, 0x38, 0x78,
  0xF8, 0x3F, 0xF0, 0x1F, 0xC0, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0xFE, 0x01, 0x8C, 0x07, 0x18, 0x6C, 0x30, 0xD8, 0x63, 0x30, 0xCE,
  0x73, 0xB8, 0x7E, 0x60, 0x79, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xE6, 0x01, 0xBF, 0x06, 0x67, 0x19, 0x86, 0x73, 0x0D, 0xC6, 0x19, 0x0C,
  0x30, 0x18, 0xE0, 0x3F, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x01,
  0xE7, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x70,
  0x0E, 0xF0, 0x03, 0xF0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x39, 0xCE,
  0x19, 0xC7, 0x8D, 0xE1, 0xCE, 0xE0, 0x76, 0x70, 0x3F, 0x38, 0x0F, 0x1C,
  0x07, 0x87, 0x0F, 0xC3, 0xFF, 0x70, 0x7F, 0x3C, 0x6F, 0xFD, 0xB6, 0x00,
  0x20, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x0C, 0x03, 0x80, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0x04, 0x00, 0xC0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00,
  0xC0, 0x38, 0x0E, 0x07, 0x80, 0x40, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x04, 0x18, 0x0E, 0x31, 0xDF, 0x6F, 0xDF, 0xFF, 0x07, 0xC0,
  0x0F, 0x00, 0x3F, 0x00, 0xE6, 0x03, 0x8E, 0x0F, 0x0E, 0x0C, 0x18, 0x00,
  0x20, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x3C, 0xE3, 0x8E,
  0x39, 0xC6, 0x38, 0xFF, 0xFF, 0xFF, 0x77, 0xFE, 0xE0, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x3C, 0xF0, 0xE0, 0x73, 0x80, 0xE7, 0x00, 0xCC, 0x01,
  0xB8, 0x07, 0x70, 0x3E, 0xE0, 0xFD, 0xC7, 0xBB, 0x1E, 0x7E, 0x70, 0xFF,
  0xC1, 0xFF, 0x03, 0x78, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE3, 0x01,
  0xC7, 0x0F, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x40, 0xF0, 0xFD, 0xFE,
  0x79, 0xB8, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xC0,
  0x01, 0xF8, 0x07, 0xFE, 0x0F, 0x9E, 0x0E, 0x07, 0x1C, 0x07, 0x1C, 0x07,
  0x38, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0x03, 0xF0,
  0x0F, 0xF8, 0x3C, 0xF8, 0xE0, 0x73, 0x80, 0xE7, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x78, 0x1F, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1D, 0xC0, 0x3B, 0x80, 0x67, 0x01, 0xC7,
  0x0F, 0x0F, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xB0, 0x03, 0x98, 0x03, 0x9C, 0x01,
  0xCE, 0x01, 0xC7, 0x01, 0xC3, 0x81, 0xC1, 0x81, 0xC1, 0xC0, 0xE0, 0xE0,
  0xE0, 0x70, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x07, 0xFF, 0x07, 0xFF, 0x0F,
  0xFF, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x19,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF8, 0x38, 0x3C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x70, 0x38, 0x78,
  0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x00, 0x18, 0x07, 0xE0, 0x3F, 0x83, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x73, 0xC1, 0xFF, 0xC7, 0xFF,
  0xBE, 0x0E, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x6E, 0x03, 0x9C, 0x1E, 0x78, 0xF0, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x01, 0xF0, 0x07, 0xFC,
  0x0F, 0x3E, 0x1E, 0x0E, 0x1C, 0x06, 0x1C, 0x07, 0x38, 0x06, 0x18, 0x0E,
  0x1C, 0x0E, 0x1C, 0x1C, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8, 0x38, 0x38,
  0x70, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38,
  0x78, 0x78, 0x3F, 0xF0, 0x1F, 0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0xEF, 0x8E,
  0x0E, 0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x03, 0xFC, 0x0E, 0x70, 0xF8, 0xFF, 0xE1, 0xFB, 0x80, 0x0C, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x00, 0xF0, 0x7F, 0x81, 0xFC, 0x07, 0x80, 0x00, 0x1C,
  0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x78, 0xF1, 0xE0, 0x07, 0x07, 0xC3, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x38, 0x1C, 0x0E,
  0x07, 0x07, 0x03, 0x03, 0x80, 0x00, 0x0C, 0x00, 0xF0, 0x1F, 0x81, 0xFC,
  0x1F, 0x83, 0xF8, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0x70, 0x00, 0x40, 0x3F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFC, 0x20,
  0x00, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xC0,
  0x1F, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0x00, 0xE0, 0x02, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0x8F, 0xBE, 0xE0, 0x77, 0x03, 0xF0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0x01, 0xE3, 0xC1, 0xC0, 0x61, 0xC0,
  0x18, 0xC7, 0xCC, 0xC7, 0xE6, 0x67, 0x31, 0x63, 0x18, 0xB3, 0x0C, 0x59,
  0x84, 0x78, 0xC6, 0x3C, 0xC3, 0x1E, 0x61, 0x8B, 0x31, 0xCD, 0x9D, 0xC6,
  0xC7, 0xBE, 0x63, 0x9E, 0x18, 0x00, 0x0C, 0x00, 0x07, 0x02, 0x01, 0xFF,
  0x00, 0x3F, 0x00, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0xFC, 0x00, 0xDC, 0x01, 0xDC, 0x01, 0x8C, 0x03, 0x8C, 0x03,
  0x0C, 0x07, 0x0E, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1F, 0xFE, 0x1F,
  0xFE, 0x38, 0x06, 0x38, 0x06, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC3, 0x80, 0xE1, 0xC0, 0x38,
  0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x38, 0x07, 0x1C, 0x0F, 0x0F, 0xFF,
  0x07, 0xFF, 0x03, 0x83, 0xC1, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x0C, 0x70,
  0x06, 0x38, 0x07, 0x1C, 0x03, 0x8C, 0x03, 0x8E, 0x0F, 0xC7, 0xFF, 0x83,
  0xFF, 0x00, 0x03, 0xF0, 0x07, 0xFC, 0x0F, 0x3E, 0x1C, 0x0E, 0x38, 0x07,
  0x38, 0x07, 0x70, 0x07, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x0C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0x70, 0xF0, 0x3F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0x03, 0x81, 0xC1, 0xC0, 0x70, 0xE0,
  0x38, 0x60, 0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0x73, 0x00, 0x33, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E,
  0x38, 0x07, 0x38, 0x07, 0x1C, 0x0F, 0x0E, 0x3F, 0x07, 0xFF, 0x03, 0xFE,
  0x00, 0x0F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF8, 0x30, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x3F, 0xFF, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xF8,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0x01, 0xE7, 0xC1, 0xC0, 0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0xE0, 0x0E,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x07,
  0xF3, 0x03, 0xF9, 0x80, 0x1C, 0xC0, 0x0E, 0x70, 0x06, 0x38, 0x03, 0x1C,
  0x03, 0x87, 0x01, 0xC3, 0xC3, 0xC0, 0xFF, 0xC0, 0x3F, 0xC0, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03,
  0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01, 0x83, 0x80, 0x30, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xC1, 0x80, 0x38,
  0x30, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x03, 0x07, 0x00, 0x60,
  0xC0, 0x1C, 0x38, 0x03, 0x80, 0x0F, 0xFF, 0x87, 0xFF, 0xC7, 0xFF, 0xE0,
  0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x0F,
  0xFF, 0xC7, 0xFF, 0xE3, 0xFF, 0xE0, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x0E, 0x07,
  0x07, 0x8F, 0x01, 0xFF, 0x00, 0x7F, 0x00, 0x0E, 0x01, 0xE1, 0xC0, 0x78,
  0x30, 0x1E, 0x0E, 0x07, 0x81, 0xC1, 0xE0, 0x38, 0x78, 0x07, 0x1E, 0x00,
  0xE7, 0x80, 0x39, 0xE0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x79, 0xC0, 0x1E, 0x38, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x30, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x3C, 0x38,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x03, 0xC7, 0x80, 0xF1,
  0xE0, 0x7C, 0x78, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0x63, 0xB1, 0xF8, 0xEC,
  0x6E, 0x3B, 0x3B, 0x8E, 0xCC, 0xC3, 0x37, 0x30, 0xCF, 0x9C, 0x73, 0xE7,
  0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC6, 0x18, 0x61, 0x8E, 0x18, 0x03, 0x8E,
  0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x03, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0xC7, 0x80, 0x71, 0xE0, 0x18, 0x78, 0x0E, 0x1F, 0x03, 0x87, 0xC0,
  0xE3, 0xB0, 0x38, 0xEE, 0x0E, 0x3B, 0x87, 0x0E, 0x61, 0xC3, 0x9C, 0x70,
  0xC7, 0x1C, 0x70, 0xC7, 0x1C, 0x39, 0xC7, 0x0E, 0xE1, 0xC1, 0xB8, 0x70,
  0x7E, 0x38, 0x1F, 0x8E, 0x03, 0xE3, 0x80, 0xF0, 0xE0, 0x3C, 0x38, 0x07,
  0x0C, 0x01, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xFC, 0x1C, 0x0E, 0x38,
  0x0E, 0x38, 0x06, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0,
  0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xF0, 0x78, 0x78, 0xF0, 0x3F, 0xE0, 0x1F,
  0x80, 0x0F, 0xF8, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x30, 0x1E, 0x1C, 0x03,
  0x87, 0x00, 0x61, 0xC0, 0x1C, 0x70, 0x06, 0x1C, 0x03, 0x86, 0x00, 0xE3,
  0x80, 0x70, 0xE1, 0xF8, 0x3F, 0xFC, 0x0F, 0xFC, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x18, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x01, 0xFF, 0x81,
  0xC0, 0xE1, 0xC0, 0x70, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x70, 0x03,
  0xB8, 0x01, 0xDC, 0x00, 0xEE, 0x00, 0x76, 0x00, 0x37, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x0E, 0x60, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x83,
  0xC7, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x02, 0x00, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFF, 0xC3, 0x80, 0xE1,
  0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x18, 0x03, 0x9C, 0x03,
  0x8E, 0x03, 0x87, 0xFF, 0x83, 0xFF, 0x81, 0xFF, 0x80, 0xC1, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x38, 0x1C, 0x1C, 0x0E, 0x0E, 0x03, 0x86, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x38, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xE7, 0xC3, 0xC0,
  0xE1, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x1C, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0xC3, 0xC3,
  0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x30, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00,
  0xC7, 0x00, 0x63, 0x00, 0x71, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70,
  0x06, 0x38, 0x07, 0x18, 0x03, 0x8C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73,
  0x80, 0x31, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x0F,
  0x07, 0x8F, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0x98,
  0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0x70, 0xE0, 0x70,
  0x70, 0x38, 0x18, 0x38, 0x0C, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x01, 0xC6,
  0x00, 0xE7, 0x00, 0x73, 0x80, 0x1B, 0x80, 0x0D, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x70, 0xE1, 0xDC, 0x38,
  0x77, 0x0E, 0x19, 0xC7, 0x8E, 0x71, 0xE3, 0x9C, 0x78, 0xE7, 0x3E, 0x31,
  0x8D, 0x9C, 0x63, 0x67, 0x19, 0xD9, 0xC6, 0x66, 0x61, 0x99, 0xB8, 0x6E,
  0x6E, 0x1B, 0x1B, 0x06, 0xC6, 0xC1, 0xF1, 0xF0, 0x78, 0x7C, 0x1E, 0x1E,
  0x0F, 0x87, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x3C, 0x1C, 0x0E, 0x07, 0x00,
  0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x38, 0x07, 0x07,
  0x80, 0x38, 0x70, 0x03, 0x8E, 0x00, 0x19, 0xC0, 0x01, 0xDC, 0x00, 0x1F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xB8, 0x00, 0x73, 0x80, 0x07, 0x18, 0x00, 0xE1, 0xC0, 0x1C, 0x1C, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x07, 0x00, 0xE0, 0x07,
  0xB8, 0x03, 0x9C, 0x03, 0x8E, 0x03, 0xC3, 0x81, 0xC1, 0xC1, 0xC0, 0xE0,
  0xE0, 0x30, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x70, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF,
  0x8F, 0xFF, 0xE0, 0x07, 0xE0, 0xFC, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x00,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x30, 0x07, 0xE1, 0xF8, 0x3F, 0x00, 0xC1, 0xC3,
  0x83, 0x06, 0x0C, 0x1C, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x0C,
  0x1C, 0x38, 0x30, 0x60, 0xC1, 0xC3, 0x83, 0x06, 0x07, 0xE1, 0xFC, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x0F, 0xC1,
  0xF8, 0x3F, 0x00, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0xFC, 0x1B, 0x87,
  0x71, 0xC6, 0x38, 0xCE, 0x1D, 0x83, 0xF0, 0x30, 0x7F, 0xFF, 0xFF, 0xF8,
  0xE3, 0x8C, 0x70, 0x07, 0xE0, 0x7F, 0xE3, 0xC3, 0xCE, 0x07, 0x70, 0x1C,
  0x00, 0x70, 0x01, 0xC7, 0xFF, 0x3F, 0xFD, 0xC0, 0x6E, 0x03, 0xB8, 0x0E,
  0xC0, 0x3B, 0x81, 0xEF, 0x1F, 0x9F, 0xEE, 0x3F, 0x38, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1D,
  0xF8, 0x1B, 0xFC, 0x1F, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x06, 0x38,
  0x06, 0x30, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x1C, 0x70, 0x3C, 0xFC, 0x78, 0xEF, 0xF0, 0xE7, 0xE0, 0x07, 0xF0, 0x1F,
  0xF0, 0x78, 0xF1, 0xC0, 0xE7, 0x00, 0xEE, 0x01, 0xF8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x2E, 0x01, 0x8E, 0x07, 0x1E,
  0x1C, 0x1F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x0F, 0xDC, 0x1F, 0xFE,
  0x1F, 0x1F, 0x0E, 0x07, 0x8E, 0x01, 0xC7, 0x01, 0xC7, 0x00, 0xE3, 0x80,
  0x71, 0xC0, 0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x38, 0x0E, 0x1C, 0x07, 0x0E,
  0x07, 0x83, 0xC7, 0xC1, 0xFF, 0xE0, 0x3E, 0x60, 0x07, 0xF0, 0x1F, 0xF0,
  0x78, 0xF1, 0xC0, 0xE7, 0x00, 0xCE, 0x01, 0xB8, 0x03, 0xFF, 0xFF, 0xFF,
  0xFD, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x03, 0x1E, 0x1E,
  0x1F, 0xF8, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x78,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F, 0xFC, 0x7F,
  0xFE, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF3,
  0x0F, 0xFF, 0x1F, 0x1F, 0x1C, 0x0F, 0x38, 0x07, 0x38, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C,
  0x78, 0x3C, 0x3C, 0x7C, 0x3F, 0xFC, 0x0F, 0x9C, 0x00, 0x38, 0x00, 0x38,
  0x40, 0x78, 0xE0, 0xF0, 0xFF, 0xE0, 0x7F, 0xC0, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0xF8, 0x1B, 0xFC, 0x1F, 0x1E, 0x3C, 0x0E, 0x38, 0x0E, 0x38, 0x06,
  0x38, 0x06, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0C, 0x60, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0x00, 0x30,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x07,
  0xFF, 0xEF, 0xFF, 0xBF, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x0F, 0xF8, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x1F, 0x1C, 0x1E, 0x0C, 0x1E, 0x0E, 0x1E, 0x07, 0x1E,
  0x03, 0x9E, 0x01, 0xDC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7D, 0xC0, 0x3C,
  0xE0, 0x1C, 0x38, 0x0E, 0x1E, 0x06, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xF1,
  0xC0, 0x38, 0x07, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x18, 0x0F, 0xFF, 0xDF, 0xFF, 0x7F, 0xFE, 0x1B,
  0xCF, 0x8F, 0xFF, 0xE3, 0xCF, 0x3C, 0xE3, 0x87, 0x38, 0xE1, 0xCC, 0x38,
  0x73, 0x0E, 0x19, 0xC3, 0x86, 0x70, 0xC3, 0x9C, 0x30, 0xE7, 0x1C, 0x39,
  0x87, 0x0E, 0x61, 0xC3, 0x38, 0x70, 0xCE, 0x18, 0x73, 0x86, 0x1C, 0xE3,
  0x87, 0x00, 0x18, 0xF8, 0x37, 0xF8, 0x7C, 0x79, 0xE0, 0x73, 0x80, 0xE7,
  0x00, 0xCE, 0x03, 0x98, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80,
  0x67, 0x01, 0xCC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1C, 0x07, 0xE0,
  0x3F, 0xF0, 0xF0, 0xE1, 0xC0, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0x80, 0x1B, 0x00, 0x77, 0x00, 0xEE, 0x03, 0x9C, 0x07,
  0x1C, 0x3C, 0x1F, 0xF0, 0x1F, 0xC0, 0x0C, 0xFC, 0x0D, 0xFE, 0x1F, 0x9F,
  0x1E, 0x07, 0x1C, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x18, 0x03, 0x38, 0x07,
  0x38, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x38, 0x1E, 0x7C, 0x3C,
  0x7F, 0xF8, 0x73, 0xF0, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xE6, 0x3F, 0xFC, 0xF8, 0xF9,
  0xC0, 0xF7, 0x00, 0xEE, 0x01, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0,
  0x3B, 0x80, 0x67, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x1C, 0x3E, 0x3F, 0xFC,
  0x1F, 0xB0, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x1C, 0xFE, 0x3B, 0xF8, 0x7F, 0xF0, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x00, 0x07,
  0xF0, 0x3F, 0xF0, 0xF8, 0xF1, 0xC0, 0xE3, 0x80, 0xE7, 0x00, 0x0E, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0xEE, 0x01, 0xDC,
  0x07, 0x1C, 0x1E, 0x3F, 0xF8, 0x1F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xE1, 0x03, 0xFC, 0x07, 0xF0, 0x38, 0x0E, 0x70, 0x1C,
  0xC0, 0x3B, 0x80, 0x77, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x38, 0x0E, 0x60,
  0x1D, 0xC0, 0x3B, 0x80, 0x77, 0x01, 0xCE, 0x03, 0x9C, 0x0F, 0x1C, 0x3E,
  0x3F, 0xDC, 0x3F, 0x30, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x73, 0x00, 0xC6,
  0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x38, 0x70, 0x30, 0xE0, 0x63, 0x80, 0xE7,
  0x01, 0xDC, 0x01, 0xB0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x0C, 0x00,
  0xE0, 0xC1, 0xF0, 0xE1, 0xF8, 0x70, 0xDC, 0x78, 0x6E, 0x3C, 0x77, 0x3E,
  0x33, 0x9B, 0x19, 0xCD, 0x9C, 0xEC, 0xCC, 0x76, 0x66, 0x3F, 0x36, 0x1F,
  0x1B, 0x0D, 0x8D, 0x87, 0x87, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x00, 0x1C, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x9C,
  0x00, 0xEF, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x1C, 0xE0, 0x0E, 0x38, 0x07, 0x87, 0x03, 0xC1, 0xC1, 0xE0,
  0x38, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x0F, 0x0E,
  0x01, 0xC0, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x06,
  0x1C, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0x37, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x20, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0x00,
  0x30, 0x0F, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0xF8, 0x0F, 0x00, 0xF8,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x0E, 0x18,
  0x30, 0x60, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18,
  0x30, 0x61, 0xC3, 0x86, 0x0C, 0x18, 0x30, 0xE1, 0xC3, 0x06, 0x0C, 0x00,
  0x0C, 0x00, 0xF0, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xF0, 0x0F,
  0x01, 0xF0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x0F, 0x00, 0x80, 0x00, 0x04,
  0x00, 0x07, 0xE0, 0x33, 0xFC, 0x0D, 0xC7, 0x87, 0x60, 0xFF, 0xB8, 0x0F,
  0xC0, 0x00, 0xE0,
};

const GFXglyph RobotoMono_Italic32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 7, 23, 19, 6, -23 },
  { 22, 9, 7, 19, 6, -24 },
  { 30, 19, 23, 19, 0, -23 },
  { 85, 16, 29, 19, 2, -26 },
  { 143, 15, 23, 19, 2, -23 },
  { 187, 17, 23, 19, 1, -23 },
  { 236, 3, 8, 19, 9, -24 },
  { 239, 11, 33, 19, 5, -26 },
  { 285, 11, 33, 19, 2, -26 },
  { 331, 15, 16, 19, 3, -23 },
  { 361, 15, 17, 19, 2, -19 },
  { 393, 6, 8, 19, 3, -3 },
  { 399, 12, 2, 19, 3, -11 },
  { 402, 5, 4, 19, 6, -4 },
  { 405, 16, 25, 19, 2, -23 },
  { 455, 15, 23, 19, 2, -23 },
  { 499, 10, 23, 19, 4, -23 },
  { 528, 16, 23, 19, 0, -23 },
  { 574, 15, 23, 19, 1, -23 },
  { 618, 17, 23, 19, 0, -23 },
  { 667, 16, 23, 19, 2, -23 },
  { 713, 14, 23, 19, 2, -23 },
  { 754, 16, 23, 19, 3, -23 },
  { 800, 16, 23, 19, 2, -23 },
  { 846, 14, 23, 19, 3, -23 },
  { 887, 7, 18, 19, 7, -18 },
  { 903, 9, 23, 19, 5, -18 },
  { 929, 14, 14, 19, 3, -17 },
  { 954, 15, 9, 19, 2, -15 },
  { 971, 14, 14, 19, 2, -17 },
  { 996, 13, 23, 19, 4, -23 },
  { 1034, 17, 23, 19, 1, -23 },
  { 1083, 16, 23, 19, 0, -23 },
  { 1129, 17, 23, 19, 1, -23 },
  { 1178, 16, 23, 19, 2, -23 },
  { 1224, 17, 23, 19, 1, -23 },
  { 1273, 18, 23, 19, 1, -23 },
  { 1325, 18, 23, 19, 1, -23 },
  { 1377, 17, 23, 19, 1, -23 },
  { 1426, 19, 23, 19, 0, -23 },
  { 1481, 17, 23, 19, 1, -23 },
  { 1530, 17, 23, 19, 1, -23 },
  { 1579, 19, 23, 19, 1, -23 },
  { 1634, 14, 23, 19, 1, -23 },
  { 1675, 18, 23, 19, 1, -23 },
  { 1727, 18, 23, 19, 1, -23 },
  { 1779, 16, 23, 19, 2, -23 },
  { 1825, 18, 23, 19, 1, -23 },
  { 1877, 17, 27, 19, 1, -23 },
  { 1935, 17, 23, 19, 1, -23 },
  { 1984, 17, 23, 19, 1, -23 },
  { 2033, 17, 23, 19, 3, -23 },
  { 2082, 17, 23, 19, 2, -23 },
  { 2131, 17, 23, 19, 3, -23 },
  { 2180, 18, 23, 19, 2, -23 },
  { 2232, 20, 23, 19, 0, -23 },
  { 2290, 17, 23, 19, 3, -23 },
  { 2339, 18, 23, 19, 0, -23 },
  { 2391, 11, 31, 19, 4, -26 },
  { 2434, 7, 25, 19, 6, -23 },
  { 2456, 11, 31, 19, 4, -26 },
  { 2499, 11, 12, 19, 4, -23 },
  { 2516, 15, 2, 19, 0, 0 },
  { 2520, 5, 4, 19, 9, -23 },
  { 2523, 14, 17, 19, 2, -17 },
  { 2553, 16, 24, 19, 1, -24 },
  { 2601, 15, 17, 19, 2, -17 },
  { 2633, 17, 24, 19, 2, -24 },
  { 2684, 15, 17, 19, 2, -17 },
  { 2716, 17, 25, 19, 3, -25 },
  { 2770, 16, 24, 19, 1, -17 },
  { 2818, 16, 24, 19, 1, -24 },
  { 2866, 15, 23, 19, 1, -23 },
  { 2910, 14, 30, 19, 1, -23 },
  { 2963, 17, 24, 19, 1, -24 },
  { 3014, 15, 24, 19, 1, -24 },
  { 3059, 18, 17, 19, 0, -17 },
  { 3098, 15, 17, 19, 1, -17 },
  { 3130, 15, 17, 19, 2, -17 },
  { 3162, 16, 24, 19, 0, -17 },
  { 3210, 15, 24, 19, 2, -17 },
  { 3255, 15, 17, 19, 3, -17 },
  { 3287, 15, 17, 19, 2, -17 },
  { 3319, 14, 21, 19, 3, -21 },
  { 3356, 15, 17, 19, 2, -17 },
  { 3388, 15, 17, 19, 3, -17 },
  { 3420, 17, 17, 19, 2, -17 },
  { 3457, 18, 17, 19, 0, -17 },
  { 3496, 19, 24, 19, 0, -17 },
  { 3553, 16, 17, 19, 1, -17 },
  { 3587, 12, 31, 19, 5, -25 },
  { 3634, 7, 29, 19, 6, -23 },
  { 3660, 12, 31, 19, 3, -25 },
  { 3707, 18, 7, 19, 0, -13 },
};

const GFXfont RobotoMono_Italic32pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic32pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _ROBOTOMONO_ITALIC32PT7B_H_
