#ifndef _ROBOTOMONO_ITALIC68PT7B_H_
#define _ROBOTOMONO_ITALIC68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xFC,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x00, 0x3E, 0x03, 0xE7, 0xC0, 0x78, 0xF8, 0x1F, 0x1F, 0x03, 0xE3, 0xC0,
  0x7C, 0xF8, 0x0F, 0x9F, 0x01, 0xE3, 0xE0, 0x3C, 0x7C, 0x0F, 0x8F, 0x01,
  0xF1, 0xE0, 0x3E, 0x7C, 0x07, 0x8F, 0x80, 0xF1, 0xF0, 0x1E, 0x3C, 0x07,
  0xC7, 0x80, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFE, 0x3F, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF8, 0x0F,
  0xF0, 0x07, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x40, 0xF8, 0x0F,
  0x80, 0x70, 0x78, 0x03, 0xC0, 0x3E, 0x3C, 0x03, 0xE0, 0x3E, 0x1E, 0x01,
  0xF0, 0x3E, 0x1F, 0x00, 0xF8, 0x1F, 0x0F, 0x80, 0x7C, 0x1F, 0x07, 0xC0,
  0x3E, 0x1F, 0x01, 0xE0, 0x1E, 0x0F, 0x80, 0xF8, 0x1F, 0x0F, 0x80, 0x7C,
  0x1F, 0x0F, 0x80, 0x1F, 0xFF, 0x8F, 0x80, 0x0F, 0xFF, 0x87, 0xC0, 0x03,
  0xFF, 0x87, 0xC0, 0x00, 0x7F, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x1C, 0x00, 0x00, 0xF8, 0x7F, 0xC0, 0x00, 0xF8, 0x7F,
  0xF0, 0x00, 0x7C, 0x7F, 0xFC, 0x00, 0x7C, 0x7F, 0x7F, 0x00, 0x7C, 0x7E,
  0x0F, 0x80, 0x7C, 0x3E, 0x03, 0xC0, 0x3E, 0x1E, 0x01, 0xE0, 0x3E, 0x1F,
  0x00, 0xF8, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x07, 0xC0, 0x3C, 0x1F, 0x03,
  0xE0, 0x1E, 0x1F, 0x01, 0xE0, 0x0F, 0x03, 0x00, 0xF0, 0x0F, 0x80, 0x80,
  0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F, 0x03, 0xE0, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0x83, 0xF0, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F,
  0xC7, 0xF8, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0xFD, 0xFC, 0x01, 0xF0, 0xFF,
  0x1F, 0x80, 0x3E, 0x3F, 0xC3, 0xF8, 0x0F, 0xCF, 0xF0, 0x3F, 0x01, 0xF9,
  0xFC, 0x07, 0xF0, 0x3E, 0x7F, 0x00, 0x7E, 0x0F, 0xCF, 0xE0, 0x0F, 0xE1,
  0xF9, 0xF8, 0x00, 0xFE, 0x7E, 0x7F, 0x00, 0x0F, 0xCF, 0xCF, 0xC0, 0x01,
  0xFF, 0xF1, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0x00, 0x03, 0xFF, 0x87, 0xE0,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x1F, 0xFE, 0x03, 0xFE, 0x1F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x9F, 0xC0, 0x3F, 0xFF,
  0xC1, 0xF8, 0x01, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x1F,
  0x1F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x70, 0x07, 0xC0, 0x18, 0xF8,
  0x0F, 0x80, 0xFB, 0xFC, 0x1E, 0x0F, 0xF7, 0xFE, 0x3C, 0x7F, 0xEF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0x80, 0x07, 0x80, 0x01, 0x00, 0x0C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF8, 0x1F,
  0x80, 0xFC, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xF8, 0x1F, 0x81,
  0xFC, 0x1F, 0xC0, 0x7C, 0x00, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0E,
  0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xF9, 0xFE, 0x3F, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0xFF, 0xCF, 0xC0, 0x00, 0xFF, 0xE7,
  0xE0, 0x01, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xF8,
  0xFC, 0x03, 0xFC, 0xFC, 0x7E, 0x03, 0xFC, 0x7E, 0x7E, 0x07, 0xF8, 0x3F,
  0x3F, 0x07, 0xF8, 0x1F, 0x9F, 0x8F, 0xF0, 0x0F, 0xCF, 0xCF, 0xF0, 0x0F,
  0xC7, 0xFF, 0xF0, 0x07, 0xE3, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xE0, 0x01,
  0xF9, 0xFF, 0xC0, 0x00, 0xFC, 0xFF, 0xC0, 0x00, 0x7E, 0x7F, 0x80, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x07, 0xF0, 0x07, 0xF8, 0x01, 0xFF, 0x0F, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xF8,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xE7, 0xE3, 0xF8, 0x3F, 0x1F, 0x01,
  0xF8, 0xC0, 0x0F, 0xC8, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0x81, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFC,
  0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0,
  0x07, 0xFC, 0x03, 0xFF, 0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x60, 0x00, 0x01, 0xFB,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x7F, 0x80, 0x1F, 0xE0, 0x01, 0x80, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0xC7, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0x7E, 0x3F, 0xF8, 0x01, 0xF1,
  0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF9,
  0xFF, 0x83, 0xFF, 0x00, 0xFF, 0x1F, 0xF8, 0x01, 0xFC, 0x7F, 0x80, 0x03,
  0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x7F, 0x01, 0xFC, 0x03, 0xFC, 0x07, 0xFC, 0x7F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC,
  0x7F, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x7F, 0x80, 0xFF, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x3F, 0xE3,
  0xFC, 0x03, 0xFF, 0x87, 0xFC, 0x3F, 0xFC, 0x1F, 0xFF, 0xFD, 0xF0, 0x3F,
  0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0x3E, 0x00, 0x7F, 0xF1, 0xF8, 0x00, 0x3E,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F,
  0xF0, 0x7F, 0xC1, 0xFF, 0x03, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07, 0xF0, 0x1F, 0xE0, 0xFF, 0x83,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x01, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x18, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0x87, 0xFC,
  0x3F, 0xC0, 0x1F, 0xE3, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x0F, 0xF0, 0x3C, 0x07, 0x80,
  0xFF, 0xE0, 0xE0, 0x78, 0x0F, 0xFF, 0x87, 0x83, 0xC0, 0xFF, 0xF8, 0x3C,
  0x3C, 0x0F, 0x81, 0xC1, 0xE1, 0xE0, 0xF8, 0x1E, 0x0F, 0x1E, 0x07, 0x80,
  0xF0, 0x78, 0xF0, 0x7C, 0x07, 0x03, 0xCF, 0x83, 0xC0, 0x38, 0x1E, 0x78,
  0x3E, 0x03, 0xC0, 0xF3, 0xC1, 0xE0, 0x1E, 0x07, 0x9E, 0x0F, 0x00, 0xF0,
  0x3D, 0xE0, 0xF8, 0x07, 0x01, 0xCF, 0x07, 0x80, 0x78, 0x0E, 0x78, 0x3C,
  0x03, 0xC0, 0x73, 0xC1, 0xE0, 0x1E, 0x07, 0x9E, 0x0F, 0x00, 0xE0, 0x39,
  0xE0, 0xF8, 0x0F, 0x01, 0xCF, 0x07, 0x80, 0x78, 0x1E, 0x78, 0x3C, 0x03,
  0xC0, 0xF3, 0xC1, 0xF0, 0x3E, 0x07, 0x1E, 0x0F, 0x83, 0xE0, 0x78, 0xF0,
  0x3C, 0x7F, 0x87, 0x87, 0x81, 0xFF, 0xFE, 0x78, 0x3C, 0x0F, 0xFD, 0xFF,
  0xC0, 0xF0, 0x3F, 0xC7, 0xFC, 0x07, 0x81, 0xF8, 0x1F, 0x80, 0x3C, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x01,
  0x80, 0x00, 0x1F, 0xC0, 0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x00,
  0xFC, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x07, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFE, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x87, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x80, 0x3F,
  0xF0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC3, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFE, 0x3F, 0x00, 0x1F, 0xFF,
  0xCF, 0xC0, 0x03, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFF, 0x3F, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0xF0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x03, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x07,
  0xE3, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xF0,
  0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x7E, 0x00,
  0x00, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xEF, 0x00, 0x3F,
  0xF8, 0x07, 0xDF, 0x00, 0xFF, 0xF0, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0x3F,
  0x7C, 0x07, 0xEF, 0x80, 0x7E, 0xF8, 0x0F, 0x9F, 0x00, 0xFD, 0xF0, 0x3F,
  0x7E, 0x01, 0xF3, 0xE0, 0x7C, 0xFC, 0x03, 0xE7, 0xC1, 0xF9, 0xF0, 0x07,
  0xC7, 0xC3, 0xE3, 0xE0, 0x1F, 0x8F, 0x8F, 0xC7, 0xC0, 0x3F, 0x1F, 0x1F,
  0x1F, 0x80, 0x7E, 0x3E, 0x7E, 0x3F, 0x00, 0xFC, 0x7C, 0xF8, 0x7E, 0x01,
  0xF0, 0xFB, 0xF0, 0xF8, 0x03, 0xE1, 0xF7, 0xC1, 0xF0, 0x0F, 0xC1, 0xFF,
  0x87, 0xE0, 0x1F, 0x83, 0xFE, 0x0F, 0xC0, 0x3F, 0x07, 0xFC, 0x1F, 0x80,
  0x7E, 0x0F, 0xF0, 0x3F, 0x00, 0xFC, 0x1F, 0xE0, 0x7C, 0x01, 0xF0, 0x3F,
  0x81, 0xF8, 0x07, 0xE0, 0x7F, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0,
  0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xE0, 0x1F, 0x80, 0x7C, 0x03,
  0xC0, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F, 0x80,
  0x7F, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0x80,
  0x01, 0xF8, 0x03, 0xFF, 0x80, 0x03, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xE0,
  0x1F, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x01, 0xF8,
  0x03, 0xF3, 0xF0, 0x03, 0xF0, 0x0F, 0xE3, 0xE0, 0x07, 0xE0, 0x1F, 0x87,
  0xE0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x0F, 0x80, 0x7E,
  0x00, 0xFC, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x3F, 0x01, 0xF8, 0x07, 0xF0,
  0x3E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0xE0, 0x1F, 0x80, 0xFC, 0x1F,
  0x80, 0x3F, 0x00, 0xF8, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x03, 0xE1, 0xF8, 0x07, 0xE0, 0x07, 0xE7,
  0xF0, 0x0F, 0xC0, 0x0F, 0xCF, 0xC0, 0x1F, 0x80, 0x0F, 0x9F, 0x80, 0x3F,
  0x00, 0x1F, 0xBF, 0x00, 0xFE, 0x00, 0x3F, 0x7E, 0x01, 0xF8, 0x00, 0x7E,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xE0, 0x00, 0xFF, 0xE0, 0x0F,
  0xC0, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x03,
  0xFF, 0x00, 0xFC, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xCF, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x1F,
  0x8F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F,
  0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0,
  0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x03,
  0xFE, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xEF, 0xFE, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x87, 0xC0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x00, 0xE7, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x1F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x3F, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x07, 0xF8, 0x07, 0xE0,
  0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7C, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFB,
  0xF0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0xF8, 0x03, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC0, 0x1F, 0x8F,
  0x80, 0x3F, 0x00, 0x7E, 0x3E, 0x01, 0xFC, 0x01, 0xF0, 0xF8, 0x07, 0xF0,
  0x0F, 0xC3, 0xE0, 0x1F, 0xC0, 0x3F, 0x0F, 0x80, 0xFF, 0x00, 0xF8, 0x7E,
  0x03, 0xFC, 0x03, 0xE1, 0xF8, 0x0F, 0xF0, 0x1F, 0x87, 0xE0, 0x7F, 0xC0,
  0x7E, 0x1F, 0x81, 0xFF, 0x01, 0xF0, 0x7E, 0x07, 0xFC, 0x0F, 0xC1, 0xF8,
  0x3E, 0xF0, 0x3F, 0x07, 0xE0, 0xFB, 0xC0, 0xFC, 0x1F, 0x83, 0xEF, 0x03,
  0xE0, 0x7E, 0x1F, 0x3C, 0x1F, 0x81, 0xF0, 0x7C, 0xF0, 0x7E, 0x07, 0xC1,
  0xF3, 0xE1, 0xF0, 0x1F, 0x0F, 0x8F, 0x87, 0xC0, 0x7C, 0x3E, 0x3E, 0x3F,
  0x01, 0xF0, 0xF8, 0xF8, 0xFC, 0x07, 0xC3, 0xC3, 0xE3, 0xE0, 0x1F, 0x1F,
  0x0F, 0x8F, 0x80, 0x7C, 0x7C, 0x3E, 0x7E, 0x01, 0xF1, 0xE0, 0xF9, 0xF0,
  0x07, 0xCF, 0x83, 0xE7, 0xC0, 0x1F, 0x3E, 0x0F, 0x9F, 0x00, 0x7C, 0xF0,
  0x3E, 0xFC, 0x01, 0xF7, 0xC0, 0xFB, 0xE0, 0x07, 0xDF, 0x03, 0xEF, 0x80,
  0x1F, 0x7C, 0x0F, 0xBE, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x01, 0xFF, 0x80,
  0xFF, 0xC0, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xEF, 0xC0, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03,
  0xE7, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x41, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8,
  0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xE0,
  0x7C, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x3E, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFE, 0x0F, 0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0x0F, 0xFC, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F,
  0xF0, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x7F, 0xF0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF3, 0xF0, 0x0F,
  0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0x83, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x38,
  0x00, 0x07, 0xE1, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xF0, 0x01, 0xFB, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F,
  0x87, 0xFC, 0x00, 0x7F, 0x83, 0xFF, 0x80, 0x7F, 0x81, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0xFF, 0xFF, 0xC0, 0x7E, 0x3F, 0xFF,
  0x80, 0x3F, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xF3, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x70, 0x07, 0xE0, 0x00, 0xFF, 0xE1, 0xFC,
  0x00, 0x7F, 0xFF, 0x3F, 0x00, 0x1F, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xE0,
  0x03, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x07, 0xF8, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xDF, 0x00, 0x0F, 0xFF, 0xF7, 0xE0,
  0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x07, 0xFE, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xF3,
  0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x0C, 0x0F, 0xE0, 0x00, 0x3C, 0x0F, 0xE0,
  0x00, 0xFC, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x7F, 0xE0, 0x1F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x30, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0xE3, 0xE0,
  0x01, 0xFF, 0xFF, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xFE, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0xE0, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0xFC, 0x00,
  0x0F, 0xFF, 0xCF, 0xC0, 0x00, 0x3F, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0x00, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x03,
  0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x18, 0x00, 0x07, 0xE0, 0xFF, 0xE0, 0x03, 0xF1, 0xFF, 0xF8, 0x01, 0xF9,
  0xFF, 0xFE, 0x00, 0xFD, 0xFF, 0xFF, 0x80, 0x7D, 0xFF, 0xFF, 0xE0, 0x7F,
  0xF0, 0x0F, 0xF0, 0x3F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF8, 0x00, 0x40, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x80, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x7E, 0x00,
  0x0F, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0xE0, 0x01, 0xF8, 0x07, 0xF8, 0x00,
  0x3F, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0x0F, 0xF8, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0xFC, 0xFF,
  0x00, 0x00, 0x1F, 0xBF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x01, 0xFE, 0x1F, 0xC0,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x03, 0x00, 0x0F, 0x8F, 0xF0, 0x7F,
  0x80, 0x7E, 0xFF, 0xE7, 0xFF, 0x01, 0xFF, 0xFF, 0xBF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0x07, 0xFC, 0x1F,
  0xC1, 0xF8, 0x0F, 0xE0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3E,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x3E, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x07,
  0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x7E, 0x01, 0xF8, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3F,
  0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x03, 0xF0, 0x0F, 0xC3,
  0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x7E, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0xFC,
  0x03, 0xF0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0x06, 0x00, 0x01, 0xF8, 0x3F, 0xF0, 0x00, 0xFC, 0x7F, 0xFE, 0x00,
  0x7C, 0x7F, 0xFF, 0x80, 0x3E, 0x7F, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xF0, 0x07,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x7F, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0x87, 0xFE, 0x00, 0x03, 0xF3, 0xFF, 0xF0, 0x00, 0x7C,
  0xFF, 0xFF, 0x00, 0x0F, 0xBF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0xFF, 0xC0, 0x1F, 0xE0, 0x1F, 0xFF, 0x1F, 0xF8, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0x7E, 0xFF, 0xFF, 0x80, 0x1F, 0xCF, 0xFF, 0xE0, 0x03, 0xF0,
  0x7F, 0xF0, 0x00, 0x7E, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFE,
  0x0F, 0xC0, 0x1F, 0xFF, 0xC7, 0xC0, 0x1F, 0xFF, 0xF7, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x0F, 0xFC, 0x1F, 0xE0,
  0x03, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF8,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F,
  0xC0, 0x7F, 0x00, 0x7F, 0xC0, 0x3F, 0xF1, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFD, 0xF8, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x1F, 0xF8,
  0x7E, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x0F, 0xC0, 0xFF, 0xF0, 0x3F, 0x0F, 0xFF, 0xC0,
  0xFC, 0x7F, 0xFF, 0x03, 0xE7, 0xFF, 0xF8, 0x0F, 0xBF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xDF, 0x81, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF8, 0x3F,
  0xF8, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x20,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x80,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFE, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0x00,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF,
  0xE7, 0xC0, 0x0F, 0xFF, 0x8F, 0xC0, 0x07, 0xFE, 0x0F, 0xC0, 0x00, 0x70,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x1F, 0xCF, 0x80, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x03,
  0xE0, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x07, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xFF,
  0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0x00, 0x3E, 0x00, 0x7D, 0xF8, 0x03, 0xF0,
  0x03, 0xE7, 0xC0, 0x1F, 0x80, 0x3F, 0x3E, 0x01, 0xFC, 0x01, 0xF1, 0xF0,
  0x0F, 0xE0, 0x0F, 0x8F, 0x80, 0x7F, 0x00, 0xF8, 0x7C, 0x07, 0xF8, 0x07,
  0xC3, 0xE0, 0x3F, 0xC0, 0x3E, 0x1F, 0x03, 0xFE, 0x03, 0xE0, 0xF8, 0x1E,
  0xF0, 0x1F, 0x07, 0xC0, 0xF7, 0x80, 0xF8, 0x3E, 0x0F, 0xBE, 0x0F, 0x81,
  0xF0, 0x79, 0xF0, 0x7C, 0x0F, 0x87, 0xCF, 0x83, 0xC0, 0x7C, 0x3C, 0x7C,
  0x3E, 0x03, 0xE3, 0xE3, 0xE1, 0xF0, 0x1F, 0x1F, 0x0F, 0x1F, 0x00, 0xF8,
  0xF0, 0x78, 0xF8, 0x07, 0xCF, 0x83, 0xC7, 0x80, 0x3E, 0x78, 0x1E, 0x7C,
  0x01, 0xF7, 0xC0, 0xF3, 0xE0, 0x0F, 0xBE, 0x07, 0x9E, 0x00, 0x7D, 0xE0,
  0x3D, 0xF0, 0x03, 0xFF, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0xFF, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x00, 0x3F, 0xC7, 0xE0, 0x00, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x7F,
  0x80, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1E, 0x3F, 0xFF, 0xC0, 0x00, 0xF1, 0xFF, 0xFF, 0x00, 0x0F, 0x9F,
  0xFF, 0xFC, 0x00, 0x7D, 0xFC, 0x0F, 0xF0, 0x07, 0xCF, 0x80, 0x3F, 0xE0,
  0x7E, 0xFC, 0x00, 0xFF, 0xFF, 0xF7, 0xC0, 0x03, 0xFF, 0xFF, 0x3E, 0x00,
  0x07, 0xFF, 0xF0, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x00, 0x3C, 0x00,
};

const GFXglyph RobotoMono_Italic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 14, 48, 40, 13, -48 },
  { 85, 19, 16, 40, 14, -51 },
  { 123, 39, 48, 40, 1, -48 },
  { 357, 33, 63, 40, 4, -56 },
  { 617, 33, 50, 40, 4, -49 },
  { 824, 35, 50, 40, 2, -49 },
  { 1043, 8, 16, 40, 18, -51 },
  { 1059, 22, 71, 40, 11, -55 },
  { 1255, 23, 71, 40, 5, -55 },
  { 1460, 31, 32, 40, 7, -48 },
  { 1584, 33, 35, 40, 4, -40 },
  { 1729, 13, 18, 40, 6, -7 },
  { 1759, 25, 5, 40, 7, -24 },
  { 1775, 10, 10, 40, 13, -9 },
  { 1788, 34, 52, 40, 4, -48 },
  { 2009, 33, 50, 40, 4, -49 },
  { 2216, 21, 48, 40, 9, -48 },
  { 2342, 35, 49, 40, 0, -49 },
  { 2557, 33, 50, 40, 2, -49 },
  { 2764, 35, 48, 40, 1, -48 },
  { 2974, 34, 49, 40, 5, -48 },
  { 3183, 30, 49, 40, 4, -48 },
  { 3367, 34, 48, 40, 6, -48 },
  { 3571, 33, 50, 40, 4, -49 },
  { 3778, 30, 49, 40, 6, -49 },
  { 3962, 14, 39, 40, 15, -38 },
  { 4031, 18, 49, 40, 11, -38 },
  { 4142, 31, 30, 40, 5, -37 },
  { 4259, 32, 19, 40, 4, -31 },
  { 4335, 32, 30, 40, 3, -36 },
  { 4455, 28, 49, 40, 9, -49 },
  { 4627, 37, 48, 40, 2, -48 },
  { 4849, 35, 48, 40, -1, -48 },
  { 5059, 36, 48, 40, 2, -48 },
  { 5275, 35, 50, 40, 3, -49 },
  { 5494, 36, 48, 40, 2, -48 },
  { 5710, 37, 48, 40, 2, -48 },
  { 5932, 37, 48, 40, 3, -48 },
  { 6154, 35, 50, 40, 3, -49 },
  { 6373, 39, 48, 40, 1, -48 },
  { 6607, 37, 48, 40, 2, -48 },
  { 6829, 37, 49, 40, 2, -48 },
  { 7056, 40, 48, 40, 2, -48 },
  { 7296, 30, 48, 40, 3, -48 },
  { 7476, 39, 48, 40, 1, -48 },
  { 7710, 39, 48, 40, 1, -48 },
  { 7944, 35, 50, 40, 3, -49 },
  { 8163, 37, 48, 40, 3, -48 },
  { 8385, 35, 57, 40, 3, -49 },
  { 8635, 36, 48, 40, 2, -48 },
  { 8851, 36, 50, 40, 3, -49 },
  { 9076, 36, 48, 40, 6, -48 },
  { 9292, 37, 49, 40, 3, -48 },
  { 9519, 35, 48, 40, 7, -48 },
  { 9729, 38, 48, 40, 5, -48 },
  { 9957, 43, 48, 40, -1, -48 },
  { 10215, 35, 48, 40, 7, -48 },
  { 10425, 37, 48, 40, 1, -48 },
  { 10647, 23, 65, 40, 9, -55 },
  { 10834, 16, 52, 40, 12, -48 },
  { 10938, 23, 65, 40, 8, -55 },
  { 11125, 24, 26, 40, 8, -48 },
  { 11203, 30, 5, 40, 1, 0 },
  { 11222, 11, 9, 40, 18, -49 },
  { 11235, 32, 38, 40, 3, -37 },
  { 11387, 33, 52, 40, 2, -51 },
  { 11602, 31, 38, 40, 4, -37 },
  { 11750, 35, 52, 40, 4, -51 },
  { 11978, 31, 38, 40, 4, -37 },
  { 12126, 35, 53, 40, 7, -53 },
  { 12358, 36, 51, 40, 1, -37 },
  { 12588, 33, 51, 40, 2, -51 },
  { 12799, 30, 49, 40, 3, -49 },
  { 12983, 31, 64, 40, 1, -49 },
  { 13231, 35, 51, 40, 2, -51 },
  { 13455, 30, 51, 40, 3, -51 },
  { 13647, 38, 37, 40, 0, -37 },
  { 13823, 33, 37, 40, 2, -37 },
  { 13976, 33, 38, 40, 3, -37 },
  { 14133, 35, 51, 40, 0, -37 },
  { 14357, 33, 51, 40, 4, -37 },
  { 14568, 30, 37, 40, 7, -37 },
  { 14707, 31, 38, 40, 4, -37 },
  { 14855, 29, 46, 40, 7, -45 },
  { 15022, 32, 37, 40, 5, -36 },
  { 15170, 33, 36, 40, 6, -36 },
  { 15319, 37, 36, 40, 4, -36 },
  { 15486, 39, 36, 40, 0, -36 },
  { 15662, 41, 51, 40, -1, -36 },
  { 15924, 34, 36, 40, 2, -36 },
  { 16077, 27, 65, 40, 10, -53 },
  { 16297, 15, 61, 40, 12, -48 },
  { 16412, 27, 65, 40, 6, -53 },
  { 16632, 37, 14, 40, 1, -27 },
};

const GFXfont RobotoMono_Italic68pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic68pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic68pt7bGlyphs,
  0x20, 0x7E, 90
};

#endif // _ROBOTOMONO_ITALIC68PT7B_H_
