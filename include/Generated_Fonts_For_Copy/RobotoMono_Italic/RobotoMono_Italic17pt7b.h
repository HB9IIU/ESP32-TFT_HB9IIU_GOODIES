#ifndef _ROBOTOMONO_ITALIC17PT7B_H_
#define _ROBOTOMONO_ITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x66, 0x64, 0x00, 0xCC, 0x4A, 0x53, 0xB0, 0x04, 0xC1,
  0x20, 0xC8, 0xFF, 0x3F, 0xC4, 0x41, 0x23, 0xFE, 0xFF, 0x89, 0x06, 0x41,
  0x30, 0x04, 0x04, 0x1E, 0x33, 0x61, 0x61, 0x20, 0x38, 0x0E, 0x02, 0xC3,
  0xC2, 0xC6, 0x7C, 0x10, 0x30, 0x70, 0x9B, 0x92, 0x96, 0x74, 0x08, 0x10,
  0x37, 0x29, 0x49, 0x09, 0x0E, 0x0E, 0x0D, 0x84, 0x42, 0x61, 0x60, 0xC0,
  0xF2, 0xC9, 0x47, 0xA1, 0x99, 0xC7, 0xB0, 0xF0, 0x08, 0xC4, 0x46, 0x23,
  0x18, 0x84, 0x21, 0x08, 0x42, 0x08, 0x41, 0x00, 0x10, 0x40, 0x82, 0x0C,
  0x30, 0x43, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x08, 0x42, 0x00, 0x08, 0x18,
  0x92, 0xFF, 0x10, 0x28, 0x4C, 0xCC, 0x0C, 0x08, 0x08, 0x18, 0xFF, 0x18,
  0x10, 0x10, 0x10, 0x69, 0x68, 0xFC, 0xFC, 0x01, 0x81, 0x80, 0x80, 0xC0,
  0x40, 0x40, 0x20, 0x20, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x00, 0x1E, 0x23,
  0x61, 0x41, 0x47, 0xCD, 0xF3, 0xE3, 0xC2, 0xC2, 0x46, 0x7C, 0x0B, 0xF2,
  0x31, 0x88, 0x42, 0x31, 0x8C, 0x40, 0x1F, 0x18, 0x98, 0x60, 0x30, 0x10,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0x1F, 0xE0, 0x1F, 0x18, 0x88, 0x60,
  0x30, 0x30, 0xF0, 0x18, 0x06, 0x03, 0x61, 0x99, 0x87, 0x80, 0x01, 0x81,
  0x81, 0xC1, 0xA1, 0xB0, 0x98, 0x8C, 0xC4, 0xFF, 0x81, 0x01, 0x80, 0xC0,
  0x1F, 0x98, 0x08, 0x04, 0x07, 0xC3, 0xB0, 0x0C, 0x06, 0x03, 0x61, 0x11,
  0x8F, 0x80, 0x0E, 0x30, 0x83, 0x05, 0xDC, 0xF0, 0xE1, 0xC3, 0x8D, 0x13,
  0xE0, 0xFF, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0xC0,
  0xC0, 0x1E, 0x33, 0x61, 0x61, 0x23, 0x3E, 0x66, 0x42, 0xC3, 0xC2, 0xC6,
  0x7C, 0x7C, 0x8F, 0x1C, 0x18, 0x70, 0xF3, 0xBA, 0x0C, 0x10, 0xE7, 0x00,
  0x6C, 0x00, 0x06, 0xC0, 0x33, 0x00, 0x00, 0x06, 0x44, 0xC8, 0x03, 0x0F,
  0x38, 0xC0, 0x70, 0x1C, 0x06, 0x7F, 0x7F, 0x00, 0x00, 0xFE, 0x40, 0x70,
  0x0E, 0x03, 0x0E, 0x70, 0xC0, 0x3C, 0xCF, 0x08, 0x30, 0x61, 0x86, 0x18,
  0x20, 0x00, 0x83, 0x00, 0x1E, 0x10, 0x93, 0x2B, 0x5B, 0x4D, 0x26, 0x95,
  0x4A, 0xBF, 0x40, 0x31, 0x0F, 0x00, 0x06, 0x03, 0x03, 0x81, 0x41, 0xB0,
  0x98, 0xCC, 0x42, 0x7F, 0x30, 0xB0, 0x58, 0x30, 0x3E, 0x63, 0x61, 0x61,
  0x43, 0x7E, 0xC6, 0xC3, 0xC3, 0x83, 0x86, 0xFC, 0x1E, 0x11, 0x98, 0x48,
  0x3C, 0x06, 0x02, 0x01, 0x00, 0x83, 0x61, 0x31, 0x8F, 0x80, 0x3E, 0x19,
  0xCC, 0x64, 0x12, 0x09, 0x05, 0x82, 0xC3, 0x61, 0xA1, 0x91, 0x9F, 0x80,
  0x3F, 0xB0, 0x18, 0x0C, 0x04, 0x03, 0xF1, 0x01, 0x80, 0xC0, 0x60, 0x20,
  0x1F, 0xC0, 0x3F, 0xB0, 0x18, 0x0C, 0x04, 0x03, 0xF1, 0xF9, 0x80, 0xC0,
  0x60, 0x20, 0x10, 0x00, 0x1E, 0x19, 0x98, 0x48, 0x1C, 0x06, 0x02, 0x3D,
  0x06, 0x83, 0x61, 0x91, 0x8F, 0x80, 0x30, 0xCC, 0x32, 0x0C, 0x82, 0x20,
  0x9F, 0xE6, 0x19, 0x06, 0x41, 0x90, 0x44, 0x13, 0x0C, 0x7F, 0x86, 0x02,
  0x01, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x10, 0x08, 0x04, 0x1F, 0xC0, 0x01,
  0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x82, 0x43, 0x33, 0x0F,
  0x00, 0x21, 0xD8, 0xC6, 0x61, 0xB0, 0x58, 0x1E, 0x0F, 0x83, 0x30, 0xCC,
  0x21, 0x08, 0x62, 0x0C, 0x20, 0x41, 0x83, 0x06, 0x08, 0x10, 0x20, 0xC1,
  0x82, 0x07, 0xF0, 0x30, 0xCC, 0x73, 0x9C, 0xAE, 0x2A, 0x9B, 0xA6, 0xC9,
  0xB6, 0x49, 0x90, 0x44, 0x13, 0x04, 0x30, 0xCC, 0x33, 0x8C, 0xA2, 0x28,
  0x9B, 0x66, 0x59, 0x96, 0x47, 0x10, 0xC4, 0x33, 0x0C, 0x1E, 0x33, 0x61,
  0x41, 0xC1, 0xC1, 0x81, 0x83, 0x83, 0xC2, 0xC6, 0x78, 0x3E, 0x30, 0x98,
  0x6C, 0x34, 0x1A, 0x19, 0xF9, 0x80, 0xC0, 0x60, 0x20, 0x10, 0x00, 0x1E,
  0x33, 0x61, 0x41, 0xC1, 0xC1, 0x81, 0x81, 0x83, 0xC2, 0xC4, 0x7C, 0x06,
  0x02, 0x3E, 0x31, 0x98, 0x4C, 0x24, 0x12, 0x39, 0xF1, 0x98, 0xC4, 0x63,
  0x21, 0x90, 0x40, 0x1E, 0x31, 0x98, 0x68, 0x06, 0x01, 0xC0, 0x38, 0x06,
  0x83, 0x41, 0xB1, 0x8F, 0x80, 0xFF, 0x8C, 0x04, 0x02, 0x01, 0x01, 0x80,
  0xC0, 0x60, 0x20, 0x10, 0x08, 0x0C, 0x00, 0x61, 0xB0, 0xD0, 0x68, 0x24,
  0x16, 0x0B, 0x0D, 0x86, 0x83, 0x61, 0x31, 0x8F, 0x00, 0x81, 0x83, 0xC2,
  0xC6, 0xC4, 0x4C, 0x48, 0x58, 0x50, 0x50, 0x70, 0x60, 0x4C, 0xD3, 0x24,
  0xC9, 0x76, 0x55, 0x35, 0x4F, 0x73, 0x9C, 0xE6, 0x39, 0x8C, 0x63, 0x10,
  0x30, 0xC4, 0x21, 0x98, 0x6C, 0x0E, 0x03, 0x00, 0xC0, 0x78, 0x32, 0x08,
  0xC6, 0x33, 0x06, 0xC3, 0xE1, 0x11, 0x88, 0x86, 0x83, 0xC0, 0xC0, 0x60,
  0x20, 0x10, 0x08, 0x0C, 0x00, 0x3F, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x30, 0x18, 0x04, 0x03, 0xFC, 0x1C, 0x43, 0x0C, 0x30,
  0x82, 0x08, 0x21, 0x86, 0x10, 0x41, 0x04, 0x3C, 0xE0, 0xCC, 0x44, 0x46,
  0x62, 0x22, 0x33, 0x10, 0x1C, 0xB0, 0x82, 0x08, 0x21, 0x86, 0x18, 0x41,
  0x04, 0x10, 0xC3, 0x38, 0xE0, 0x18, 0x63, 0x8A, 0x4F, 0x10, 0xFF, 0xD0,
  0x3E, 0x62, 0x43, 0x02, 0x7E, 0xC2, 0x86, 0xCE, 0x7E, 0x20, 0x20, 0x60,
  0x60, 0x5E, 0x62, 0x43, 0xC3, 0xC3, 0xC3, 0x82, 0xC6, 0xBC, 0x3E, 0x63,
  0x43, 0xC0, 0xC0, 0xC0, 0xC2, 0x46, 0x7C, 0x01, 0x80, 0xC0, 0x40, 0x23,
  0xD3, 0x19, 0x0D, 0x86, 0xC2, 0x41, 0x30, 0x98, 0xC7, 0xE0, 0x3E, 0x62,
  0x43, 0xC3, 0xFF, 0x80, 0xC0, 0x46, 0x7C, 0x0F, 0x18, 0x10, 0x30, 0xFE,
  0x30, 0x20, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x1E, 0x98, 0xC8, 0x6C,
  0x36, 0x12, 0x09, 0x84, 0xC6, 0x3F, 0x01, 0xB1, 0x8F, 0x81, 0x00, 0x20,
  0x20, 0x60, 0x60, 0x5E, 0x63, 0x43, 0xC3, 0xC2, 0xC2, 0x82, 0x82, 0x86,
  0x0C, 0x08, 0x03, 0xE0, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x47, 0xF0, 0x03,
  0x01, 0x00, 0x1F, 0x02, 0x02, 0x06, 0x06, 0x06, 0x04, 0x04, 0x04, 0x0C,
  0x0C, 0xF8, 0xE0, 0x20, 0x20, 0x60, 0x60, 0x63, 0x46, 0x4C, 0x70, 0xF0,
  0xD8, 0x8C, 0x84, 0x86, 0x3C, 0x78, 0x10, 0x60, 0xC1, 0x82, 0x04, 0x08,
  0x30, 0x60, 0x8F, 0xE0, 0x7F, 0xB6, 0x53, 0x29, 0x94, 0xCE, 0x4F, 0x27,
  0x93, 0x99, 0x00, 0x5E, 0x63, 0x43, 0xC3, 0xC2, 0xC2, 0x82, 0x86, 0x86,
  0x3C, 0x62, 0xC3, 0xC3, 0x83, 0x83, 0xC2, 0xC6, 0x7C, 0x2F, 0x19, 0x88,
  0x6C, 0x36, 0x1B, 0x09, 0x04, 0xC6, 0x5E, 0x60, 0x30, 0x18, 0x00, 0x3D,
  0x63, 0x43, 0xC3, 0xC2, 0x82, 0xC2, 0xC6, 0x7E, 0x06, 0x04, 0x04, 0x6E,
  0xE5, 0x82, 0x04, 0x18, 0x30, 0x60, 0x80, 0x3E, 0x63, 0x43, 0x60, 0x3C,
  0x06, 0xC2, 0xC6, 0x7C, 0x30, 0x63, 0xF9, 0x02, 0x04, 0x18, 0x30, 0x60,
  0xC0, 0xF0, 0x61, 0x43, 0x43, 0x43, 0xC2, 0xC2, 0xC2, 0xC6, 0x7E, 0xC1,
  0xA1, 0x90, 0x8C, 0xC2, 0x41, 0x60, 0xA0, 0x70, 0x10, 0x00, 0x88, 0xC4,
  0xE6, 0x53, 0x2A, 0xB5, 0x72, 0x99, 0x88, 0xC4, 0x00, 0x31, 0xCC, 0x41,
  0xB0, 0x38, 0x0C, 0x07, 0x03, 0x61, 0x88, 0xC3, 0x00, 0x60, 0xC8, 0x62,
  0x18, 0xCC, 0x32, 0x05, 0x81, 0x40, 0x70, 0x08, 0x04, 0x03, 0x03, 0x80,
  0xC0, 0x00, 0x3F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0x00, 0x0C, 0x61, 0x04, 0x30, 0xC2, 0x30, 0xC1, 0x86, 0x18, 0x61, 0x82,
  0x0C, 0x32, 0x22, 0x22, 0x64, 0x44, 0x44, 0xCC, 0x80, 0x18, 0x10, 0x20,
  0x60, 0x81, 0x03, 0x03, 0x0E, 0x30, 0x40, 0x81, 0x06, 0x08, 0x60, 0x30,
  0x1E, 0x3C, 0xF8, 0x0C,
};

const GFXglyph RobotoMono_Italic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 12, 10, 3, -12 },
  { 7, 5, 4, 10, 3, -13 },
  { 10, 10, 12, 10, 0, -12 },
  { 25, 8, 16, 10, 1, -14 },
  { 41, 8, 12, 10, 1, -12 },
  { 53, 9, 12, 10, 0, -12 },
  { 67, 1, 4, 10, 5, -13 },
  { 68, 5, 18, 10, 3, -14 },
  { 80, 6, 18, 10, 1, -14 },
  { 94, 8, 8, 10, 2, -12 },
  { 102, 8, 9, 10, 1, -10 },
  { 111, 3, 5, 10, 2, -2 },
  { 113, 6, 1, 10, 2, -6 },
  { 114, 3, 2, 10, 3, -2 },
  { 115, 9, 13, 10, 1, -12 },
  { 130, 8, 12, 10, 1, -12 },
  { 142, 5, 12, 10, 2, -12 },
  { 150, 9, 12, 10, 0, -12 },
  { 164, 9, 12, 10, 0, -12 },
  { 178, 9, 12, 10, 0, -12 },
  { 192, 9, 12, 10, 1, -12 },
  { 206, 7, 12, 10, 1, -12 },
  { 217, 8, 12, 10, 2, -12 },
  { 229, 8, 12, 10, 1, -12 },
  { 241, 7, 12, 10, 2, -12 },
  { 252, 3, 9, 10, 4, -9 },
  { 256, 4, 12, 10, 3, -9 },
  { 262, 8, 7, 10, 1, -9 },
  { 269, 8, 5, 10, 1, -8 },
  { 274, 8, 7, 10, 1, -9 },
  { 281, 7, 12, 10, 2, -12 },
  { 292, 9, 12, 10, 1, -12 },
  { 306, 9, 12, 10, 0, -12 },
  { 320, 8, 12, 10, 1, -12 },
  { 332, 9, 12, 10, 1, -12 },
  { 346, 9, 12, 10, 0, -12 },
  { 360, 9, 12, 10, 1, -12 },
  { 374, 9, 12, 10, 1, -12 },
  { 388, 9, 12, 10, 1, -12 },
  { 402, 10, 12, 10, 0, -12 },
  { 417, 9, 12, 10, 1, -12 },
  { 431, 9, 12, 10, 1, -12 },
  { 445, 10, 12, 10, 1, -12 },
  { 460, 7, 12, 10, 1, -12 },
  { 471, 10, 12, 10, 0, -12 },
  { 486, 10, 12, 10, 0, -12 },
  { 501, 8, 12, 10, 1, -12 },
  { 513, 9, 12, 10, 1, -12 },
  { 527, 8, 14, 10, 1, -12 },
  { 541, 9, 12, 10, 1, -12 },
  { 555, 9, 12, 10, 1, -12 },
  { 569, 9, 12, 10, 2, -12 },
  { 583, 9, 12, 10, 1, -12 },
  { 597, 8, 12, 10, 2, -12 },
  { 609, 10, 12, 10, 1, -12 },
  { 624, 10, 12, 10, 0, -12 },
  { 639, 9, 12, 10, 2, -12 },
  { 653, 10, 12, 10, 0, -12 },
  { 668, 6, 17, 10, 2, -14 },
  { 681, 4, 13, 10, 3, -12 },
  { 688, 6, 17, 10, 2, -14 },
  { 701, 6, 6, 10, 2, -12 },
  { 706, 8, 1, 10, 0, 0 },
  { 707, 2, 2, 10, 5, -12 },
  { 708, 8, 9, 10, 1, -9 },
  { 717, 8, 13, 10, 1, -13 },
  { 730, 8, 9, 10, 1, -9 },
  { 739, 9, 13, 10, 1, -13 },
  { 754, 8, 9, 10, 1, -9 },
  { 763, 8, 13, 10, 2, -13 },
  { 776, 9, 13, 10, 0, -9 },
  { 791, 8, 13, 10, 1, -13 },
  { 804, 7, 12, 10, 1, -12 },
  { 815, 8, 16, 10, 0, -12 },
  { 831, 8, 13, 10, 1, -13 },
  { 844, 7, 13, 10, 1, -13 },
  { 856, 9, 9, 10, 0, -9 },
  { 867, 8, 9, 10, 1, -9 },
  { 876, 8, 9, 10, 1, -9 },
  { 885, 9, 12, 10, 0, -9 },
  { 899, 8, 12, 10, 1, -9 },
  { 911, 7, 9, 10, 2, -9 },
  { 919, 8, 9, 10, 1, -9 },
  { 928, 7, 11, 10, 2, -11 },
  { 938, 8, 9, 10, 1, -9 },
  { 947, 9, 9, 10, 1, -9 },
  { 958, 9, 9, 10, 1, -9 },
  { 969, 10, 9, 10, 0, -9 },
  { 981, 10, 13, 10, 0, -9 },
  { 998, 9, 9, 10, 0, -9 },
  { 1009, 6, 16, 10, 3, -13 },
  { 1021, 4, 15, 10, 3, -12 },
  { 1029, 7, 16, 10, 1, -13 },
  { 1043, 10, 4, 10, 0, -7 },
};

const GFXfont RobotoMono_Italic17pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic17pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _ROBOTOMONO_ITALIC17PT7B_H_
