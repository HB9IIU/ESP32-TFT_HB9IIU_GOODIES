#ifndef _ROBOTOMONO_ITALIC18PT7B_H_
#define _ROBOTOMONO_ITALIC18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic18pt7bBitmaps[] PROGMEM = {
  0x00, 0x13, 0x33, 0x22, 0x26, 0x60, 0x04, 0xC0, 0xDC, 0xA5, 0x29, 0x00,
  0x06, 0x40, 0x88, 0x12, 0x06, 0x43, 0xFE, 0x12, 0x06, 0x40, 0x98, 0xFF,
  0x84, 0x40, 0x98, 0x32, 0x04, 0xC0, 0x06, 0x02, 0x03, 0x87, 0x62, 0x19,
  0x0C, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xD8, 0x6C, 0x33, 0x31, 0xF0, 0x20,
  0x10, 0x00, 0x70, 0x2C, 0x22, 0x51, 0x4D, 0x63, 0x20, 0x20, 0x30, 0x17,
  0x14, 0xD2, 0x61, 0x20, 0x70, 0x0F, 0x06, 0x41, 0x10, 0x44, 0x13, 0x07,
  0x01, 0x80, 0xF3, 0x66, 0xD1, 0xA4, 0x39, 0x9C, 0x3D, 0x80, 0x7E, 0x80,
  0x0C, 0x63, 0x08, 0x61, 0x04, 0x30, 0xC3, 0x08, 0x20, 0x83, 0x0C, 0x10,
  0x60, 0x80, 0x10, 0x20, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0xC3, 0x08,
  0x61, 0x0C, 0x63, 0x00, 0x08, 0x08, 0x08, 0xEB, 0x7E, 0x38, 0x2C, 0xC4,
  0x44, 0x0C, 0x06, 0x03, 0x01, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18, 0x08,
  0x00, 0x6D, 0x68, 0xFE, 0xEC, 0x01, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04, 0x06, 0x00, 0x1E, 0x19, 0x98,
  0x6C, 0x34, 0x3A, 0x3F, 0x35, 0xE2, 0xE1, 0x61, 0xB0, 0xC8, 0xC7, 0xC0,
  0x04, 0xF6, 0xA2, 0x08, 0x61, 0x86, 0x10, 0x41, 0x0C, 0x30, 0x0F, 0x1D,
  0xC8, 0x6C, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x08, 0x0F,
  0xF0, 0x0F, 0x0C, 0xCC, 0x24, 0x10, 0x18, 0x18, 0x78, 0x06, 0x01, 0x00,
  0xB0, 0xCC, 0xE3, 0xE0, 0x01, 0x81, 0xC0, 0xE0, 0xB0, 0xD0, 0xC8, 0xC4,
  0x46, 0x43, 0x7F, 0xC0, 0x80, 0x40, 0x60, 0x1F, 0x8F, 0xCC, 0x06, 0x02,
  0x01, 0xF1, 0x8C, 0x06, 0x01, 0x01, 0xB0, 0xCC, 0xC3, 0xC0, 0x06, 0x1E,
  0x30, 0x20, 0x60, 0x7E, 0xE3, 0xC3, 0xC3, 0xC3, 0xC2, 0x66, 0x3C, 0xFF,
  0xFF, 0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x00, 0x0E, 0x1D, 0x88, 0x64, 0x32, 0x19, 0x98, 0x78, 0xC6, 0xC3,
  0x61, 0xB0, 0xCC, 0xC7, 0xC0, 0x3C, 0x66, 0xC2, 0xC2, 0x83, 0x82, 0xC6,
  0xFE, 0x36, 0x04, 0x0C, 0x38, 0xE0, 0x77, 0x00, 0x00, 0x00, 0xCC, 0x39,
  0xC0, 0x00, 0x00, 0x00, 0x63, 0x19, 0x88, 0x00, 0x01, 0x03, 0x1E, 0x70,
  0xC0, 0x38, 0x0E, 0x02, 0x7F, 0x80, 0x00, 0x1F, 0xEF, 0xF0, 0x40, 0x70,
  0x3C, 0x07, 0x03, 0x1E, 0xF0, 0xC0, 0x3C, 0x76, 0x43, 0x83, 0x02, 0x06,
  0x0C, 0x18, 0x30, 0x00, 0x00, 0x20, 0x60, 0x0E, 0x18, 0x88, 0x29, 0xDD,
  0x2C, 0x96, 0x93, 0x49, 0xA4, 0xDF, 0xA0, 0x18, 0x87, 0xC0, 0x02, 0x03,
  0x01, 0xC1, 0xE0, 0xB0, 0xC8, 0x44, 0x62, 0x3F, 0x3F, 0xD8, 0x78, 0x3C,
  0x18, 0x3E, 0x1F, 0x98, 0x6C, 0x36, 0x1A, 0x19, 0xF8, 0x86, 0xC1, 0x60,
  0xB0, 0xD0, 0xCF, 0xC0, 0x1E, 0x19, 0x98, 0x6C, 0x14, 0x06, 0x03, 0x01,
  0x80, 0x80, 0x60, 0xB0, 0xC8, 0xC7, 0xC0, 0x1E, 0x0F, 0xE3, 0x08, 0xC3,
  0x20, 0xC8, 0x32, 0x0D, 0x83, 0x60, 0x98, 0x64, 0x11, 0x1C, 0xFC, 0x00,
  0x3F, 0x9F, 0xD8, 0x0C, 0x06, 0x03, 0x01, 0xFC, 0x80, 0xC0, 0x60, 0x30,
  0x10, 0x2F, 0xE0, 0x3F, 0xCF, 0xE2, 0x01, 0x80, 0x60, 0x18, 0x07, 0xF1,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x00, 0x1E, 0x1D, 0x98, 0x68,
  0x1C, 0x06, 0x03, 0x01, 0x9F, 0x81, 0x60, 0xB0, 0x4C, 0x63, 0xC0, 0x30,
  0x66, 0x08, 0xC1, 0x10, 0x22, 0x0C, 0x41, 0x9F, 0xE3, 0x04, 0x60, 0x88,
  0x31, 0x06, 0x20, 0xCC, 0x10, 0x3F, 0x9F, 0xC3, 0x01, 0x80, 0xC0, 0x40,
  0x20, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x0F, 0xE0, 0x00, 0x80, 0xC0, 0x60,
  0x30, 0x10, 0x08, 0x04, 0x06, 0x03, 0x41, 0xA0, 0x99, 0xC7, 0xC0, 0x20,
  0xC8, 0x66, 0x31, 0x98, 0x6C, 0x16, 0x07, 0x81, 0xB0, 0xCC, 0x31, 0x8C,
  0x62, 0x08, 0x83, 0x00, 0x30, 0x20, 0x20, 0x60, 0x60, 0x60, 0x40, 0x40,
  0x40, 0xC0, 0xC0, 0xC0, 0xFF, 0x18, 0x67, 0x18, 0xE7, 0x14, 0xA2, 0xBC,
  0x55, 0x9B, 0xB3, 0x64, 0x6C, 0x88, 0x11, 0x06, 0x20, 0xCC, 0x18, 0x30,
  0x67, 0x08, 0xE1, 0x1C, 0x62, 0xCC, 0x59, 0x99, 0x23, 0x34, 0x67, 0x8C,
  0x71, 0x0E, 0x21, 0xCC, 0x10, 0x1E, 0x1D, 0x98, 0x6C, 0x34, 0x1E, 0x0F,
  0x07, 0x83, 0x81, 0x61, 0xB0, 0xCC, 0xC7, 0xC0, 0x3E, 0x1F, 0xC8, 0x2C,
  0x16, 0x0B, 0x0D, 0x1C, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x08, 0x00, 0x1E,
  0x1D, 0x98, 0x68, 0x3C, 0x1E, 0x0F, 0x07, 0x03, 0x81, 0x40, 0xB0, 0xCC,
  0xC7, 0xC0, 0x30, 0x0C, 0x3E, 0x1F, 0x98, 0x6C, 0x36, 0x1B, 0x0D, 0xFC,
  0xF8, 0xC4, 0x63, 0x31, 0x90, 0x48, 0x30, 0x1E, 0x1D, 0x98, 0x6C, 0x16,
  0x01, 0x80, 0x70, 0x0E, 0x03, 0x40, 0xB0, 0xDC, 0xE7, 0xC0, 0xFF, 0xFF,
  0xC6, 0x03, 0x01, 0x80, 0x80, 0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02,
  0x00, 0x60, 0xD8, 0x26, 0x09, 0x06, 0x41, 0x90, 0x6C, 0x1B, 0x04, 0xC1,
  0x30, 0xCC, 0x31, 0x98, 0x7C, 0x00, 0x81, 0xE0, 0xB0, 0xD8, 0x4C, 0x62,
  0x31, 0x30, 0x98, 0x68, 0x3C, 0x1C, 0x06, 0x02, 0x00, 0x44, 0x53, 0x34,
  0xCD, 0x32, 0x5C, 0x95, 0x65, 0x59, 0xD4, 0xE5, 0x39, 0xCE, 0x63, 0x18,
  0xC6, 0x00, 0x30, 0x62, 0x18, 0x62, 0x0C, 0xC0, 0xB0, 0x1C, 0x01, 0x80,
  0x70, 0x1A, 0x06, 0x60, 0xCC, 0x30, 0x8C, 0x18, 0xC1, 0xE1, 0x90, 0xC8,
  0xC6, 0x43, 0x60, 0xE0, 0x60, 0x30, 0x18, 0x08, 0x04, 0x06, 0x00, 0x3F,
  0xCF, 0xF0, 0x18, 0x04, 0x03, 0x01, 0x80, 0xC0, 0x20, 0x18, 0x0C, 0x06,
  0x03, 0x02, 0xFF, 0x00, 0x1C, 0x71, 0x04, 0x30, 0xC3, 0x08, 0x20, 0x82,
  0x18, 0x61, 0x84, 0x10, 0x73, 0xC0, 0xC4, 0x44, 0x66, 0x22, 0x23, 0x31,
  0x11, 0x1C, 0x70, 0xC3, 0x0C, 0x30, 0x82, 0x08, 0x61, 0x86, 0x10, 0x41,
  0x0C, 0xF3, 0xC0, 0x08, 0x30, 0x71, 0xE2, 0x48, 0xB1, 0x80, 0xFF, 0xCC,
  0x1C, 0x3F, 0x63, 0x03, 0x3F, 0x63, 0xC3, 0x82, 0xCE, 0x7A, 0x30, 0x20,
  0x20, 0x60, 0x6C, 0x7F, 0x63, 0x41, 0x41, 0xC1, 0xC3, 0xC3, 0xE6, 0xBC,
  0x0C, 0x3F, 0x61, 0x41, 0xC0, 0xC0, 0xC0, 0xC3, 0x66, 0x3C, 0x00, 0x80,
  0x40, 0x60, 0x31, 0xD9, 0xFD, 0x8C, 0x82, 0xC3, 0x61, 0xB0, 0xD8, 0x46,
  0x63, 0xD0, 0x0C, 0x3F, 0x63, 0x41, 0xFF, 0xFF, 0xC0, 0xC0, 0x67, 0x3C,
  0x07, 0x87, 0xC6, 0x02, 0x0F, 0xF7, 0xF8, 0xC0, 0x60, 0x20, 0x10, 0x08,
  0x0C, 0x06, 0x03, 0x00, 0x0E, 0xC7, 0xF3, 0x18, 0x82, 0x61, 0x98, 0x66,
  0x19, 0x86, 0x33, 0x0F, 0x40, 0x31, 0x0C, 0xFE, 0x0E, 0x00, 0x30, 0x20,
  0x20, 0x60, 0x6E, 0x7F, 0x63, 0x41, 0x41, 0xC3, 0xC3, 0xC3, 0x82, 0x82,
  0x06, 0x06, 0x00, 0x7C, 0x7C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18,
  0xFF, 0x01, 0x01, 0x00, 0x1F, 0x1F, 0x03, 0x02, 0x02, 0x02, 0x06, 0x06,
  0x06, 0x04, 0x04, 0x0C, 0x78, 0xF0, 0x30, 0x10, 0x08, 0x0C, 0x06, 0x1B,
  0x19, 0x18, 0xB8, 0x70, 0x7C, 0x33, 0x19, 0x88, 0x64, 0x38, 0x3E, 0x3E,
  0x06, 0x04, 0x04, 0x0C, 0x0C, 0x0C, 0x08, 0x08, 0x08, 0x18, 0x18, 0xFF,
  0x2D, 0x9F, 0xF6, 0x4D, 0x93, 0x44, 0xD3, 0x3C, 0xCB, 0x32, 0xC8, 0xA2,
  0x60, 0x6E, 0x5F, 0x63, 0x41, 0x41, 0xC3, 0xC3, 0xC3, 0x82, 0x82, 0x1C,
  0x3E, 0x63, 0xC1, 0xC1, 0xC1, 0xC3, 0xC3, 0x46, 0x7C, 0x36, 0x17, 0xCC,
  0x64, 0x12, 0x0B, 0x05, 0x86, 0xC3, 0x63, 0x2F, 0x30, 0x18, 0x0C, 0x06,
  0x00, 0x1D, 0x9F, 0xD8, 0xC8, 0x2C, 0x36, 0x1B, 0x0D, 0x84, 0x46, 0x3D,
  0x01, 0x80, 0xC0, 0x60, 0x20, 0x27, 0x7F, 0x70, 0x60, 0x40, 0x40, 0xC0,
  0xC0, 0xC0, 0xC0, 0x0C, 0x3F, 0x61, 0x60, 0x70, 0x1E, 0x03, 0xC3, 0xC6,
  0x7C, 0x10, 0x23, 0xFF, 0xF3, 0x04, 0x08, 0x10, 0x60, 0xC1, 0x81, 0xE0,
  0x61, 0xB0, 0xD8, 0x48, 0x24, 0x36, 0x1B, 0x0D, 0x86, 0x46, 0x3D, 0x00,
  0x81, 0x83, 0x82, 0xC6, 0x44, 0x4C, 0x48, 0x70, 0x70, 0x20, 0xCC, 0xF3,
  0x3C, 0xCB, 0x56, 0xD5, 0x3D, 0x4E, 0x73, 0x98, 0xC6, 0x31, 0x00, 0x20,
  0xCC, 0x21, 0x98, 0x6C, 0x0E, 0x03, 0x01, 0xE0, 0xC8, 0x63, 0x30, 0x60,
  0x60, 0x64, 0x18, 0xC2, 0x18, 0xC3, 0x10, 0x26, 0x05, 0x80, 0xE0, 0x1C,
  0x01, 0x00, 0x60, 0x18, 0x0E, 0x01, 0x80, 0x00, 0x7F, 0xBF, 0x80, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7F, 0x80, 0x06, 0x10, 0x60, 0xC1,
  0x02, 0x0C, 0x10, 0xC0, 0xC0, 0x81, 0x02, 0x0C, 0x18, 0x10, 0x30, 0x11,
  0x33, 0x22, 0x22, 0x66, 0x44, 0x44, 0x4C, 0xC0, 0x30, 0x20, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x0E, 0x30, 0xC1, 0x83, 0x04, 0x08, 0x30, 0xC0, 0x78,
  0x53, 0x1C, 0x78,
};

const GFXglyph RobotoMono_Italic18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 13, 11, 3, -13 },
  { 8, 5, 5, 11, 4, -14 },
  { 12, 11, 13, 11, 0, -13 },
  { 30, 9, 17, 11, 1, -15 },
  { 50, 9, 13, 11, 1, -13 },
  { 65, 10, 13, 11, 0, -13 },
  { 82, 2, 5, 11, 5, -14 },
  { 84, 6, 18, 11, 3, -14 },
  { 98, 6, 18, 11, 1, -14 },
  { 112, 8, 9, 11, 2, -13 },
  { 121, 9, 10, 11, 1, -11 },
  { 133, 3, 5, 11, 2, -2 },
  { 135, 7, 1, 11, 2, -6 },
  { 136, 3, 2, 11, 3, -2 },
  { 137, 9, 14, 11, 1, -13 },
  { 153, 9, 13, 11, 1, -13 },
  { 168, 6, 13, 11, 2, -13 },
  { 178, 9, 13, 11, 0, -13 },
  { 193, 9, 13, 11, 0, -13 },
  { 208, 9, 13, 11, 0, -13 },
  { 223, 9, 13, 11, 1, -13 },
  { 238, 8, 13, 11, 1, -13 },
  { 251, 9, 13, 11, 2, -13 },
  { 266, 9, 13, 11, 1, -13 },
  { 281, 8, 13, 11, 2, -13 },
  { 294, 4, 10, 11, 4, -10 },
  { 299, 5, 13, 11, 3, -10 },
  { 308, 8, 8, 11, 1, -10 },
  { 316, 9, 5, 11, 1, -8 },
  { 322, 8, 8, 11, 1, -10 },
  { 330, 8, 13, 11, 2, -13 },
  { 343, 9, 13, 11, 1, -13 },
  { 358, 9, 13, 11, 0, -13 },
  { 373, 9, 13, 11, 1, -13 },
  { 388, 9, 13, 11, 1, -13 },
  { 403, 10, 13, 11, 0, -13 },
  { 420, 9, 13, 11, 1, -13 },
  { 435, 10, 13, 11, 1, -13 },
  { 452, 9, 13, 11, 1, -13 },
  { 467, 11, 13, 11, 0, -13 },
  { 485, 9, 13, 11, 1, -13 },
  { 500, 9, 13, 11, 1, -13 },
  { 515, 10, 13, 11, 1, -13 },
  { 532, 8, 13, 11, 1, -13 },
  { 545, 11, 13, 11, 0, -13 },
  { 563, 11, 13, 11, 0, -13 },
  { 581, 9, 13, 11, 1, -13 },
  { 596, 9, 13, 11, 1, -13 },
  { 611, 9, 15, 11, 1, -13 },
  { 628, 9, 13, 11, 1, -13 },
  { 643, 9, 13, 11, 1, -13 },
  { 658, 9, 13, 11, 2, -13 },
  { 673, 10, 13, 11, 1, -13 },
  { 690, 9, 13, 11, 2, -13 },
  { 705, 10, 13, 11, 1, -13 },
  { 722, 11, 13, 11, 0, -13 },
  { 740, 9, 13, 11, 2, -13 },
  { 755, 10, 13, 11, 0, -13 },
  { 772, 6, 18, 11, 2, -15 },
  { 786, 4, 14, 11, 3, -13 },
  { 793, 6, 18, 11, 2, -15 },
  { 807, 7, 7, 11, 2, -13 },
  { 814, 8, 1, 11, 0, 0 },
  { 815, 3, 2, 11, 5, -13 },
  { 816, 8, 10, 11, 1, -10 },
  { 826, 8, 14, 11, 1, -14 },
  { 840, 8, 10, 11, 1, -10 },
  { 850, 9, 14, 11, 1, -14 },
  { 866, 8, 10, 11, 1, -10 },
  { 876, 9, 14, 11, 2, -14 },
  { 892, 10, 14, 11, 0, -10 },
  { 910, 8, 14, 11, 1, -14 },
  { 924, 8, 13, 11, 1, -13 },
  { 937, 8, 17, 11, 0, -13 },
  { 954, 9, 14, 11, 1, -14 },
  { 970, 8, 14, 11, 1, -14 },
  { 984, 10, 10, 11, 0, -10 },
  { 997, 8, 10, 11, 1, -10 },
  { 1007, 8, 10, 11, 1, -10 },
  { 1017, 9, 14, 11, 0, -10 },
  { 1033, 9, 14, 11, 1, -10 },
  { 1049, 8, 10, 11, 2, -10 },
  { 1059, 8, 10, 11, 1, -10 },
  { 1069, 7, 12, 11, 2, -12 },
  { 1080, 9, 10, 11, 1, -10 },
  { 1092, 8, 10, 11, 2, -10 },
  { 1102, 10, 10, 11, 1, -10 },
  { 1115, 10, 10, 11, 0, -10 },
  { 1128, 11, 14, 11, 0, -10 },
  { 1148, 9, 10, 11, 1, -10 },
  { 1160, 7, 17, 11, 3, -14 },
  { 1175, 4, 17, 11, 3, -13 },
  { 1184, 7, 17, 11, 2, -14 },
  { 1199, 10, 3, 11, 0, -7 },
};

const GFXfont RobotoMono_Italic18pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic18pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _ROBOTOMONO_ITALIC18PT7B_H_
