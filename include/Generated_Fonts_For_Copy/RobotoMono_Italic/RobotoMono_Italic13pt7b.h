#ifndef _ROBOTOMONO_ITALIC13PT7B_H_
#define _ROBOTOMONO_ITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x24, 0xB4, 0x80, 0xC0, 0xB6, 0x80, 0x0A, 0x12, 0x7F, 0x14, 0x24,
  0xFE, 0x28, 0x48, 0x50, 0x08, 0x43, 0xD1, 0x45, 0x83, 0x82, 0x8E, 0x27,
  0x08, 0xE2, 0xBA, 0x94, 0x20, 0xF5, 0x65, 0x18, 0x3C, 0x48, 0x91, 0xC3,
  0x0B, 0x73, 0xA2, 0x7E, 0x5C, 0x12, 0x64, 0x48, 0x88, 0x88, 0x84, 0x20,
  0x21, 0x11, 0x11, 0x11, 0x12, 0x24, 0x80, 0x12, 0x5F, 0xCC, 0x69, 0x20,
  0x10, 0x41, 0x3F, 0x20, 0x82, 0x00, 0x6B, 0x00, 0xF8, 0xC0, 0x04, 0x20,
  0x84, 0x10, 0x82, 0x10, 0xC2, 0x00, 0x79, 0x1C, 0x67, 0xB7, 0x18, 0xA2,
  0x70, 0x3E, 0x22, 0x22, 0x64, 0x40, 0x3C, 0x8C, 0x18, 0x20, 0x82, 0x08,
  0x20, 0xFC, 0x3C, 0xCC, 0x18, 0x23, 0x80, 0x81, 0x66, 0x78, 0x06, 0x18,
  0x51, 0xA2, 0x49, 0xBF, 0x84, 0x08, 0x3D, 0x04, 0x1E, 0x48, 0x30, 0xE2,
  0x70, 0x3B, 0x11, 0x7C, 0xC6, 0x31, 0x70, 0xFE, 0x08, 0x20, 0x41, 0x06,
  0x08, 0x20, 0xC0, 0x3D, 0x14, 0x53, 0x7A, 0x28, 0xE2, 0x70, 0x79, 0x18,
  0x61, 0xCD, 0xE0, 0x84, 0x60, 0x4C, 0x00, 0x26, 0x23, 0x00, 0x00, 0x04,
  0x48, 0x04, 0xEC, 0x38, 0x38, 0x20, 0xFC, 0x00, 0x3E, 0x43, 0xC0, 0xC6,
  0xE2, 0x00, 0xFC, 0x42, 0x22, 0x20, 0x00, 0xC0, 0x1E, 0x22, 0x5D, 0x65,
  0xAA, 0xAA, 0xBC, 0x40, 0x78, 0x08, 0x38, 0x51, 0xA2, 0x44, 0x9F, 0x22,
  0x86, 0x3E, 0x44, 0x8B, 0x37, 0xC8, 0xD1, 0xA2, 0xF8, 0x7D, 0x18, 0x60,
  0x82, 0x08, 0xE2, 0x70, 0x3C, 0x45, 0x8A, 0x14, 0x28, 0x51, 0xA6, 0xF8,
  0x3F, 0x20, 0x20, 0x60, 0x7C, 0x40, 0x40, 0x40, 0xFC, 0x7E, 0x81, 0x06,
  0x0F, 0x90, 0x20, 0x40, 0x80, 0x7D, 0x18, 0x20, 0x9E, 0x18, 0x63, 0x78,
  0x23, 0x22, 0x42, 0x42, 0x7E, 0x42, 0x44, 0xC4, 0x84, 0x3E, 0x10, 0x20,
  0xC1, 0x02, 0x04, 0x08, 0xFC, 0x02, 0x04, 0x08, 0x10, 0x60, 0xB1, 0x26,
  0x78, 0x23, 0x24, 0x28, 0x78, 0x78, 0x68, 0x48, 0x44, 0xC6, 0x42, 0x10,
  0x88, 0x42, 0x10, 0xF8, 0x23, 0x26, 0x56, 0x5A, 0x5A, 0x52, 0x46, 0x44,
  0x84, 0x23, 0x32, 0x72, 0x52, 0x5A, 0x4E, 0x4C, 0xCC, 0x84, 0x79, 0x18,
  0x61, 0x86, 0x18, 0xE2, 0x70, 0x7C, 0x89, 0x1E, 0x2F, 0x90, 0x20, 0x40,
  0x80, 0x79, 0x18, 0x61, 0x86, 0x18, 0xE2, 0x70, 0x60, 0x80, 0x3E, 0x44,
  0x8B, 0x17, 0xC9, 0x13, 0x22, 0xC4, 0x7D, 0x1C, 0x18, 0x38, 0x38, 0x62,
  0x78, 0xFE, 0x20, 0x40, 0x82, 0x04, 0x08, 0x10, 0x20, 0x46, 0x8A, 0x14,
  0x28, 0x50, 0xA2, 0x44, 0x70, 0xC6, 0x89, 0x32, 0x44, 0x8A, 0x14, 0x30,
  0x20, 0x93, 0x26, 0xD5, 0xAB, 0x5A, 0xB6, 0x6C, 0x98, 0x63, 0x26, 0x14,
  0x18, 0x18, 0x38, 0x2C, 0x44, 0xC6, 0xC6, 0x89, 0x23, 0xC3, 0x04, 0x08,
  0x10, 0x20, 0x7E, 0x0C, 0x30, 0x41, 0x06, 0x18, 0x20, 0xFC, 0x32, 0x44,
  0x44, 0x44, 0xC8, 0x88, 0xC0, 0xC9, 0x24, 0x49, 0x24, 0x35, 0x13, 0x22,
  0x22, 0x22, 0x44, 0xC0, 0x11, 0x8A, 0x9C, 0x80, 0xFC, 0xE0, 0x7B, 0x20,
  0xDE, 0x8A, 0x2F, 0x80, 0x20, 0x40, 0x81, 0xE6, 0x48, 0x50, 0xA2, 0x45,
  0xF0, 0x39, 0x38, 0x60, 0x82, 0x27, 0x00, 0x06, 0x08, 0x13, 0xAC, 0xD1,
  0xA2, 0x44, 0x88, 0xF0, 0x39, 0x38, 0x7F, 0x82, 0x27, 0x80, 0x0E, 0x20,
  0xC7, 0xE2, 0x04, 0x08, 0x10, 0x60, 0x80, 0x3A, 0xCD, 0x1A, 0x24, 0x48,
  0x9F, 0x02, 0xC8, 0x60, 0x20, 0x40, 0x81, 0xE6, 0x68, 0x51, 0xA2, 0x45,
  0x88, 0x18, 0x1C, 0x21, 0x18, 0x84, 0xF8, 0x04, 0x03, 0xC3, 0x08, 0x20,
  0x82, 0x08, 0x41, 0x38, 0x20, 0x40, 0x81, 0x36, 0xCA, 0x1C, 0x2C, 0x49,
  0x88, 0x78, 0x84, 0x21, 0x08, 0xC4, 0x27, 0xC0, 0x76, 0xB5, 0x4A, 0x99,
  0x32, 0x65, 0x00, 0x3C, 0xCD, 0x1A, 0x24, 0x48, 0xB1, 0x00, 0x7B, 0x28,
  0x61, 0x8E, 0x27, 0x00, 0x3C, 0xC9, 0x1A, 0x34, 0x48, 0xBE, 0x40, 0x81,
  0x00, 0x77, 0x38, 0xE2, 0x8A, 0x2F, 0x82, 0x18, 0x40, 0x7D, 0x84, 0x10,
  0x41, 0x0C, 0x00, 0x79, 0x3C, 0x1C, 0x0A, 0x27, 0x80, 0x30, 0x8F, 0xC8,
  0x20, 0x86, 0x18, 0x38, 0x47, 0x18, 0xE2, 0x8A, 0x2F, 0x80, 0x87, 0x14,
  0x96, 0x51, 0x82, 0x00, 0x93, 0x6A, 0xD6, 0xAD, 0x9B, 0x24, 0x00, 0x62,
  0x48, 0x60, 0x83, 0x8D, 0xB1, 0x00, 0x43, 0x62, 0x24, 0x2C, 0x28, 0x30,
  0x10, 0x20, 0x60, 0xC0, 0x7E, 0x08, 0x20, 0x83, 0x0C, 0x3F, 0x00, 0x18,
  0x88, 0x42, 0x23, 0x08, 0x62, 0x10, 0x40, 0x24, 0x94, 0x92, 0x4A, 0x40,
  0x20, 0x84, 0x21, 0x0C, 0x64, 0x21, 0x09, 0x80, 0x73, 0x3C,
};

const GFXglyph RobotoMono_Italic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 9, 8, 2, -9 },
  { 5, 3, 3, 8, 3, -10 },
  { 7, 8, 9, 8, 0, -9 },
  { 16, 6, 12, 8, 1, -11 },
  { 25, 6, 9, 8, 1, -9 },
  { 32, 7, 9, 8, 0, -9 },
  { 40, 2, 3, 8, 3, -10 },
  { 41, 4, 13, 8, 2, -10 },
  { 48, 4, 13, 8, 1, -10 },
  { 55, 6, 6, 8, 1, -9 },
  { 60, 6, 7, 8, 1, -8 },
  { 66, 3, 3, 8, 1, -1 },
  { 68, 5, 1, 8, 1, -5 },
  { 69, 1, 2, 8, 3, -2 },
  { 70, 6, 10, 8, 1, -9 },
  { 78, 6, 9, 8, 1, -9 },
  { 85, 4, 9, 8, 2, -9 },
  { 90, 7, 9, 8, 0, -9 },
  { 98, 7, 9, 8, 0, -9 },
  { 106, 7, 9, 8, 0, -9 },
  { 114, 6, 9, 8, 1, -9 },
  { 121, 5, 9, 8, 1, -9 },
  { 127, 7, 9, 8, 1, -9 },
  { 135, 6, 9, 8, 1, -9 },
  { 142, 6, 9, 8, 1, -9 },
  { 149, 3, 8, 8, 3, -8 },
  { 152, 4, 10, 8, 2, -8 },
  { 157, 6, 6, 8, 1, -7 },
  { 162, 6, 4, 8, 1, -6 },
  { 165, 6, 6, 8, 1, -7 },
  { 170, 5, 9, 8, 2, -9 },
  { 176, 8, 9, 8, 0, -9 },
  { 185, 7, 9, 8, 0, -9 },
  { 193, 7, 9, 8, 0, -9 },
  { 201, 6, 9, 8, 1, -9 },
  { 208, 7, 9, 8, 0, -9 },
  { 216, 8, 9, 8, 0, -9 },
  { 225, 7, 9, 8, 1, -9 },
  { 233, 6, 9, 8, 1, -9 },
  { 240, 8, 9, 8, 0, -9 },
  { 249, 7, 9, 8, 0, -9 },
  { 257, 7, 9, 8, 0, -9 },
  { 265, 8, 9, 8, 0, -9 },
  { 274, 5, 9, 8, 1, -9 },
  { 280, 8, 9, 8, 0, -9 },
  { 289, 8, 9, 8, 0, -9 },
  { 298, 6, 9, 8, 1, -9 },
  { 305, 7, 9, 8, 1, -9 },
  { 313, 6, 11, 8, 1, -9 },
  { 322, 7, 9, 8, 0, -9 },
  { 330, 6, 9, 8, 1, -9 },
  { 337, 7, 9, 8, 1, -9 },
  { 345, 7, 9, 8, 1, -9 },
  { 353, 7, 9, 8, 1, -9 },
  { 361, 7, 9, 8, 1, -9 },
  { 369, 8, 9, 8, 0, -9 },
  { 378, 7, 9, 8, 1, -9 },
  { 386, 7, 9, 8, 0, -9 },
  { 394, 4, 13, 8, 2, -11 },
  { 401, 3, 10, 8, 2, -9 },
  { 405, 4, 13, 8, 2, -11 },
  { 412, 5, 5, 8, 1, -9 },
  { 416, 6, 1, 8, 0, 0 },
  { 417, 3, 1, 8, 3, -9 },
  { 418, 6, 7, 8, 1, -7 },
  { 424, 7, 10, 8, 0, -10 },
  { 433, 6, 7, 8, 1, -7 },
  { 439, 7, 10, 8, 1, -10 },
  { 448, 6, 7, 8, 1, -7 },
  { 454, 7, 10, 8, 1, -10 },
  { 463, 7, 10, 8, 0, -7 },
  { 472, 7, 10, 8, 0, -10 },
  { 481, 5, 9, 8, 1, -9 },
  { 487, 6, 12, 8, 0, -9 },
  { 496, 7, 10, 8, 0, -10 },
  { 505, 5, 10, 8, 1, -10 },
  { 512, 7, 7, 8, 0, -7 },
  { 519, 7, 7, 8, 0, -7 },
  { 526, 6, 7, 8, 1, -7 },
  { 532, 7, 10, 8, 0, -7 },
  { 541, 6, 10, 8, 1, -7 },
  { 549, 6, 7, 8, 1, -7 },
  { 555, 6, 7, 8, 1, -7 },
  { 561, 6, 9, 8, 1, -9 },
  { 568, 6, 7, 8, 1, -7 },
  { 574, 6, 7, 8, 1, -7 },
  { 580, 7, 7, 8, 1, -7 },
  { 587, 7, 7, 8, 0, -7 },
  { 594, 8, 10, 8, 0, -7 },
  { 604, 7, 7, 8, 0, -7 },
  { 611, 5, 12, 8, 2, -10 },
  { 619, 3, 12, 8, 2, -9 },
  { 624, 5, 12, 8, 1, -10 },
  { 632, 7, 2, 8, 0, -5 },
};

const GFXfont RobotoMono_Italic13pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic13pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _ROBOTOMONO_ITALIC13PT7B_H_
