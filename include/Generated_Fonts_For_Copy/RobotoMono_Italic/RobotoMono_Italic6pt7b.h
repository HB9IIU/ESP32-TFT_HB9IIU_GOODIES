#ifndef _ROBOTOMONO_ITALIC6PT7B_H_
#define _ROBOTOMONO_ITALIC6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xF0, 0x67, 0xEC, 0x2D, 0x1A, 0x80, 0xE9, 0xB0, 0x6B, 0xF0,
  0xC0, 0x6A, 0xA0, 0x55, 0x70, 0x6C, 0x3D, 0x20, 0xC0, 0xC0, 0x80, 0x25,
  0x60, 0x77, 0xF0, 0xDA, 0xE5, 0x70, 0xEC, 0xF0, 0x2F, 0x90, 0x6C, 0xF0,
  0x6E, 0xF0, 0xEA, 0x40, 0x6E, 0xF0, 0xFE, 0x42, 0x42, 0x80, 0x7C, 0x7C,
  0x5C, 0xDA, 0x7E, 0xF0, 0x2D, 0xD0, 0x7E, 0xF0, 0x72, 0x70, 0x76, 0xF0,
  0x7E, 0x70, 0x7E, 0x88, 0x72, 0xF0, 0x9E, 0xAA, 0x69, 0x70, 0x24, 0xF0,
  0x74, 0xAA, 0x52, 0x70, 0x75, 0xEA, 0x56, 0xAA, 0x76, 0xF0, 0x77, 0x40,
  0x76, 0xF2, 0x77, 0xD0, 0x68, 0xF0, 0xF2, 0x40, 0x9A, 0xAE, 0xBA, 0x40,
  0xB5, 0xAA, 0x74, 0x4A, 0xFA, 0x40, 0x69, 0x70, 0x6A, 0xA0, 0xF0, 0x56,
  0xA0, 0x70, 0xE0, 0x80, 0xEF, 0x80, 0x4A, 0xDE, 0xF3, 0x80, 0x27, 0xDE,
  0xFF, 0x80, 0x73, 0x48, 0xF6, 0xF0, 0x4A, 0xDA, 0x2D, 0x70, 0x2C, 0xAC,
  0x4A, 0xEA, 0x64, 0xAE, 0xFF, 0x80, 0xF6, 0x80, 0xF7, 0x80, 0xF7, 0xC0,
  0xF7, 0x90, 0xE8, 0x6F, 0x80, 0xBB, 0xB7, 0x80, 0xF8, 0xDE, 0xA0, 0x6A,
  0x80, 0xB6, 0x4C, 0x6B, 0x80, 0x56, 0xA0, 0xF8, 0x99, 0xA0, 0xE0,
};

const GFXglyph RobotoMono_Italic6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 2, 4, 1, -5 },
  { 3, 4, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 3, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 2, 4, 1, -5 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 2, 6, 4, 0, -5 },
  { 17, 2, 3, 4, 1, -4 },
  { 18, 3, 4, 4, 0, -4 },
  { 20, 1, 2, 4, 1, -1 },
  { 21, 2, 1, 4, 1, -2 },
  { 22, 1, 1, 4, 1, -1 },
  { 23, 3, 4, 4, 0, -4 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 2, 4, 4, 1, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 3, 4, 4, 0, -4 },
  { 36, 3, 4, 4, 0, -4 },
  { 38, 3, 4, 4, 1, -4 },
  { 40, 3, 4, 4, 0, -4 },
  { 42, 2, 4, 4, 1, -4 },
  { 43, 2, 4, 4, 1, -4 },
  { 44, 2, 5, 4, 1, -4 },
  { 46, 3, 2, 4, 0, -3 },
  { 47, 3, 2, 4, 0, -3 },
  { 48, 3, 2, 4, 0, -3 },
  { 49, 2, 4, 4, 1, -4 },
  { 50, 3, 4, 4, 0, -4 },
  { 52, 3, 4, 4, 0, -4 },
  { 54, 3, 4, 4, 0, -4 },
  { 56, 3, 4, 4, 0, -4 },
  { 58, 3, 4, 4, 0, -4 },
  { 60, 3, 4, 4, 0, -4 },
  { 62, 4, 4, 4, 0, -4 },
  { 64, 3, 4, 4, 0, -4 },
  { 66, 4, 4, 4, 0, -4 },
  { 68, 3, 4, 4, 0, -4 },
  { 70, 3, 4, 4, 0, -4 },
  { 72, 4, 4, 4, 0, -4 },
  { 74, 3, 4, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -4 },
  { 78, 4, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 5, 4, 0, -4 },
  { 86, 3, 4, 4, 0, -4 },
  { 88, 3, 4, 4, 0, -4 },
  { 90, 3, 4, 4, 1, -4 },
  { 92, 4, 4, 4, 0, -4 },
  { 94, 3, 4, 4, 1, -4 },
  { 96, 4, 4, 4, 0, -4 },
  { 98, 4, 4, 4, 0, -4 },
  { 100, 3, 4, 4, 1, -4 },
  { 102, 3, 4, 4, 0, -4 },
  { 104, 2, 6, 4, 1, -5 },
  { 106, 1, 4, 4, 1, -4 },
  { 107, 2, 6, 4, 1, -5 },
  { 109, 2, 2, 4, 1, -4 },
  { 110, 3, 1, 4, 0, 0 },
  { 111, 1, 1, 4, 2, -4 },
  { 112, 3, 3, 4, 0, -3 },
  { 114, 3, 5, 4, 0, -5 },
  { 116, 3, 3, 4, 0, -3 },
  { 118, 3, 5, 4, 0, -5 },
  { 120, 3, 3, 4, 0, -3 },
  { 122, 3, 5, 4, 1, -5 },
  { 124, 3, 4, 4, 0, -3 },
  { 126, 3, 5, 4, 0, -5 },
  { 128, 3, 4, 4, 0, -4 },
  { 130, 3, 5, 4, 0, -4 },
  { 132, 3, 5, 4, 0, -5 },
  { 134, 3, 5, 4, 0, -5 },
  { 136, 3, 3, 4, 0, -3 },
  { 138, 3, 3, 4, 0, -3 },
  { 140, 3, 3, 4, 0, -3 },
  { 142, 3, 4, 4, 0, -3 },
  { 144, 3, 4, 4, 0, -3 },
  { 146, 2, 3, 4, 1, -3 },
  { 147, 3, 3, 4, 0, -3 },
  { 149, 2, 4, 4, 1, -4 },
  { 150, 3, 3, 4, 0, -3 },
  { 152, 2, 3, 4, 1, -3 },
  { 153, 4, 3, 4, 0, -3 },
  { 155, 3, 3, 4, 0, -3 },
  { 157, 4, 4, 4, 0, -3 },
  { 159, 3, 3, 4, 0, -3 },
  { 161, 2, 6, 4, 1, -5 },
  { 163, 1, 5, 4, 1, -4 },
  { 164, 2, 6, 4, 1, -5 },
  { 166, 3, 1, 4, 0, -2 },
};

const GFXfont RobotoMono_Italic6pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic6pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _ROBOTOMONO_ITALIC6PT7B_H_
