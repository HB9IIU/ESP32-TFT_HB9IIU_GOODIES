#ifndef _ROBOTOMONO_ITALIC63PT7B_H_
#define _ROBOTOMONO_ITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x07, 0xF0, 0x3F, 0x81, 0xF8,
  0x07, 0xC0, 0x00, 0x3E, 0x07, 0x9E, 0x07, 0xCF, 0x03, 0xEF, 0x81, 0xF7,
  0xC0, 0xF3, 0xE0, 0x79, 0xE0, 0x3C, 0xF0, 0x1E, 0x78, 0x1F, 0x3C, 0x0F,
  0x3E, 0x07, 0x9E, 0x03, 0xCF, 0x01, 0xE7, 0x81, 0xF0, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0x80, 0xF0,
  0x04, 0x1E, 0x03, 0xC0, 0x38, 0xF8, 0x0F, 0x00, 0xF3, 0xE0, 0x3C, 0x07,
  0x8F, 0x00, 0xF0, 0x3E, 0x3C, 0x03, 0xC1, 0xF0, 0xF0, 0x0F, 0x07, 0x83,
  0xC0, 0x3C, 0x3E, 0x0F, 0x81, 0xE1, 0xF0, 0x1E, 0x0F, 0x87, 0x80, 0x7E,
  0xFC, 0x3E, 0x00, 0xFF, 0xF1, 0xF0, 0x03, 0xFF, 0x87, 0x80, 0x03, 0xF8,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x87, 0xF0, 0x00, 0x7C, 0x3F, 0xE0,
  0x01, 0xE3, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0x80, 0x7C, 0x7C, 0x1E, 0x01,
  0xE3, 0xE0, 0x7C, 0x0F, 0x8F, 0x01, 0xF0, 0x7C, 0x3C, 0x03, 0xC1, 0xE0,
  0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0x3C, 0x7C, 0x0F, 0x01, 0xF1, 0xE0, 0x7C,
  0x07, 0xC1, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x01, 0xF0,
  0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F,
  0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xC3, 0xFD, 0xF8, 0x07, 0xC3,
  0xF8, 0x7E, 0x03, 0xE3, 0xF8, 0x3F, 0x01, 0xF1, 0xF8, 0x0F, 0xC0, 0xF9,
  0xFC, 0x07, 0xE0, 0xFC, 0xFC, 0x01, 0xF8, 0x7C, 0xFC, 0x00, 0x7E, 0x7E,
  0x7E, 0x00, 0x3F, 0x3E, 0x3F, 0x00, 0x0F, 0xFF, 0x1F, 0x80, 0x07, 0xFF,
  0x0F, 0xC0, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0x83, 0xF0, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x3F, 0x00, 0xFF, 0xFF,
  0x1F, 0xC0, 0x1F, 0xFE, 0x07, 0xF0, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x7C,
  0xF9, 0xE3, 0xCF, 0x9F, 0x3E, 0x78, 0xF1, 0xE7, 0xCF, 0x9E, 0x34, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x20, 0x00, 0x01, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x03, 0x00, 0x78, 0x07, 0x7C, 0x07, 0x81, 0xF7, 0xF0, 0x70, 0xFF,
  0xFF, 0xEF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x0F,
  0x80, 0x7F, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x1C, 0x00, 0x78, 0x00,
  0xC0, 0x06, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83,
  0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x07,
  0xC0, 0x30, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFC, 0xFE, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFC, 0x3F, 0xC0, 0x3F, 0x80, 0x3F, 0x00,
  0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7C, 0x00,
  0x01, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x03,
  0xFC, 0xFC, 0x00, 0x3F, 0xF3, 0xE0, 0x01, 0xFF, 0xCF, 0x80, 0x1F, 0xFF,
  0x3E, 0x00, 0xFF, 0xFD, 0xF8, 0x0F, 0xF3, 0xE7, 0xE0, 0x7F, 0x8F, 0x9F,
  0x83, 0xF8, 0x3E, 0x7C, 0x3F, 0xC1, 0xF9, 0xF1, 0xFC, 0x07, 0xE7, 0xDF,
  0xE0, 0x1F, 0xBF, 0xFE, 0x00, 0x7E, 0xFF, 0xF0, 0x01, 0xF3, 0xFF, 0x80,
  0x07, 0xCF, 0xF8, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x03,
  0xF3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x3F, 0xE0, 0x3F, 0xFC, 0x1F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xFC, 0xFF, 0xCF, 0x9F, 0xC1, 0xF3, 0xC0, 0x7E, 0x40, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xC3,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F,
  0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F,
  0x87, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x7E, 0xF8,
  0x00, 0x00, 0xFC, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC7, 0xF8, 0x00,
  0x07, 0xDF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x0F, 0xF8, 0x07, 0xE7, 0xFF, 0x80, 0xFB, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x87, 0xFF, 0xCF, 0xF8, 0xFF, 0xC0, 0x3F, 0x9F, 0xE0,
  0x03, 0xF3, 0xF8, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x7F, 0x80, 0x3F,
  0x80, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x81, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xF1, 0xFE, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xF8, 0x7F, 0x80, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x80,
  0x1F, 0xC0, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0x80, 0x7F, 0x87, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFD,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF3, 0xF8, 0x01, 0xFE, 0x3F,
  0x80, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xE7,
  0xC0, 0x7F, 0xF8, 0xF8, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x3F, 0x81, 0xFE, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xE0, 0x7E, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xE0, 0xFF, 0x07, 0xF8, 0x1F, 0x80, 0x30, 0x00, 0x00, 0x3E, 0x00,
  0x3F, 0x80, 0x3F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x10, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x20, 0x1F,
  0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x80, 0x04, 0x00, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xBF, 0xF3, 0xFC, 0x03, 0xF9, 0xF8, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xC0,
  0x0F, 0xC0, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x07, 0x00, 0xE0, 0x7C, 0x0F, 0xF8, 0x38, 0x1E, 0x07, 0xFF,
  0x0F, 0x0F, 0x03, 0xFF, 0xC3, 0xC3, 0xC1, 0xF8, 0x70, 0x71, 0xE0, 0xF8,
  0x1C, 0x1C, 0x78, 0x3C, 0x0F, 0x07, 0x1C, 0x1E, 0x03, 0x81, 0xCF, 0x07,
  0x80, 0xE0, 0x73, 0xC3, 0xC0, 0x78, 0x1C, 0xE0, 0xF0, 0x1E, 0x07, 0x78,
  0x3C, 0x07, 0x03, 0xDE, 0x1E, 0x01, 0xC0, 0xF7, 0x87, 0x80, 0xF0, 0x39,
  0xC1, 0xE0, 0x3C, 0x0E, 0xF0, 0x78, 0x0E, 0x03, 0xBC, 0x1C, 0x03, 0x81,
  0xEF, 0x07, 0x01, 0xE0, 0x73, 0xC3, 0xC0, 0x78, 0x1C, 0xF0, 0xF0, 0x3E,
  0x0F, 0x3C, 0x1E, 0x0F, 0x83, 0x8F, 0x07, 0x8F, 0xE1, 0xE3, 0xC1, 0xFF,
  0xFC, 0xF0, 0xF0, 0x7F, 0xDF, 0xF8, 0x3C, 0x0F, 0xE3, 0xFC, 0x07, 0x01,
  0xF0, 0x7E, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x20, 0x00,
  0x1F, 0x80, 0x38, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0xBE, 0x00,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xC3, 0xC0,
  0x00, 0x07, 0xE1, 0xF0, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x1F, 0x1F,
  0x80, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xE0, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x07, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F,
  0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x01, 0xF0,
  0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x7F,
  0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x30, 0xFC, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x07,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x01, 0xFF, 0x00, 0x1F, 0x80,
  0x1F, 0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x03,
  0xFC, 0x03, 0xE0, 0x01, 0xFE, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0xFF, 0xC0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0xFF, 0xFE, 0x7E, 0x00, 0x7F, 0xFE,
  0x3F, 0x00, 0x3F, 0xFF, 0x1F, 0x80, 0x1F, 0xFF, 0x8F, 0xC0, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xE0, 0x1F, 0xF0,
  0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7C,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x3F, 0xE1, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xC0, 0x00, 0x3E, 0x03,
  0xFC, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x1F, 0x83, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0xC0,
  0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0xFD,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xCF,
  0xC0, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x3E, 0xF0, 0x07, 0xFE,
  0x03, 0xEF, 0x00, 0xFB, 0xE0, 0x3E, 0xF0, 0x0F, 0xFC, 0x03, 0xEF, 0x01,
  0xF7, 0xC0, 0x3E, 0xF8, 0x1F, 0x7C, 0x03, 0xEF, 0x83, 0xE7, 0xC0, 0x7C,
  0xF8, 0x3E, 0x7C, 0x07, 0xC7, 0x87, 0xCF, 0xC0, 0x7C, 0x78, 0xFC, 0xF8,
  0x07, 0xC7, 0x8F, 0x8F, 0x80, 0x7C, 0x79, 0xF8, 0xF8, 0x0F, 0xC7, 0xDF,
  0x0F, 0x80, 0xFC, 0x7F, 0xF1, 0xF8, 0x0F, 0x87, 0xFE, 0x1F, 0x80, 0xF8,
  0x7F, 0xE1, 0xF0, 0x0F, 0x83, 0xFC, 0x1F, 0x00, 0xF8, 0x3F, 0xC1, 0xF0,
  0x1F, 0x83, 0xF8, 0x3F, 0x01, 0xF8, 0x3F, 0x83, 0xF0, 0x1F, 0x03, 0xF0,
  0x3F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1E, 0x03, 0xE0, 0x3F, 0x01, 0xC0, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x03,
  0xE0, 0x1F, 0xE0, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xF0,
  0x00, 0x7E, 0x03, 0xFF, 0x00, 0x07, 0xE0, 0x3F, 0xF0, 0x00, 0x7C, 0x03,
  0xFF, 0x80, 0x07, 0xC0, 0x3F, 0xF8, 0x00, 0xFC, 0x03, 0xEF, 0x80, 0x0F,
  0xC0, 0x3E, 0xFC, 0x00, 0xFC, 0x07, 0xE7, 0xC0, 0x0F, 0xC0, 0x7E, 0x7C,
  0x00, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0x80, 0x7E, 0x3E, 0x01, 0xF8, 0x07,
  0xC3, 0xE0, 0x1F, 0x80, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF0, 0x1F,
  0x00, 0xFC, 0x1F, 0x01, 0xF0, 0x0F, 0xC1, 0xF8, 0x3F, 0x00, 0xF8, 0x0F,
  0x83, 0xF0, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F,
  0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0x7E, 0x7E,
  0x01, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x00, 0x3E, 0x7E, 0x03, 0xF0, 0x03,
  0xF7, 0xE0, 0x3F, 0x00, 0x1F, 0x7C, 0x03, 0xF0, 0x01, 0xF7, 0xC0, 0x3F,
  0x00, 0x1F, 0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x3E, 0x00, 0x0F, 0xFC,
  0x07, 0xE0, 0x00, 0xFF, 0xC0, 0x7E, 0x00, 0x07, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x80, 0x7C, 0x00, 0x07, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x3E, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F,
  0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x07,
  0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x80,
  0x3F, 0x80, 0x1F, 0xF1, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0C,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x01, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x03,
  0xE0, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F,
  0xC0, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x07,
  0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x07, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFE, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0xF8, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x7F,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x3E, 0x07,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7E, 0x01, 0xF0, 0x07, 0xDF, 0x00, 0x7C, 0x01, 0xF7, 0xC0,
  0x1F, 0x00, 0x7D, 0xF0, 0x0F, 0xC0, 0x3F, 0x7C, 0x03, 0xF0, 0x0F, 0x9F,
  0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x7F, 0x01, 0xF9, 0xF0, 0x1F, 0xC0, 0x7C,
  0x7C, 0x07, 0xF0, 0x1F, 0x1F, 0x03, 0xFC, 0x07, 0xC7, 0xC0, 0xFF, 0x03,
  0xF1, 0xF0, 0x3F, 0xC0, 0xF8, 0x7C, 0x1F, 0xF0, 0x3E, 0x1F, 0x07, 0xFC,
  0x0F, 0x87, 0xC1, 0xEF, 0x07, 0xE1, 0xF0, 0xFB, 0xC1, 0xF0, 0x7C, 0x3E,
  0xF0, 0x7C, 0x1F, 0x0F, 0x3C, 0x1F, 0x07, 0xC7, 0xCF, 0x0F, 0x81, 0xE1,
  0xF3, 0xE3, 0xE0, 0x78, 0x78, 0xF8, 0xF8, 0x3E, 0x3E, 0x3E, 0x3E, 0x0F,
  0x8F, 0x8F, 0x9F, 0x03, 0xE3, 0xC3, 0xE7, 0xC0, 0xF9, 0xF0, 0xF9, 0xF0,
  0x3E, 0x7C, 0x3E, 0x7C, 0x0F, 0x9E, 0x0F, 0xBE, 0x03, 0xEF, 0x83, 0xEF,
  0x80, 0xFB, 0xE0, 0xFB, 0xE0, 0x3E, 0xF0, 0x3E, 0xF0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x03, 0xFF, 0x03, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80,
  0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x03,
  0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0, 0x08, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0xCF, 0x80,
  0x1F, 0x0F, 0x00, 0x7E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x1F, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0xF8, 0x03, 0xE3, 0xF0,
  0x07, 0xC7, 0xC0, 0x07, 0x9F, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x03, 0xE0,
  0xF8, 0x1F, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFC,
  0x07, 0xF8, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x87, 0xF8, 0x00,
  0xF8, 0x7F, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x87, 0xE0, 0x0F,
  0xFC, 0x3F, 0xE3, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFD, 0xF8,
  0x1F, 0xFF, 0xCF, 0xC0, 0x3F, 0xF8, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x83, 0xF8, 0x00, 0x3E, 0x3F, 0xF8, 0x01, 0xFB, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0x81, 0xFE,
  0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C,
  0x7E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x80, 0x0F, 0xE1, 0xFF, 0x00, 0x7F,
  0x07, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFD, 0xFF, 0xFF, 0x03,
  0xF3, 0xFF, 0xF0, 0x0F, 0x83, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x3F, 0x80, 0x1F,
  0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x04, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x7F, 0x80,
  0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x7F, 0xF8, 0xFC, 0x01, 0xFF, 0xFC, 0xFC, 0x03, 0xFF,
  0xFE, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x0F, 0xF8, 0x1F, 0xF8, 0x0F, 0xE0,
  0x07, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00,
  0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xE0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x3F, 0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC3, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0x9F, 0x00, 0x03, 0xFF,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xE0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xF7, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x9F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x0F,
  0xC0, 0x00, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x78, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0x87, 0xC0, 0x0F, 0xFF, 0xE7, 0xE0, 0x0F, 0xFF, 0xFB, 0xF0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF8, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0x81, 0xF8, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC3, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xF3, 0xF0, 0x00, 0x3F, 0xF1,
  0xF0, 0x00, 0x03, 0x80, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x40, 0x00, 0x3F, 0x00, 0x70, 0x00,
  0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x1F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x3E, 0x1F, 0xFC, 0x01, 0xF8, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xF0, 0x1F,
  0x7F, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F, 0x81, 0xFF, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x3E, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x30, 0x3F, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x04, 0x0F, 0x80, 0x03, 0xFC, 0x07, 0xC0, 0x03, 0xFC, 0x07, 0xE0,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0xF8,
  0x03, 0xF8, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x3F,
  0x07, 0xF8, 0x00, 0x1F, 0x87, 0xF8, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x07,
  0xC7, 0xF0, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x1F, 0xE1, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x0F, 0xC0,
  0x01, 0xF0, 0x07, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x07,
  0xF0, 0x0F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0xF9, 0xFF, 0x1F, 0xF0,
  0x1F, 0x7F, 0xE7, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xC1, 0xFE, 0x0F, 0xC3, 0xF0, 0x3F, 0x81, 0xF8, 0x7C, 0x03,
  0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0x7C, 0x3E,
  0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F, 0x80, 0x7C,
  0x3E, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0,
  0x3E, 0x1F, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x01, 0xF8, 0xFC, 0x07,
  0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x7C,
  0x03, 0xE0, 0x1F, 0x0F, 0x80, 0xFC, 0x07, 0xE3, 0xF0, 0x1F, 0x80, 0xFC,
  0x7E, 0x03, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x80,
  0x7C, 0x3E, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x7E, 0x03, 0xF1, 0xF8, 0x0F,
  0xC0, 0x7E, 0x3E, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0xF8,
  0x07, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x0F, 0x87, 0xFF, 0x00, 0x7C, 0x7F, 0xFE, 0x01, 0xF3, 0xFF, 0xFC, 0x07,
  0xDF, 0xFF, 0xF8, 0x1F, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC1, 0xFC,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xE0, 0x3F, 0x80, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x07,
  0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0xFF, 0xE0,
  0x01, 0xF3, 0xFF, 0xF0, 0x01, 0xF7, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E,
  0x0F, 0x80, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0,
  0x1F, 0xF8, 0x1F, 0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0xC0,
  0x3F, 0x3F, 0xFF, 0x00, 0x3F, 0x0F, 0xFE, 0x00, 0x3F, 0x00, 0xE0, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF, 0xCF, 0xC0,
  0xFF, 0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0, 0x3F, 0xE0, 0xFE,
  0x00, 0x7F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x03,
  0xF1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xF8,
  0xFC, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x7E, 0x3E,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x80, 0xFF, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xDF, 0x00, 0x0F, 0xFC, 0x7C, 0x00, 0x07, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0xFC, 0x3F, 0xFC, 0x1F, 0x0F, 0xFF, 0x83, 0xE7, 0xFF, 0xF0, 0x7D,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFC,
  0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x01,
  0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0xC1, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x01, 0xF8,
  0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x3F, 0xE0, 0x3F, 0x83, 0xFF, 0x80, 0xFF, 0xFF,
  0xBE, 0x01, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0xE3, 0xE0, 0x07, 0xFE, 0x1F,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03,
  0xE0, 0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x01, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0x3E,
  0x00, 0xFB, 0xE0, 0x0F, 0x80, 0x3E, 0xF8, 0x07, 0xE0, 0x0F, 0x3E, 0x01,
  0xF8, 0x07, 0xCF, 0x80, 0xFE, 0x01, 0xF3, 0xE0, 0x3F, 0x80, 0xF8, 0xF8,
  0x0E, 0xE0, 0x3E, 0x3E, 0x07, 0xB8, 0x0F, 0x0F, 0x81, 0xEF, 0x07, 0xC3,
  0xE0, 0xF3, 0xC1, 0xF0, 0xF8, 0x3C, 0xF0, 0x78, 0x1E, 0x1F, 0x3C, 0x3E,
  0x07, 0x87, 0x8F, 0x0F, 0x81, 0xE1, 0xE3, 0xC3, 0xC0, 0x78, 0xF0, 0xF1,
  0xF0, 0x1E, 0x3C, 0x3C, 0x78, 0x07, 0x9F, 0x0F, 0x1E, 0x01, 0xE7, 0x83,
  0xCF, 0x80, 0x79, 0xE0, 0xF3, 0xC0, 0x1E, 0xF0, 0x3C, 0xF0, 0x07, 0xBC,
  0x0F, 0x7C, 0x01, 0xFF, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x77, 0x80, 0x1F,
  0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC, 0x01, 0xFC, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x0F,
  0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0x00, 0x7D, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xF9, 0xF0,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0x9F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0xBF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xBF, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0x8F, 0xFF, 0xE0, 0x01,
  0xE3, 0xFF, 0xFE, 0x00, 0x3C, 0xFE, 0x3F, 0xE0, 0x0F, 0x9F, 0x01, 0xFE,
  0x03, 0xF3, 0xC0, 0x0F, 0xF9, 0xFC, 0xF8, 0x00, 0xFF, 0xFF, 0x1E, 0x00,
  0x0F, 0xFF, 0xE3, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x1E, 0x00,
};

const GFXglyph RobotoMono_Italic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 37, 0, -1 },
  { 1, 13, 45, 37, 12, -45 },
  { 75, 17, 14, 37, 13, -47 },
  { 105, 37, 45, 37, 1, -45 },
  { 314, 31, 58, 37, 4, -52 },
  { 539, 30, 47, 37, 4, -46 },
  { 716, 33, 47, 37, 2, -46 },
  { 910, 7, 15, 37, 17, -47 },
  { 924, 21, 65, 37, 10, -51 },
  { 1095, 21, 65, 37, 5, -51 },
  { 1266, 28, 31, 37, 7, -45 },
  { 1375, 31, 33, 37, 3, -37 },
  { 1503, 11, 17, 37, 6, -7 },
  { 1527, 24, 5, 37, 6, -22 },
  { 1542, 9, 9, 37, 12, -8 },
  { 1553, 32, 49, 37, 3, -45 },
  { 1749, 30, 47, 37, 4, -46 },
  { 1926, 19, 45, 37, 9, -45 },
  { 2033, 32, 45, 37, 0, -45 },
  { 2213, 31, 46, 37, 1, -45 },
  { 2392, 32, 45, 37, 1, -45 },
  { 2572, 32, 46, 37, 4, -45 },
  { 2756, 27, 46, 37, 4, -45 },
  { 2912, 31, 45, 37, 6, -45 },
  { 3087, 31, 46, 37, 4, -45 },
  { 3266, 27, 45, 37, 6, -45 },
  { 3418, 13, 36, 37, 14, -35 },
  { 3477, 17, 45, 37, 10, -35 },
  { 3573, 28, 28, 37, 5, -34 },
  { 3671, 30, 18, 37, 4, -29 },
  { 3739, 29, 28, 37, 3, -34 },
  { 3841, 25, 45, 37, 9, -45 },
  { 3982, 34, 45, 37, 2, -45 },
  { 4174, 33, 45, 37, -1, -45 },
  { 4360, 33, 45, 37, 2, -45 },
  { 4546, 33, 46, 37, 3, -45 },
  { 4736, 34, 45, 37, 1, -45 },
  { 4928, 34, 45, 37, 2, -45 },
  { 5120, 35, 45, 37, 2, -45 },
  { 5317, 33, 46, 37, 3, -45 },
  { 5507, 36, 45, 37, 1, -45 },
  { 5710, 34, 45, 37, 2, -45 },
  { 5902, 34, 46, 37, 2, -45 },
  { 6098, 37, 45, 37, 2, -45 },
  { 6307, 27, 45, 37, 3, -45 },
  { 6459, 36, 45, 37, 1, -45 },
  { 6662, 36, 45, 37, 1, -45 },
  { 6865, 32, 46, 37, 3, -45 },
  { 7049, 35, 45, 37, 2, -45 },
  { 7246, 32, 53, 37, 3, -45 },
  { 7458, 33, 45, 37, 2, -45 },
  { 7644, 33, 46, 37, 3, -45 },
  { 7834, 33, 45, 37, 6, -45 },
  { 8020, 34, 46, 37, 3, -45 },
  { 8216, 33, 45, 37, 6, -45 },
  { 8402, 34, 45, 37, 5, -45 },
  { 8594, 39, 45, 37, 0, -45 },
  { 8814, 32, 45, 37, 7, -45 },
  { 8994, 34, 45, 37, 1, -45 },
  { 9186, 22, 61, 37, 8, -51 },
  { 9354, 14, 49, 37, 12, -45 },
  { 9440, 21, 61, 37, 8, -51 },
  { 9601, 23, 24, 37, 7, -45 },
  { 9670, 28, 5, 37, 1, 0 },
  { 9688, 10, 9, 37, 17, -46 },
  { 9700, 29, 35, 37, 3, -34 },
  { 9827, 30, 48, 37, 2, -47 },
  { 10007, 29, 35, 37, 4, -34 },
  { 10134, 32, 48, 37, 4, -47 },
  { 10326, 30, 35, 37, 3, -34 },
  { 10458, 33, 49, 37, 6, -49 },
  { 10661, 33, 47, 37, 1, -34 },
  { 10855, 30, 47, 37, 2, -47 },
  { 11032, 28, 45, 37, 3, -45 },
  { 11190, 29, 59, 37, 1, -45 },
  { 11404, 33, 47, 37, 2, -47 },
  { 11598, 28, 47, 37, 3, -47 },
  { 11763, 35, 34, 37, 0, -34 },
  { 11912, 30, 34, 37, 2, -34 },
  { 12040, 30, 35, 37, 3, -34 },
  { 12172, 32, 47, 37, 0, -34 },
  { 12360, 30, 47, 37, 4, -34 },
  { 12537, 27, 34, 37, 7, -34 },
  { 12652, 29, 35, 37, 4, -34 },
  { 12779, 27, 42, 37, 6, -41 },
  { 12921, 30, 34, 37, 4, -33 },
  { 13049, 31, 33, 37, 5, -33 },
  { 13177, 34, 33, 37, 4, -33 },
  { 13318, 36, 33, 37, 0, -33 },
  { 13467, 38, 47, 37, -1, -33 },
  { 13691, 32, 33, 37, 2, -33 },
  { 13823, 25, 60, 37, 9, -49 },
  { 14011, 14, 57, 37, 11, -45 },
  { 14111, 25, 60, 37, 5, -49 },
  { 14299, 35, 13, 37, 1, -25 },
};

const GFXfont RobotoMono_Italic63pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic63pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic63pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _ROBOTOMONO_ITALIC63PT7B_H_
