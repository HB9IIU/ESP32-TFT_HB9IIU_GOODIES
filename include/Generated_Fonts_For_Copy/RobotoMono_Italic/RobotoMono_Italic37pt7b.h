#ifndef _ROBOTOMONO_ITALIC37PT7B_H_
#define _ROBOTOMONO_ITALIC37PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic37pt7bBitmaps[] PROGMEM = {
  0x00, 0x0F, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x1E, 0x1C, 0x1C, 0x1C, 0x1C,
  0x3C, 0x3C, 0x38, 0x38, 0x38, 0x38, 0x40, 0x00, 0x00, 0x00, 0x00, 0x60,
  0xF0, 0xF0, 0xF0, 0x38, 0xE6, 0x1D, 0xC3, 0x38, 0x67, 0x1C, 0xE3, 0x98,
  0x73, 0x0C, 0xE1, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x60, 0xE0, 0x03, 0x83,
  0x00, 0x0E, 0x1C, 0x00, 0x30, 0x60, 0x01, 0xC3, 0x80, 0x07, 0x0E, 0x03,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x0C, 0x18, 0x00, 0x70,
  0xE0, 0x01, 0x83, 0x80, 0x0E, 0x0C, 0x00, 0x38, 0x70, 0x00, 0xC1, 0x80,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x03, 0x87, 0x00, 0x0E,
  0x1C, 0x00, 0x30, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x30,
  0x00, 0xE1, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x3F, 0xF8, 0x1F, 0x1E, 0x0F, 0x03,
  0xC3, 0x80, 0xF1, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x80, 0x00,
  0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x73, 0xC0, 0x1E, 0xF0, 0x07,
  0x3C, 0x01, 0xC7, 0x00, 0xF1, 0xE0, 0x7C, 0x7F, 0xFE, 0x0F, 0xFF, 0x00,
  0xFF, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x0F, 0xE0, 0x03, 0xB8, 0x01, 0xC7, 0x00, 0x61, 0xC1, 0x18, 0x70,
  0xEE, 0x1C, 0x73, 0x87, 0x38, 0x61, 0x8C, 0x1C, 0xE7, 0x07, 0xF3, 0x80,
  0x78, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x9F, 0x01, 0xCF, 0xE0, 0x67, 0x1C, 0x39, 0x87, 0x1C, 0xE1, 0xC6, 0x38,
  0x73, 0x8E, 0x1C, 0x43, 0x86, 0x00, 0xE3, 0x80, 0x1F, 0xC0, 0x03, 0xE0,
  0x00, 0x30, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xE3, 0x80, 0x78, 0x70,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0xE3, 0xC0,
  0x1F, 0xF0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00,
  0xF7, 0x07, 0x3C, 0xF0, 0xEF, 0x0F, 0x1D, 0xC0, 0xE7, 0x78, 0x1E, 0xEF,
  0x01, 0xF9, 0xE0, 0x3F, 0x3C, 0x03, 0xC3, 0x80, 0xF8, 0x7C, 0xFF, 0x87,
  0xFF, 0x70, 0x7F, 0x8F, 0x00, 0x77, 0x77, 0x6E, 0xEE, 0xC0, 0x00, 0x10,
  0x03, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01,
  0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x40, 0x02, 0x00, 0x20, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0xE0, 0x0C, 0x00, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x0C, 0x03, 0x06, 0x1B, 0xE7, 0x3F, 0xFF, 0xFF, 0x1F,
  0xFE, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xDC, 0x01, 0xE6, 0x01, 0xE3, 0x81,
  0xE1, 0xE0, 0xE0, 0x70, 0x30, 0x30, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xC7, 0x8E, 0x3C, 0xF0, 0x40, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0x80, 0x33, 0xFF, 0xF7, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x7F, 0x80, 0x7F, 0xF0, 0x3E,
  0x1E, 0x0E, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x07, 0x38, 0x01,
  0xCE, 0x01, 0xF7, 0x80, 0xFD, 0xE0, 0xFF, 0x70, 0x7B, 0xDC, 0x3C, 0xF7,
  0x3E, 0x39, 0xDE, 0x0E, 0x7F, 0x03, 0xBF, 0x00, 0xEF, 0x80, 0x7B, 0x80,
  0x1C, 0xE0, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xE0, 0x78, 0x3E, 0x7C,
  0x07, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x60, 0x7C, 0x7F, 0xBF, 0xFF, 0xDD,
  0xC3, 0xA0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x3F, 0xE0, 0x0F, 0xFE,
  0x03, 0xC1, 0xE0, 0xF0, 0x1C, 0x1C, 0x03, 0xC7, 0x80, 0x38, 0xE0, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0x1E, 0x1E, 0x03, 0xC7, 0x00, 0xF1,
  0xC0, 0x1C, 0xF0, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0xE0, 0x07, 0x38, 0x03, 0xCF,
  0x00, 0xE1, 0xC0, 0x78, 0x7E, 0x7C, 0x0F, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3B, 0x80, 0x0E, 0x70, 0x03, 0x9E, 0x00, 0xF3, 0x80, 0x3C, 0x70, 0x07,
  0x0E, 0x01, 0xC1, 0xC0, 0x70, 0x78, 0x1E, 0x0E, 0x07, 0x81, 0xC0, 0xE0,
  0x38, 0x38, 0x07, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0xFF, 0xFC, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0xFC, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x0E,
  0x38, 0x07, 0x8F, 0x03, 0xC1, 0xF3, 0xE0, 0x3F, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0xFE, 0x03, 0xFE, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x39, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE,
  0x7C, 0x0F, 0x78, 0x0F, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x1C, 0x3E, 0x7C,
  0x1F, 0xF8, 0x0F, 0xE0, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x3F,
  0xF8, 0x1E, 0x1E, 0x0F, 0x03, 0xC3, 0x80, 0x71, 0xE0, 0x1C, 0x78, 0x07,
  0x1C, 0x01, 0xC7, 0x80, 0xF0, 0xE0, 0x38, 0x3C, 0x3C, 0x07, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0xE0, 0x78, 0x3C, 0x38, 0x07, 0x1E, 0x01, 0xC7, 0x00,
  0x79, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xC7, 0x00, 0xF1, 0xE0, 0x78,
  0x3E, 0x7E, 0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0x0F, 0xF0, 0x1F,
  0xFC, 0x3E, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x1E, 0xF0,
  0x3E, 0x7F, 0xFE, 0x3F, 0xFC, 0x1F, 0x9C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x78,
  0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0x78, 0x03, 0x01,
  0xE0, 0x7C, 0x1F, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x01, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0x81, 0xE0, 0x70, 0x38, 0x04, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1F, 0x00, 0xFF, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x80, 0xFC, 0x00,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3C, 0x00, 0x0C, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x3F, 0xFF, 0xC0, 0x20, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x1F,
  0xC0, 0x7F, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xE0, 0x01, 0x80,
  0x00, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xF0, 0xFF, 0xF3, 0xE1, 0xE7,
  0x81, 0xFE, 0x01, 0xF8, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFC,
  0x03, 0xC1, 0xE0, 0x70, 0x06, 0x0E, 0x00, 0x70, 0xC3, 0xC3, 0x18, 0x7F,
  0x33, 0x8E, 0x63, 0x31, 0xC6, 0x33, 0x18, 0x63, 0x63, 0x86, 0x36, 0x30,
  0x63, 0x63, 0x0C, 0x36, 0x70, 0xC3, 0xE7, 0x0C, 0x6C, 0x60, 0xC6, 0xC6,
  0x18, 0x6C, 0x73, 0xCC, 0xE7, 0xEF, 0x8E, 0x3C, 0xF0, 0x60, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0xB8, 0x00, 0x73, 0x80, 0x0F,
  0x38, 0x00, 0xE1, 0x80, 0x0E, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x1C, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xE0,
  0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0x80, 0x0E,
  0x78, 0x00, 0xEF, 0x00, 0x0F, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x00, 0xE1, 0xE0,
  0x0E, 0x1C, 0x01, 0xE1, 0xC0, 0x3C, 0x1C, 0x07, 0x81, 0xFF, 0xF0, 0x3F,
  0xFE, 0x03, 0xFF, 0xF0, 0x38, 0x07, 0x83, 0x80, 0x3C, 0x38, 0x01, 0xC3,
  0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x78,
  0x70, 0x0F, 0x07, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xC3, 0xC1, 0xE0, 0x3C, 0x38, 0x03,
  0x8F, 0x00, 0x79, 0xC0, 0x07, 0x78, 0x00, 0xEE, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x01, 0xCE, 0x00, 0x71,
  0xE0, 0x0E, 0x1C, 0x03, 0xC3, 0xC0, 0xF0, 0x3E, 0x7C, 0x03, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xF0, 0x0E, 0x3F, 0x80, 0xE0,
  0x3C, 0x0E, 0x01, 0xC1, 0xE0, 0x1E, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF3, 0xC0, 0x0E, 0x38, 0x00, 0xE3,
  0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1C,
  0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x87, 0x00, 0xF0, 0xF0, 0x3E,
  0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x7F,
  0xFF, 0x0F, 0xFF, 0xF0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xFF, 0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x3F, 0xC0, 0x1F, 0xFE, 0x07, 0xC3, 0xE1, 0xE0, 0x3C, 0x38, 0x03,
  0x8F, 0x00, 0x79, 0xC0, 0x07, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x1F, 0xF7, 0x03, 0xFE,
  0xE0, 0x7F, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39,
  0xE0, 0x0F, 0x1C, 0x01, 0xE3, 0xC0, 0x78, 0x3F, 0xFE, 0x03, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x0E, 0x00, 0x38, 0x70, 0x03, 0x83, 0x80, 0x1C, 0x3C,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80, 0x1C,
  0x1C, 0x00, 0xE1, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x7F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70, 0x01, 0xC3,
  0x80, 0x0E, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x00,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x07, 0xFF, 0xF0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0xE0, 0x07, 0x8E, 0x00, 0x78, 0xF0, 0x07, 0x07, 0x00, 0xF0,
  0x78, 0x1E, 0x03, 0xEF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0x00,
  0x7C, 0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xF0, 0x0E, 0x07, 0x80,
  0x38, 0x3E, 0x00, 0xE1, 0xF0, 0x07, 0x8F, 0x80, 0x1C, 0x7C, 0x00, 0x71,
  0xE0, 0x01, 0xCF, 0x00, 0x07, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xC0,
  0x03, 0xF7, 0x00, 0x0F, 0x9E, 0x00, 0x3C, 0x38, 0x00, 0xE0, 0xF0, 0x07,
  0x81, 0xC0, 0x1E, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x00,
  0xF0, 0x1C, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x1F, 0x03,
  0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x76, 0x1D, 0xC3, 0xB0, 0xEE, 0x1D,
  0x8E, 0xE0, 0xEE, 0x77, 0x0E, 0x77, 0x38, 0x73, 0xB9, 0xC3, 0x9F, 0x8E,
  0x1C, 0x7C, 0xF0, 0xE3, 0xC7, 0x07, 0x1E, 0x38, 0x78, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x30, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x78, 0x01, 0xC3,
  0xC0, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x07, 0x87, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x78, 0x78, 0x03, 0x83, 0xC0, 0x1C, 0x1F, 0x00, 0xE1, 0xF8, 0x07,
  0x0F, 0xC0, 0x78, 0x7F, 0x03, 0xC3, 0xB8, 0x1C, 0x1D, 0xC0, 0xE1, 0xEF,
  0x07, 0x0F, 0x38, 0x38, 0x71, 0xC3, 0xC3, 0x8F, 0x1E, 0x1C, 0x38, 0xE0,
  0xE1, 0xC7, 0x0F, 0x0F, 0x38, 0x78, 0x3B, 0xC3, 0x81, 0xDE, 0x1C, 0x0F,
  0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x78, 0x0F, 0xC3, 0xC0, 0x3E, 0x1C,
  0x01, 0xF0, 0xE0, 0x0F, 0x07, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x7F,
  0x80, 0x7F, 0xF0, 0x3E, 0x3E, 0x0E, 0x03, 0x87, 0x00, 0xF3, 0xC0, 0x1C,
  0xE0, 0x07, 0x78, 0x01, 0xDC, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x1E, 0xE0, 0x07, 0x3C, 0x03, 0xC7, 0x00, 0xE1,
  0xE0, 0x78, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x01, 0xC1, 0xF8, 0x1E, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x87,
  0x00, 0x3C, 0x38, 0x03, 0xC1, 0xC0, 0xFC, 0x0F, 0xFF, 0xC0, 0xFF, 0xF8,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x1F,
  0xFC, 0x07, 0xC7, 0xC1, 0xE0, 0x3C, 0x38, 0x03, 0x8F, 0x00, 0x71, 0xC0,
  0x0E, 0x78, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x7B, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x71, 0xC0, 0x0E, 0x1C, 0x03,
  0x83, 0xC0, 0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0x80, 0x07, 0xFF, 0x00, 0x7F,
  0xF8, 0x0F, 0x0F, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x0E,
  0x00, 0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x01, 0xE1,
  0xC0, 0x3C, 0x1C, 0x3F, 0x83, 0xFF, 0xF0, 0x3F, 0xFC, 0x03, 0x81, 0xC0,
  0x38, 0x1C, 0x03, 0x81, 0xE0, 0x38, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0F,
  0x07, 0x00, 0xF0, 0x70, 0x07, 0x07, 0x00, 0x70, 0x70, 0x07, 0x8F, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7C, 0x3E, 0x0F,
  0x01, 0xE0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC7, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0,
  0x78, 0x3F, 0xBF, 0x01, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0xF1, 0xC0, 0x0E, 0x1C, 0x00, 0xE3, 0xC0, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x38, 0x01,
  0xC7, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00,
  0x38, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0,
  0x07, 0x8E, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0x78, 0x1E, 0x03,
  0xEF, 0xC0, 0x3F, 0xF8, 0x00, 0xFE, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x7B,
  0x80, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x70, 0xE0, 0x1E, 0x1C, 0x03, 0xC3,
  0x80, 0x70, 0x70, 0x1E, 0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x3C, 0x1C, 0x03,
  0x87, 0x80, 0x70, 0xE0, 0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x38, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x70, 0x77,
  0x0F, 0x07, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xF0, 0xEE, 0x1F, 0x0E,
  0xE1, 0xF1, 0xCE, 0x3F, 0x1C, 0xE3, 0xF1, 0xCE, 0x37, 0x18, 0xE7, 0x73,
  0x8E, 0x77, 0x38, 0xE6, 0x33, 0x8E, 0xE3, 0x70, 0xEE, 0x37, 0x0E, 0xC3,
  0x70, 0xFC, 0x37, 0x0F, 0xC3, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3C, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E,
  0x03, 0x80, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x70, 0x1E, 0x01, 0xE0, 0x1C,
  0x07, 0x80, 0x3C, 0x1E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0xF0, 0x00, 0xF3,
  0xC0, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xDE, 0x00, 0x07, 0x9C, 0x00, 0x1E, 0x3C, 0x00, 0x78, 0x38, 0x00,
  0xF0, 0x70, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x78,
  0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xFE, 0x00, 0x79, 0xC0, 0x1E,
  0x38, 0x03, 0x87, 0x80, 0xF0, 0x70, 0x3C, 0x0E, 0x07, 0x01, 0xC1, 0xE0,
  0x1C, 0x38, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x0F, 0x70, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x87, 0xFF, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xE0, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xE0, 0xE0,
  0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07,
  0x07, 0x07, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0x00, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x07, 0xF0, 0x1D, 0xC0, 0xE7, 0x03, 0x9C, 0x1C, 0x30,
  0x70, 0xE3, 0x83, 0x9E, 0x0E, 0x70, 0x3B, 0xC0, 0x70, 0x7F, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC3, 0x8E, 0x1C, 0x01, 0xF0, 0x03, 0xFF,
  0x07, 0xFF, 0xC3, 0xC1, 0xE3, 0xC0, 0x71, 0xC0, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x03, 0xFF, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0x00, 0xEF, 0x00, 0xF7,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x3C, 0xF0, 0x3E, 0x7F, 0xFF, 0x1F, 0xFB,
  0x87, 0xF1, 0xC0, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x7C, 0x07,
  0xFF, 0xC1, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E, 0x03, 0xC7, 0x00, 0xF1, 0xC0,
  0x1C, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x0F,
  0x78, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x79, 0xE0, 0x1C, 0x7C, 0x0F, 0x1F,
  0xDF, 0x8F, 0xFF, 0xC3, 0x8F, 0xE0, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xC1, 0xE3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x1C, 0xE0, 0x1E, 0x78, 0x1E, 0x1F, 0x3E, 0x07, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xF1, 0xC0, 0xFF,
  0x78, 0x3F, 0xFF, 0x0F, 0x07, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x1E, 0x00,
  0xE3, 0x80, 0x3C, 0x70, 0x07, 0x9E, 0x00, 0xE3, 0xC0, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x71, 0xE0, 0x1E, 0x3C, 0x03, 0xC3, 0x80, 0x70, 0x78, 0x1E,
  0x0F, 0xDF, 0xC0, 0xFF, 0xB8, 0x0F, 0xE7, 0x00, 0x01, 0xF8, 0x03, 0xFE,
  0x03, 0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x08, 0x78, 0x0F, 0x1F, 0x1F, 0x07, 0xFF,
  0x01, 0xFE, 0x00, 0x00, 0x06, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0x00, 0xFC,
  0x60, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xF8, 0xE0, 0x7F, 0x9C, 0x1F, 0xFF, 0x87, 0x83, 0xE1, 0xE0, 0x3C,
  0x38, 0x03, 0x8F, 0x00, 0x71, 0xC0, 0x1E, 0x38, 0x03, 0xCF, 0x00, 0x71,
  0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xF0, 0x0F, 0x1E, 0x01, 0xE1,
  0xC0, 0x38, 0x3C, 0x0F, 0x07, 0xEF, 0xE0, 0x7F, 0xDC, 0x07, 0xF3, 0x80,
  0x00, 0xF0, 0x00, 0x1C, 0x10, 0x07, 0x83, 0x00, 0xE0, 0xF0, 0x7C, 0x0F,
  0xFF, 0x00, 0xFF, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x3E, 0x07, 0xBF, 0xC1, 0xDF, 0xF8, 0x7E, 0x1F, 0x1E, 0x03,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3,
  0x80, 0x38, 0xE0, 0x0E, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0,
  0x1E, 0x70, 0x07, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0x00, 0x18,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x02, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x07, 0xFE,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xC0, 0xFF, 0x00,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x01, 0xE3,
  0xC0, 0x78, 0x78, 0x1E, 0x0E, 0x07, 0x81, 0xC3, 0xE0, 0x38, 0xF8, 0x07,
  0x3E, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x1F,
  0x78, 0x07, 0xCF, 0x00, 0xF0, 0xF0, 0x1C, 0x0F, 0x03, 0x81, 0xE0, 0x70,
  0x1E, 0x0E, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x03, 0xC0, 0x0F, 0xFC, 0x0F,
  0xFC, 0x0F, 0xFC, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0xF1, 0xC0, 0xFF, 0xDF, 0x87, 0xFF,
  0xFC, 0x38, 0xF8, 0xE3, 0xC3, 0x87, 0x9C, 0x1C, 0x3C, 0xE0, 0xE1, 0xC7,
  0x0F, 0x0E, 0x38, 0x70, 0x71, 0xC3, 0x83, 0x9E, 0x1C, 0x1C, 0xE0, 0xE1,
  0xE7, 0x07, 0x0E, 0x38, 0x78, 0x71, 0xC3, 0x83, 0x8E, 0x1C, 0x1C, 0xE0,
  0xE0, 0xE7, 0x07, 0x0E, 0x38, 0x38, 0x71, 0xC3, 0xC3, 0x80, 0x0C, 0x3C,
  0x07, 0x3F, 0xC1, 0xDF, 0xF8, 0x7E, 0x1F, 0x1E, 0x03, 0xC7, 0x00, 0x73,
  0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0,
  0x0E, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x79, 0xC0, 0x1E, 0x70, 0x07,
  0x1C, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x1C, 0x01, 0xF0, 0x03, 0xFE, 0x03,
  0xFF, 0x83, 0xC1, 0xE3, 0xC0, 0x7B, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3B, 0x80, 0x3D, 0xE0, 0x1C, 0x78, 0x1E, 0x3E, 0x3E, 0x0F, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0x3E, 0x01, 0xDF, 0xF0, 0x3F, 0xFF, 0x07, 0xC1, 0xE0,
  0xF0, 0x1C, 0x1C, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0xF3, 0xC0, 0x1C, 0x78, 0x03, 0x8E,
  0x00, 0xF1, 0xE0, 0x1C, 0x3C, 0x07, 0x87, 0xE7, 0xE1, 0xFF, 0xF8, 0x3D,
  0xFE, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF1, 0xC1,
  0xFF, 0x70, 0xFF, 0xFC, 0x78, 0x3E, 0x3C, 0x07, 0x8E, 0x00, 0xE7, 0x80,
  0x39, 0xC0, 0x1E, 0x70, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1C,
  0xE0, 0x07, 0x3C, 0x03, 0xCF, 0x00, 0xF1, 0xC0, 0x38, 0x78, 0x1E, 0x1F,
  0x9F, 0x83, 0xFE, 0xE0, 0x7F, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x1C, 0x3F, 0x1C, 0xFF, 0x1D, 0xFF, 0x1F, 0xE3, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x03, 0xFF, 0xC3, 0xC1,
  0xF3, 0xC0, 0x79, 0xE0, 0x1C, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x3B, 0xC0, 0x1D,
  0xE0, 0x0E, 0x78, 0x0F, 0x3F, 0x3F, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFC, 0x38, 0x03, 0xBC, 0x01,
  0xDE, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39, 0xC0, 0x1D, 0xE0,
  0x0E, 0xF0, 0x0F, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7,
  0x00, 0xF3, 0x80, 0x79, 0xC0, 0x38, 0xF0, 0x7C, 0x7E, 0xFE, 0x1F, 0xF7,
  0x07, 0xF3, 0x80, 0xE0, 0x01, 0xFC, 0x00, 0xF7, 0x00, 0x39, 0xC0, 0x1E,
  0x70, 0x07, 0x1C, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x0E, 0x01, 0x87, 0x80, 0x71, 0xC0, 0x1C, 0xF0, 0x07, 0x38, 0x00, 0xDC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0xE0, 0x60, 0x7E, 0x06, 0x07, 0xE0, 0xF0, 0x7E, 0x0F, 0x0E, 0x60, 0xF0,
  0xE6, 0x1B, 0x0E, 0x61, 0xB1, 0xC6, 0x3B, 0x1C, 0x63, 0x31, 0x86, 0x73,
  0x38, 0x67, 0x33, 0x86, 0x63, 0x30, 0x6E, 0x37, 0x06, 0xC3, 0x60, 0x6C,
  0x36, 0x07, 0x83, 0xE0, 0x78, 0x3C, 0x07, 0x83, 0xC0, 0x70, 0x3C, 0x07,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x78, 0x07, 0x81, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x38, 0x3C, 0x01, 0xE3, 0xC0, 0x07, 0x3C, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xEE, 0x00, 0x1E, 0x38, 0x01, 0xE1, 0xE0, 0x1E, 0x07, 0x01, 0xE0,
  0x3C, 0x1E, 0x00, 0xE1, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x1E, 0x00,
  0x78, 0x3C, 0x00, 0xF0, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x38, 0x01, 0xC0, 0xF0, 0x03, 0x81, 0xC0, 0x07, 0x07, 0x00,
  0x0F, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0x39, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x7F, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x7C, 0x03, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x20, 0x07, 0x06, 0x0E, 0x0E, 0x0E,
  0x0E, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x18, 0x38, 0x38,
  0x38, 0x38, 0x30, 0x30, 0x70, 0x70, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0xC0, 0x02, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x7C, 0x01, 0xF8, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x01, 0xF0, 0x03, 0xC0, 0x06, 0x00, 0x00,
  0x02, 0x00, 0x00, 0xFE, 0x00, 0x8F, 0xF8, 0x0E, 0xFB, 0xE0, 0x77, 0x07,
  0xC7, 0x30, 0x1F, 0xF3, 0x80, 0x7F, 0x80, 0x00, 0xF0,
};

const GFXglyph RobotoMono_Italic37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 8, 26, 22, 7, -26 },
  { 27, 11, 9, 22, 7, -28 },
  { 40, 22, 26, 22, 0, -26 },
  { 112, 18, 35, 22, 2, -31 },
  { 191, 18, 27, 22, 2, -27 },
  { 252, 19, 27, 22, 1, -27 },
  { 317, 4, 9, 22, 10, -28 },
  { 322, 12, 38, 22, 6, -30 },
  { 379, 12, 39, 22, 3, -30 },
  { 438, 17, 17, 22, 4, -26 },
  { 475, 18, 19, 22, 2, -22 },
  { 518, 7, 10, 22, 3, -4 },
  { 527, 14, 3, 22, 4, -13 },
  { 533, 5, 5, 22, 7, -5 },
  { 537, 19, 28, 22, 2, -26 },
  { 604, 18, 27, 22, 2, -27 },
  { 665, 11, 26, 22, 5, -26 },
  { 701, 19, 27, 22, 0, -27 },
  { 766, 18, 27, 22, 1, -27 },
  { 827, 19, 26, 22, 0, -26 },
  { 889, 18, 26, 22, 3, -26 },
  { 948, 16, 26, 22, 2, -26 },
  { 1000, 19, 26, 22, 3, -26 },
  { 1062, 18, 27, 22, 2, -27 },
  { 1123, 16, 27, 22, 4, -27 },
  { 1177, 8, 21, 22, 8, -21 },
  { 1198, 10, 27, 22, 6, -21 },
  { 1232, 16, 16, 22, 3, -20 },
  { 1264, 18, 10, 22, 2, -17 },
  { 1287, 17, 17, 22, 2, -20 },
  { 1324, 15, 27, 22, 5, -27 },
  { 1375, 20, 26, 22, 1, -26 },
  { 1440, 20, 26, 22, -1, -26 },
  { 1505, 20, 26, 22, 1, -26 },
  { 1570, 19, 27, 22, 2, -27 },
  { 1635, 20, 26, 22, 1, -26 },
  { 1700, 20, 26, 22, 1, -26 },
  { 1765, 21, 26, 22, 1, -26 },
  { 1834, 19, 27, 22, 2, -27 },
  { 1899, 21, 26, 22, 1, -26 },
  { 1968, 20, 26, 22, 1, -26 },
  { 2033, 20, 26, 22, 1, -26 },
  { 2098, 22, 26, 22, 1, -26 },
  { 2170, 16, 26, 22, 2, -26 },
  { 2222, 21, 26, 22, 1, -26 },
  { 2291, 21, 26, 22, 1, -26 },
  { 2360, 18, 27, 22, 2, -27 },
  { 2421, 21, 26, 22, 1, -26 },
  { 2490, 19, 31, 22, 2, -27 },
  { 2564, 20, 26, 22, 1, -26 },
  { 2629, 20, 27, 22, 1, -27 },
  { 2697, 20, 26, 22, 3, -26 },
  { 2762, 20, 26, 22, 2, -26 },
  { 2827, 19, 26, 22, 4, -26 },
  { 2889, 20, 26, 22, 3, -26 },
  { 2954, 23, 26, 22, 0, -26 },
  { 3029, 19, 26, 22, 4, -26 },
  { 3091, 21, 26, 22, 0, -26 },
  { 3160, 12, 36, 22, 5, -30 },
  { 3214, 8, 28, 22, 7, -26 },
  { 3242, 12, 36, 22, 5, -30 },
  { 3296, 14, 14, 22, 4, -26 },
  { 3321, 17, 3, 22, 0, 0 },
  { 3328, 6, 5, 22, 10, -27 },
  { 3332, 17, 20, 22, 2, -20 },
  { 3375, 18, 28, 22, 1, -28 },
  { 3438, 17, 20, 22, 2, -20 },
  { 3481, 19, 28, 22, 2, -28 },
  { 3548, 17, 20, 22, 2, -20 },
  { 3591, 19, 29, 22, 4, -29 },
  { 3660, 19, 28, 22, 1, -20 },
  { 3727, 18, 28, 22, 1, -28 },
  { 3790, 16, 27, 22, 2, -27 },
  { 3844, 16, 35, 22, 1, -27 },
  { 3914, 19, 28, 22, 1, -28 },
  { 3981, 16, 28, 22, 2, -28 },
  { 4037, 21, 20, 22, 0, -20 },
  { 4090, 18, 20, 22, 1, -20 },
  { 4135, 17, 20, 22, 2, -20 },
  { 4178, 19, 28, 22, 0, -20 },
  { 4245, 18, 28, 22, 2, -20 },
  { 4308, 16, 20, 22, 4, -20 },
  { 4348, 17, 20, 22, 2, -20 },
  { 4391, 15, 24, 22, 4, -24 },
  { 4436, 17, 20, 22, 3, -20 },
  { 4479, 18, 20, 22, 3, -20 },
  { 4524, 20, 20, 22, 2, -20 },
  { 4574, 21, 20, 22, 0, -20 },
  { 4627, 23, 28, 22, -1, -20 },
  { 4708, 19, 20, 22, 1, -20 },
  { 4756, 14, 36, 22, 6, -29 },
  { 4819, 8, 33, 22, 7, -26 },
  { 4852, 15, 36, 22, 3, -29 },
  { 4920, 21, 8, 22, 0, -15 },
};

const GFXfont RobotoMono_Italic37pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic37pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _ROBOTOMONO_ITALIC37PT7B_H_
