#ifndef _ROBOTOMONO_ITALIC9PT7B_H_
#define _ROBOTOMONO_ITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x6A, 0x20, 0xF0, 0x2B, 0xCD, 0xF5, 0x50, 0x2D, 0x94, 0x29, 0xE4,
  0x8D, 0xE4, 0x6D, 0x70, 0x22, 0x94, 0x46, 0xC9, 0xE0, 0xC0, 0x29, 0x29,
  0x22, 0x40, 0x44, 0x92, 0x92, 0x80, 0x2F, 0x6A, 0x33, 0xE8, 0x40, 0xC0,
  0xE0, 0x80, 0x08, 0x84, 0x44, 0x22, 0x00, 0x69, 0x9F, 0x9A, 0xE0, 0xE4,
  0xA4, 0x80, 0x22, 0xC2, 0x22, 0x23, 0xC0, 0x32, 0x42, 0x61, 0x49, 0xC0,
  0x19, 0x94, 0xAF, 0x88, 0x78, 0xE1, 0x9E, 0x73, 0xDB, 0xC0, 0xF2, 0x24,
  0x48, 0x2D, 0x96, 0x99, 0xE0, 0xF9, 0x9F, 0x2C, 0x40, 0x80, 0x20, 0x05,
  0x80, 0x16, 0xC2, 0xFE, 0x41, 0x8F, 0x80, 0x2D, 0x12, 0x40, 0x40, 0x7B,
  0xF7, 0xBB, 0x30, 0x11, 0x94, 0xE9, 0x44, 0x7A, 0x5C, 0x98, 0xF8, 0x32,
  0x53, 0x08, 0x45, 0xC0, 0x7A, 0x52, 0x99, 0x70, 0x7A, 0x1C, 0x88, 0x78,
  0x7A, 0x1C, 0x84, 0x40, 0x13, 0x51, 0x09, 0xC5, 0xC0, 0x4A, 0x5F, 0x18,
  0xC8, 0x79, 0x08, 0x42, 0x78, 0x08, 0x42, 0x19, 0x38, 0x4D, 0x46, 0x18,
  0x92, 0x60, 0x44, 0x44, 0x4F, 0x4B, 0xDF, 0x58, 0xC8, 0x4B, 0x5B, 0x59,
  0x48, 0x13, 0x53, 0x18, 0xC5, 0xC0, 0x7A, 0x52, 0xE4, 0x40, 0x13, 0x53,
  0x18, 0xC5, 0xC2, 0x7A, 0x52, 0xE9, 0x48, 0x32, 0x50, 0x41, 0x45, 0xC0,
  0xFA, 0x10, 0x84, 0x20, 0x4A, 0x53, 0x19, 0x38, 0x9C, 0xA9, 0x44, 0x20,
  0xAF, 0xBD, 0x6A, 0x50, 0x4C, 0xC2, 0x0C, 0x52, 0x60, 0x9D, 0x18, 0x84,
  0x20, 0x78, 0x88, 0x44, 0x78, 0x69, 0x24, 0xA6, 0xAA, 0x94, 0x64, 0x92,
  0x96, 0x6E, 0x80, 0xF0, 0x90, 0x32, 0x5D, 0x27, 0x00, 0x42, 0x1C, 0x94,
  0xCB, 0xC0, 0x69, 0x8A, 0xE0, 0x11, 0x79, 0x9A, 0xE0, 0x32, 0x5F, 0x07,
  0x00, 0x3A, 0x3C, 0x84, 0x22, 0x00, 0x3A, 0x63, 0x27, 0x0B, 0x80, 0x42,
  0x1C, 0x94, 0xCA, 0x40, 0x10, 0x72, 0x22, 0xF0, 0x01, 0x31, 0x11, 0x22,
  0xC0, 0x42, 0x12, 0xE6, 0x52, 0x40, 0x71, 0x12, 0x22, 0xF0, 0x7D, 0x6B,
  0x5A, 0x80, 0x72, 0x53, 0x29, 0x00, 0x32, 0x63, 0x17, 0x00, 0x72, 0x53,
  0x2F, 0x42, 0x00, 0x79, 0x9A, 0xE2, 0x20, 0x74, 0x88, 0x80, 0x69, 0x62,
  0xE0, 0x4F, 0x44, 0x46, 0x99, 0x9A, 0xE0, 0x99, 0xAC, 0x40, 0xDD, 0xBA,
  0xA0, 0x4A, 0x88, 0xA9, 0x00, 0x4A, 0x54, 0xC2, 0x22, 0x00, 0x78, 0x88,
  0x8F, 0x00, 0x12, 0x24, 0xC4, 0x44, 0x20, 0x6A, 0xAA, 0x45, 0x12, 0x92,
  0x80, 0x45, 0xC0,
};

const GFXglyph RobotoMono_Italic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 6, 5, 2, -6 },
  { 3, 2, 2, 5, 2, -7 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 4, 8, 5, 1, -7 },
  { 12, 4, 7, 5, 1, -7 },
  { 16, 5, 7, 5, 0, -7 },
  { 21, 1, 2, 5, 2, -7 },
  { 22, 3, 9, 5, 1, -7 },
  { 26, 3, 9, 5, 1, -7 },
  { 30, 4, 4, 5, 1, -6 },
  { 32, 5, 4, 5, 0, -5 },
  { 35, 1, 2, 5, 1, -1 },
  { 36, 3, 1, 5, 1, -3 },
  { 37, 1, 1, 5, 2, -1 },
  { 38, 5, 7, 5, 0, -6 },
  { 43, 4, 7, 5, 1, -7 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 5, 7, 5, 0, -7 },
  { 55, 5, 7, 5, 0, -7 },
  { 60, 5, 6, 5, 0, -6 },
  { 64, 4, 6, 5, 1, -6 },
  { 67, 3, 6, 5, 1, -6 },
  { 70, 4, 6, 5, 1, -6 },
  { 73, 4, 7, 5, 1, -7 },
  { 77, 4, 6, 5, 1, -6 },
  { 80, 2, 5, 5, 2, -5 },
  { 82, 3, 6, 5, 1, -5 },
  { 85, 4, 4, 5, 1, -5 },
  { 87, 4, 2, 5, 1, -4 },
  { 88, 5, 4, 5, 0, -5 },
  { 91, 4, 7, 5, 1, -7 },
  { 95, 5, 6, 5, 0, -6 },
  { 99, 5, 6, 5, 0, -6 },
  { 103, 5, 6, 5, 0, -6 },
  { 107, 5, 7, 5, 0, -7 },
  { 112, 5, 6, 5, 0, -6 },
  { 116, 5, 6, 5, 0, -6 },
  { 120, 5, 6, 5, 0, -6 },
  { 124, 5, 7, 5, 0, -7 },
  { 129, 5, 6, 5, 0, -6 },
  { 133, 5, 6, 5, 0, -6 },
  { 137, 5, 6, 5, 0, -6 },
  { 141, 6, 6, 5, 0, -6 },
  { 146, 4, 6, 5, 0, -6 },
  { 149, 5, 6, 5, 0, -6 },
  { 153, 5, 6, 5, 0, -6 },
  { 157, 5, 7, 5, 0, -7 },
  { 162, 5, 6, 5, 0, -6 },
  { 166, 5, 8, 5, 0, -7 },
  { 171, 5, 6, 5, 0, -6 },
  { 175, 5, 7, 5, 0, -7 },
  { 180, 5, 6, 5, 1, -6 },
  { 184, 5, 6, 5, 0, -6 },
  { 188, 5, 6, 5, 1, -6 },
  { 192, 5, 6, 5, 1, -6 },
  { 196, 6, 6, 5, 0, -6 },
  { 201, 5, 6, 5, 1, -6 },
  { 205, 5, 6, 5, 0, -6 },
  { 209, 3, 8, 5, 1, -7 },
  { 212, 2, 7, 5, 2, -6 },
  { 214, 3, 8, 5, 1, -7 },
  { 217, 3, 3, 5, 1, -6 },
  { 219, 4, 1, 5, 0, 0 },
  { 220, 2, 2, 5, 2, -7 },
  { 221, 5, 5, 5, 0, -5 },
  { 225, 5, 7, 5, 0, -7 },
  { 230, 4, 5, 5, 1, -5 },
  { 233, 4, 7, 5, 1, -7 },
  { 237, 5, 5, 5, 0, -5 },
  { 241, 5, 7, 5, 1, -7 },
  { 246, 5, 7, 5, 0, -5 },
  { 251, 5, 7, 5, 0, -7 },
  { 256, 4, 7, 5, 0, -7 },
  { 260, 4, 9, 5, 0, -7 },
  { 265, 5, 7, 5, 0, -7 },
  { 270, 4, 7, 5, 0, -7 },
  { 274, 5, 5, 5, 0, -5 },
  { 278, 5, 5, 5, 0, -5 },
  { 282, 5, 5, 5, 0, -5 },
  { 286, 5, 7, 5, 0, -5 },
  { 291, 4, 7, 5, 1, -5 },
  { 295, 4, 5, 5, 1, -5 },
  { 298, 4, 5, 5, 1, -5 },
  { 301, 4, 6, 5, 1, -6 },
  { 304, 4, 5, 5, 1, -5 },
  { 307, 4, 5, 5, 1, -5 },
  { 310, 4, 5, 5, 1, -5 },
  { 313, 5, 5, 5, 0, -5 },
  { 317, 5, 7, 5, 0, -5 },
  { 322, 5, 5, 5, 0, -5 },
  { 326, 4, 9, 5, 1, -7 },
  { 331, 2, 8, 5, 2, -6 },
  { 333, 3, 9, 5, 1, -7 },
  { 337, 5, 2, 5, 0, -4 },
};

const GFXfont RobotoMono_Italic9pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic9pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _ROBOTOMONO_ITALIC9PT7B_H_
