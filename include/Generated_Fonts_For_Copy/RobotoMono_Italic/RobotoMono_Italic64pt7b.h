#ifndef _ROBOTOMONO_ITALIC64PT7B_H_
#define _ROBOTOMONO_ITALIC64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic64pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x7C,
  0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x00, 0x3E, 0x07,
  0xCF, 0x81, 0xF3, 0xE0, 0x78, 0xF0, 0x1E, 0x3C, 0x0F, 0x9F, 0x03, 0xE7,
  0xC0, 0xF9, 0xF0, 0x3C, 0x78, 0x0F, 0x1E, 0x03, 0xC7, 0x81, 0xF3, 0xE0,
  0x78, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00,
  0x78, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x1E, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x78, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x3F,
  0xE1, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1E, 0x03, 0xE0,
  0x18, 0x3C, 0x07, 0xC0, 0x7C, 0xF8, 0x0F, 0x80, 0xF1, 0xF0, 0x1F, 0x03,
  0xE3, 0xE0, 0x3E, 0x0F, 0x87, 0x80, 0x78, 0x3E, 0x0F, 0x80, 0xF0, 0x78,
  0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x1F, 0x0F, 0x00,
  0x7F, 0xFC, 0x3E, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x7F, 0xC1, 0xE0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0x00, 0x07,
  0xC3, 0xFF, 0x00, 0x0F, 0x1F, 0xFF, 0x00, 0x3E, 0x3F, 0x3F, 0x00, 0xF8,
  0xF8, 0x3E, 0x01, 0xE1, 0xE0, 0x3C, 0x07, 0xC7, 0xC0, 0x78, 0x1F, 0x0F,
  0x00, 0xF0, 0x3C, 0x1E, 0x01, 0xE0, 0xF8, 0x3C, 0x03, 0xC3, 0xE0, 0x78,
  0x07, 0x87, 0x80, 0xF0, 0x0F, 0x02, 0x01, 0xE0, 0x3E, 0x00, 0x03, 0xC0,
  0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x07,
  0xC3, 0xFC, 0xFC, 0x03, 0xE3, 0xF8, 0x7E, 0x01, 0xF3, 0xF8, 0x1F, 0x81,
  0xF9, 0xF8, 0x0F, 0xC0, 0xF9, 0xFC, 0x03, 0xF0, 0x7C, 0xFC, 0x01, 0xFC,
  0x7E, 0xFC, 0x00, 0x7E, 0x3E, 0x7E, 0x00, 0x3F, 0xBF, 0x3F, 0x00, 0x0F,
  0xFF, 0x1F, 0x80, 0x03, 0xFF, 0x0F, 0xC0, 0x01, 0xFF, 0x87, 0xE0, 0x00,
  0x7F, 0x83, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x3F, 0xF0, 0x1F, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xBF, 0x80, 0x7F, 0xFF, 0x0F, 0xC0, 0x1F, 0xFE, 0x07, 0xF0, 0x00,
  0x70, 0x00, 0x00, 0x1E, 0x7C, 0xF9, 0xF3, 0xE7, 0x8F, 0x3E, 0x7C, 0xF9,
  0xE3, 0xC7, 0x9F, 0x3E, 0x00, 0x00, 0x00, 0x18, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x60, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x60,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0x00, 0x3C, 0x00, 0x8E, 0x01, 0xE0, 0x3C, 0xFE, 0x0F, 0x07,
  0xE7, 0xFC, 0x79, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF9, 0xF0,
  0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0xFC, 0x07, 0xC0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xE0,
  0x07, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x10, 0x00, 0x80, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x1F, 0xC3, 0xF0, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E, 0x1F, 0xC3, 0xF0,
  0xFC, 0x1F, 0x87, 0xE0, 0x38, 0x02, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFD, 0xFE, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0xFF, 0x3F, 0x00, 0x07, 0xFE, 0x7E, 0x00, 0x1F, 0xFC,
  0xFC, 0x00, 0x7F, 0xF1, 0xF0, 0x03, 0xFF, 0xE3, 0xE0, 0x0F, 0xE7, 0xCF,
  0xC0, 0x7F, 0x9F, 0x9F, 0x81, 0xFC, 0x3F, 0x3F, 0x0F, 0xF0, 0x7E, 0x7E,
  0x3F, 0xC0, 0xF8, 0xF9, 0xFE, 0x01, 0xF1, 0xF7, 0xF8, 0x03, 0xE7, 0xFF,
  0xC0, 0x0F, 0xCF, 0xFF, 0x00, 0x1F, 0x9F, 0xF8, 0x00, 0x3F, 0x3F, 0xE0,
  0x00, 0x7C, 0x7F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x07, 0xE3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x1F,
  0x80, 0x1F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0x7F, 0xEF, 0xDF, 0xE1, 0xF3, 0xE0, 0x3E, 0x70, 0x07, 0xC8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x0C, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F,
  0xC0, 0x1F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0x9F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x02, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE1, 0xE0, 0x00, 0x03, 0xF7, 0xFF,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0x80,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80,
  0x0F, 0xF0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x03, 0xE0,
  0x01, 0xF1, 0xFF, 0xC0, 0x3F, 0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x87, 0xFF, 0x03, 0xFC, 0x7F, 0xC0, 0x0F, 0xC7, 0xF8, 0x00,
  0xFE, 0x7F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x1F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xE0,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0xC0,
  0x7F, 0x81, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x01, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x01, 0xFE,
  0x3F, 0x00, 0x7F, 0xE3, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x7C, 0x07, 0xFF, 0xCF, 0xC0, 0x3F, 0xF8, 0xF8, 0x00, 0x7C, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0x81, 0xFF,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0xFE, 0x0F, 0xF8, 0x3F,
  0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x02, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0x7E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0x80, 0x06, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF0, 0x1F, 0xE7, 0xF0, 0x03, 0xF9,
  0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0xFC, 0x0F, 0x03, 0xE0, 0x7F, 0xE0, 0xE0,
  0x78, 0x1F, 0xFE, 0x1C, 0x1E, 0x07, 0xFF, 0xC3, 0x83, 0xC1, 0xF0, 0x70,
  0x78, 0xF0, 0x7C, 0x0E, 0x0F, 0x1E, 0x0F, 0x01, 0xC1, 0xE7, 0x83, 0xC0,
  0x78, 0x3C, 0xF0, 0x78, 0x0E, 0x07, 0x9E, 0x1E, 0x01, 0xC0, 0xE7, 0x83,
  0xC0, 0x38, 0x1C, 0xF0, 0x78, 0x0F, 0x03, 0x9E, 0x1E, 0x01, 0xE0, 0x73,
  0xC3, 0xC0, 0x38, 0x0E, 0x70, 0x78, 0x0F, 0x03, 0xDE, 0x0F, 0x01, 0xE0,
  0x73, 0xC1, 0xE0, 0x3C, 0x0E, 0x78, 0x3C, 0x07, 0x01, 0xCF, 0x07, 0x81,
  0xE0, 0x71, 0xE0, 0xF0, 0x3C, 0x0E, 0x3C, 0x1E, 0x0F, 0x83, 0xC7, 0x83,
  0xE7, 0xF0, 0xF0, 0xF0, 0x7F, 0xEF, 0x3C, 0x1E, 0x0F, 0xF9, 0xFF, 0x83,
  0xC0, 0xFE, 0x3F, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x08, 0x00, 0x03, 0xF8, 0x07, 0x00, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x7C, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x1F, 0x00, 0x07, 0xF0, 0x07, 0xC0, 0x00,
  0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0xE0,
  0x1F, 0x00, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x1F, 0x81, 0xF0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8,
  0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0x83, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0xF8, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03,
  0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0x80, 0x03, 0xFC, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0x7C, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFC, 0x7C, 0x00, 0x7F, 0xFE, 0x7E, 0x00,
  0x3F, 0xFF, 0x3F, 0x00, 0x1F, 0xFF, 0x9F, 0x80, 0x1F, 0xFF, 0xCF, 0xC0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x07, 0xF0, 0x07, 0xFC, 0x3F, 0xF0, 0x03, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00,
  0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x7F, 0xE0, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F, 0x80,
  0xFF, 0x00, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00,
  0x07, 0xE1, 0xFE, 0x00, 0x00, 0x1F, 0x8F, 0xF0, 0x00, 0x00, 0x7C, 0x7F,
  0x80, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00,
  0x3F, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF7, 0xE0, 0x00, 0x01,
  0xFF, 0x9F, 0x80, 0x00, 0x07, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0xFC,
  0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F,
  0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x7F,
  0xC0, 0x3F, 0xE0, 0x07, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0xFB, 0xC0, 0x1F, 0xF8, 0x07, 0xDF, 0x01, 0xF7, 0xC0,
  0x3E, 0xF8, 0x0F, 0xBE, 0x01, 0xF7, 0xC0, 0xF9, 0xF0, 0x0F, 0xBE, 0x07,
  0xDF, 0x80, 0x7C, 0xF0, 0x7C, 0xF8, 0x07, 0xE7, 0x83, 0xE7, 0xC0, 0x3E,
  0x3C, 0x3E, 0x3E, 0x01, 0xF1, 0xF1, 0xF1, 0xF0, 0x0F, 0x8F, 0x9F, 0x1F,
  0x80, 0x7C, 0x7C, 0xF8, 0xFC, 0x07, 0xE3, 0xEF, 0x87, 0xC0, 0x3F, 0x1F,
  0x7C, 0x3E, 0x01, 0xF8, 0x7F, 0xC1, 0xF0, 0x0F, 0x83, 0xFE, 0x1F, 0x80,
  0x7C, 0x1F, 0xE0, 0xFC, 0x03, 0xE0, 0xFF, 0x07, 0xE0, 0x3F, 0x07, 0xF0,
  0x3E, 0x01, 0xF8, 0x3F, 0x81, 0xF0, 0x0F, 0xC1, 0xF8, 0x1F, 0x80, 0x7C,
  0x07, 0xC0, 0xFC, 0x03, 0xE0, 0x3C, 0x07, 0xE0, 0x1F, 0x01, 0xE0, 0x3E,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x00, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0xFF, 0x00, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xE0,
  0x00, 0x7C, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x00,
  0xFF, 0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x00, 0x0F, 0xC0, 0x3F, 0xFC, 0x00,
  0x7E, 0x01, 0xFF, 0xE0, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0x3F, 0x00, 0xFC,
  0xFC, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x7E,
  0x01, 0xF8, 0xFC, 0x03, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x00, 0xFC, 0x1F,
  0x01, 0xF8, 0x07, 0xE0, 0xF8, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x7E, 0x01,
  0xF8, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xE1,
  0xF8, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x7E, 0x01, 0xF8,
  0x07, 0xE3, 0xF0, 0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0xF8,
  0x03, 0xE0, 0x07, 0xEF, 0xC0, 0x3F, 0x00, 0x1F, 0x7E, 0x01, 0xF8, 0x00,
  0xFB, 0xF0, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xFC, 0x03,
  0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0x00, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x1F,
  0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x07, 0xFC, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFC,
  0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7C, 0xFC, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF0, 0x7E, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xF9, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x3F, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03,
  0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03,
  0xE0, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xF8, 0x1F, 0xE0, 0x07,
  0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3E, 0x03,
  0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x0F,
  0xFC, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x39, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x07,
  0xE0, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x01, 0xFC, 0x07, 0xC0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0xFF, 0x80, 0xFC, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xC0,
  0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0,
  0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x3E, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x01, 0xF8,
  0x1F, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7E,
  0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0,
  0x3E, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x3E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0x80, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xEF, 0xC0, 0x3F, 0x00, 0xFD,
  0xF8, 0x07, 0xE0, 0x1F, 0xBF, 0x00, 0xFC, 0x03, 0xE7, 0xE0, 0x3F, 0x80,
  0x7C, 0xF8, 0x07, 0xF0, 0x1F, 0x9F, 0x00, 0xFE, 0x03, 0xE3, 0xE0, 0x3F,
  0xC0, 0x7C, 0x7C, 0x07, 0xF8, 0x0F, 0x8F, 0x80, 0xFF, 0x03, 0xF1, 0xF0,
  0x3F, 0xE0, 0x7C, 0x3E, 0x07, 0xFC, 0x0F, 0x87, 0xC0, 0xF7, 0x81, 0xF0,
  0xF8, 0x3E, 0xF0, 0x7E, 0x1F, 0x07, 0xDE, 0x0F, 0x83, 0xE0, 0xF3, 0xC1,
  0xF0, 0x7C, 0x3E, 0x78, 0x3E, 0x0F, 0x87, 0xCF, 0x0F, 0x81, 0xF0, 0xF1,
  0xE1, 0xF0, 0x3E, 0x3E, 0x3C, 0x3E, 0x07, 0xC7, 0xC7, 0x8F, 0xC0, 0xF8,
  0xF0, 0xF1, 0xF0, 0x1F, 0x3E, 0x1E, 0x3E, 0x03, 0xC7, 0xC3, 0xC7, 0xC0,
  0xF8, 0xF0, 0x79, 0xF8, 0x1F, 0x3E, 0x0F, 0x3E, 0x03, 0xE7, 0xC1, 0xE7,
  0xC0, 0x7C, 0xF8, 0x3C, 0xF8, 0x0F, 0x9E, 0x07, 0xBE, 0x01, 0xF7, 0xC0,
  0xF7, 0xC0, 0x3E, 0xF8, 0x1E, 0xF8, 0x07, 0xDE, 0x03, 0xDF, 0x00, 0xFF,
  0xC0, 0x7F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xF9, 0xF0, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x1F, 0xC3, 0xE0,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x07, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xFD,
  0xF0, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03, 0xF0,
  0xF8, 0x03, 0xE0, 0x78, 0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80,
  0x7C, 0x1F, 0x80, 0x7C, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00,
  0x3E, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x0F, 0xF8, 0x1F, 0xC0,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x07,
  0xE3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x3F, 0xCF, 0xE0, 0x03, 0xFC, 0x3F, 0x80, 0x7F,
  0xE1, 0xFF, 0x9F, 0xFF, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xE7, 0xC0,
  0x7F, 0xFE, 0x3E, 0x01, 0xFF, 0xC1, 0xF8, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x7F, 0xE0, 0x01, 0xF3, 0xFF,
  0xE0, 0x07, 0xEF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x7F,
  0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x7F, 0x80, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x7F, 0x83, 0xFF, 0xC3,
  0xFE, 0x07, 0xDF, 0xFF, 0xF8, 0x1F, 0xBF, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF,
  0x80, 0x7C, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x3E, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x1F, 0xC0, 0xFF, 0x03,
  0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xC1, 0xF0, 0x01, 0xFF,
  0xF9, 0xF8, 0x01, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0x9F, 0xFF, 0x01, 0xFE, 0x01, 0xFF, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x7F, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x7C, 0x00, 0x3F, 0xFF, 0x3E, 0x00, 0x07, 0xFE,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xE0, 0x07, 0xFC, 0x7F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0x7E, 0x0F, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x07, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x08,
  0x0F, 0xC0, 0x00, 0x70, 0x3F, 0x80, 0x03, 0xE0, 0x7F, 0x00, 0x3F, 0xC1,
  0xFF, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFB, 0xF0, 0x00, 0x3F, 0xC0, 0x08, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x83, 0xF0, 0x01, 0xFF, 0xF8, 0xF8, 0x00, 0xFF,
  0xFF, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xF3, 0xFF, 0xE0, 0x1F,
  0xE0, 0x1F, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x87, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFD, 0xF0, 0x00, 0x7F, 0xFE, 0x7C, 0x00, 0x07, 0xFE,
  0x3F, 0x00, 0x00, 0x38, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x00, 0x3F, 0x00, 0x38,
  0x00, 0x1F, 0xC0, 0x1F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFF, 0x8F, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0xF0, 0x01, 0xF0, 0xFF, 0xF0, 0x07,
  0xE7, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xF0, 0x0F, 0xE0, 0x7F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03,
  0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x01,
  0x01, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0xFE,
  0x07, 0xC0, 0x01, 0xFE, 0x03, 0xE0, 0x01, 0xFE, 0x03, 0xF0, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x3E, 0x03, 0xFC, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0x1F, 0x83, 0xFC,
  0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x03, 0xE3, 0xF8,
  0x00, 0x01, 0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xF1, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xF8,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x07,
  0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xC7, 0xF0, 0x7F, 0x80, 0x7C, 0xFF, 0x8F,
  0xFC, 0x07, 0xDF, 0xFD, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x0F, 0xF0, 0x3E, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0xFC, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x7C, 0x03, 0xF0, 0xF8, 0x07, 0xC0,
  0x3E, 0x0F, 0x80, 0x7C, 0x03, 0xE1, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0x80,
  0xFC, 0x03, 0xE1, 0xF0, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0xF8, 0x07, 0xE1,
  0xF0, 0x0F, 0x80, 0x7C, 0x1F, 0x00, 0xF8, 0x07, 0xC3, 0xF0, 0x0F, 0x80,
  0x7C, 0x3F, 0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0xFC, 0x3E, 0x01,
  0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x0F, 0x87,
  0xE0, 0x3F, 0x00, 0xF8, 0x7E, 0x03, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x01,
  0xF8, 0x7C, 0x03, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x01, 0xF0, 0x7C, 0x03,
  0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x03, 0xE0, 0xFF, 0xC0, 0x07, 0xC7, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF,
  0xC0, 0x3E, 0x7F, 0xFF, 0xC0, 0x7D, 0xFD, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0x81, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xE0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xF0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xC3, 0xFE,
  0x01, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xF8,
  0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xF8, 0x3F,
  0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x7F,
  0xE0, 0x00, 0x7C, 0xFF, 0xF8, 0x00, 0x7E, 0xFF, 0xFE, 0x00, 0x3E, 0xFF,
  0xFF, 0x80, 0x1F, 0xFE, 0x7F, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x07, 0xF0,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x0F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF,
  0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0x80, 0x3F, 0x3F, 0xFF,
  0x80, 0x1F, 0x87, 0xFF, 0x00, 0x0F, 0xC0, 0x38, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0xFC, 0x03, 0xFF, 0xF1, 0xF0, 0x0F,
  0xFF, 0xF3, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0xC7, 0xFF, 0x83, 0xFC,
  0x01, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1,
  0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F, 0xE0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xEF, 0x80, 0x1F, 0xFF, 0x9F, 0x00, 0x0F,
  0xFC, 0x7E, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x02, 0x00, 0x3E, 0x07, 0xFF,
  0x07, 0xE1, 0xFF, 0xF0, 0x7E, 0x7F, 0xFF, 0x07, 0xCF, 0xFF, 0xE0, 0x7D,
  0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0xE0, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE3, 0xFF, 0x03, 0xF8, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE1, 0xF8, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0xFC,
  0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0xC7, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xE1, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xFE, 0x07, 0xF0,
  0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xF8, 0x0F, 0xFF, 0xFB, 0xE0, 0x0F, 0xFF,
  0xE7, 0xC0, 0x0F, 0xFF, 0x8F, 0x80, 0x0F, 0xFC, 0x1F, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x00, 0x7E, 0x7C, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0xC0, 0x1F, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xC1, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xFF, 0x00,
  0x3C, 0x00, 0xFB, 0xE0, 0x07, 0x80, 0x1F, 0x7C, 0x01, 0xF0, 0x03, 0xEF,
  0x80, 0x3E, 0x00, 0xF9, 0xF0, 0x0F, 0xE0, 0x1F, 0x3E, 0x01, 0xFC, 0x03,
  0xC7, 0xC0, 0x7F, 0x80, 0xF8, 0xF8, 0x0F, 0xF0, 0x1F, 0x1F, 0x01, 0xFE,
  0x07, 0xC3, 0xE0, 0x7B, 0xC0, 0xF8, 0x7C, 0x0F, 0x78, 0x1F, 0x07, 0x83,
  0xEF, 0x07, 0xC0, 0xF0, 0x79, 0xE0, 0xF8, 0x1E, 0x0F, 0x3C, 0x1E, 0x03,
  0xC3, 0xC7, 0x87, 0xC0, 0x78, 0x78, 0xF0, 0xF8, 0x0F, 0x1F, 0x1E, 0x1E,
  0x01, 0xE3, 0xC3, 0xC7, 0xC0, 0x3C, 0xF8, 0x78, 0xF0, 0x07, 0x9E, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0xF7, 0xC0, 0x1E, 0xF8, 0x1E, 0xF0, 0x03, 0xDE,
  0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x7F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x01,
  0xFE, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF0, 0x03,
  0xF0, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x00, 0x0F,
  0xDF, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x30, 0x7F, 0xFE, 0x00, 0x07, 0x8F, 0xFF, 0xE0, 0x00, 0xF3,
  0xFF, 0xFF, 0x00, 0x3E, 0xFE, 0x1F, 0xF0, 0x0F, 0x9F, 0x00, 0xFF, 0x03,
  0xF7, 0xC0, 0x0F, 0xFF, 0xFC, 0xF8, 0x00, 0xFF, 0xFF, 0x9E, 0x00, 0x07,
  0xFF, 0xE0, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00,
};

const GFXglyph RobotoMono_Italic64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 14, 46, 38, 12, -46 },
  { 82, 18, 15, 38, 13, -48 },
  { 116, 37, 46, 38, 1, -46 },
  { 329, 31, 60, 38, 4, -53 },
  { 562, 31, 47, 38, 4, -46 },
  { 745, 33, 47, 38, 2, -46 },
  { 939, 7, 15, 38, 17, -48 },
  { 953, 21, 66, 38, 10, -51 },
  { 1127, 21, 66, 38, 5, -51 },
  { 1301, 29, 31, 38, 7, -46 },
  { 1414, 31, 33, 38, 4, -38 },
  { 1542, 11, 18, 38, 6, -7 },
  { 1567, 24, 4, 38, 6, -22 },
  { 1579, 9, 9, 38, 12, -8 },
  { 1590, 32, 50, 38, 4, -46 },
  { 1790, 31, 47, 38, 4, -46 },
  { 1973, 19, 46, 38, 9, -46 },
  { 2083, 33, 46, 38, 0, -46 },
  { 2273, 32, 47, 38, 1, -46 },
  { 2461, 33, 46, 38, 1, -46 },
  { 2651, 33, 47, 38, 4, -46 },
  { 2845, 28, 47, 38, 4, -46 },
  { 3010, 31, 46, 38, 6, -46 },
  { 3189, 31, 47, 38, 4, -46 },
  { 3372, 28, 46, 38, 6, -46 },
  { 3533, 14, 36, 38, 14, -35 },
  { 3596, 17, 46, 38, 10, -35 },
  { 3694, 29, 29, 38, 5, -35 },
  { 3800, 30, 18, 38, 4, -29 },
  { 3868, 30, 28, 38, 3, -34 },
  { 3973, 26, 46, 38, 9, -46 },
  { 4123, 35, 46, 38, 2, -46 },
  { 4325, 33, 46, 38, -1, -46 },
  { 4515, 34, 46, 38, 2, -46 },
  { 4711, 33, 47, 38, 3, -46 },
  { 4905, 35, 46, 38, 1, -46 },
  { 5107, 35, 46, 38, 2, -46 },
  { 5309, 35, 46, 38, 3, -46 },
  { 5511, 33, 47, 38, 3, -46 },
  { 5705, 37, 46, 38, 1, -46 },
  { 5918, 35, 46, 38, 2, -46 },
  { 6120, 34, 47, 38, 2, -46 },
  { 6320, 38, 46, 38, 2, -46 },
  { 6539, 28, 46, 38, 3, -46 },
  { 6700, 37, 46, 38, 1, -46 },
  { 6913, 37, 46, 38, 1, -46 },
  { 7126, 32, 47, 38, 3, -46 },
  { 7314, 34, 46, 38, 3, -46 },
  { 7510, 33, 54, 38, 3, -46 },
  { 7733, 34, 46, 38, 2, -46 },
  { 7929, 33, 47, 38, 3, -46 },
  { 8123, 34, 46, 38, 6, -46 },
  { 8319, 35, 47, 38, 3, -46 },
  { 8525, 33, 46, 38, 6, -46 },
  { 8715, 35, 46, 38, 5, -46 },
  { 8917, 39, 46, 38, 0, -46 },
  { 9142, 33, 46, 38, 7, -46 },
  { 9332, 35, 46, 38, 1, -46 },
  { 9534, 22, 62, 38, 8, -52 },
  { 9705, 14, 50, 38, 12, -46 },
  { 9793, 22, 62, 38, 8, -52 },
  { 9964, 24, 25, 38, 7, -46 },
  { 10039, 28, 5, 38, 1, 0 },
  { 10057, 11, 8, 38, 17, -46 },
  { 10068, 29, 36, 38, 3, -35 },
  { 10199, 31, 49, 38, 2, -48 },
  { 10389, 29, 36, 38, 4, -35 },
  { 10520, 33, 49, 38, 4, -48 },
  { 10723, 30, 36, 38, 3, -35 },
  { 10858, 33, 49, 38, 6, -49 },
  { 11061, 34, 48, 38, 1, -35 },
  { 11265, 31, 48, 38, 2, -48 },
  { 11451, 28, 46, 38, 3, -46 },
  { 11612, 29, 60, 38, 1, -46 },
  { 11830, 33, 48, 38, 2, -48 },
  { 12028, 28, 48, 38, 3, -48 },
  { 12196, 36, 34, 38, 0, -34 },
  { 12349, 31, 34, 38, 2, -34 },
  { 12481, 31, 36, 38, 3, -35 },
  { 12621, 33, 47, 38, 0, -34 },
  { 12815, 31, 48, 38, 4, -35 },
  { 13001, 28, 35, 38, 7, -35 },
  { 13124, 29, 35, 38, 4, -34 },
  { 13251, 28, 43, 38, 6, -42 },
  { 13402, 31, 35, 38, 4, -34 },
  { 13538, 32, 34, 38, 5, -34 },
  { 13674, 35, 34, 38, 4, -34 },
  { 13823, 37, 34, 38, 0, -34 },
  { 13981, 39, 48, 38, -1, -34 },
  { 14215, 32, 34, 38, 2, -34 },
  { 14351, 25, 61, 38, 10, -50 },
  { 14542, 14, 58, 38, 11, -46 },
  { 14644, 25, 62, 38, 6, -50 },
  { 14838, 35, 13, 38, 1, -25 },
};

const GFXfont RobotoMono_Italic64pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic64pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic64pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _ROBOTOMONO_ITALIC64PT7B_H_
