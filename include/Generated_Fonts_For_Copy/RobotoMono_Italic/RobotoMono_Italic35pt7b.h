#ifndef _ROBOTOMONO_ITALIC35PT7B_H_
#define _ROBOTOMONO_ITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x78, 0xE1, 0xC3, 0x87, 0x0E, 0x3C, 0x70, 0xE1, 0xC3,
  0x87, 0x1E, 0x38, 0x70, 0x00, 0x00, 0x00, 0x08, 0x38, 0x70, 0xE0, 0x71,
  0xDC, 0x76, 0x19, 0x86, 0x61, 0xB8, 0xEE, 0x33, 0x0C, 0x00, 0x18, 0x70,
  0x01, 0xC3, 0x80, 0x0C, 0x18, 0x00, 0x61, 0xC0, 0x07, 0x0C, 0x00, 0x30,
  0x60, 0x01, 0x87, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0x80,
  0x70, 0xC0, 0x03, 0x0E, 0x00, 0x38, 0x70, 0x01, 0x83, 0x00, 0x0C, 0x38,
  0x00, 0xE1, 0x80, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x03, 0x86, 0x00, 0x18,
  0x30, 0x01, 0xC3, 0x80, 0x0E, 0x18, 0x00, 0x61, 0xC0, 0x07, 0x0E, 0x00,
  0x30, 0x60, 0x00, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x1F, 0xC0, 0x1F, 0xF0, 0x3F, 0xFC, 0x1E, 0x0E, 0x1E, 0x07, 0x8E, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1C, 0xF0, 0x0E, 0x38, 0x0F, 0x1F, 0xBF,
  0x07, 0xFF, 0x01, 0xFE, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1C, 0x60, 0x0C, 0x30, 0x4E, 0x18,
  0x77, 0x0C, 0x73, 0x86, 0x31, 0xC7, 0x38, 0x77, 0x38, 0x3F, 0x98, 0x07,
  0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x20, 0x0E, 0x7E,
  0x06, 0x77, 0x06, 0x71, 0xC7, 0x30, 0xE7, 0x18, 0x73, 0x0C, 0x38, 0x86,
  0x18, 0x03, 0x0C, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0xFF,
  0x00, 0x7D, 0xE0, 0x1C, 0x38, 0x0F, 0x07, 0x03, 0x83, 0x80, 0xE0, 0xE0,
  0x38, 0x78, 0x07, 0x3C, 0x01, 0xDE, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x03, 0xCE, 0x1D, 0xE3, 0xC7, 0x70, 0x71, 0xFC, 0x1E,
  0xEE, 0x03, 0xBB, 0x80, 0xFC, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x8F, 0xF0,
  0xFF, 0xDC, 0x1F, 0xC7, 0x80, 0x37, 0x77, 0x66, 0x6E, 0x00, 0x20, 0x1C,
  0x07, 0x81, 0xC0, 0x78, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x02, 0x00, 0x04,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x0E,
  0x03, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x38, 0x1E, 0x03, 0x80, 0x40,
  0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x61,
  0x86, 0xF9, 0x9E, 0xFF, 0xFF, 0x1F, 0xF8, 0x03, 0x80, 0x07, 0xC0, 0x0E,
  0xC0, 0x1C, 0xE0, 0x38, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x20, 0x20, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0x1E, 0x38, 0x70, 0xE3, 0xC7, 0x0E, 0x38, 0xF0,
  0x40, 0x7F, 0xFF, 0xFF, 0xE0, 0x27, 0xBF, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xFC,
  0x03, 0xFF, 0x03, 0xE7, 0xC3, 0xC0, 0xE1, 0xC0, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x78, 0x0F, 0xB8, 0x0F, 0xDC, 0x0F, 0xEE, 0x1E, 0x77,
  0x1E, 0x73, 0xBC, 0x3B, 0xFC, 0x1D, 0xFC, 0x0E, 0xF8, 0x07, 0x78, 0x07,
  0xB8, 0x03, 0x9C, 0x01, 0xC6, 0x01, 0xC3, 0x81, 0xE1, 0xF1, 0xE0, 0x7F,
  0xE0, 0x1F, 0xE0, 0x00, 0x00, 0x40, 0xF1, 0xFD, 0xFF, 0xFD, 0xF8, 0xE8,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7C, 0xF8, 0x3C, 0x0E, 0x1E, 0x03, 0xC7,
  0x00, 0x71, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x01, 0xFC, 0x03,
  0xFF, 0x03, 0xE7, 0xC3, 0xC0, 0xE1, 0xC0, 0x39, 0xE0, 0x1C, 0xE0, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x7F, 0x80, 0x3F,
  0x80, 0x1F, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x38,
  0x03, 0x9C, 0x01, 0xCE, 0x01, 0xE7, 0x81, 0xE1, 0xE1, 0xE0, 0x7F, 0xE0,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00, 0xE7, 0x00,
  0x71, 0xC0, 0x38, 0x70, 0x1E, 0x1C, 0x07, 0x07, 0x03, 0x83, 0xC1, 0xC0,
  0xE0, 0xE0, 0x38, 0x78, 0x0E, 0x1F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF8, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xCE, 0x00, 0xF1, 0x80, 0x38, 0x70, 0x0E, 0x1C,
  0x07, 0x03, 0xC7, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x00, 0x1C, 0x01,
  0xF8, 0x0F, 0xF0, 0x3E, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x77, 0xE1, 0xDF, 0xF3, 0xF1, 0xE7, 0x81, 0xEE, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xF7, 0x01,
  0xCE, 0x07, 0x8F, 0x3E, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF7, 0xC1, 0xE0, 0xF1, 0xE0,
  0x38, 0xE0, 0x1C, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x07, 0x8F, 0x03, 0x83,
  0xC7, 0x80, 0xFF, 0x80, 0x7F, 0x80, 0xFF, 0xE0, 0xF0, 0x78, 0xF0, 0x1C,
  0x70, 0x07, 0x78, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xCF, 0x00, 0xE3, 0x80,
  0xF1, 0xF1, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x0F, 0xF8,
  0x1F, 0x7C, 0x3C, 0x1E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x1E, 0x78, 0x7E,
  0x3F, 0xEE, 0x1F, 0xDC, 0x07, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xF0, 0x03, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0x7C, 0x00, 0x08, 0x3C,
  0xF9, 0xF1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10,
  0xF1, 0xF3, 0xC7, 0x80, 0x01, 0x00, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x07, 0x81, 0xC0, 0x70, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0xF0, 0x08,
  0x00, 0x00, 0x02, 0x00, 0x1C, 0x00, 0xF8, 0x0F, 0xF0, 0x7F, 0x03, 0xF8,
  0x3F, 0x80, 0x7C, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x00, 0x06, 0x00, 0x04, 0x3F, 0xFF, 0x9F, 0xFF, 0x9F,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0xFF, 0xFE, 0x7F, 0xFF, 0x00, 0x20, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x3F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x80,
  0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0xBC, 0x0F, 0xE0, 0x1F, 0x80, 0x70,
  0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xE0, 0x0F, 0x1E, 0x03, 0x80, 0xE0, 0xE0, 0x0C, 0x38, 0x70, 0xC6,
  0x3F, 0x99, 0x8F, 0x33, 0x31, 0x8C, 0x6E, 0x61, 0x8D, 0x8C, 0x31, 0xB3,
  0x86, 0x36, 0x61, 0x87, 0x8C, 0x30, 0xB1, 0x86, 0x36, 0x30, 0xC6, 0xC6,
  0x38, 0x98, 0xFF, 0x73, 0x1F, 0x7C, 0x30, 0x82, 0x06, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x0C, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x73, 0x00, 0x1C, 0x60, 0x03, 0x8E, 0x00,
  0xE1, 0xC0, 0x1C, 0x38, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x07,
  0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0x0E, 0x00, 0xE1, 0xC0, 0x1C, 0x70,
  0x03, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01, 0xE0, 0x0F, 0xF8, 0x03,
  0xFF, 0xC0, 0xFF, 0xF8, 0x38, 0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x71, 0xC0,
  0x1C, 0x70, 0x07, 0x1C, 0x03, 0xC7, 0x00, 0xE1, 0xC1, 0xF0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0E, 0x07, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x9C,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E, 0x70, 0x07, 0x1C, 0x07, 0xC7, 0xFF,
  0xE3, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xF8,
  0xF0, 0x78, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x1D, 0xC0, 0x07,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xCE, 0x00,
  0x73, 0x80, 0x38, 0xE0, 0x0E, 0x1C, 0x07, 0x07, 0xC7, 0x80, 0xFF, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFC, 0x07, 0x07,
  0xC1, 0xC0, 0x38, 0x38, 0x07, 0x87, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x01,
  0xC7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03,
  0x8E, 0x00, 0x73, 0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x1C,
  0x38, 0x07, 0x87, 0x01, 0xE1, 0xE0, 0x78, 0x3F, 0xFE, 0x07, 0xFF, 0x80,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0x7F, 0xFC,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xF0,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF0, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFD,
  0xF0, 0x78, 0x1E, 0x1C, 0x03, 0x8E, 0x00, 0xF3, 0x80, 0x1D, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x1F, 0xEE, 0x07, 0xFB, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x1C, 0xF0, 0x07, 0x1E, 0x03, 0x83, 0xE7, 0xE0, 0xFF, 0xE0,
  0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x1C, 0x00, 0xE1, 0xC0,
  0x0E, 0x1C, 0x00, 0xE1, 0xC0, 0x0E, 0x1C, 0x00, 0xC1, 0x80, 0x1C, 0x38,
  0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0x83,
  0xFF, 0xF8, 0x70, 0x03, 0x87, 0x00, 0x38, 0x70, 0x03, 0x87, 0x00, 0x38,
  0x70, 0x07, 0x06, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0xE0, 0x0E, 0x00, 0x0F, 0xFF, 0xE1, 0xFF, 0xFC, 0x3F,
  0xFF, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x1F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x01, 0xE0, 0xE0, 0x78, 0x1F, 0x3F,
  0x01, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0xF8, 0x70, 0x0F, 0x03,
  0x80, 0x78, 0x1C, 0x07, 0x80, 0xE0, 0x78, 0x0F, 0x07, 0x80, 0x70, 0x78,
  0x03, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xE7, 0x80, 0x07, 0x78, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0x8E, 0x00,
  0x38, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0F, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x3C, 0x1C, 0x00, 0xE0, 0xE0, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFE, 0x0F, 0x00, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE1, 0xF0, 0x3E,
  0x1F, 0x03, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xE1, 0xF8, 0xEE, 0x1B, 0x8D,
  0xC3, 0x99, 0xDC, 0x39, 0x99, 0xC3, 0x9B, 0x9C, 0x39, 0xF1, 0xC3, 0x9F,
  0x38, 0x71, 0xE3, 0x87, 0x1E, 0x38, 0x70, 0xC3, 0x87, 0x0C, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E,
  0x00, 0x70, 0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x1F, 0x00,
  0xE1, 0xF0, 0x0E, 0x1F, 0x00, 0xE1, 0xF8, 0x1E, 0x1F, 0x81, 0xC1, 0xF8,
  0x1C, 0x3D, 0xC1, 0xC3, 0x9C, 0x1C, 0x39, 0xC1, 0xC3, 0x8E, 0x3C, 0x38,
  0xE3, 0x83, 0x8E, 0x38, 0x78, 0x73, 0x87, 0x07, 0x38, 0x70, 0x73, 0x87,
  0x03, 0xF8, 0x70, 0x3F, 0x07, 0x03, 0xF0, 0xF0, 0x1F, 0x0E, 0x01, 0xF0,
  0xE0, 0x1F, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x00, 0x01, 0xF8, 0x03, 0xFF,
  0x03, 0xFF, 0xC3, 0xC0, 0xE1, 0xC0, 0x79, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0,
  0x07, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03,
  0x9C, 0x01, 0xCF, 0x01, 0xC3, 0x81, 0xE1, 0xFB, 0xE0, 0x7F, 0xE0, 0x0F,
  0xC0, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0xF0, 0x3F, 0xFF, 0x07, 0x00, 0xE0,
  0xE0, 0x0E, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3,
  0x80, 0x3C, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xFF, 0xF8, 0x7F, 0xFE, 0x0F,
  0xFF, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x1C, 0x1C,
  0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0xDC, 0x00,
  0xFE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0,
  0x1E, 0x1C, 0x0F, 0x07, 0xEF, 0x80, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0C, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xE0, 0x3F, 0xFE, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x80,
  0x78, 0xE0, 0x0F, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0F, 0x0E, 0x03,
  0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xC1, 0xC0, 0x38, 0x3C,
  0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0F, 0x07, 0x00, 0xE0, 0xE0, 0x1C,
  0x1C, 0x03, 0x87, 0x80, 0x78, 0xE0, 0x07, 0x00, 0x00, 0xFE, 0x00, 0x7F,
  0xE0, 0x1F, 0xBE, 0x07, 0x81, 0xE1, 0xE0, 0x1C, 0x38, 0x03, 0xC7, 0x00,
  0x38, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x73, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x1E,
  0x0F, 0xCF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xE3, 0x80,
  0x38, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0xF1, 0xC0, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x38, 0x01,
  0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x07, 0x0F, 0x01, 0xE0, 0xE0, 0x78,
  0x1F, 0x3E, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0xF0, 0x01, 0xDC, 0x00,
  0xF7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x80, 0xE0,
  0xE0, 0x38, 0x38, 0x1E, 0x0E, 0x07, 0x03, 0x83, 0xC0, 0xE0, 0xE0, 0x38,
  0x38, 0x06, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x70,
  0x01, 0xDC, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x87,
  0x70, 0xF0, 0xEE, 0x1E, 0x1D, 0xC3, 0xC3, 0x38, 0xF8, 0xE7, 0x1B, 0x1C,
  0xE3, 0x63, 0x9C, 0xEC, 0x63, 0x99, 0x9C, 0x73, 0x33, 0x8E, 0xE6, 0x71,
  0xD8, 0xDC, 0x3B, 0x1B, 0x87, 0xE3, 0x70, 0xF8, 0x6C, 0x1B, 0x0F, 0x83,
  0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x03, 0xC0, 0xE0, 0x70, 0x00, 0x0F, 0x00, 0x7C, 0x1C, 0x01, 0xE0, 0x70,
  0x0F, 0x01, 0xE0, 0x78, 0x03, 0x81, 0xC0, 0x0E, 0x0F, 0x00, 0x1C, 0x78,
  0x00, 0x71, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x77,
  0x00, 0x03, 0x9C, 0x00, 0x1E, 0x78, 0x00, 0xF0, 0xE0, 0x03, 0x83, 0x80,
  0x1E, 0x07, 0x00, 0xF0, 0x1C, 0x03, 0x80, 0x78, 0x1E, 0x00, 0xE0, 0xF0,
  0x03, 0xC0, 0xE0, 0x03, 0xF8, 0x01, 0xEF, 0x00, 0xF1, 0xC0, 0x38, 0x70,
  0x1E, 0x1C, 0x07, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x38, 0x70, 0x06, 0x38,
  0x01, 0xCE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0x87, 0xFF, 0xF8, 0xFF,
  0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xF0, 0xFC, 0x00,
  0xE0, 0x60, 0x70, 0x70, 0x70, 0x70, 0x30, 0x38, 0x38, 0x38, 0x38, 0x18,
  0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x0E, 0x06, 0x07, 0x07,
  0x07, 0x07, 0x03, 0x07, 0xF0, 0x7F, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x60,
  0x0E, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xC0,
  0x7E, 0x07, 0x70, 0x3B, 0x83, 0x8C, 0x1C, 0x71, 0xC3, 0x8E, 0x1C, 0xE0,
  0x6F, 0x03, 0x80, 0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0xE3, 0x87,
  0x01, 0xE0, 0x0F, 0xFC, 0x1F, 0xFE, 0x3C, 0x1E, 0x38, 0x0F, 0x38, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x0F, 0xFE, 0x3F, 0xFE, 0x7C, 0x0E, 0xF0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x7C, 0xF9, 0xFC, 0x7F, 0xDC,
  0x3F, 0x9C, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0xF0, 0x1D, 0xFE, 0x0F, 0xFF, 0x87,
  0xC3, 0xC3, 0x80, 0xF3, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07,
  0x38, 0x03, 0x9C, 0x01, 0xDE, 0x01, 0xEE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x79, 0xE0, 0x78, 0xFC, 0xF8, 0xEF, 0xF8, 0x73, 0xF8, 0x00, 0x01, 0xF0,
  0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x38, 0x07, 0x78, 0x07, 0x70, 0x07,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x7C, 0x7C, 0x3F, 0xF0, 0x0F, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x0F, 0x8E, 0x0F, 0xFB, 0x87, 0xFF, 0xE3, 0xE1,
  0xF0, 0xE0, 0x3C, 0x78, 0x07, 0x1C, 0x01, 0xC7, 0x00, 0x73, 0x80, 0x3C,
  0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x3C,
  0x07, 0x07, 0x03, 0xC1, 0xF3, 0xF0, 0x3F, 0xFC, 0x07, 0xE7, 0x00, 0x01,
  0xF0, 0x07, 0xFC, 0x0F, 0xFE, 0x1E, 0x0E, 0x3C, 0x07, 0x78, 0x07, 0x70,
  0x07, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x08, 0x70, 0x1E, 0x7C, 0x7C, 0x3F, 0xF8, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xFC, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xCF,
  0xFF, 0xF0, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0x70, 0xFF, 0xFC, 0x7C, 0x3E, 0x1C,
  0x07, 0x8F, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x70, 0x07, 0x9C, 0x01,
  0xC7, 0x00, 0x71, 0xC0, 0x1C, 0x70, 0x07, 0x1C, 0x01, 0xC7, 0x80, 0xF0,
  0xE0, 0x78, 0x3E, 0x7E, 0x07, 0xFF, 0x80, 0xFC, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x10, 0x07, 0x0E, 0x03, 0x83, 0xE3, 0xE0, 0x7F, 0xF0, 0x07, 0xF0,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x38, 0x78, 0x1C, 0xFE, 0x0F, 0xFF, 0x87, 0xC1,
  0xE3, 0xC0, 0xF3, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x38,
  0x07, 0x9C, 0x03, 0x9E, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x39,
  0xC0, 0x3C, 0xE0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x00, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x3F, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x07,
  0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0xF8, 0x3F, 0xE0, 0x7F, 0x00, 0x10, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x01, 0x1C, 0x07, 0x87, 0x03, 0xC1, 0xC1, 0xE0, 0x70,
  0xF0, 0x3C, 0xF8, 0x0E, 0x7C, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF8, 0x07, 0xCE, 0x01, 0xE3, 0xC0, 0x70, 0x78, 0x1C, 0x0E, 0x07,
  0x03, 0xC1, 0xC0, 0x70, 0xF0, 0x1E, 0x38, 0x03, 0xC0, 0x0F, 0xF8, 0x1F,
  0xF0, 0x3F, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0xE3,
  0x81, 0xFF, 0x7E, 0x1F, 0xFF, 0xE3, 0xC7, 0x8E, 0x38, 0x70, 0xE3, 0x87,
  0x0E, 0x38, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0xE7, 0x07, 0x0E, 0x70,
  0xE0, 0xE7, 0x0E, 0x1C, 0x70, 0xE1, 0xC7, 0x0E, 0x1C, 0x60, 0xE1, 0xCE,
  0x0C, 0x1C, 0xE1, 0xC1, 0xCE, 0x1C, 0x38, 0xE1, 0xC3, 0x80, 0x14, 0x7C,
  0x0E, 0xFF, 0x07, 0xFF, 0xC3, 0xE0, 0xF1, 0xE0, 0x79, 0xE0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x38, 0x03, 0x9C, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xE7,
  0x00, 0x73, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x1C, 0x70, 0x0E, 0x70, 0x07,
  0x38, 0x03, 0x80, 0x01, 0xE0, 0x07, 0xF8, 0x1F, 0xFC, 0x3C, 0x1E, 0x38,
  0x0F, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0x70, 0x3C, 0x78,
  0x78, 0x3F, 0xF0, 0x1F, 0xE0, 0x0A, 0x3C, 0x03, 0xBF, 0xC0, 0xFF, 0xF8,
  0x3E, 0x1E, 0x0E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x1C, 0x70, 0x07, 0x1C,
  0x01, 0xC7, 0x00, 0x71, 0xC0, 0x1C, 0xE0, 0x0F, 0x38, 0x03, 0x8E, 0x00,
  0xE3, 0x80, 0x78, 0xF0, 0x3C, 0x3E, 0x3E, 0x1F, 0xFF, 0x07, 0x3F, 0x81,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x00, 0x03, 0xE0, 0x07, 0xFD, 0xC7, 0xFF, 0xE7, 0xC1,
  0xE3, 0x80, 0x73, 0xC0, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0xE0, 0x0F, 0x70,
  0x07, 0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0xC0, 0x70,
  0xE0, 0x78, 0x7C, 0xFC, 0x1F, 0xFE, 0x07, 0xE7, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x00, 0x7E, 0x3B, 0xFC, 0x6F, 0xF9, 0xFC, 0x23, 0xE0, 0x07, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x01, 0xF0, 0x07, 0xFC, 0x1F, 0xFE, 0x1E, 0x0F, 0x3C, 0x07, 0x38, 0x07,
  0x38, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x3E,
  0x00, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x1E, 0x7C, 0x7C, 0x3F, 0xF8,
  0x1F, 0xF0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x0F,
  0xFF, 0xFF, 0xFF, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xF9, 0x81, 0xFF, 0x01, 0xFE, 0x00, 0x3C, 0x03,
  0x9C, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0x80, 0x73, 0xC0, 0x39, 0xC0,
  0x1C, 0xE0, 0x1E, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x03, 0x9E, 0x01, 0xCF,
  0x00, 0xE3, 0x80, 0xF1, 0xC0, 0xF0, 0xF1, 0xF8, 0x3F, 0xDC, 0x0F, 0xCE,
  0x00, 0xE0, 0x00, 0x70, 0x03, 0xF8, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE3,
  0x80, 0xE1, 0xC0, 0x70, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x38, 0x0E, 0x1C,
  0x03, 0x1C, 0x01, 0xCC, 0x00, 0xEE, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1B, 0x87,
  0x87, 0x70, 0xF0, 0xEE, 0x1E, 0x19, 0xC6, 0xC7, 0x38, 0xD8, 0xE3, 0x3B,
  0x18, 0x66, 0x67, 0x0D, 0xCC, 0xC1, 0xB1, 0x98, 0x36, 0x37, 0x07, 0xC6,
  0xC0, 0xF0, 0xD8, 0x1E, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x06,
  0x00, 0x1E, 0x01, 0xF0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0x38, 0x78, 0x03,
  0x8F, 0x00, 0x1D, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0x9C, 0x00, 0xF1, 0xE0,
  0x1E, 0x0E, 0x03, 0xC0, 0xF0, 0x78, 0x07, 0x0F, 0x00, 0x38, 0x1C, 0x00,
  0x78, 0xE0, 0x07, 0x87, 0x80, 0x78, 0x1C, 0x03, 0x80, 0xE0, 0x3C, 0x07,
  0x01, 0xC0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00, 0x38, 0x70,
  0x00, 0xE7, 0x00, 0x07, 0x78, 0x00, 0x3B, 0x80, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x00, 0xF8, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC7, 0xFF, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xFF, 0xFC, 0xFF, 0xFF, 0x3F, 0xFF, 0x80,
  0x00, 0x1C, 0x01, 0xF0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x07,
  0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x1C,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70,
  0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3F, 0x00, 0x3C,
  0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0,
  0x3E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x03, 0x3F, 0xE0, 0x77,
  0x0F, 0x0E, 0x60, 0x7F, 0xEE, 0x03, 0xFC, 0x00, 0x0F, 0x80,
};

const GFXglyph RobotoMono_Italic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 7, 25, 21, 7, -25 },
  { 23, 10, 8, 21, 7, -26 },
  { 33, 21, 25, 21, 0, -25 },
  { 99, 17, 33, 21, 2, -29 },
  { 170, 17, 25, 21, 2, -25 },
  { 224, 18, 25, 21, 1, -25 },
  { 281, 4, 8, 21, 9, -26 },
  { 285, 11, 36, 21, 6, -28 },
  { 335, 11, 36, 21, 3, -28 },
  { 385, 16, 17, 21, 4, -25 },
  { 419, 17, 19, 21, 2, -21 },
  { 460, 7, 10, 21, 3, -4 },
  { 469, 14, 2, 21, 3, -12 },
  { 473, 5, 5, 21, 7, -5 },
  { 477, 18, 27, 21, 2, -25 },
  { 538, 17, 25, 21, 2, -25 },
  { 592, 10, 25, 21, 5, -25 },
  { 624, 18, 25, 21, 0, -25 },
  { 681, 17, 25, 21, 1, -25 },
  { 735, 18, 25, 21, 0, -25 },
  { 792, 18, 25, 21, 2, -25 },
  { 849, 15, 25, 21, 2, -25 },
  { 896, 17, 25, 21, 3, -25 },
  { 950, 17, 25, 21, 2, -25 },
  { 1004, 16, 25, 21, 3, -25 },
  { 1054, 7, 20, 21, 8, -20 },
  { 1072, 10, 26, 21, 5, -20 },
  { 1105, 15, 16, 21, 3, -19 },
  { 1135, 17, 10, 21, 2, -16 },
  { 1157, 16, 16, 21, 2, -19 },
  { 1189, 14, 25, 21, 5, -25 },
  { 1233, 19, 25, 21, 1, -25 },
  { 1293, 19, 25, 21, -1, -25 },
  { 1353, 18, 25, 21, 1, -25 },
  { 1410, 18, 25, 21, 2, -25 },
  { 1467, 19, 25, 21, 1, -25 },
  { 1527, 19, 25, 21, 1, -25 },
  { 1587, 20, 25, 21, 1, -25 },
  { 1650, 18, 25, 21, 2, -25 },
  { 1707, 20, 25, 21, 1, -25 },
  { 1770, 19, 25, 21, 1, -25 },
  { 1830, 19, 25, 21, 1, -25 },
  { 1890, 21, 25, 21, 1, -25 },
  { 1956, 16, 25, 21, 1, -25 },
  { 2006, 20, 25, 21, 1, -25 },
  { 2069, 20, 25, 21, 1, -25 },
  { 2132, 17, 25, 21, 2, -25 },
  { 2186, 19, 25, 21, 1, -25 },
  { 2246, 18, 29, 21, 2, -25 },
  { 2312, 19, 25, 21, 1, -25 },
  { 2372, 19, 25, 21, 1, -25 },
  { 2432, 19, 25, 21, 3, -25 },
  { 2492, 19, 25, 21, 2, -25 },
  { 2552, 18, 25, 21, 3, -25 },
  { 2609, 19, 25, 21, 3, -25 },
  { 2669, 22, 25, 21, 0, -25 },
  { 2738, 18, 25, 21, 4, -25 },
  { 2795, 20, 25, 21, 0, -25 },
  { 2858, 11, 33, 21, 5, -28 },
  { 2904, 8, 27, 21, 6, -25 },
  { 2931, 12, 33, 21, 4, -28 },
  { 2981, 13, 13, 21, 4, -25 },
  { 3003, 16, 3, 21, 0, 0 },
  { 3009, 6, 4, 21, 9, -25 },
  { 3012, 16, 19, 21, 2, -19 },
  { 3050, 17, 26, 21, 1, -26 },
  { 3106, 16, 19, 21, 2, -19 },
  { 3144, 18, 26, 21, 2, -26 },
  { 3203, 16, 19, 21, 2, -19 },
  { 3241, 18, 27, 21, 3, -27 },
  { 3302, 18, 26, 21, 1, -19 },
  { 3361, 17, 26, 21, 1, -26 },
  { 3417, 15, 25, 21, 2, -25 },
  { 3464, 15, 33, 21, 1, -25 },
  { 3526, 18, 26, 21, 1, -26 },
  { 3585, 15, 26, 21, 2, -26 },
  { 3634, 20, 19, 21, 0, -19 },
  { 3682, 17, 19, 21, 1, -19 },
  { 3723, 16, 19, 21, 2, -19 },
  { 3761, 18, 26, 21, 0, -19 },
  { 3820, 17, 26, 21, 2, -19 },
  { 3876, 15, 19, 21, 4, -19 },
  { 3912, 16, 19, 21, 2, -19 },
  { 3950, 15, 23, 21, 3, -23 },
  { 3994, 17, 18, 21, 2, -18 },
  { 4033, 17, 19, 21, 3, -19 },
  { 4074, 19, 18, 21, 2, -18 },
  { 4117, 20, 18, 21, 0, -18 },
  { 4162, 21, 26, 21, 0, -18 },
  { 4231, 18, 18, 21, 1, -18 },
  { 4272, 14, 33, 21, 5, -27 },
  { 4330, 8, 32, 21, 6, -25 },
  { 4362, 14, 33, 21, 3, -27 },
  { 4420, 20, 7, 21, 0, -14 },
};

const GFXfont RobotoMono_Italic35pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic35pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic35pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _ROBOTOMONO_ITALIC35PT7B_H_
