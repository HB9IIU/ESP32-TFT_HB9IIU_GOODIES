#ifndef _ROBOTOMONO_ITALIC22PT7B_H_
#define _ROBOTOMONO_ITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xCC, 0x63, 0x18, 0xC6, 0x63, 0x18, 0x00, 0x03, 0x98, 0x66,
  0xC9, 0x12, 0x24, 0xD9, 0x80, 0x01, 0x18, 0x18, 0x80, 0xCC, 0x04, 0x40,
  0x62, 0x1F, 0xFC, 0x11, 0x01, 0x98, 0x08, 0xC0, 0xC4, 0x3F, 0xF9, 0xFF,
  0xC3, 0x10, 0x19, 0x80, 0x88, 0x0C, 0xC0, 0x01, 0x00, 0x20, 0x1E, 0x0F,
  0xE1, 0x8E, 0x60, 0xCC, 0x19, 0x80, 0x38, 0x03, 0xC0, 0x3E, 0x00, 0xC0,
  0x0D, 0x81, 0xB0, 0x33, 0x0E, 0x7F, 0x87, 0xE0, 0x20, 0x0C, 0x00, 0x38,
  0x0D, 0x81, 0x11, 0x62, 0x6C, 0xD8, 0x9A, 0x1E, 0xC0, 0x30, 0x04, 0x01,
  0xB0, 0x6F, 0x0B, 0x32, 0x66, 0xCC, 0xC1, 0x90, 0x1E, 0x07, 0x03, 0xF0,
  0x66, 0x18, 0xC3, 0x18, 0x66, 0x07, 0x80, 0xE0, 0x3C, 0x0D, 0xCF, 0x19,
  0xE1, 0xEC, 0x3D, 0x83, 0x39, 0xF3, 0xF6, 0x5F, 0xE0, 0x01, 0x03, 0x06,
  0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0x60, 0x40, 0x40,
  0x40, 0x40, 0x60, 0x60, 0x60, 0x30, 0x18, 0x10, 0x10, 0x30, 0x20, 0x60,
  0x40, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x30,
  0x61, 0x86, 0x18, 0x20, 0x00, 0x06, 0x01, 0x80, 0x61, 0x11, 0xF5, 0xCF,
  0xE0, 0xC0, 0x78, 0x33, 0x18, 0xC2, 0x20, 0x03, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x61, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x33,
  0x66, 0xC4, 0xFF, 0xFF, 0x7F, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60,
  0x18, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x01, 0x80,
  0x60, 0x0C, 0x03, 0x00, 0xE0, 0x00, 0x07, 0x83, 0xF8, 0xE3, 0x18, 0x36,
  0x06, 0xC1, 0xD8, 0x7B, 0x3B, 0x6E, 0x6F, 0x1B, 0xC3, 0x60, 0x6C, 0x0C,
  0xC3, 0x1C, 0xC1, 0xF0, 0x02, 0x39, 0xF7, 0x68, 0xC1, 0x83, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x86, 0x0C, 0x18, 0x07, 0x83, 0xF8, 0xE1, 0x98, 0x33,
  0x06, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3F, 0xF7, 0xFE, 0x07, 0x81, 0xF8, 0x61, 0x98, 0x30, 0x06, 0x00,
  0xC0, 0x30, 0x7C, 0x0F, 0x80, 0x18, 0x03, 0x00, 0x66, 0x0C, 0xC1, 0x9C,
  0xE1, 0xF8, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0x60, 0x6C, 0x0C,
  0xC1, 0x8C, 0x18, 0xC3, 0x0C, 0x60, 0x9F, 0xFE, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x1F, 0xE3, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x1F, 0xC3,
  0xFC, 0x21, 0x80, 0x30, 0x06, 0x00, 0xC8, 0x19, 0x86, 0x39, 0xC3, 0xF0,
  0x01, 0x81, 0xE1, 0xE0, 0x60, 0x30, 0x08, 0x06, 0xF1, 0xEE, 0x60, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x98, 0x67, 0x70, 0xF8, 0x7F, 0xFF, 0xFC, 0x03,
  0x00, 0x60, 0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x60, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0x07, 0x83, 0xF8, 0x61, 0x98, 0x33,
  0x06, 0x60, 0xCE, 0x30, 0xFC, 0x1F, 0x8E, 0x19, 0x83, 0x20, 0x6C, 0x0C,
  0xC3, 0x9C, 0xE1, 0xF8, 0x0E, 0x0F, 0xC7, 0x19, 0x86, 0xC0, 0xF0, 0x3C,
  0x0F, 0x06, 0x63, 0x9F, 0xE3, 0x98, 0x0C, 0x03, 0x03, 0x87, 0xC1, 0xC0,
  0x37, 0x30, 0x00, 0x00, 0x0C, 0xEE, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x0C, 0x31, 0x8E, 0x10, 0x00, 0x40, 0xE0, 0xF8, 0xF0, 0xE0,
  0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0x40, 0x7F, 0xEF, 0xF8, 0x00, 0x00,
  0x07, 0xFD, 0xFF, 0x80, 0x20, 0x1C, 0x03, 0xE0, 0x1E, 0x01, 0xC0, 0x70,
  0xF1, 0xF0, 0xF0, 0x20, 0x00, 0x1E, 0x3F, 0xB8, 0xF8, 0x30, 0x18, 0x1C,
  0x0C, 0x0C, 0x1C, 0x0C, 0x0C, 0x06, 0x00, 0x00, 0x01, 0xC0, 0xC0, 0x03,
  0x00, 0xFC, 0x18, 0x62, 0x02, 0x67, 0xA4, 0xCB, 0xD9, 0x39, 0x12, 0x91,
  0x29, 0x12, 0x93, 0x69, 0xFC, 0x89, 0x8C, 0x00, 0x62, 0x03, 0xE0, 0x01,
  0x80, 0x30, 0x0E, 0x01, 0xC0, 0x68, 0x0D, 0x83, 0x30, 0x66, 0x18, 0xC3,
  0x18, 0xFF, 0x1F, 0xE6, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0x3F, 0x07, 0xF8,
  0xC3, 0x98, 0x33, 0x06, 0xC0, 0xD8, 0x33, 0xFC, 0x7F, 0x8C, 0x19, 0x83,
  0x60, 0x6C, 0x0D, 0x83, 0xBF, 0xE7, 0xF0, 0x07, 0x83, 0xF8, 0xE1, 0x98,
  0x36, 0x06, 0xC0, 0x18, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x6C,
  0x0C, 0xC3, 0x1C, 0xE1, 0xF0, 0x1F, 0x01, 0xFC, 0x18, 0xE1, 0x83, 0x30,
  0x33, 0x03, 0x30, 0x33, 0x03, 0x30, 0x33, 0x03, 0x60, 0x36, 0x06, 0x60,
  0xE6, 0x1C, 0x7F, 0x8F, 0xE0, 0x3F, 0xF3, 0xFF, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x60, 0x07, 0xFC, 0x7F, 0x86, 0x00, 0x60, 0x04, 0x00, 0xC0,
  0x0C, 0x00, 0xFF, 0x8F, 0xF8, 0x1F, 0xF3, 0xFF, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x20, 0x07, 0xFC, 0x7F, 0x86, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x83, 0xF8, 0xE1, 0x98, 0x36, 0x06,
  0xC0, 0x18, 0x06, 0x00, 0xC3, 0xF8, 0x7F, 0x01, 0x60, 0x6C, 0x0C, 0xC1,
  0x9F, 0xE1, 0xF8, 0x18, 0x18, 0xC0, 0xC6, 0x06, 0x20, 0x23, 0x03, 0x18,
  0x18, 0xC0, 0xC7, 0xFE, 0x3F, 0xF3, 0x01, 0x18, 0x18, 0xC0, 0xC6, 0x06,
  0x30, 0x31, 0x01, 0x18, 0x18, 0x3F, 0xF3, 0xFE, 0x03, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0xFF, 0x8F, 0xF8, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCC, 0x0C, 0xC1,
  0x8C, 0x18, 0x77, 0x03, 0xE0, 0x30, 0x39, 0x83, 0x8C, 0x38, 0x63, 0x83,
  0x38, 0x33, 0x81, 0xB8, 0x0F, 0x80, 0x7E, 0x03, 0xB0, 0x19, 0xC1, 0x86,
  0x0C, 0x38, 0x60, 0xC3, 0x06, 0x18, 0x18, 0x18, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x30,
  0x0F, 0xFF, 0xFE, 0x1C, 0x18, 0xE1, 0xC7, 0x0E, 0x38, 0xF3, 0x4D, 0x1A,
  0x78, 0xD6, 0xC6, 0xF6, 0x37, 0x31, 0x39, 0x19, 0x98, 0xCC, 0xC6, 0x06,
  0x30, 0x31, 0x81, 0x98, 0x18, 0x18, 0x18, 0xC0, 0xC7, 0x06, 0x38, 0x63,
  0xC3, 0x1B, 0x18, 0xD8, 0xC6, 0xC6, 0x33, 0x33, 0x1B, 0x18, 0xD8, 0xC3,
  0xC6, 0x1E, 0x30, 0xF1, 0x83, 0x18, 0x18, 0x07, 0x03, 0xF8, 0xE3, 0x18,
  0x36, 0x06, 0xC0, 0xD8, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x60, 0x6C,
  0x0C, 0xC3, 0x1F, 0xC1, 0xF0, 0x1F, 0x03, 0xFC, 0x30, 0x63, 0x03, 0x30,
  0x33, 0x03, 0x20, 0x66, 0x0E, 0x7F, 0xC7, 0xF0, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x83, 0xF8, 0xE3, 0x98, 0x36, 0x06,
  0xC0, 0xD0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x6C, 0x0C, 0xC3,
  0x1F, 0xC1, 0xF8, 0x03, 0x80, 0x38, 0x02, 0x00, 0x3F, 0x07, 0xF8, 0xC3,
  0x98, 0x33, 0x06, 0x60, 0xD8, 0x1B, 0x06, 0x7F, 0x8F, 0xE1, 0x8C, 0x21,
  0x8C, 0x19, 0x83, 0x30, 0x66, 0x06, 0x07, 0x81, 0xFC, 0x38, 0x63, 0x06,
  0x70, 0x63, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xCC, 0x0C,
  0xC0, 0xCE, 0x0C, 0x77, 0x83, 0xF0, 0xFF, 0xFF, 0xFE, 0x06, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x33, 0x03, 0x30, 0x32, 0x02,
  0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x60, 0x6C, 0x0C, 0xC0, 0xCC, 0x0C,
  0xC0, 0xC6, 0x18, 0x77, 0x03, 0xE0, 0xC0, 0x78, 0x0D, 0x03, 0x30, 0x66,
  0x0C, 0xC3, 0x18, 0x63, 0x18, 0x63, 0x04, 0xC0, 0xD8, 0x1E, 0x03, 0xC0,
  0x70, 0x0E, 0x01, 0x80, 0xC6, 0x3C, 0x62, 0xCE, 0x6C, 0xE6, 0xCE, 0x6D,
  0xE4, 0xDE, 0xCD, 0x6C, 0xF6, 0xCF, 0x68, 0xA7, 0x8E, 0x78, 0xE7, 0x0C,
  0x70, 0xC3, 0x0C, 0x30, 0x18, 0x1C, 0x60, 0xE1, 0x83, 0x03, 0x18, 0x0C,
  0xE0, 0x1B, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xD8, 0x06,
  0x60, 0x38, 0xC0, 0xC3, 0x06, 0x0C, 0x38, 0x18, 0xC0, 0x76, 0x06, 0x60,
  0xC6, 0x1C, 0x21, 0x83, 0x30, 0x33, 0x03, 0x60, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x10, 0x03, 0x00, 0x1F, 0xF1, 0xFF, 0x20,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xEF, 0xFC, 0x1E, 0x3C, 0x60, 0xC1,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x83,
  0x06, 0x0F, 0x00, 0xC6, 0x30, 0x86, 0x31, 0x8C, 0x21, 0x8C, 0x63, 0x08,
  0x63, 0x18, 0x1E, 0x3C, 0x18, 0x30, 0x41, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x41, 0x83, 0x06, 0x0C, 0x18, 0x20, 0xC1, 0x8F, 0x00, 0x06, 0x03, 0x03,
  0x83, 0x41, 0xB1, 0x98, 0xCC, 0xC2, 0xE1, 0x80, 0xFF, 0xFF, 0xF0, 0xCC,
  0x80, 0x0F, 0x0F, 0xE3, 0x0D, 0x83, 0x00, 0xC7, 0xF7, 0x0F, 0x02, 0xC1,
  0xB0, 0x6F, 0xF9, 0xF6, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xC3,
  0xF9, 0xC3, 0x60, 0xD8, 0x36, 0x0D, 0x83, 0xC0, 0xF0, 0x3E, 0x1B, 0xDE,
  0xDF, 0x00, 0x0F, 0x07, 0xE3, 0x0D, 0x81, 0x60, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xD8, 0x67, 0x38, 0xF8, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xE6, 0x3F, 0xE3, 0x0C, 0x60, 0xC6, 0x0C, 0xC0, 0xCC, 0x0C, 0xC0,
  0xCC, 0x08, 0x61, 0x87, 0x78, 0x3D, 0x80, 0x0F, 0x07, 0xE3, 0x0D, 0x83,
  0x60, 0x7F, 0xFF, 0xFF, 0x00, 0xC0, 0x18, 0x37, 0x38, 0xFC, 0x03, 0xF0,
  0x7E, 0x0E, 0x00, 0xC0, 0x0C, 0x0F, 0xFC, 0xFF, 0xC1, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x00,
  0x07, 0x31, 0xFF, 0x18, 0x73, 0x06, 0x30, 0x66, 0x06, 0x60, 0x66, 0x06,
  0x60, 0x63, 0x0C, 0x3B, 0xC1, 0xEC, 0x00, 0xC4, 0x18, 0xE3, 0x87, 0xF0,
  0x0C, 0x00, 0x18, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xE2, 0xFD, 0xC3,
  0x60, 0xD8, 0x36, 0x0D, 0x83, 0xC0, 0xF0, 0x3C, 0x1B, 0x06, 0xC1, 0x80,
  0x03, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x00,
  0x00, 0x0F, 0xC3, 0xF0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0x80, 0xE1, 0xF0, 0xF0, 0x00, 0x18,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xC8, 0x73, 0x1C, 0x67, 0x0D,
  0x81, 0xF0, 0x3E, 0x0E, 0x61, 0x8C, 0x30, 0xC6, 0x1C, 0xC1, 0xC0, 0x1F,
  0x87, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x3E, 0x63, 0xFF,
  0x63, 0x36, 0x33, 0x63, 0x36, 0x63, 0x66, 0x34, 0x63, 0xC6, 0x6C, 0x66,
  0xC4, 0x6C, 0xC6, 0x27, 0x8B, 0xF7, 0x0D, 0x83, 0x60, 0xD8, 0x36, 0x0F,
  0x03, 0xC0, 0xF0, 0x6C, 0x1B, 0x06, 0x0F, 0x07, 0xF0, 0xC3, 0x30, 0x66,
  0x05, 0x80, 0xB0, 0x36, 0x06, 0xC0, 0xCC, 0x31, 0xDE, 0x1F, 0x00, 0x13,
  0x83, 0xF8, 0xE1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x1B, 0x03, 0x60, 0x6C,
  0x19, 0xEF, 0x37, 0x86, 0x01, 0x80, 0x30, 0x06, 0x00, 0x0E, 0x67, 0xFC,
  0xC3, 0xB0, 0x66, 0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0x8C, 0x31, 0xDE,
  0x1E, 0xC0, 0x18, 0x03, 0x00, 0x40, 0x18, 0x33, 0xCD, 0xF3, 0xC0, 0xC0,
  0x30, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x03, 0x00, 0x0F, 0x07,
  0xF3, 0x0C, 0x83, 0x30, 0x0F, 0x00, 0xF8, 0x06, 0xC0, 0xF8, 0x37, 0x38,
  0xFC, 0x0C, 0x06, 0x0F, 0xFF, 0xFE, 0x18, 0x06, 0x01, 0x80, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x3F, 0x07, 0xC0, 0x60, 0xD8, 0x3C, 0x0F, 0x06,
  0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0x81, 0x30, 0xCE, 0xF1, 0xEC, 0xC0, 0xF8,
  0x1B, 0x06, 0x20, 0xC6, 0x30, 0xC6, 0x19, 0x81, 0x30, 0x2C, 0x07, 0x80,
  0xE0, 0x08, 0x00, 0xC2, 0x1C, 0x63, 0xC6, 0x34, 0xE2, 0x4A, 0x64, 0xA4,
  0x5A, 0xC5, 0x2C, 0x72, 0x86, 0x38, 0x63, 0x06, 0x30, 0x30, 0x38, 0xC3,
  0x86, 0x38, 0x19, 0x80, 0xD8, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x19, 0x81,
  0xCC, 0x1C, 0x31, 0xC1, 0xC0, 0x30, 0x19, 0x81, 0x8C, 0x0C, 0x60, 0xC1,
  0x8E, 0x0C, 0x60, 0x66, 0x01, 0x30, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x18,
  0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x1E, 0x00, 0xC0, 0x00, 0x3F, 0xEF, 0xFC,
  0x07, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF,
  0x7F, 0xC0, 0x01, 0x83, 0x81, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18,
  0x18, 0x38, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x60, 0x30, 0x18, 0x06, 0x03,
  0x00, 0xC0, 0x18, 0x84, 0x23, 0x18, 0xC6, 0x21, 0x18, 0xC6, 0x31, 0x08,
  0x46, 0x31, 0x80, 0x18, 0x06, 0x03, 0x00, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x03, 0xC0, 0xC1, 0xC1, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x0C,
  0x0C, 0x0C, 0x00, 0x18, 0x07, 0xE1, 0x67, 0x3C, 0x3E, 0x00, 0xC0,
};

const GFXglyph RobotoMono_Italic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 16, 13, 4, -16 },
  { 11, 7, 6, 13, 4, -17 },
  { 17, 13, 16, 13, 0, -16 },
  { 43, 11, 20, 13, 1, -18 },
  { 71, 11, 16, 13, 1, -16 },
  { 93, 11, 16, 13, 1, -16 },
  { 115, 2, 6, 13, 6, -17 },
  { 117, 8, 23, 13, 3, -18 },
  { 140, 7, 23, 13, 2, -18 },
  { 161, 10, 11, 13, 2, -16 },
  { 175, 11, 11, 13, 1, -13 },
  { 191, 4, 6, 13, 2, -2 },
  { 194, 8, 2, 13, 2, -8 },
  { 196, 3, 3, 13, 4, -3 },
  { 198, 11, 17, 13, 1, -16 },
  { 222, 11, 16, 13, 1, -16 },
  { 244, 7, 16, 13, 3, -16 },
  { 258, 11, 16, 13, 0, -16 },
  { 280, 11, 16, 13, 0, -16 },
  { 302, 12, 16, 13, 0, -16 },
  { 326, 11, 16, 13, 2, -16 },
  { 348, 10, 16, 13, 1, -16 },
  { 368, 11, 16, 13, 2, -16 },
  { 390, 11, 16, 13, 1, -16 },
  { 412, 10, 16, 13, 2, -16 },
  { 432, 4, 12, 13, 5, -12 },
  { 438, 6, 16, 13, 3, -12 },
  { 450, 10, 10, 13, 2, -12 },
  { 463, 11, 6, 13, 1, -10 },
  { 472, 10, 10, 13, 1, -12 },
  { 485, 9, 16, 13, 3, -16 },
  { 503, 12, 16, 13, 1, -16 },
  { 527, 11, 16, 13, 0, -16 },
  { 549, 11, 16, 13, 1, -16 },
  { 571, 11, 16, 13, 1, -16 },
  { 593, 12, 16, 13, 0, -16 },
  { 617, 12, 16, 13, 1, -16 },
  { 641, 12, 16, 13, 1, -16 },
  { 665, 11, 16, 13, 1, -16 },
  { 687, 13, 16, 13, 0, -16 },
  { 713, 12, 16, 13, 1, -16 },
  { 737, 12, 16, 13, 1, -16 },
  { 761, 13, 16, 13, 1, -16 },
  { 787, 10, 16, 13, 1, -16 },
  { 807, 13, 16, 13, 0, -16 },
  { 833, 13, 16, 13, 0, -16 },
  { 859, 11, 16, 13, 1, -16 },
  { 881, 12, 16, 13, 1, -16 },
  { 905, 11, 19, 13, 1, -16 },
  { 932, 11, 16, 13, 1, -16 },
  { 954, 12, 16, 13, 1, -16 },
  { 978, 12, 16, 13, 2, -16 },
  { 1002, 12, 16, 13, 1, -16 },
  { 1026, 11, 16, 13, 2, -16 },
  { 1048, 12, 16, 13, 2, -16 },
  { 1072, 14, 16, 13, 0, -16 },
  { 1100, 12, 16, 13, 2, -16 },
  { 1124, 12, 16, 13, 0, -16 },
  { 1148, 7, 21, 13, 3, -18 },
  { 1167, 5, 17, 13, 4, -16 },
  { 1178, 7, 21, 13, 3, -18 },
  { 1197, 9, 9, 13, 2, -16 },
  { 1208, 10, 2, 13, 0, 0 },
  { 1211, 3, 3, 13, 6, -16 },
  { 1213, 10, 12, 13, 1, -12 },
  { 1228, 10, 17, 13, 1, -17 },
  { 1250, 10, 12, 13, 1, -12 },
  { 1265, 12, 17, 13, 1, -17 },
  { 1291, 10, 12, 13, 1, -12 },
  { 1306, 12, 17, 13, 2, -17 },
  { 1332, 12, 17, 13, 0, -12 },
  { 1358, 10, 17, 13, 1, -17 },
  { 1380, 10, 16, 13, 1, -16 },
  { 1400, 10, 21, 13, 0, -16 },
  { 1427, 11, 17, 13, 1, -17 },
  { 1451, 10, 17, 13, 1, -17 },
  { 1473, 12, 12, 13, 0, -12 },
  { 1491, 10, 12, 13, 1, -12 },
  { 1506, 11, 12, 13, 1, -12 },
  { 1523, 11, 16, 13, 0, -12 },
  { 1545, 11, 16, 13, 1, -12 },
  { 1567, 10, 12, 13, 2, -12 },
  { 1582, 10, 12, 13, 1, -12 },
  { 1597, 10, 14, 13, 2, -14 },
  { 1615, 10, 12, 13, 2, -12 },
  { 1630, 11, 12, 13, 2, -12 },
  { 1647, 12, 12, 13, 1, -12 },
  { 1665, 13, 12, 13, 0, -12 },
  { 1685, 13, 17, 13, 0, -12 },
  { 1713, 11, 12, 13, 1, -12 },
  { 1730, 9, 21, 13, 3, -17 },
  { 1754, 5, 20, 13, 4, -16 },
  { 1767, 9, 21, 13, 2, -17 },
  { 1791, 12, 5, 13, 0, -9 },
};

const GFXfont RobotoMono_Italic22pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic22pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _ROBOTOMONO_ITALIC22PT7B_H_
