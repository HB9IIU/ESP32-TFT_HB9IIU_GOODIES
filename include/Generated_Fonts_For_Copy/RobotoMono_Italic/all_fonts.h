#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/RobotoMono_Italic
// Headers: 67

#include "RobotoMono_Italic6pt7b.h"
#include "RobotoMono_Italic7pt7b.h"
#include "RobotoMono_Italic8pt7b.h"
#include "RobotoMono_Italic9pt7b.h"
#include "RobotoMono_Italic10pt7b.h"
#include "RobotoMono_Italic11pt7b.h"
#include "RobotoMono_Italic12pt7b.h"
#include "RobotoMono_Italic13pt7b.h"
#include "RobotoMono_Italic14pt7b.h"
#include "RobotoMono_Italic15pt7b.h"
#include "RobotoMono_Italic16pt7b.h"
#include "RobotoMono_Italic17pt7b.h"
#include "RobotoMono_Italic18pt7b.h"
#include "RobotoMono_Italic19pt7b.h"
#include "RobotoMono_Italic20pt7b.h"
#include "RobotoMono_Italic21pt7b.h"
#include "RobotoMono_Italic22pt7b.h"
#include "RobotoMono_Italic23pt7b.h"
#include "RobotoMono_Italic24pt7b.h"
#include "RobotoMono_Italic25pt7b.h"
#include "RobotoMono_Italic26pt7b.h"
#include "RobotoMono_Italic27pt7b.h"
#include "RobotoMono_Italic28pt7b.h"
#include "RobotoMono_Italic29pt7b.h"
#include "RobotoMono_Italic30pt7b.h"
#include "RobotoMono_Italic31pt7b.h"
#include "RobotoMono_Italic32pt7b.h"
#include "RobotoMono_Italic33pt7b.h"
#include "RobotoMono_Italic34pt7b.h"
#include "RobotoMono_Italic35pt7b.h"
#include "RobotoMono_Italic36pt7b.h"
#include "RobotoMono_Italic37pt7b.h"
#include "RobotoMono_Italic38pt7b.h"
#include "RobotoMono_Italic39pt7b.h"
#include "RobotoMono_Italic40pt7b.h"
#include "RobotoMono_Italic41pt7b.h"
#include "RobotoMono_Italic42pt7b.h"
#include "RobotoMono_Italic43pt7b.h"
#include "RobotoMono_Italic44pt7b.h"
#include "RobotoMono_Italic45pt7b.h"
#include "RobotoMono_Italic46pt7b.h"
#include "RobotoMono_Italic47pt7b.h"
#include "RobotoMono_Italic48pt7b.h"
#include "RobotoMono_Italic49pt7b.h"
#include "RobotoMono_Italic50pt7b.h"
#include "RobotoMono_Italic51pt7b.h"
#include "RobotoMono_Italic52pt7b.h"
#include "RobotoMono_Italic53pt7b.h"
#include "RobotoMono_Italic54pt7b.h"
#include "RobotoMono_Italic55pt7b.h"
#include "RobotoMono_Italic56pt7b.h"
#include "RobotoMono_Italic57pt7b.h"
#include "RobotoMono_Italic58pt7b.h"
#include "RobotoMono_Italic59pt7b.h"
#include "RobotoMono_Italic60pt7b.h"
#include "RobotoMono_Italic61pt7b.h"
#include "RobotoMono_Italic62pt7b.h"
#include "RobotoMono_Italic63pt7b.h"
#include "RobotoMono_Italic64pt7b.h"
#include "RobotoMono_Italic65pt7b.h"
#include "RobotoMono_Italic66pt7b.h"
#include "RobotoMono_Italic67pt7b.h"
#include "RobotoMono_Italic68pt7b.h"
#include "RobotoMono_Italic69pt7b.h"
#include "RobotoMono_Italic70pt7b.h"
#include "RobotoMono_Italic71pt7b.h"
#include "RobotoMono_Italic72pt7b.h"
