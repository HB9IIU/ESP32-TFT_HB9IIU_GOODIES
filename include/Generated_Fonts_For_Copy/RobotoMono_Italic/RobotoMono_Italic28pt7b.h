#ifndef _ROBOTOMONO_ITALIC28PT7B_H_
#define _ROBOTOMONO_ITALIC28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic28pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC7, 0x18, 0x61, 0x8E, 0x38, 0xE3, 0x0C, 0x31, 0xC0,
  0x00, 0x01, 0x8E, 0x38, 0x67, 0x8F, 0x1E, 0x3C, 0x78, 0xA3, 0x00, 0x00,
  0x63, 0x00, 0x61, 0x80, 0x31, 0x80, 0x30, 0xC0, 0x18, 0xC0, 0x0C, 0x60,
  0x7F, 0xFE, 0x3F, 0xFE, 0x03, 0x18, 0x03, 0x0C, 0x01, 0x8C, 0x00, 0xC6,
  0x00, 0xC3, 0x27, 0xFF, 0xE0, 0x61, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x18,
  0x60, 0x0C, 0x60, 0x0E, 0x30, 0x00, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0F,
  0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0xE7, 0x03, 0x30, 0x19, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x76, 0x01, 0xB0,
  0x1D, 0xC0, 0xEE, 0x0E, 0x3F, 0xE0, 0xFE, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x3C, 0x03, 0x70, 0x31, 0x89, 0x8C, 0x6C, 0x66, 0x63, 0x33, 0x33,
  0x0F, 0xB0, 0x11, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xDF, 0x0D, 0xCC,
  0xCC, 0x66, 0x63, 0x63, 0x18, 0x18, 0xC0, 0xCC, 0x03, 0xC0, 0x03, 0xE0,
  0x3F, 0xC0, 0xE3, 0x07, 0x0C, 0x1C, 0x30, 0x71, 0xC1, 0xCE, 0x03, 0x70,
  0x0F, 0x80, 0x38, 0x01, 0xF0, 0x0E, 0xE3, 0x73, 0x8F, 0x87, 0x7E, 0x1D,
  0xB0, 0x3E, 0xE0, 0x73, 0x83, 0xC7, 0xFF, 0x8F, 0xCE, 0xFB, 0x6D, 0xA0,
  0x00, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C,
  0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C,
  0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x18, 0x18, 0x18, 0x00, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x06, 0x06, 0x31, 0x7D, 0x7D, 0xFF, 0xC0, 0xE0, 0x0F, 0x00, 0xDC, 0x0E,
  0x60, 0xE3, 0x86, 0x0C, 0x00, 0x40, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x39, 0x8C, 0xE7, 0x73, 0x08, 0xFF, 0xFF,
  0xF0, 0x27, 0xF7, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60,
  0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x00, 0x00, 0x07, 0xE0, 0xFF, 0x87, 0x0C, 0x70,
  0x77, 0x01, 0xB8, 0x0D, 0x80, 0xEC, 0x0F, 0xE1, 0xDF, 0x1D, 0xFB, 0xCF,
  0xB8, 0x7F, 0x83, 0x70, 0x1B, 0x01, 0xD8, 0x0E, 0xC0, 0xE7, 0x06, 0x1F,
  0xF0, 0x7E, 0x00, 0x01, 0x0F, 0x7F, 0xFF, 0xC6, 0x06, 0x06, 0x06, 0x0E,
  0x0E, 0x0C, 0x0C, 0x0C, 0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x03,
  0xF0, 0x3F, 0xE1, 0xE1, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x30, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0x07, 0xE0,
  0x7F, 0x87, 0x0E, 0x70, 0x33, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00,
  0xF0, 0x3E, 0x03, 0xF8, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xD8, 0x0E,
  0xC0, 0x67, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x3B, 0x00, 0xE6, 0x01, 0x8C, 0x06, 0x38,
  0x1C, 0x70, 0x70, 0xC1, 0xC1, 0x83, 0x03, 0x0F, 0xFF, 0xDF, 0xFF, 0xC0,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0F, 0xFC, 0x3F,
  0xF0, 0xFF, 0xC7, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0D, 0xF0, 0x3F,
  0xE1, 0xE3, 0xC1, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x30,
  0x1C, 0xE0, 0x71, 0x83, 0x87, 0xFC, 0x0F, 0xE0, 0x00, 0xE0, 0x7E, 0x0F,
  0x81, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0x78, 0x7F, 0xEF, 0x8E, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xE0, 0xE6, 0x1C, 0x7F,
  0xC3, 0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x00, 0x07,
  0xE0, 0x7F, 0x87, 0x0E, 0x70, 0x33, 0x81, 0x98, 0x0C, 0xC0, 0xE7, 0x07,
  0x1C, 0xF0, 0x7E, 0x0F, 0xF8, 0xE0, 0xC6, 0x07, 0x70, 0x1B, 0x00, 0xD8,
  0x0E, 0xE0, 0x77, 0x07, 0x1F, 0xF0, 0x7F, 0x00, 0x0F, 0x83, 0xFC, 0x70,
  0xE6, 0x06, 0xE0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x0E, 0xE1,
  0xE7, 0xFE, 0x3F, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x81, 0xF0, 0x7E,
  0x0F, 0x00, 0x18, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x63,
  0xCF, 0x3C, 0x06, 0x0F, 0x0F, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x18, 0x38, 0x38, 0x38, 0x30, 0x70, 0xE0, 0x40, 0x00,
  0x18, 0x03, 0x80, 0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x7F, 0xFB, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xDF, 0xFE, 0x30, 0x01, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x3E, 0x0F, 0xC3, 0xF0,
  0x1E, 0x01, 0xC0, 0x00, 0x1F, 0x8F, 0xF9, 0xC3, 0xF0, 0x7C, 0x06, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x38, 0x0E, 0x01, 0x80, 0x30, 0x08,
  0x00, 0x00, 0x00, 0x06, 0x01, 0xC0, 0x18, 0x00, 0x01, 0xF0, 0x0F, 0xF0,
  0x38, 0x30, 0xC0, 0x23, 0x0E, 0x66, 0x7E, 0xD9, 0x89, 0xB3, 0x13, 0x4C,
  0x67, 0x98, 0xCF, 0x31, 0x1E, 0x42, 0x2C, 0x8C, 0x59, 0xB9, 0xB3, 0xDE,
  0x62, 0x10, 0xC0, 0x00, 0xC0, 0x80, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x60,
  0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x06, 0xC0, 0x3B, 0x00, 0xCC,
  0x07, 0x38, 0x18, 0xE0, 0xE1, 0x83, 0x06, 0x1C, 0x18, 0x7F, 0xE3, 0xFF,
  0x8C, 0x06, 0x70, 0x1D, 0x80, 0x7E, 0x01, 0xF0, 0x03, 0x1F, 0xE0, 0x3F,
  0xF0, 0x60, 0xF0, 0xC0, 0x61, 0x80, 0xC7, 0x01, 0x8E, 0x03, 0x1C, 0x0E,
  0x30, 0xF8, 0x7F, 0xC1, 0xFF, 0xC3, 0x81, 0xC7, 0x01, 0x8C, 0x03, 0x18,
  0x06, 0x30, 0x0C, 0xE0, 0x39, 0xC1, 0xE3, 0xFF, 0x87, 0xFC, 0x00, 0x03,
  0xF0, 0x1F, 0xF0, 0x38, 0x70, 0xE0, 0x63, 0x80, 0xE6, 0x01, 0xDC, 0x00,
  0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x06, 0x30, 0x1C, 0x60, 0x30, 0xE0, 0xE0, 0xFF, 0x80, 0xFC,
  0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x61, 0xE1, 0xC0, 0xE3, 0x81, 0xC7, 0x01,
  0x8C, 0x03, 0x18, 0x07, 0x30, 0x0E, 0xE0, 0x19, 0xC0, 0x33, 0x80, 0x66,
  0x01, 0xCC, 0x03, 0x98, 0x0E, 0x70, 0x1C, 0xE0, 0x71, 0xC3, 0xC3, 0xFF,
  0x07, 0xF8, 0x00, 0x1F, 0xFE, 0x3F, 0xFC, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x08, 0x7F, 0xE0, 0xFF, 0xC3,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0xFF, 0xC7, 0xFF, 0x80, 0x1F, 0xFE, 0x3F, 0xFC, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xF0,
  0xFF, 0xC1, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x38,
  0x70, 0xE0, 0x63, 0x80, 0xE6, 0x01, 0xDC, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x83, 0xF7, 0x07, 0xEE, 0x11, 0xDC, 0x03, 0xB8, 0x06, 0x30,
  0x0C, 0x70, 0x18, 0x70, 0xF0, 0xFF, 0xC0, 0x7E, 0x00, 0x0C, 0x03, 0x0C,
  0x03, 0x1C, 0x03, 0x1C, 0x03, 0x18, 0x07, 0x18, 0x07, 0x18, 0x06, 0x18,
  0x06, 0x38, 0x06, 0x3F, 0xFE, 0x3F, 0xFE, 0x30, 0x0C, 0x30, 0x0C, 0x30,
  0x0C, 0x70, 0x0C, 0x70, 0x1C, 0x60, 0x1C, 0x60, 0x18, 0x60, 0x18, 0xE0,
  0x18, 0x1F, 0xFE, 0x3F, 0xFC, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x03, 0xFF,
  0xC7, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x00,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x30, 0x0C, 0x60, 0x18, 0xE0, 0x70, 0xE1,
  0xC1, 0xFF, 0x01, 0xFC, 0x00, 0x1C, 0x07, 0x1C, 0x0E, 0x18, 0x1C, 0x18,
  0x38, 0x18, 0x70, 0x38, 0xE0, 0x39, 0xC0, 0x3B, 0x80, 0x37, 0x00, 0x3F,
  0x00, 0x7F, 0x80, 0x79, 0x80, 0x71, 0xC0, 0x71, 0xC0, 0x60, 0xE0, 0x60,
  0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xC0, 0x38, 0x0C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x7F, 0xFD, 0xFF, 0xE0, 0x1C, 0x0F, 0x1C, 0x0E, 0x1C, 0x1E,
  0x3C, 0x1E, 0x36, 0x36, 0x36, 0x3E, 0x36, 0x6E, 0x36, 0x6C, 0x36, 0xCC,
  0x76, 0xCC, 0x77, 0x9C, 0x63, 0x9C, 0x63, 0x18, 0x63, 0x18, 0xE0, 0x18,
  0xE0, 0x18, 0xE0, 0x38, 0xC0, 0x38, 0xC0, 0x30, 0xC0, 0x30, 0x0E, 0x03,
  0x0E, 0x03, 0x1E, 0x03, 0x1E, 0x07, 0x1F, 0x07, 0x1F, 0x07, 0x1B, 0x06,
  0x1B, 0x86, 0x39, 0x8E, 0x39, 0x8E, 0x39, 0xCE, 0x30, 0xCC, 0x30, 0xCC,
  0x30, 0xEC, 0x70, 0x7C, 0x70, 0x7C, 0x70, 0x7C, 0x60, 0x38, 0x60, 0x38,
  0xE0, 0x38, 0x03, 0xF0, 0x3F, 0xE0, 0xE3, 0x87, 0x07, 0x38, 0x0C, 0xC0,
  0x37, 0x00, 0xDC, 0x03, 0x60, 0x0D, 0x80, 0x36, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x6E, 0x01, 0x98, 0x0E, 0x70, 0x71, 0xC3, 0x83, 0xFE, 0x07,
  0xE0, 0x1F, 0xF0, 0x3F, 0xF0, 0x70, 0x70, 0xC0, 0x71, 0x80, 0x63, 0x00,
  0xCE, 0x01, 0x9C, 0x07, 0x38, 0x0C, 0x60, 0x78, 0xFF, 0xE1, 0xFF, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0xF0, 0xE0, 0xE3, 0x80,
  0xC6, 0x01, 0x9C, 0x03, 0xB8, 0x07, 0x60, 0x0E, 0xC0, 0x1B, 0x80, 0x37,
  0x00, 0x6E, 0x01, 0xDC, 0x03, 0xB8, 0x06, 0x30, 0x1C, 0x60, 0x30, 0xE1,
  0xC0, 0xFF, 0x00, 0xFF, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0C, 0x00, 0x1F,
  0xE0, 0x3F, 0xF0, 0x60, 0xF0, 0xC0, 0x61, 0x80, 0xE7, 0x01, 0xCE, 0x03,
  0x9C, 0x06, 0x30, 0x1C, 0x60, 0xF0, 0xFF, 0xC3, 0xFE, 0x07, 0x0C, 0x0E,
  0x1C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x71, 0xC0, 0xE3, 0x80, 0xC7, 0x01,
  0xC0, 0x03, 0xF0, 0x1F, 0xF0, 0x78, 0x70, 0xE0, 0x73, 0x80, 0xE7, 0x01,
  0xCE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x38, 0x07, 0x70, 0x0C, 0x60, 0x38, 0xE0, 0xF0, 0xFF,
  0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x06, 0x30, 0x0C, 0xE0, 0x19, 0xC0, 0x73, 0x80, 0xE6,
  0x01, 0xCC, 0x03, 0x18, 0x06, 0x70, 0x0C, 0xE0, 0x39, 0xC0, 0x73, 0x00,
  0xE6, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x30, 0x1C, 0x60, 0x70, 0xE1, 0xC0,
  0xFF, 0x80, 0xFC, 0x00, 0xC0, 0x1F, 0x80, 0x6E, 0x03, 0xB8, 0x0E, 0xE0,
  0x71, 0x81, 0xC6, 0x06, 0x18, 0x38, 0x60, 0xC1, 0xC7, 0x07, 0x18, 0x0C,
  0xE0, 0x33, 0x00, 0xDC, 0x03, 0x60, 0x0D, 0x80, 0x3E, 0x00, 0xF0, 0x01,
  0xC0, 0x06, 0x00, 0x61, 0x87, 0x61, 0x86, 0x63, 0x86, 0x63, 0x8E, 0x63,
  0x8C, 0x67, 0x8C, 0x67, 0x9C, 0x67, 0x9C, 0xED, 0x98, 0xED, 0x98, 0xED,
  0xB8, 0xF9, 0xB0, 0xD9, 0xB0, 0xD9, 0xB0, 0xF1, 0xF0, 0xF0, 0xE0, 0xF0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xC0, 0xE0, 0xC0, 0x1C, 0x03, 0x86, 0x03, 0x83,
  0x81, 0xC0, 0xC1, 0xC0, 0x71, 0xC0, 0x39, 0xC0, 0x0C, 0xE0, 0x07, 0xE0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x76, 0x00, 0x33,
  0x00, 0x39, 0xC0, 0x38, 0x60, 0x38, 0x38, 0x1C, 0x1C, 0x1C, 0x07, 0x1C,
  0x03, 0x80, 0xE0, 0x1F, 0x80, 0xE6, 0x03, 0x98, 0x1C, 0x70, 0x60, 0xC3,
  0x83, 0x1C, 0x0E, 0x60, 0x3B, 0x80, 0x6C, 0x01, 0xE0, 0x07, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E,
  0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0F, 0x87, 0xC3, 0x03, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70,
  0x38, 0x18, 0x0C, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xC0, 0x7C, 0x3E, 0x00,
  0xC1, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC1, 0x83,
  0x06, 0x0C, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0xC0, 0x07, 0xC3, 0xF0, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x80,
  0xC0, 0x30, 0x0C, 0x1F, 0x0F, 0xC0, 0x03, 0x01, 0xC0, 0x78, 0x3E, 0x0D,
  0x87, 0x61, 0x98, 0xC7, 0x70, 0xD8, 0x3E, 0x0C, 0x7F, 0xFF, 0xFF, 0xC0,
  0xF1, 0x86, 0x07, 0xE0, 0xFF, 0x8F, 0x0E, 0x70, 0x70, 0x01, 0x80, 0x0C,
  0x3F, 0xE7, 0xFF, 0x70, 0x33, 0x01, 0xB8, 0x0D, 0xC0, 0xE7, 0x0F, 0x3F,
  0xF8, 0xFD, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xEF, 0x87, 0xFE, 0x3C, 0x39, 0xC1, 0xCC, 0x06, 0x60, 0x37, 0x01,
  0xB8, 0x0D, 0x80, 0x6C, 0x07, 0x60, 0x3F, 0x03, 0xBC, 0x3D, 0xFF, 0xCC,
  0xFC, 0x00, 0x0F, 0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x66, 0x03, 0xF0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x1D, 0xC0, 0xCE, 0x0E, 0x3F,
  0xE0, 0xFC, 0x00, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0xF9, 0x8F, 0xFE, 0x38, 0x79, 0xC0, 0xE6, 0x03, 0x38, 0x0C,
  0xC0, 0x33, 0x01, 0xCC, 0x07, 0x30, 0x18, 0xC0, 0x63, 0x83, 0x8E, 0x1E,
  0x1F, 0xF8, 0x3E, 0xE0, 0x07, 0xE0, 0x3F, 0xC1, 0xC3, 0x8E, 0x06, 0x30,
  0x19, 0xC0, 0x67, 0xFF, 0x9F, 0xFE, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C,
  0x08, 0x78, 0x70, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0x30, 0x07, 0xF0, 0x3F,
  0xC1, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0xFC, 0xFF, 0xF0, 0x30,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x00, 0x07, 0xCC,
  0x7F, 0xF1, 0xC3, 0xCE, 0x07, 0x30, 0x19, 0xC0, 0x66, 0x01, 0x98, 0x0E,
  0x60, 0x39, 0x80, 0xE6, 0x03, 0x1C, 0x1C, 0x70, 0xF0, 0xFF, 0xC1, 0xF7,
  0x00, 0x18, 0x00, 0x63, 0x03, 0x8E, 0x3C, 0x1F, 0xE0, 0x1E, 0x00, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE7, 0x87, 0xFE,
  0x3C, 0x39, 0xC0, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xB8, 0x0D, 0x80, 0xEC,
  0x07, 0x60, 0x37, 0x01, 0xB8, 0x0D, 0xC0, 0x6C, 0x07, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x04, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x01, 0xC0, 0x04,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x7F, 0x07,
  0xE0, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x81, 0xCE, 0x0E, 0x38, 0x70, 0xC7, 0x83, 0x3C, 0x0D, 0xC0, 0x7E,
  0x01, 0xFC, 0x07, 0xB8, 0x1C, 0xE0, 0x61, 0xC1, 0x87, 0x0E, 0x0E, 0x38,
  0x1C, 0xC0, 0x70, 0x0F, 0xE0, 0x7F, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0x9C, 0x3F, 0xFE, 0x39, 0xE7, 0x31, 0xC7, 0x31, 0xC6,
  0x71, 0xC6, 0x71, 0x86, 0x61, 0x86, 0x61, 0x8E, 0x63, 0x8E, 0x63, 0x8C,
  0xE3, 0x8C, 0xE3, 0x0C, 0xC3, 0x0C, 0xC3, 0x1C, 0x39, 0xE1, 0xBF, 0x8F,
  0x0E, 0x70, 0x33, 0x01, 0x98, 0x0D, 0xC0, 0x6E, 0x07, 0x60, 0x3B, 0x01,
  0xD8, 0x0D, 0xC0, 0x6E, 0x03, 0x70, 0x3B, 0x01, 0xC0, 0x07, 0xE0, 0x3F,
  0xC1, 0xC3, 0x8E, 0x0E, 0x70, 0x19, 0xC0, 0x76, 0x01, 0xD8, 0x07, 0xE0,
  0x1B, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x70, 0xF0, 0xFF, 0x81, 0xF8, 0x00,
  0x1D, 0xF0, 0x6F, 0xE1, 0xE3, 0xC7, 0x07, 0x18, 0x0C, 0x60, 0x33, 0x80,
  0xCE, 0x03, 0x30, 0x0C, 0xC0, 0x73, 0x01, 0xDC, 0x0E, 0x78, 0x79, 0xFF,
  0xC7, 0x7E, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0,
  0x00, 0x0F, 0x99, 0xFF, 0xCE, 0x1E, 0xE0, 0x76, 0x03, 0x70, 0x1B, 0x00,
  0xD8, 0x0E, 0xC0, 0x76, 0x03, 0x30, 0x19, 0xC1, 0xCE, 0x1E, 0x3F, 0xF0,
  0xFB, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0x39, 0xF3, 0xFF, 0x3F, 0x33, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F,
  0xC0, 0xFF, 0x0E, 0x1C, 0xE0, 0x67, 0x03, 0xB8, 0x00, 0xF8, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0x30, 0x1D, 0x80, 0xEE, 0x0E, 0x3F, 0xE0, 0xFE, 0x00,
  0x0E, 0x00, 0xE0, 0x0C, 0x0F, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0,
  0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1F, 0xC0, 0xFC, 0x70, 0x1B, 0x81, 0xDC, 0x0E, 0xC0, 0x76, 0x03, 0x30,
  0x1B, 0x80, 0xDC, 0x0E, 0xE0, 0x76, 0x03, 0xB0, 0x19, 0xC1, 0xCE, 0x1E,
  0x3F, 0xB0, 0xFB, 0x80, 0xE0, 0x1D, 0x80, 0x66, 0x03, 0x98, 0x0C, 0x70,
  0x70, 0xC1, 0x83, 0x0E, 0x0C, 0x30, 0x39, 0x80, 0x66, 0x01, 0xB0, 0x06,
  0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x00, 0xC3, 0x07, 0x86, 0x1B, 0x0C,
  0x36, 0x38, 0x6C, 0x71, 0x99, 0xB3, 0x33, 0x66, 0x6C, 0xD8, 0xD9, 0xB1,
  0xB3, 0x43, 0xC7, 0x87, 0x8F, 0x0E, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0x00,
  0x1C, 0x07, 0x1C, 0x0E, 0x0E, 0x1C, 0x06, 0x38, 0x07, 0x70, 0x03, 0xE0,
  0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x60, 0x1C, 0x70,
  0x38, 0x30, 0x70, 0x38, 0xF0, 0x1C, 0x38, 0x03, 0x9C, 0x03, 0x86, 0x03,
  0x83, 0x81, 0xC1, 0xC1, 0xC0, 0xE0, 0xC0, 0x30, 0xE0, 0x1C, 0x60, 0x0E,
  0x70, 0x03, 0x70, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x0E, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xFF, 0xCF, 0xFF, 0x00, 0x00, 0x60, 0x1C, 0x06, 0x01, 0x80,
  0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x07, 0x81,
  0xE0, 0x3E, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x18, 0x00, 0x0C, 0x30, 0xC6, 0x18,
  0x61, 0x86, 0x18, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x86, 0x18, 0x61,
  0x8C, 0x30, 0xC0, 0x04, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x1E, 0x01, 0xC0, 0xF8,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0,
  0x38, 0x1E, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0x03, 0x73, 0xC6, 0x61,
  0xFE, 0xC0, 0x7C, 0x00, 0x10,
};

const GFXglyph RobotoMono_Italic28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 6, 20, 16, 5, -20 },
  { 16, 7, 7, 16, 6, -21 },
  { 23, 17, 20, 16, 0, -20 },
  { 66, 13, 26, 16, 2, -23 },
  { 109, 13, 20, 16, 2, -20 },
  { 142, 14, 20, 16, 1, -20 },
  { 177, 3, 7, 16, 8, -21 },
  { 180, 10, 28, 16, 4, -22 },
  { 215, 9, 28, 16, 2, -22 },
  { 247, 13, 14, 16, 3, -20 },
  { 270, 13, 14, 16, 2, -16 },
  { 293, 5, 8, 16, 3, -3 },
  { 298, 10, 2, 16, 3, -10 },
  { 301, 4, 4, 16, 5, -4 },
  { 303, 14, 22, 16, 2, -20 },
  { 342, 13, 20, 16, 2, -20 },
  { 375, 8, 20, 16, 4, -20 },
  { 395, 14, 20, 16, 0, -20 },
  { 430, 13, 20, 16, 1, -20 },
  { 463, 15, 20, 16, 0, -20 },
  { 501, 14, 20, 16, 2, -20 },
  { 536, 12, 20, 16, 2, -20 },
  { 566, 13, 20, 16, 3, -20 },
  { 599, 13, 20, 16, 2, -20 },
  { 632, 12, 20, 16, 3, -20 },
  { 662, 6, 16, 16, 6, -16 },
  { 674, 8, 21, 16, 4, -16 },
  { 695, 13, 12, 16, 2, -15 },
  { 715, 13, 8, 16, 2, -13 },
  { 728, 13, 12, 16, 1, -15 },
  { 748, 11, 20, 16, 4, -20 },
  { 776, 15, 20, 16, 1, -20 },
  { 814, 14, 20, 16, 0, -20 },
  { 849, 15, 20, 16, 1, -20 },
  { 887, 15, 20, 16, 1, -20 },
  { 925, 15, 20, 16, 1, -20 },
  { 963, 15, 20, 16, 1, -20 },
  { 1001, 15, 20, 16, 1, -20 },
  { 1039, 15, 20, 16, 1, -20 },
  { 1077, 16, 20, 16, 0, -20 },
  { 1117, 15, 20, 16, 1, -20 },
  { 1155, 15, 20, 16, 1, -20 },
  { 1193, 16, 20, 16, 1, -20 },
  { 1233, 13, 20, 16, 1, -20 },
  { 1266, 16, 20, 16, 1, -20 },
  { 1306, 16, 20, 16, 0, -20 },
  { 1346, 14, 20, 16, 1, -20 },
  { 1381, 15, 20, 16, 1, -20 },
  { 1419, 15, 23, 16, 1, -20 },
  { 1463, 15, 20, 16, 1, -20 },
  { 1501, 15, 20, 16, 1, -20 },
  { 1539, 14, 20, 16, 3, -20 },
  { 1574, 15, 20, 16, 1, -20 },
  { 1612, 14, 20, 16, 3, -20 },
  { 1647, 16, 20, 16, 2, -20 },
  { 1687, 17, 20, 16, 0, -20 },
  { 1730, 14, 20, 16, 3, -20 },
  { 1765, 16, 20, 16, 0, -20 },
  { 1805, 9, 27, 16, 4, -23 },
  { 1836, 7, 22, 16, 5, -20 },
  { 1856, 10, 27, 16, 3, -23 },
  { 1890, 10, 11, 16, 3, -20 },
  { 1904, 13, 2, 16, 0, 0 },
  { 1908, 5, 3, 16, 7, -20 },
  { 1910, 13, 15, 16, 1, -15 },
  { 1935, 13, 21, 16, 1, -21 },
  { 1970, 13, 15, 16, 2, -15 },
  { 1995, 14, 21, 16, 2, -21 },
  { 2032, 14, 15, 16, 1, -15 },
  { 2059, 14, 22, 16, 3, -22 },
  { 2098, 14, 21, 16, 1, -15 },
  { 2135, 13, 21, 16, 1, -21 },
  { 2170, 13, 20, 16, 1, -20 },
  { 2203, 13, 26, 16, 0, -20 },
  { 2246, 14, 21, 16, 1, -21 },
  { 2283, 13, 21, 16, 1, -21 },
  { 2318, 16, 15, 16, 0, -15 },
  { 2348, 13, 15, 16, 1, -15 },
  { 2373, 14, 15, 16, 1, -15 },
  { 2400, 14, 21, 16, 0, -15 },
  { 2437, 13, 21, 16, 2, -15 },
  { 2472, 12, 15, 16, 3, -15 },
  { 2495, 13, 15, 16, 2, -15 },
  { 2520, 12, 18, 16, 3, -18 },
  { 2547, 13, 15, 16, 2, -15 },
  { 2572, 14, 15, 16, 2, -15 },
  { 2599, 15, 15, 16, 2, -15 },
  { 2628, 16, 15, 16, 0, -15 },
  { 2658, 17, 21, 16, 0, -15 },
  { 2703, 14, 15, 16, 1, -15 },
  { 2730, 11, 27, 16, 4, -22 },
  { 2768, 6, 25, 16, 5, -20 },
  { 2787, 11, 27, 16, 2, -22 },
  { 2825, 16, 6, 16, 0, -11 },
};

const GFXfont RobotoMono_Italic28pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic28pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _ROBOTOMONO_ITALIC28PT7B_H_
