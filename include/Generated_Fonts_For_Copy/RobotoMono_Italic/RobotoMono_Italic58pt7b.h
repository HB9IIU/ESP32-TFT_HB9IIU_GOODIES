#ifndef _ROBOTOMONO_ITALIC58PT7B_H_
#define _ROBOTOMONO_ITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0xC0,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x78, 0x00, 0x3C, 0x0F, 0x3C, 0x0F, 0x3C, 0x1F, 0x7C, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x3C, 0xF0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x3C, 0xF0, 0x38, 0xE0, 0x38, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03,
  0xC0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x01, 0xF0,
  0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xC1, 0x07, 0xFF,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x78, 0x0F, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x1E, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x80,
  0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0xFC, 0x0F, 0xC0,
  0x0F, 0xE0, 0x7F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x3C, 0x07, 0x80, 0xC7, 0x80, 0xF0, 0x3E, 0xF0, 0x1E, 0x07,
  0x9E, 0x03, 0xC1, 0xE3, 0xC0, 0x78, 0x78, 0x78, 0x1E, 0x0F, 0x0F, 0x03,
  0xC3, 0xC1, 0xE0, 0x78, 0xF0, 0x3E, 0x3E, 0x3E, 0x03, 0xFF, 0xC7, 0x80,
  0x3F, 0xF1, 0xE0, 0x03, 0xF8, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x7C, 0x08, 0x00, 0x0F, 0x1F, 0xE0, 0x03, 0xC7,
  0xFE, 0x00, 0xF1, 0xFF, 0xE0, 0x1E, 0x3C, 0x3E, 0x07, 0x8F, 0x03, 0xC1,
  0xE1, 0xE0, 0x78, 0x7C, 0x78, 0x0F, 0x0F, 0x0F, 0x01, 0xE3, 0xC1, 0xE0,
  0x3C, 0xF8, 0x3C, 0x07, 0x8E, 0x07, 0x80, 0xF0, 0x80, 0xF0, 0x1E, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xBF, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0xFC,
  0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFB,
  0xE0, 0x1F, 0x1F, 0xCF, 0xC0, 0x7C, 0xFE, 0x1F, 0x01, 0xE3, 0xF0, 0x7E,
  0x0F, 0x9F, 0x80, 0xF8, 0x3E, 0x7C, 0x03, 0xF0, 0xFB, 0xF0, 0x07, 0xE7,
  0xCF, 0x80, 0x0F, 0x9F, 0x3E, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x7F, 0xE3,
  0xE0, 0x01, 0xFF, 0x0F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x7F, 0x81, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF,
  0xFD, 0xF8, 0x0F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFC, 0x0F, 0xC0, 0x07, 0x00,
  0x00, 0x00, 0x3C, 0xF7, 0xDF, 0x79, 0xE7, 0x9E, 0xFB, 0xCF, 0x3C, 0xF3,
  0xC0, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x20, 0x00,
  0x00, 0x40, 0x00, 0x0C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x80, 0x3C,
  0x00, 0x38, 0x0F, 0x01, 0xDF, 0x83, 0xC1, 0xF7, 0xF8, 0xF3, 0xFF, 0xFF,
  0xBB, 0xFF, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xF8,
  0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00,
  0xC0, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x1F, 0x07,
  0xE1, 0xF8, 0x0E, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x3E, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0x7E,
  0x18, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0x7F, 0x80, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xE1, 0xF0, 0x00, 0x1E, 0x3E, 0x00, 0x01, 0xF3,
  0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xE3, 0xE0, 0x01, 0xFE, 0x7E, 0x00,
  0x7F, 0xE7, 0xC0, 0x0F, 0xFE, 0x7C, 0x03, 0xFB, 0xE7, 0xC0, 0x7F, 0x3E,
  0x7C, 0x0F, 0xE3, 0xE7, 0xC3, 0xF8, 0x7E, 0xFC, 0x7F, 0x07, 0xCF, 0x9F,
  0xC0, 0x7C, 0xFB, 0xF8, 0x07, 0xCF, 0xFE, 0x00, 0x7C, 0xFF, 0xC0, 0x07,
  0xCF, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF0,
  0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x07,
  0xF0, 0x1F, 0x80, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xFC,
  0xFF, 0x3E, 0xFC, 0x1F, 0x70, 0x0F, 0xA0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xDF, 0xF0, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFB, 0xFE, 0x00, 0xFE, 0x03,
  0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8, 0xFC,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x3E, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x1F, 0x00, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x3F, 0x80, 0x01, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xC0, 0xFE, 0x00, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x1F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x7C, 0xFF, 0xE0, 0x3E, 0x7F, 0xFC,
  0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0x8F, 0xF0, 0xFF, 0x00, 0xFC, 0x7F, 0x80,
  0x1F, 0x9F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xE0, 0xFC,
  0x01, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0x80, 0xFE,
  0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0x7C,
  0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0xFF, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8,
  0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x7E,
  0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xC0, 0xFE, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x7E,
  0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07,
  0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF9, 0xF8, 0x07, 0xFC, 0xFF, 0x0F,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xDF, 0x03, 0xFF, 0xCF, 0x00, 0x7F,
  0x8F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7E, 0x01, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x7C, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x30,
  0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x3F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x3F, 0x80, 0xFC, 0x7E, 0x00, 0x7E, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0E, 0x07, 0x80, 0x78, 0x1E, 0x0F, 0x03, 0xFC, 0x1C, 0x3C, 0x1F, 0xFC,
  0x38, 0x70, 0x7F, 0xF8, 0x71, 0xE1, 0xF0, 0x70, 0xE3, 0x83, 0xC1, 0xC1,
  0xCF, 0x0F, 0x03, 0x83, 0x9C, 0x1E, 0x07, 0x07, 0x38, 0x78, 0x0E, 0x0E,
  0xF0, 0xF0, 0x3C, 0x1D, 0xC1, 0xC0, 0x70, 0x3B, 0x87, 0x80, 0xE0, 0x77,
  0x0F, 0x01, 0xC0, 0xDE, 0x1E, 0x07, 0x83, 0xBC, 0x38, 0x0E, 0x07, 0x78,
  0x70, 0x1C, 0x0E, 0xE0, 0xE0, 0x38, 0x19, 0xC1, 0xC0, 0xF0, 0x73, 0x83,
  0x83, 0xE0, 0xE7, 0x07, 0x8F, 0xC3, 0x8E, 0x0F, 0xFF, 0x8E, 0x1E, 0x1F,
  0xF7, 0xFC, 0x3C, 0x1F, 0xCF, 0xF0, 0x78, 0x1E, 0x0F, 0x80, 0x70, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x01, 0xF0, 0x06, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x0F,
  0x8F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x3E, 0x01, 0xE0, 0x00, 0xF8, 0x07, 0x80, 0x07, 0xC0, 0x1F, 0x00,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x3F, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x0F, 0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07,
  0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x01,
  0xF8, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x87, 0xC0, 0x01, 0xFC, 0x1F, 0x00, 0x0F, 0xE0, 0x7C, 0x03,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xBF, 0xE0,
  0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x0F,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x8F, 0x80, 0x00,
  0x7C, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00,
  0xFE, 0x03, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFE, 0x00, 0x1F, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0,
  0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7C,
  0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0xFE, 0x03, 0xE0, 0x07, 0xF8, 0x07, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x07, 0xFF, 0xCF, 0x80, 0x1F, 0xFF, 0x3E, 0x00, 0x7F, 0xFC,
  0xF8, 0x01, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xCF, 0x80, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x1F,
  0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03,
  0xE0, 0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x1F, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3C, 0x00, 0x01, 0xF0, 0x1E, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x7C, 0x07, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x7C, 0x0F,
  0x80, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00,
  0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x3F, 0x80, 0x07, 0xE0,
  0x1F, 0xC0, 0x01, 0xF0, 0x0F, 0xE0, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F,
  0x03, 0xF8, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x7E,
  0x00, 0x00, 0x7F, 0x8F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xE0,
  0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0xFC, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xC0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x0F, 0xF0,
  0x03, 0xFC, 0x07, 0xFC, 0x03, 0xFE, 0x03, 0xDE, 0x03, 0xFF, 0x01, 0xEF,
  0x01, 0xFF, 0x81, 0xF7, 0x81, 0xF7, 0xC0, 0xFB, 0xC0, 0xFB, 0xC0, 0x7D,
  0xE0, 0xF9, 0xE0, 0x3E, 0xF0, 0x7D, 0xF0, 0x1E, 0x7C, 0x7C, 0xF8, 0x0F,
  0x1E, 0x3E, 0x7C, 0x0F, 0x8F, 0x3E, 0x3E, 0x07, 0xC7, 0x9F, 0x1E, 0x03,
  0xE3, 0xDF, 0x1F, 0x01, 0xF1, 0xEF, 0x8F, 0x80, 0xF8, 0xFF, 0x87, 0xC0,
  0xF8, 0x7F, 0xC3, 0xE0, 0x7C, 0x1F, 0xC1, 0xF0, 0x3E, 0x0F, 0xE1, 0xF0,
  0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xF0, 0x7C, 0x07, 0xC1, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x78, 0x1F, 0x01, 0xF0, 0x38, 0x0F,
  0x80, 0xF8, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01,
  0xF0, 0x3E, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x03, 0xE0, 0x3F, 0xC0, 0x01, 0xF0, 0x1F, 0xE0, 0x00, 0xF8,
  0x0F, 0xF0, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0x3E, 0x03, 0xFE, 0x00, 0x3F,
  0x03, 0xFF, 0x00, 0x1F, 0x01, 0xFF, 0xC0, 0x0F, 0x80, 0xFB, 0xE0, 0x07,
  0xC0, 0x7D, 0xF0, 0x03, 0xE0, 0x3E, 0x7C, 0x03, 0xF0, 0x1F, 0x3E, 0x01,
  0xF8, 0x1F, 0x9F, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x7C, 0x07, 0xC3, 0xE0,
  0x3E, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x1F, 0x80, 0xF8, 0x3E,
  0x0F, 0x80, 0xFC, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x03,
  0xE1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8, 0x0F, 0x80, 0x7C, 0xFC, 0x0F, 0xC0,
  0x3E, 0x7C, 0x07, 0xE0, 0x1F, 0x3E, 0x03, 0xE0, 0x07, 0xDF, 0x01, 0xF0,
  0x03, 0xEF, 0x80, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x00, 0x7F, 0xE0, 0x7E,
  0x00, 0x3F, 0xE0, 0x3E, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x07, 0xF8, 0x0F,
  0x80, 0x03, 0xFC, 0x07, 0xC0, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0xFC,
  0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x06, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3E,
  0x00, 0x7F, 0x80, 0x7C, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F, 0x00,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x1F, 0xC0, 0x7C, 0x01, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00,
  0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0xFE, 0x00,
  0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00,
  0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x7C, 0x7E, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x0F,
  0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xE8, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1E, 0x00, 0x00, 0xF8,
  0x7C, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83,
  0xE0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x7C, 0x3E,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x07, 0x80, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00,
  0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03,
  0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3E, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03,
  0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0xF8,
  0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x1F, 0x3E, 0x03, 0xE0,
  0x1F, 0x3C, 0x03, 0xE0, 0x1F, 0x3C, 0x03, 0xE0, 0x3E, 0x3C, 0x07, 0xE0,
  0x3E, 0x3C, 0x07, 0xE0, 0x3E, 0x3C, 0x07, 0xE0, 0x3C, 0x3C, 0x0F, 0xE0,
  0x7C, 0x7C, 0x0F, 0xE0, 0x7C, 0x7C, 0x0F, 0xE0, 0x7C, 0x7C, 0x1E, 0xE0,
  0x78, 0x7C, 0x1E, 0xE0, 0xF8, 0x7C, 0x1E, 0xE0, 0xF8, 0x7C, 0x3C, 0xE0,
  0xF8, 0x7C, 0x3C, 0xE0, 0xF0, 0x7C, 0x3C, 0xE1, 0xF0, 0x7C, 0x78, 0xE1,
  0xF0, 0x7C, 0x78, 0xE1, 0xE0, 0x7C, 0x78, 0xF1, 0xE0, 0x7C, 0xF0, 0xF3,
  0xE0, 0x78, 0xF0, 0xF3, 0xE0, 0x78, 0xF0, 0xF3, 0xC0, 0x79, 0xF0, 0xF3,
  0xC0, 0x79, 0xE0, 0xF7, 0xC0, 0x79, 0xE0, 0xF7, 0xC0, 0x7B, 0xE0, 0xF7,
  0x80, 0x7B, 0xC0, 0xFF, 0x80, 0x7B, 0xC0, 0xFF, 0x80, 0x7F, 0xC0, 0xFF,
  0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x07, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x00, 0xF8, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x00, 0x3F,
  0x3E, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x01, 0xFD, 0xF0, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xE0,
  0x1F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x78,
  0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF,
  0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0x7C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01,
  0xF0, 0x07, 0x80, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F,
  0xBE, 0x00, 0xF8, 0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3E, 0x07, 0xC1, 0xF0,
  0x3E, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0x01, 0xE1, 0xF0, 0x0F, 0x9F, 0x00,
  0x7C, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0x7C, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFC, 0x0F,
  0x83, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x3F,
  0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x3F, 0xE0, 0x0F, 0x8F, 0xC0, 0x03, 0xE7, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0xCF, 0xF0, 0x7F, 0xF1,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xBF, 0x07, 0xFF, 0xCF, 0xC0, 0xFF, 0xC1,
  0xF0, 0x01, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x3F, 0xC0, 0x07, 0xCF, 0xFF, 0x00, 0x7D, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xE3, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0xFE,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x3F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0x87, 0xF0, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x07, 0xFC, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFE, 0x0F, 0xBF, 0xFF, 0xC0, 0xF9, 0xFF, 0xF8, 0x0F, 0x87,
  0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0x83, 0xF8, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x1F, 0x00, 0x03,
  0xE7, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x03,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xFC, 0x3E,
  0x00, 0x3F, 0xFC, 0x7C, 0x00, 0xFF, 0xFE, 0xF8, 0x03, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x7F, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xF8, 0x1F,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80,
  0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xBC,
  0x00, 0x3F, 0xFE, 0x78, 0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x20, 0x7E, 0x00,
  0x0E, 0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x20,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x3C, 0x00, 0xFF, 0xF1, 0xF0, 0x07, 0xFF,
  0xF7, 0xC0, 0x3F, 0xFF, 0xDF, 0x01, 0xFE, 0x1F, 0xFC, 0x0F, 0xE0, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xF8,
  0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x7E, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xF7, 0xC0, 0x0F, 0xFF, 0xBE, 0x00, 0x0F, 0xF8, 0xF8, 0x00, 0x03,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x0C, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xF0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x1F, 0xE0, 0x07, 0xC7, 0xFF,
  0x00, 0x7C, 0xFF, 0xF8, 0x07, 0x9F, 0xFF, 0xC0, 0xFB, 0xE1, 0xFE, 0x0F,
  0xF8, 0x07, 0xE0, 0xFE, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF1,
  0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0,
  0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x7C, 0x00, 0x3F, 0x81, 0xF0,
  0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x00, 0xF8, 0x07,
  0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x0F, 0x81, 0xFC, 0x00, 0x3E, 0x0F, 0xE0,
  0x00, 0xF8, 0x7F, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x7D, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFE, 0xFC, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3F,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0,
  0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x8F, 0xC1, 0xF8, 0x07, 0xBF, 0xE3,
  0xFE, 0x07, 0xFF, 0xF7, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xE3, 0xFE,
  0x3F, 0x0F, 0xC1, 0xF8, 0x1F, 0x0F, 0x81, 0xF8, 0x1F, 0x0F, 0x81, 0xF0,
  0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0,
  0x1F, 0x1F, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x1E, 0x1F, 0x03, 0xE0,
  0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0,
  0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x3E, 0x03, 0xE0, 0x3C, 0x3C, 0x07, 0xC0,
  0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0,
  0x7C, 0x7C, 0x07, 0xC0, 0x7C, 0x7C, 0x07, 0xC0, 0x78, 0x78, 0x0F, 0x80,
  0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80,
  0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x01, 0xF0, 0x07, 0xC1, 0xFE,
  0x00, 0x7C, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x80, 0x7B, 0xFF, 0xFC, 0x0F,
  0xFE, 0x1F, 0xE0, 0xFF, 0x80, 0x7E, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x00,
  0x3F, 0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x1F, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC7, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00,
  0x3E, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x01, 0xF0,
  0xFF, 0x00, 0x07, 0xCF, 0xFE, 0x00, 0x1E, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x03, 0xFF, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x1F,
  0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0,
  0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x1F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0x80,
  0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x01,
  0xFE, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xF9,
  0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0x80, 0x0F, 0x80, 0x70, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE1, 0xF0, 0x0F, 0xFF, 0x9F, 0x01,
  0xFF, 0xFD, 0xF0, 0x3F, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xF0, 0xFE, 0x00,
  0xFE, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x1F,
  0x07, 0xC0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x3F,
  0x81, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xDE, 0x00, 0xFF, 0xFB,
  0xE0, 0x03, 0xFE, 0x3E, 0x00, 0x03, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0xFF, 0xC1, 0xF0, 0xFF, 0xF0, 0x7C, 0xFF, 0xF8, 0x1F, 0x7F, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFF, 0x80, 0x20, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xF0, 0x07, 0xE1,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x08, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x38, 0x00, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0x8F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00,
  0x1F, 0x1F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0xFC,
  0x00, 0x7E, 0x0F, 0x80, 0x3F, 0xC1, 0xF8, 0x0F, 0xF8, 0x3F, 0xFF, 0xDF,
  0x03, 0xFF, 0xF3, 0xE0, 0x3F, 0xFC, 0x78, 0x03, 0xFF, 0x1F, 0x00, 0x0E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0x83, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x7E, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x01,
  0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x0F, 0x03,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x78, 0x7C, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x78, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x3F, 0xE0, 0x0F, 0x00, 0x7F, 0xC0,
  0x1E, 0x00, 0xF7, 0x80, 0x7C, 0x03, 0xEF, 0x00, 0xF8, 0x07, 0xDE, 0x01,
  0xF0, 0x0F, 0x3C, 0x07, 0xE0, 0x3E, 0x78, 0x0F, 0xC0, 0x78, 0xF0, 0x3F,
  0xC0, 0xF1, 0xE0, 0x7F, 0x83, 0xE3, 0xC1, 0xEF, 0x07, 0x87, 0x83, 0xDE,
  0x0F, 0x0F, 0x07, 0xBC, 0x3E, 0x1E, 0x1E, 0x78, 0x78, 0x3C, 0x3C, 0xF0,
  0xF0, 0x78, 0xF1, 0xE3, 0xC0, 0xF1, 0xE3, 0xC7, 0x81, 0xE7, 0x87, 0x8F,
  0x03, 0xCF, 0x07, 0x3C, 0x07, 0x9E, 0x0E, 0x78, 0x0F, 0x78, 0x1C, 0xF0,
  0x1E, 0xF0, 0x3B, 0xC0, 0x3D, 0xC0, 0x77, 0x80, 0x7F, 0x80, 0xEE, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03,
  0xE0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x80, 0x1F,
  0xC0, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03,
  0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0xF8, 0x03,
  0xF8, 0x00, 0x3E, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0x3F, 0xFF, 0x80, 0x0F, 0x3F, 0xFF, 0xC0, 0x1E, 0x7C, 0x1F,
  0xE0, 0x3E, 0x78, 0x07, 0xF8, 0x7E, 0xF0, 0x03, 0xFF, 0xFC, 0xF0, 0x01,
  0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0x80,
};

const GFXglyph RobotoMono_Italic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 12, 41, 34, 11, -41 },
  { 63, 16, 14, 34, 12, -44 },
  { 91, 34, 41, 34, 1, -41 },
  { 266, 29, 54, 34, 3, -48 },
  { 462, 27, 43, 34, 4, -42 },
  { 608, 30, 43, 34, 2, -42 },
  { 770, 6, 14, 34, 16, -44 },
  { 781, 19, 60, 34, 9, -47 },
  { 924, 19, 60, 34, 5, -47 },
  { 1067, 26, 28, 34, 6, -41 },
  { 1158, 29, 30, 34, 3, -34 },
  { 1267, 11, 16, 34, 5, -6 },
  { 1289, 22, 4, 34, 6, -20 },
  { 1300, 8, 9, 34, 11, -8 },
  { 1309, 30, 45, 34, 3, -41 },
  { 1478, 28, 43, 34, 4, -42 },
  { 1629, 17, 41, 34, 8, -41 },
  { 1717, 30, 42, 34, 0, -42 },
  { 1875, 29, 43, 34, 1, -42 },
  { 2031, 29, 41, 34, 1, -41 },
  { 2180, 29, 42, 34, 4, -41 },
  { 2333, 26, 42, 34, 3, -41 },
  { 2470, 29, 41, 34, 5, -41 },
  { 2619, 28, 43, 34, 4, -42 },
  { 2770, 25, 42, 34, 6, -42 },
  { 2902, 12, 34, 34, 13, -33 },
  { 2953, 16, 43, 34, 9, -33 },
  { 3039, 25, 25, 34, 5, -31 },
  { 3118, 27, 17, 34, 4, -27 },
  { 3176, 27, 26, 34, 3, -31 },
  { 3264, 24, 42, 34, 8, -42 },
  { 3390, 31, 41, 34, 2, -41 },
  { 3549, 30, 41, 34, -1, -41 },
  { 3703, 30, 41, 34, 2, -41 },
  { 3857, 30, 43, 34, 3, -42 },
  { 4019, 31, 41, 34, 1, -41 },
  { 4178, 32, 41, 34, 2, -41 },
  { 4342, 32, 41, 34, 2, -41 },
  { 4506, 30, 43, 34, 3, -42 },
  { 4668, 33, 41, 34, 1, -41 },
  { 4838, 31, 41, 34, 2, -41 },
  { 4997, 31, 42, 34, 2, -41 },
  { 5160, 34, 41, 34, 2, -41 },
  { 5335, 26, 41, 34, 2, -41 },
  { 5469, 33, 41, 34, 1, -41 },
  { 5639, 33, 41, 34, 1, -41 },
  { 5809, 29, 43, 34, 3, -42 },
  { 5965, 32, 41, 34, 2, -41 },
  { 6129, 29, 49, 34, 3, -42 },
  { 6307, 31, 41, 34, 2, -41 },
  { 6466, 31, 43, 34, 2, -42 },
  { 6633, 31, 41, 34, 5, -41 },
  { 6792, 31, 42, 34, 3, -41 },
  { 6955, 30, 41, 34, 6, -41 },
  { 7109, 32, 41, 34, 4, -41 },
  { 7273, 36, 41, 34, 0, -41 },
  { 7458, 30, 41, 34, 6, -41 },
  { 7612, 32, 41, 34, 1, -41 },
  { 7776, 19, 56, 34, 8, -47 },
  { 7909, 13, 45, 34, 11, -41 },
  { 7983, 20, 56, 34, 7, -47 },
  { 8123, 21, 22, 34, 7, -41 },
  { 8181, 26, 4, 34, 1, 0 },
  { 8194, 10, 8, 34, 15, -42 },
  { 8204, 26, 32, 34, 3, -31 },
  { 8308, 28, 45, 34, 2, -44 },
  { 8466, 27, 32, 34, 3, -31 },
  { 8574, 31, 45, 34, 3, -44 },
  { 8749, 27, 32, 34, 3, -31 },
  { 8857, 30, 45, 34, 6, -45 },
  { 9026, 30, 43, 34, 1, -31 },
  { 9188, 28, 44, 34, 2, -44 },
  { 9342, 25, 42, 34, 3, -42 },
  { 9474, 26, 54, 34, 1, -42 },
  { 9650, 30, 44, 34, 2, -44 },
  { 9815, 25, 44, 34, 3, -44 },
  { 9953, 32, 31, 34, 0, -31 },
  { 10077, 28, 31, 34, 2, -31 },
  { 10186, 27, 32, 34, 3, -31 },
  { 10294, 30, 43, 34, 0, -31 },
  { 10456, 28, 43, 34, 3, -31 },
  { 10607, 26, 31, 34, 6, -31 },
  { 10708, 26, 32, 34, 4, -31 },
  { 10812, 25, 39, 34, 6, -38 },
  { 10934, 27, 32, 34, 4, -31 },
  { 11042, 28, 31, 34, 5, -31 },
  { 11151, 31, 31, 34, 4, -31 },
  { 11272, 33, 31, 34, 0, -31 },
  { 11400, 35, 43, 34, -1, -31 },
  { 11589, 29, 31, 34, 2, -31 },
  { 11702, 22, 55, 34, 9, -45 },
  { 11854, 13, 52, 34, 10, -41 },
  { 11939, 23, 55, 34, 5, -45 },
  { 12098, 32, 12, 34, 1, -23 },
};

const GFXfont RobotoMono_Italic58pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic58pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic58pt7bGlyphs,
  0x20, 0x7E, 77
};

#endif // _ROBOTOMONO_ITALIC58PT7B_H_
