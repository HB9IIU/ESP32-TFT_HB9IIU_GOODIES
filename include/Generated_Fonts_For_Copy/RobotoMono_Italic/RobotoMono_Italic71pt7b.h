#ifndef _ROBOTOMONO_ITALIC71PT7B_H_
#define _ROBOTOMONO_ITALIC71PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic71pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x07,
  0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x1F,
  0x01, 0xF1, 0xF0, 0x1F, 0x1F, 0x01, 0xF3, 0xF0, 0x3F, 0x3E, 0x03, 0xE3,
  0xE0, 0x3E, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xC7, 0xC0, 0x7C,
  0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x7C, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07,
  0x8F, 0x80, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE7, 0xFF, 0x00, 0x3F, 0xE0,
  0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x7F, 0xC0, 0x3F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x81, 0xF0, 0x0F, 0x80, 0x30, 0x7C, 0x03, 0xE0, 0x1F, 0x1F,
  0x00, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x81, 0xF0,
  0x78, 0x03, 0xE0, 0xFC, 0x1E, 0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x7C, 0x1F,
  0x01, 0xF0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0xC3, 0xE0, 0x1F, 0x87, 0xE1,
  0xF0, 0x03, 0xFF, 0xF0, 0xF8, 0x00, 0x7F, 0xF8, 0x7E, 0x00, 0x0F, 0xFC,
  0x1F, 0x00, 0x00, 0xFC, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x10, 0x00, 0x00, 0xF8, 0x3F, 0xC0, 0x00, 0x7C, 0x3F,
  0xF8, 0x00, 0x3F, 0x1F, 0xFF, 0x00, 0x0F, 0x8F, 0xFF, 0xE0, 0x07, 0xC7,
  0xE0, 0xF8, 0x03, 0xE1, 0xF0, 0x1F, 0x01, 0xF8, 0x78, 0x07, 0xC0, 0x7C,
  0x3E, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x7C, 0x1F, 0x83, 0xE0, 0x1F, 0x07,
  0xC0, 0xF8, 0x07, 0xC3, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x0F, 0x00, 0x7C,
  0x0C, 0x03, 0xC0, 0x1F, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x7F,
  0x80, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x00, 0x7E, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xDF, 0xC0, 0x1F, 0x87, 0xFC, 0xFE, 0x00, 0xFC, 0x3F, 0xC3, 0xF8,
  0x07, 0xE3, 0xFC, 0x1F, 0xC0, 0x3E, 0x3F, 0xC0, 0x7F, 0x03, 0xF1, 0xFC,
  0x01, 0xF8, 0x1F, 0x9F, 0xC0, 0x0F, 0xE1, 0xF8, 0xFE, 0x00, 0x3F, 0x8F,
  0xC7, 0xE0, 0x01, 0xFC, 0xFE, 0x7F, 0x00, 0x07, 0xF7, 0xE3, 0xF8, 0x00,
  0x3F, 0xFE, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0xFE, 0x00, 0x07, 0xFF, 0x07,
  0xF0, 0x00, 0x1F, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x07, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xE0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xFF, 0x3F,
  0x80, 0x1F, 0xFF, 0xE0, 0xFE, 0x00, 0x3F, 0xFC, 0x07, 0xF8, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x1F, 0x3F, 0x3F, 0x3E, 0x3E, 0x3E, 0x3E, 0x7E, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x78, 0xF8, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x10, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x20, 0x03, 0xE0, 0x02, 0x7C, 0x03, 0xE0, 0x1E,
  0x7F, 0x03, 0xE0, 0x7E, 0x7F, 0xC3, 0xC3, 0xFE, 0xFF, 0xF3, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x7F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x1E, 0x00,
  0x04, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x0F,
  0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x83, 0xF8, 0x3F,
  0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x38, 0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0x80, 0x3E, 0x1F, 0xEF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFE, 0x7F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0x81, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x1F, 0xE3,
  0xF0, 0x00, 0x0F, 0xFC, 0x7E, 0x00, 0x03, 0xFF, 0x0F, 0xC0, 0x01, 0xFF,
  0xE3, 0xF8, 0x00, 0x7F, 0xFC, 0x7F, 0x00, 0x1F, 0xFF, 0x8F, 0xC0, 0x0F,
  0xFB, 0xF1, 0xF8, 0x03, 0xFC, 0xFE, 0x3F, 0x01, 0xFF, 0x1F, 0xC7, 0xE0,
  0x7F, 0x83, 0xF0, 0xFC, 0x3F, 0xE0, 0x7E, 0x3F, 0x8F, 0xF0, 0x0F, 0xC7,
  0xE7, 0xFC, 0x01, 0xF8, 0xFD, 0xFF, 0x00, 0x7F, 0x1F, 0xFF, 0x80, 0x0F,
  0xE3, 0xFF, 0xE0, 0x01, 0xF8, 0x7F, 0xF0, 0x00, 0x3F, 0x0F, 0xFC, 0x00,
  0x07, 0xE3, 0xFE, 0x00, 0x00, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x07, 0xFF, 0x7F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x0F, 0xC0, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x07, 0xFF,
  0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xF7, 0xF7, 0xFC, 0x3F, 0x3F,
  0x01, 0xF9, 0xE0, 0x0F, 0xC8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x81, 0xFF, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80,
  0x3F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x07,
  0xEF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0xFC, 0x7F, 0xFC, 0x01, 0xF9, 0xFF,
  0xFC, 0x03, 0xE7, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0x07,
  0xFC, 0x3F, 0xF8, 0x03, 0xF8, 0x7F, 0xC0, 0x03, 0xF9, 0xFF, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0xFE, 0x03, 0xFC,
  0x07, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xF9,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x1F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0x83, 0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xF9, 0xFC, 0x00,
  0x3F, 0xE1, 0xFC, 0x01, 0xFF, 0xC3, 0xFE, 0x0F, 0xFF, 0x83, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x7C, 0x03, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xE3,
  0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x01, 0xFE, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x03,
  0xFE, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF, 0xC0, 0x7F,
  0xC0, 0x7F, 0xC0, 0x3F, 0x80, 0x0C, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x10, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x02,
  0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x1F, 0xFC, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0xFE,
  0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0x01, 0xE0, 0x3E,
  0x03, 0xFF, 0x83, 0xC0, 0x78, 0x0F, 0xFF, 0x87, 0x81, 0xF0, 0x3F, 0xFF,
  0x07, 0x03, 0xC0, 0xFC, 0x1E, 0x0E, 0x0F, 0x83, 0xF0, 0x38, 0x1E, 0x1E,
  0x07, 0xC0, 0xF0, 0x3C, 0x7C, 0x1F, 0x01, 0xE0, 0x78, 0xF0, 0x3C, 0x03,
  0xC0, 0xF1, 0xE0, 0xF8, 0x07, 0x01, 0xE7, 0x81, 0xE0, 0x1E, 0x03, 0x8F,
  0x07, 0xC0, 0x3C, 0x07, 0x1E, 0x0F, 0x80, 0x78, 0x0E, 0x7C, 0x1E, 0x00,
  0xF0, 0x3C, 0xF0, 0x3C, 0x03, 0xC0, 0x79, 0xE0, 0xF8, 0x07, 0x80, 0xF3,
  0xC1, 0xF0, 0x0F, 0x01, 0xC7, 0x83, 0xC0, 0x1E, 0x03, 0x8F, 0x07, 0x80,
  0x78, 0x0F, 0x3E, 0x0F, 0x00, 0xF0, 0x1E, 0x7C, 0x1E, 0x01, 0xE0, 0x38,
  0xF0, 0x3C, 0x07, 0xC0, 0xF1, 0xE0, 0x78, 0x1F, 0x81, 0xC3, 0xE0, 0xF8,
  0x7F, 0x07, 0x87, 0xC1, 0xFF, 0xFE, 0x1E, 0x0F, 0x83, 0xFF, 0xBF, 0xFC,
  0x0F, 0x03, 0xFE, 0x7F, 0xF0, 0x1E, 0x03, 0xF8, 0x7F, 0x80, 0x3C, 0x03,
  0xC0, 0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x60, 0x00, 0x03, 0xFE, 0x07, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x00, 0xFC, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x07, 0xF0,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x1F, 0x80,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x7F, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xF0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0x83,
  0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x07, 0xFC,
  0x07, 0xE0, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0xFB, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xF0, 0x07, 0xFE, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x7F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x1F, 0x80, 0x0F, 0xFC, 0x00, 0x7E,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x10, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x7F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x1F,
  0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0xF8, 0xFC, 0x00, 0x3F, 0xFF, 0xC7, 0xE0, 0x01,
  0xFF, 0xFE, 0x3F, 0x00, 0x0F, 0xFF, 0xF3, 0xF8, 0x00, 0xFF, 0xFF, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x00,
  0x7E, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x01,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x07, 0xF3,
  0xFC, 0x00, 0x00, 0x01, 0xF9, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x01, 0xF7, 0xE0, 0x0F, 0x9F, 0x01,
  0xFB, 0xF0, 0x07, 0xCF, 0x80, 0xF9, 0xF8, 0x07, 0xE7, 0xC0, 0xFC, 0xF8,
  0x03, 0xF3, 0xE0, 0x7C, 0xFC, 0x01, 0xF9, 0xF0, 0x7E, 0x7E, 0x00, 0xFC,
  0xF8, 0x7E, 0x3F, 0x00, 0x7C, 0x7E, 0x3F, 0x1F, 0x80, 0x7E, 0x1F, 0x3F,
  0x0F, 0xC0, 0x3F, 0x0F, 0x9F, 0x8F, 0xC0, 0x1F, 0x87, 0xDF, 0x87, 0xE0,
  0x0F, 0xC3, 0xEF, 0xC3, 0xF0, 0x07, 0xE1, 0xFF, 0xC1, 0xF8, 0x03, 0xF0,
  0xFF, 0xE0, 0xFC, 0x03, 0xF0, 0x7F, 0xE0, 0xFC, 0x01, 0xF8, 0x1F, 0xF0,
  0x7E, 0x00, 0xFC, 0x0F, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF8, 0x1F, 0x80,
  0x3F, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F,
  0xE0, 0x00, 0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x00,
  0x03, 0xF8, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xFE, 0x00,
  0x0F, 0xC0, 0x0F, 0xDF, 0x80, 0x07, 0xE0, 0x0F, 0xEF, 0xC0, 0x03, 0xF0,
  0x07, 0xF7, 0xE0, 0x01, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xFC, 0x01, 0xF8,
  0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x87, 0xE0, 0x1F, 0xC0,
  0x1F, 0x81, 0xF8, 0x0F, 0xE0, 0x0F, 0xC0, 0xFC, 0x07, 0xF0, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x03, 0xF8, 0x0F, 0xC0,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x7F, 0x00,
  0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x80,
  0x1F, 0x8F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x0F, 0xC0, 0x07, 0xE7,
  0xF0, 0x07, 0xE0, 0x01, 0xFB, 0xF8, 0x03, 0xF0, 0x00, 0xFD, 0xF8, 0x01,
  0xF8, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x00, 0x01, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0xFF, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00,
  0x07, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x00,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x0F, 0xF8, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x9F,
  0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF8, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x03,
  0xFC, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x01, 0xFC, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xE0,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x00, 0xFE,
  0x7E, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xF8, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F,
  0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0xFC,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7C, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x00,
  0xFC, 0xFC, 0x01, 0xF8, 0x01, 0xF9, 0xF8, 0x03, 0xF0, 0x07, 0xE3, 0xF0,
  0x0F, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F, 0xE0, 0x1F, 0x8F, 0xC0, 0x3F, 0xC0,
  0x3F, 0x1F, 0x80, 0xFF, 0x80, 0xFC, 0x3F, 0x01, 0xFF, 0x01, 0xF8, 0x7C,
  0x03, 0xFE, 0x03, 0xF0, 0xF8, 0x0F, 0xFC, 0x07, 0xC1, 0xF0, 0x1F, 0xF8,
  0x1F, 0x83, 0xE0, 0x3F, 0xF0, 0x3F, 0x07, 0xC0, 0xFB, 0xE0, 0x7E, 0x0F,
  0x81, 0xF7, 0xC0, 0xF8, 0x1F, 0x03, 0xEF, 0x83, 0xF0, 0x7E, 0x0F, 0x9F,
  0x07, 0xE0, 0xFC, 0x1F, 0x3E, 0x0F, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x03,
  0xF0, 0xFC, 0xF8, 0x7E, 0x07, 0xE1, 0xF1, 0xF0, 0xFC, 0x0F, 0xC3, 0xE3,
  0xE1, 0xF0, 0x1F, 0x8F, 0xC7, 0xC3, 0xE0, 0x3F, 0x1F, 0x0F, 0x8F, 0xC0,
  0x7E, 0x3E, 0x1F, 0x1F, 0x80, 0xFC, 0xFC, 0x3E, 0x3E, 0x01, 0xF9, 0xF0,
  0x7C, 0xFC, 0x03, 0xE3, 0xE0, 0xF9, 0xF8, 0x07, 0xCF, 0xC1, 0xF3, 0xF0,
  0x0F, 0x9F, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x07, 0xDF, 0x80, 0x3E, 0xFC,
  0x0F, 0xBF, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x3E, 0xF8,
  0x01, 0xF7, 0xC0, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x07, 0xFE,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x07, 0xFE,
  0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x81, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x07, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xC0,
  0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x02, 0x00, 0x7F, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF, 0x00,
  0x07, 0xE7, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0x1F,
  0x80, 0x1F, 0x83, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0xC0, 0x1F, 0x87,
  0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x0F,
  0x9F, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0xFC,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x03, 0xFC, 0x0F, 0xE0,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0x80, 0x07, 0xE0, 0xFF, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x1F,
  0xF0, 0xFE, 0x00, 0x3F, 0xF8, 0x7F, 0xC0, 0x7F, 0xF8, 0x1F, 0xFF, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x3F, 0x80, 0x7F, 0xFF,
  0x1F, 0xC0, 0x1F, 0xFE, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC1, 0xFF, 0x00, 0x01, 0xF8, 0xFF, 0xF8,
  0x00, 0x7E, 0x7F, 0xFF, 0x80, 0x0F, 0xDF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x1F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x03, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0x03,
  0xFF, 0xC0, 0x7F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xFE,
  0x01, 0xF9, 0xFF, 0xFF, 0x80, 0x3F, 0x1F, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xFE, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x81, 0xF8, 0x00, 0x3F, 0xFF, 0x0F, 0xC0, 0x03, 0xFF, 0xFE, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x7F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F,
  0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xEF, 0x80, 0x03, 0xFF, 0xFE, 0x7C, 0x00, 0x0F, 0xFF, 0xE7, 0xE0,
  0x00, 0x1F, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F,
  0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x03, 0xF8, 0x00,
  0x03, 0x80, 0xFE, 0x00, 0x03, 0xE0, 0x7F, 0x80, 0x07, 0xF8, 0x1F, 0xE0,
  0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x80,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x01, 0xF0, 0x00,
  0xFF, 0xFC, 0x3F, 0x00, 0x1F, 0xFF, 0xE3, 0xF0, 0x03, 0xFF, 0xFF, 0xBF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xE0, 0x3F, 0xC0, 0x03, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01,
  0xFE, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xEF, 0xC0,
  0x01, 0xFF, 0xFC, 0xFC, 0x00, 0x07, 0xFF, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x10, 0x00, 0x03, 0xF8, 0x03, 0x00, 0x00, 0x7F, 0x00,
  0x78, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0xC0, 0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0xFF, 0x80, 0x01, 0xF8, 0x7F, 0xFC, 0x00, 0x7E, 0x3F, 0xFF, 0xC0,
  0x0F, 0xCF, 0xFF, 0xFC, 0x01, 0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFE, 0x1F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x07, 0xF0, 0x3F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC,
  0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x60, 0x3F, 0xF0,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x01,
  0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0xFE, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x03, 0xFE, 0x00, 0x01, 0xF8, 0x3F,
  0xE0, 0x00, 0x0F, 0xC3, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0xC0, 0x00, 0x01, 0xFB, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x9F, 0xC0, 0x00,
  0x0F, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x80, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x03,
  0xF1, 0xFC, 0x07, 0xF0, 0x03, 0xE7, 0xFE, 0x1F, 0xF8, 0x03, 0xEF, 0xFF,
  0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFC, 0x7F, 0xF0, 0xFE, 0x07, 0xF0, 0x3F, 0xE0, 0x7E, 0x07, 0xE0,
  0x1F, 0xC0, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x80,
  0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x3E, 0x00, 0xFC,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xF0, 0x1F,
  0xF0, 0x00, 0x3E, 0x0F, 0xFF, 0x80, 0x0F, 0xC7, 0xFF, 0xF8, 0x01, 0xF9,
  0xFF, 0xFF, 0x80, 0x3F, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xC1, 0xFF, 0x00,
  0xFF, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xFF, 0xBF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x0F, 0xF8, 0x00, 0x07,
  0xC3, 0xFF, 0xE0, 0x00, 0xFC, 0xFF, 0xFF, 0x00, 0x0F, 0xDF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x0F, 0xFC, 0x00, 0xFF, 0x80,
  0x1F, 0xE0, 0x1F, 0xF0, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x1F,
  0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xFB, 0xFF, 0xFF, 0x00,
  0x3F, 0x8F, 0xFF, 0xE0, 0x03, 0xF8, 0x7F, 0xF8, 0x00, 0x3F, 0x80, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x0F, 0xFF, 0xC3, 0xF0, 0x07, 0xFF, 0xFC,
  0xFC, 0x03, 0xFF, 0xFF, 0xBF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0,
  0xFF, 0xE0, 0x7F, 0xC0, 0x0F, 0xF8, 0x3F, 0xC0, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC7,
  0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F,
  0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x01,
  0xF8, 0xFE, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xEF, 0xC0, 0x03, 0xFF, 0xF3,
  0xF0, 0x00, 0x7F, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xFE, 0x01, 0xF8, 0x3F,
  0xFF, 0x01, 0xF8, 0xFF, 0xFE, 0x03, 0xF1, 0xFF, 0xFE, 0x03, 0xF3, 0xFF,
  0xFE, 0x03, 0xF7, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0C, 0x03, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8,
  0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x06, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF1, 0xFC,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x01, 0xFC,
  0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x80, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFD, 0xF8, 0x0F, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xFC, 0x7C, 0x00, 0xFF,
  0xFC, 0x7E, 0x00, 0x3F, 0xF8, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x03, 0xE0,
  0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x00, 0xF9, 0xF8,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0x80, 0x0F,
  0xBE, 0x00, 0x7E, 0x00, 0x7E, 0xF8, 0x01, 0xF8, 0x01, 0xFB, 0xE0, 0x07,
  0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x80, 0x3F, 0x3E, 0x00, 0xFE, 0x00, 0xF8,
  0xF8, 0x07, 0xF8, 0x03, 0xE3, 0xE0, 0x1F, 0xE0, 0x1F, 0x8F, 0x80, 0xFF,
  0x80, 0x7C, 0x3E, 0x03, 0xFE, 0x01, 0xF0, 0xF8, 0x0F, 0x7C, 0x0F, 0xC3,
  0xE0, 0x7D, 0xF0, 0x3E, 0x0F, 0x81, 0xF7, 0xC0, 0xF8, 0x3E, 0x0F, 0x9F,
  0x07, 0xC0, 0xF8, 0x3E, 0x7C, 0x1F, 0x03, 0xE0, 0xF1, 0xF0, 0x7C, 0x0F,
  0x87, 0xC7, 0xC3, 0xE0, 0x3E, 0x1F, 0x0F, 0x0F, 0x80, 0xF8, 0xF8, 0x3C,
  0x3C, 0x03, 0xE3, 0xE0, 0xF1, 0xF0, 0x0F, 0x9F, 0x03, 0xC7, 0xC0, 0x3E,
  0x7C, 0x0F, 0x3E, 0x00, 0xF9, 0xE0, 0x3C, 0xF8, 0x03, 0xEF, 0x80, 0xF3,
  0xE0, 0x0F, 0xBE, 0x03, 0xDF, 0x00, 0x3E, 0xF0, 0x0F, 0x7C, 0x00, 0xFF,
  0xC0, 0x3D, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE,
  0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0,
  0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF8,
  0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x02, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x78, 0x7F, 0xFF, 0x80, 0x01, 0xF1, 0xFF, 0xFF,
  0x80, 0x03, 0xE7, 0xFF, 0xFF, 0x80, 0x0F, 0xDF, 0xC0, 0xFF, 0x80, 0x1F,
  0x3F, 0x00, 0x7F, 0xC0, 0xFE, 0x7C, 0x00, 0x7F, 0xFF, 0xF9, 0xF0, 0x00,
  0x7F, 0xFF, 0xF3, 0xE0, 0x00, 0x7F, 0xFF, 0xC7, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
};

const GFXglyph RobotoMono_Italic71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 42, 0, -1 },
  { 1, 15, 50, 42, 13, -50 },
  { 95, 20, 16, 42, 14, -53 },
  { 135, 41, 50, 42, 1, -50 },
  { 392, 35, 66, 42, 4, -59 },
  { 681, 34, 52, 42, 4, -51 },
  { 902, 37, 52, 42, 2, -51 },
  { 1143, 8, 16, 42, 19, -53 },
  { 1159, 24, 73, 42, 11, -57 },
  { 1378, 23, 73, 42, 6, -57 },
  { 1588, 32, 34, 42, 8, -50 },
  { 1724, 35, 37, 42, 4, -42 },
  { 1886, 12, 20, 42, 7, -8 },
  { 1916, 27, 6, 42, 7, -25 },
  { 1937, 10, 10, 42, 14, -9 },
  { 1950, 36, 54, 42, 4, -50 },
  { 2193, 35, 52, 42, 4, -51 },
  { 2421, 21, 50, 42, 10, -50 },
  { 2553, 35, 51, 42, 1, -51 },
  { 2777, 35, 52, 42, 2, -51 },
  { 3005, 36, 50, 42, 1, -50 },
  { 3230, 36, 51, 42, 5, -50 },
  { 3460, 31, 52, 42, 4, -51 },
  { 3662, 35, 50, 42, 7, -50 },
  { 3881, 35, 52, 42, 4, -51 },
  { 4109, 31, 51, 42, 7, -51 },
  { 4307, 16, 40, 42, 15, -39 },
  { 4387, 19, 51, 42, 11, -39 },
  { 4509, 31, 31, 42, 6, -38 },
  { 4630, 34, 20, 42, 4, -33 },
  { 4715, 33, 31, 42, 3, -38 },
  { 4843, 29, 51, 42, 10, -51 },
  { 5028, 39, 51, 42, 2, -51 },
  { 5277, 37, 50, 42, -1, -50 },
  { 5509, 37, 50, 42, 2, -50 },
  { 5741, 37, 52, 42, 3, -51 },
  { 5982, 38, 50, 42, 2, -50 },
  { 6220, 39, 50, 42, 2, -50 },
  { 6464, 39, 50, 42, 3, -50 },
  { 6708, 37, 52, 42, 3, -51 },
  { 6949, 41, 50, 42, 1, -50 },
  { 7206, 39, 50, 42, 2, -50 },
  { 7450, 38, 51, 42, 2, -50 },
  { 7693, 42, 50, 42, 2, -50 },
  { 7956, 31, 50, 42, 3, -50 },
  { 8150, 41, 50, 42, 1, -50 },
  { 8407, 41, 50, 42, 1, -50 },
  { 8664, 35, 52, 42, 4, -51 },
  { 8892, 38, 50, 42, 3, -50 },
  { 9130, 37, 60, 42, 3, -51 },
  { 9408, 38, 50, 42, 2, -50 },
  { 9646, 37, 52, 42, 3, -51 },
  { 9887, 37, 50, 42, 7, -50 },
  { 10119, 38, 51, 42, 4, -50 },
  { 10362, 36, 50, 42, 7, -50 },
  { 10587, 39, 50, 42, 5, -50 },
  { 10831, 45, 50, 42, -1, -50 },
  { 11113, 37, 50, 42, 7, -50 },
  { 11345, 39, 50, 42, 1, -50 },
  { 11589, 24, 69, 42, 9, -58 },
  { 11796, 16, 54, 42, 13, -50 },
  { 11904, 24, 69, 42, 9, -58 },
  { 12111, 26, 27, 42, 8, -50 },
  { 12199, 31, 5, 42, 1, 0 },
  { 12219, 12, 9, 42, 19, -51 },
  { 12233, 33, 39, 42, 3, -38 },
  { 12394, 35, 54, 42, 2, -53 },
  { 12631, 33, 39, 42, 4, -38 },
  { 12792, 37, 54, 42, 4, -53 },
  { 13042, 33, 39, 42, 4, -38 },
  { 13203, 37, 55, 42, 7, -55 },
  { 13458, 36, 53, 42, 2, -38 },
  { 13697, 35, 53, 42, 2, -53 },
  { 13929, 32, 51, 42, 3, -51 },
  { 14133, 32, 66, 42, 1, -51 },
  { 14397, 37, 53, 42, 2, -53 },
  { 14643, 32, 53, 42, 3, -53 },
  { 14855, 40, 38, 42, 0, -38 },
  { 15045, 35, 38, 42, 2, -38 },
  { 15212, 34, 39, 42, 3, -38 },
  { 15378, 36, 52, 42, 0, -38 },
  { 15612, 34, 52, 42, 4, -38 },
  { 15833, 32, 38, 42, 7, -38 },
  { 15985, 33, 39, 42, 4, -38 },
  { 16146, 30, 48, 42, 7, -47 },
  { 16326, 33, 39, 42, 5, -38 },
  { 16487, 35, 38, 42, 6, -38 },
  { 16654, 38, 38, 42, 5, -38 },
  { 16835, 41, 38, 42, 0, -38 },
  { 17030, 43, 53, 42, -1, -38 },
  { 17315, 36, 38, 42, 2, -38 },
  { 17486, 27, 68, 42, 11, -55 },
  { 17716, 15, 64, 42, 13, -50 },
  { 17836, 28, 68, 42, 6, -55 },
  { 18074, 39, 14, 42, 1, -28 },
};

const GFXfont RobotoMono_Italic71pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic71pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic71pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _ROBOTOMONO_ITALIC71PT7B_H_
