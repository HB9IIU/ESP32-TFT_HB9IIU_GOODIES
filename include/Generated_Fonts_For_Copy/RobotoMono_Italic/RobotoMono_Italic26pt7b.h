#ifndef _ROBOTOMONO_ITALIC26PT7B_H_
#define _ROBOTOMONO_ITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x33, 0x9C, 0xC0, 0x00, 0x08, 0xE6,
  0x00, 0x63, 0x66, 0x66, 0x66, 0x46, 0xC6, 0xC4, 0x00, 0xC6, 0x03, 0x18,
  0x06, 0x30, 0x08, 0x40, 0x31, 0x83, 0xFF, 0xCF, 0xFF, 0x83, 0x18, 0x06,
  0x30, 0x18, 0xC0, 0x31, 0x83, 0xFF, 0xCF, 0xFF, 0x83, 0x18, 0x04, 0x20,
  0x18, 0xC0, 0x31, 0x80, 0xC6, 0x00, 0x01, 0x80, 0x18, 0x03, 0x80, 0xFE,
  0x1C, 0xF3, 0x87, 0x30, 0x33, 0x03, 0x30, 0x03, 0x80, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0xC0, 0x6C, 0x0E, 0xE1, 0xC7, 0xFC,
  0x3F, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x07, 0xC0, 0xCC, 0x0C, 0x46,
  0x84, 0x68, 0xCC, 0xCD, 0x87, 0x90, 0x03, 0x00, 0x60, 0x0C, 0x00, 0xDC,
  0x1B, 0xF3, 0x23, 0x36, 0x36, 0x63, 0x46, 0x30, 0x76, 0x03, 0xC0, 0x03,
  0x80, 0x7E, 0x03, 0x18, 0x38, 0xC1, 0x86, 0x0C, 0x70, 0x67, 0x03, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x86, 0xE6, 0x3E, 0x39, 0xE0, 0xDB, 0x07, 0xD8,
  0x1C, 0xE1, 0xE3, 0xFF, 0x8F, 0xCC, 0x6D, 0xED, 0xB0, 0x00, 0x81, 0xC1,
  0xC1, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x06, 0x03, 0x01, 0x80, 0x40,
  0x30, 0x0C, 0x02, 0x00, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x70, 0x70, 0x20, 0x00, 0x07,
  0x00, 0x60, 0x06, 0x0C, 0x62, 0xF7, 0xE7, 0xFF, 0x0E, 0x01, 0xE0, 0x3B,
  0x07, 0x30, 0xE1, 0x84, 0x10, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x3F, 0xFD, 0xFF, 0xF0, 0xE0, 0x07, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0xE0, 0x00, 0x19, 0xCE, 0x63, 0x33, 0x80, 0xFF, 0xFF, 0xC0, 0xEF,
  0xE0, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x0C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00,
  0x07, 0x81, 0xFE, 0x3C, 0xE3, 0x03, 0x70, 0x36, 0x03, 0x60, 0x7E, 0x0F,
  0xE3, 0xBC, 0x77, 0xDC, 0x7F, 0x86, 0xF0, 0x6C, 0x06, 0xC0, 0xEC, 0x0C,
  0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x0E, 0x7F, 0xFE, 0x70, 0xE1, 0x83, 0x06,
  0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0x01, 0xC0, 0x7F,
  0x87, 0x8E, 0x30, 0x33, 0x81, 0x98, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0xFF, 0xBF, 0xFC, 0x03, 0x80, 0xFE, 0x1C, 0x73, 0x03, 0x30, 0x34,
  0x03, 0x00, 0x30, 0x07, 0x01, 0xE0, 0xF8, 0x0F, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0xC0, 0x6C, 0x0E, 0xE1, 0xC7, 0xF8, 0x3F, 0x00, 0x00, 0x38, 0x01,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xB0, 0x0C, 0xC0, 0x73, 0x03, 0x8C, 0x0C,
  0x70, 0x61, 0xC3, 0x06, 0x1C, 0x18, 0x7F, 0xFF, 0xFF, 0xE0, 0x0E, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x1F, 0xF8, 0xFF, 0xC6, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xFE, 0x07, 0xF8, 0x70, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x60, 0x33, 0x03, 0x9C, 0x38, 0x7F, 0x81, 0xF8, 0x00, 0x00,
  0x30, 0x3E, 0x07, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x03, 0x7C, 0x6F,
  0xE7, 0x86, 0x70, 0x76, 0x03, 0x60, 0x36, 0x07, 0x60, 0x66, 0x06, 0x70,
  0xE3, 0xFC, 0x1F, 0x80, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0x80,
  0xFE, 0x1C, 0x73, 0x83, 0x30, 0x33, 0x03, 0x30, 0x33, 0x06, 0x1D, 0xE1,
  0xF8, 0x3F, 0xC6, 0x0E, 0xE0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xE1, 0xC7,
  0xF8, 0x3F, 0x00, 0x07, 0x01, 0xFC, 0x38, 0xE3, 0x06, 0x60, 0x76, 0x07,
  0x60, 0x36, 0x07, 0x60, 0x76, 0x0E, 0x71, 0xE3, 0xF6, 0x1E, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x0F, 0x07, 0xE0, 0x78, 0x00, 0x39, 0xCE, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xCE, 0x70, 0x0E, 0x3C, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC3, 0x86, 0x0C, 0x38, 0x61, 0x80, 0x00, 0x30, 0x0E,
  0x03, 0xE1, 0xF8, 0x7C, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3C,
  0x00, 0xC0, 0x7F, 0xF7, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0xFF,
  0xE0, 0x20, 0x03, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0x00, 0xF0,
  0x7C, 0x3F, 0x07, 0x80, 0xE0, 0x08, 0x00, 0x1E, 0x1F, 0xEF, 0x3F, 0x07,
  0xC0, 0xC0, 0x30, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x0C,
  0x00, 0x00, 0x00, 0x20, 0x1C, 0x07, 0x00, 0x00, 0x80, 0x1F, 0xC0, 0xE3,
  0x86, 0x02, 0x31, 0x8C, 0x8F, 0xB6, 0x64, 0xD3, 0x13, 0xCC, 0x4F, 0x23,
  0x3D, 0x8C, 0xA6, 0x22, 0x99, 0x9A, 0x7F, 0xCC, 0xEE, 0x30, 0x00, 0x60,
  0x01, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x36, 0x01, 0xB0, 0x19, 0xC0, 0xC6, 0x0E, 0x30, 0x61, 0x87, 0x0C, 0x3F,
  0xE3, 0xFF, 0x18, 0x19, 0xC0, 0xEC, 0x03, 0xE0, 0x1E, 0x00, 0xC0, 0x1F,
  0xF0, 0xFF, 0xCE, 0x06, 0x70, 0x33, 0x01, 0x98, 0x0C, 0xC0, 0xE7, 0xFC,
  0x7F, 0xC3, 0x87, 0x18, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x1B, 0x81, 0xDC,
  0x1C, 0xFF, 0xC7, 0xF8, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xE3, 0x86, 0x06,
  0x30, 0x18, 0xC0, 0x77, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0xCE, 0x03, 0x18, 0x1C, 0x70, 0xE0, 0xFF,
  0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xE7, 0xC3, 0x83, 0x0C, 0x0E, 0x30, 0x18,
  0xC0, 0x63, 0x01, 0x9C, 0x06, 0x70, 0x19, 0x80, 0x66, 0x01, 0x98, 0x0E,
  0x60, 0x33, 0x81, 0xCE, 0x0E, 0x30, 0x70, 0xFF, 0x83, 0xF8, 0x00, 0x1F,
  0xFC, 0x7F, 0xF1, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x0F,
  0xFC, 0x3F, 0xE1, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x38, 0x00, 0xFF, 0xE3, 0xFF, 0x80, 0x1F, 0xFC, 0x7F, 0xF1, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x3F, 0xF0, 0xFF,
  0x87, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xC1, 0xE7, 0x86, 0x06, 0x38, 0x1C,
  0xC0, 0x77, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x1F, 0xB8, 0x7E,
  0xE0, 0x3B, 0x80, 0xCE, 0x03, 0x18, 0x0C, 0x70, 0x70, 0xFF, 0x81, 0xF8,
  0x00, 0x1C, 0x06, 0x30, 0x0C, 0x60, 0x18, 0xC0, 0x71, 0x80, 0xC3, 0x01,
  0x8E, 0x03, 0x1F, 0xFE, 0x3F, 0xFC, 0x60, 0x38, 0xC0, 0x61, 0x80, 0xC7,
  0x01, 0x8C, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x31, 0xC0, 0x60, 0x1F,
  0xFC, 0x7F, 0xF0, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x80, 0xFF, 0xE3, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x73, 0x01, 0x8C, 0x0E, 0x38, 0x70, 0x7F,
  0x80, 0xFC, 0x00, 0x18, 0x1E, 0x30, 0x70, 0xE1, 0xC1, 0xC7, 0x03, 0x0C,
  0x06, 0x38, 0x0C, 0xE0, 0x1B, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xEE, 0x03,
  0x8C, 0x06, 0x1C, 0x0C, 0x18, 0x38, 0x38, 0x70, 0x70, 0xC0, 0x71, 0x80,
  0xE0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0xFF, 0xFF, 0xFE, 0x0E, 0x0E, 0x3C, 0x1C, 0x78, 0x78, 0xF0, 0xF1,
  0xE3, 0xE3, 0xCF, 0x8E, 0x9B, 0x19, 0xF6, 0x33, 0xCC, 0x67, 0xB8, 0xCE,
  0x71, 0x9C, 0xC7, 0x31, 0x8E, 0x03, 0x18, 0x06, 0x30, 0x1C, 0x60, 0x39,
  0xC0, 0x60, 0x1C, 0x06, 0x3C, 0x0C, 0x78, 0x38, 0xF0, 0x71, 0xF0, 0xC3,
  0x61, 0x8E, 0xC3, 0x1D, 0xC6, 0x31, 0x9C, 0x63, 0x38, 0xC7, 0x61, 0x86,
  0xC7, 0x0D, 0x8E, 0x1F, 0x18, 0x1E, 0x30, 0x3C, 0x60, 0x71, 0xC0, 0x60,
  0x03, 0x80, 0x7F, 0x07, 0x9C, 0x30, 0x73, 0x01, 0x98, 0x0D, 0xC0, 0x6C,
  0x03, 0x60, 0x1B, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x19, 0x81,
  0xCC, 0x0C, 0x70, 0xE1, 0xFE, 0x07, 0xE0, 0x1F, 0xF0, 0x61, 0xE1, 0x81,
  0xC6, 0x03, 0x38, 0x0C, 0xC0, 0x33, 0x01, 0xCC, 0x0E, 0x30, 0xF0, 0xFF,
  0x87, 0xF0, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xC1, 0xE7, 0x06, 0x0E, 0x30, 0x18,
  0xC0, 0x66, 0x01, 0x98, 0x07, 0x60, 0x1B, 0x80, 0x6E, 0x01, 0xB0, 0x06,
  0xC0, 0x3B, 0x80, 0xCE, 0x03, 0x18, 0x18, 0x70, 0xE0, 0xFF, 0x01, 0xFC,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0x80, 0x1F, 0xF0, 0x63, 0xE1, 0x81, 0x8E,
  0x06, 0x38, 0x1C, 0xC0, 0x63, 0x01, 0x8C, 0x0E, 0x31, 0xF1, 0xFF, 0x06,
  0x18, 0x18, 0x70, 0x60, 0xC1, 0x83, 0x06, 0x0E, 0x38, 0x18, 0xC0, 0x63,
  0x01, 0xC0, 0x03, 0xC0, 0x3F, 0xC1, 0xE7, 0x8E, 0x06, 0x38, 0x1C, 0xC0,
  0x73, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x30, 0x00, 0xCE, 0x03, 0x38, 0x0C, 0x70, 0x70, 0xFF, 0x81, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x00, 0x38, 0x0C, 0xC0, 0x33,
  0x00, 0xCC, 0x07, 0x30, 0x18, 0xC0, 0x67, 0x01, 0x98, 0x06, 0x60, 0x19,
  0x80, 0xE6, 0x03, 0x18, 0x0C, 0xE0, 0x33, 0x81, 0xC6, 0x06, 0x1C, 0x38,
  0x3F, 0xC0, 0x7C, 0x00, 0xC0, 0x3E, 0x01, 0xB0, 0x1D, 0xC0, 0xCE, 0x0E,
  0x70, 0x61, 0x87, 0x0C, 0x30, 0x63, 0x83, 0x18, 0x18, 0xC0, 0xEC, 0x03,
  0x60, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x63, 0x0D,
  0x8C, 0x36, 0x71, 0xB9, 0xC6, 0xC7, 0x9B, 0x36, 0x6C, 0xDB, 0x33, 0x6C,
  0xD9, 0xB3, 0x66, 0xCD, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x06, 0x00, 0x1C, 0x07, 0x0C, 0x0E, 0x0E, 0x1C,
  0x06, 0x38, 0x06, 0x30, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0C, 0xE0, 0x1C, 0x60, 0x38, 0x70,
  0x30, 0x30, 0x70, 0x38, 0xE0, 0x38, 0xC0, 0x3F, 0x03, 0x98, 0x38, 0xC1,
  0x87, 0x1C, 0x18, 0xC0, 0xCC, 0x06, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x01, 0x80, 0x00,
  0x1F, 0xFE, 0x3F, 0xF8, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xFF, 0xF1, 0xFF, 0xE0, 0x0F, 0x87,
  0xC3, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xF8, 0xF8, 0x00, 0xC3, 0x0C, 0x18, 0x61, 0x86, 0x18, 0x30, 0xC3, 0x0C,
  0x30, 0x61, 0x86, 0x18, 0x60, 0xC3, 0x0F, 0x87, 0xC0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x61, 0xF0, 0xF8, 0x00, 0x06,
  0x07, 0x83, 0xC3, 0xE1, 0xB1, 0x8C, 0xC6, 0xC3, 0xE1, 0x80, 0xFF, 0xFF,
  0xFF, 0xE6, 0x33, 0x07, 0xC1, 0xFE, 0x38, 0x73, 0x03, 0x00, 0x30, 0x03,
  0x1F, 0xF7, 0xC7, 0x60, 0x6E, 0x06, 0xE0, 0x6E, 0x1E, 0x7F, 0xE3, 0xE6,
  0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x33, 0xC3, 0xFE,
  0x3C, 0x73, 0x03, 0x70, 0x37, 0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x07,
  0xE0, 0x6F, 0x0E, 0xFF, 0xCD, 0xF8, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0xE0, 0x7C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x02, 0xC0, 0xCE, 0x1C,
  0x7F, 0x83, 0xF0, 0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x79, 0x87, 0xFE, 0x38, 0x78, 0xC0, 0xC7, 0x03, 0x18, 0x0C,
  0x60, 0x31, 0x81, 0xC6, 0x07, 0x18, 0x18, 0x60, 0x61, 0xC3, 0x83, 0xFE,
  0x07, 0xD8, 0x07, 0xC0, 0xFF, 0x0E, 0x1C, 0x60, 0x67, 0x03, 0x30, 0x19,
  0xFF, 0xDF, 0xFE, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0xC3, 0xFE, 0x0F,
  0xC0, 0x01, 0xF8, 0x1F, 0xC1, 0xC0, 0x1C, 0x00, 0xC0, 0x06, 0x03, 0xFF,
  0x9F, 0xFC, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0x98,
  0xFE, 0xCE, 0x1E, 0x60, 0x67, 0x03, 0x30, 0x19, 0x80, 0xCC, 0x0E, 0x60,
  0x73, 0x03, 0x18, 0x18, 0xE1, 0xC3, 0xFE, 0x0F, 0xB0, 0x03, 0x80, 0x18,
  0xC1, 0xC7, 0xFC, 0x1F, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x03, 0x80, 0x33, 0xC3, 0x7F, 0x3C, 0x73, 0x03, 0x70, 0x37, 0x03, 0x60,
  0x36, 0x03, 0x60, 0x76, 0x07, 0xE0, 0x6E, 0x06, 0xC0, 0x6C, 0x06, 0x00,
  0xC0, 0x1C, 0x00, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x30, 0x07, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x7E, 0x0F, 0xE0, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80,
  0x30, 0x4F, 0x07, 0xE0, 0xB0, 0x00, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0xE6, 0x0E, 0x30, 0xE1, 0x8E, 0x1D, 0xE0,
  0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xCC, 0x0C, 0x70, 0xE1, 0x87, 0x0E, 0x30,
  0x39, 0x81, 0xE0, 0x0F, 0xC1, 0xFC, 0x1F, 0xC0, 0x0C, 0x01, 0xC0, 0x1C,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x07, 0x00, 0x60, 0xFF, 0xFF, 0xFE, 0x37, 0x38, 0xFF,
  0xF3, 0x1C, 0xCC, 0x63, 0x71, 0x8D, 0x86, 0x36, 0x38, 0xD8, 0xC3, 0x63,
  0x1D, 0x8C, 0x6E, 0x31, 0xB0, 0xC6, 0xC7, 0x1B, 0x18, 0x60, 0x33, 0xC3,
  0x7F, 0x3C, 0x73, 0x03, 0x70, 0x37, 0x03, 0x60, 0x36, 0x03, 0x60, 0x76,
  0x07, 0xE0, 0x6E, 0x06, 0xC0, 0x6C, 0x06, 0x07, 0xC0, 0xFF, 0x0E, 0x1C,
  0x60, 0x66, 0x03, 0x30, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0x37, 0x01, 0x98,
  0x18, 0xE1, 0xC3, 0xFC, 0x0F, 0xC0, 0x19, 0xE0, 0xFF, 0x87, 0x0E, 0x30,
  0x33, 0x81, 0x9C, 0x0C, 0xC0, 0x66, 0x03, 0x30, 0x19, 0x81, 0xDC, 0x0C,
  0xE0, 0xE7, 0xFE, 0x37, 0xE1, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30,
  0x00, 0x07, 0x98, 0xFE, 0xCE, 0x1E, 0x60, 0x67, 0x03, 0x30, 0x19, 0x80,
  0xCC, 0x0E, 0x60, 0x73, 0x03, 0x18, 0x18, 0xE1, 0xC3, 0xFE, 0x0F, 0xB0,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x33, 0xE6, 0xFC, 0xF8,
  0x9C, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x00, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60, 0x17,
  0x00, 0x3E, 0x00, 0xF8, 0x01, 0xC0, 0x0E, 0xC0, 0xEE, 0x0C, 0x7F, 0xC3,
  0xF0, 0x06, 0x00, 0x60, 0x0E, 0x07, 0xFF, 0x7F, 0xE8, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0xFC, 0x0F, 0xC0, 0x70, 0x36, 0x03, 0x60, 0x76, 0x07, 0x60, 0x6E, 0x06,
  0xE0, 0x6C, 0x0E, 0xC0, 0xEC, 0x0C, 0xC0, 0xCE, 0x1C, 0xFF, 0xC7, 0xCC,
  0xC0, 0x3F, 0x01, 0x98, 0x1C, 0xC0, 0xC6, 0x0E, 0x38, 0x60, 0xC6, 0x06,
  0x30, 0x33, 0x01, 0x98, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xC2,
  0x0F, 0x1C, 0x6C, 0x71, 0xB1, 0xC6, 0xCF, 0x33, 0x2C, 0xCD, 0xB2, 0x36,
  0xD8, 0xF3, 0x63, 0xCD, 0x0E, 0x3C, 0x38, 0x60, 0xE1, 0x83, 0x06, 0x00,
  0x18, 0x0E, 0x38, 0x38, 0x30, 0xE0, 0x73, 0x80, 0x6E, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x1D, 0x80, 0x73, 0x81, 0xC3, 0x07, 0x07,
  0x1C, 0x07, 0x00, 0x30, 0x06, 0x70, 0x1C, 0x60, 0x70, 0xC0, 0xC1, 0x83,
  0x83, 0x86, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0xC0, 0x1D, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x01, 0xF0,
  0x03, 0xC0, 0x06, 0x00, 0x00, 0x3F, 0xF9, 0xFF, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0x7F, 0xF0, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0x83, 0xC0, 0xE0, 0x1C, 0x03, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x38, 0x04, 0x00,
  0x18, 0xC6, 0x31, 0x18, 0xC6, 0x31, 0x88, 0xC6, 0x31, 0x8C, 0x62, 0x31,
  0x8C, 0x63, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x1C, 0x07, 0x01, 0xC0, 0x30, 0x07, 0x01, 0xC1, 0xC0, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x03, 0xC0, 0xC0, 0x00, 0x3E,
  0x04, 0xFE, 0x0D, 0x8E, 0x36, 0x0F, 0xE0, 0x07, 0x00,
};

const GFXglyph RobotoMono_Italic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 5, 18, 15, 5, -18 },
  { 13, 8, 7, 15, 5, -20 },
  { 20, 15, 18, 15, 0, -18 },
  { 54, 12, 24, 15, 2, -21 },
  { 90, 12, 19, 15, 2, -19 },
  { 119, 13, 19, 15, 1, -19 },
  { 150, 3, 7, 15, 7, -20 },
  { 153, 9, 27, 15, 4, -21 },
  { 184, 9, 27, 15, 2, -21 },
  { 215, 12, 12, 15, 3, -18 },
  { 233, 13, 13, 15, 1, -15 },
  { 255, 5, 7, 15, 2, -3 },
  { 260, 9, 2, 15, 3, -9 },
  { 263, 4, 3, 15, 5, -3 },
  { 265, 14, 20, 15, 1, -18 },
  { 300, 12, 19, 15, 2, -19 },
  { 329, 7, 18, 15, 4, -18 },
  { 345, 13, 19, 15, 0, -19 },
  { 376, 12, 19, 15, 1, -19 },
  { 405, 14, 18, 15, 0, -18 },
  { 437, 13, 18, 15, 2, -18 },
  { 467, 12, 19, 15, 1, -19 },
  { 496, 13, 18, 15, 2, -18 },
  { 526, 12, 19, 15, 2, -19 },
  { 555, 12, 19, 15, 2, -19 },
  { 584, 5, 14, 15, 6, -14 },
  { 593, 7, 18, 15, 4, -14 },
  { 609, 12, 11, 15, 2, -14 },
  { 626, 12, 7, 15, 2, -12 },
  { 637, 12, 12, 15, 1, -14 },
  { 655, 10, 19, 15, 4, -19 },
  { 679, 14, 19, 15, 1, -19 },
  { 713, 13, 18, 15, 0, -18 },
  { 743, 13, 18, 15, 1, -18 },
  { 773, 14, 19, 15, 1, -19 },
  { 807, 14, 18, 15, 1, -18 },
  { 839, 14, 18, 15, 1, -18 },
  { 871, 14, 18, 15, 1, -18 },
  { 903, 14, 19, 15, 1, -19 },
  { 937, 15, 18, 15, 0, -18 },
  { 971, 14, 18, 15, 1, -18 },
  { 1003, 14, 18, 15, 1, -18 },
  { 1035, 15, 18, 15, 1, -18 },
  { 1069, 12, 18, 15, 1, -18 },
  { 1096, 15, 18, 15, 0, -18 },
  { 1130, 15, 18, 15, 0, -18 },
  { 1164, 13, 19, 15, 1, -19 },
  { 1195, 14, 18, 15, 1, -18 },
  { 1227, 14, 22, 15, 1, -19 },
  { 1266, 14, 18, 15, 1, -18 },
  { 1298, 14, 19, 15, 1, -19 },
  { 1332, 14, 18, 15, 2, -18 },
  { 1364, 14, 18, 15, 1, -18 },
  { 1396, 13, 18, 15, 3, -18 },
  { 1426, 14, 18, 15, 2, -18 },
  { 1458, 16, 18, 15, 0, -18 },
  { 1494, 13, 18, 15, 3, -18 },
  { 1524, 15, 18, 15, 0, -18 },
  { 1558, 9, 25, 15, 3, -21 },
  { 1587, 6, 20, 15, 5, -18 },
  { 1602, 9, 25, 15, 3, -21 },
  { 1631, 9, 9, 15, 3, -18 },
  { 1642, 12, 2, 15, 0, 0 },
  { 1645, 4, 4, 15, 7, -19 },
  { 1647, 12, 14, 15, 1, -14 },
  { 1668, 12, 20, 15, 1, -20 },
  { 1698, 12, 14, 15, 2, -14 },
  { 1719, 14, 20, 15, 1, -20 },
  { 1754, 13, 14, 15, 1, -14 },
  { 1777, 13, 20, 15, 3, -20 },
  { 1810, 13, 19, 15, 1, -14 },
  { 1841, 12, 20, 15, 1, -20 },
  { 1871, 12, 19, 15, 1, -19 },
  { 1900, 12, 25, 15, 0, -19 },
  { 1938, 13, 20, 15, 1, -20 },
  { 1971, 12, 20, 15, 1, -20 },
  { 2001, 14, 14, 15, 0, -14 },
  { 2026, 12, 14, 15, 1, -14 },
  { 2047, 13, 14, 15, 1, -14 },
  { 2070, 13, 19, 15, 0, -14 },
  { 2101, 13, 19, 15, 1, -14 },
  { 2132, 11, 14, 15, 3, -14 },
  { 2152, 12, 14, 15, 2, -14 },
  { 2173, 12, 17, 15, 2, -17 },
  { 2199, 12, 14, 15, 2, -14 },
  { 2220, 13, 14, 15, 2, -14 },
  { 2243, 14, 14, 15, 2, -14 },
  { 2268, 15, 14, 15, 0, -14 },
  { 2295, 15, 20, 15, 0, -14 },
  { 2333, 13, 14, 15, 1, -14 },
  { 2356, 10, 25, 15, 4, -20 },
  { 2388, 5, 23, 15, 5, -18 },
  { 2403, 10, 25, 15, 2, -20 },
  { 2435, 15, 5, 15, 0, -10 },
};

const GFXfont RobotoMono_Italic26pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic26pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _ROBOTOMONO_ITALIC26PT7B_H_
