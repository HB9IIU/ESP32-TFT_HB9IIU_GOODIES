#ifndef _ROBOTOMONO_ITALIC51PT7B_H_
#define _ROBOTOMONO_ITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0, 0x3C, 0x1E,
  0x78, 0x38, 0xE0, 0xF1, 0xC1, 0xE7, 0x83, 0xCF, 0x07, 0x1E, 0x0E, 0x38,
  0x1C, 0x70, 0x78, 0xE0, 0xF3, 0xC1, 0xC7, 0x83, 0x80, 0x00, 0x01, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xE0, 0x38, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x78, 0x1E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01,
  0xE0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x03, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03, 0x80, 0x00, 0x70, 0x1C, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0xF0, 0x38, 0x03, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x78, 0x00, 0x0E,
  0x03, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x1E,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x01, 0xFC, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x78, 0x00,
  0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC0, 0xFF, 0x7F, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0x8F, 0x00, 0x07,
  0x83, 0x80, 0x03, 0x81, 0xC0, 0x41, 0xC0, 0xF0, 0x79, 0xE0, 0x78, 0x38,
  0xF0, 0x38, 0x3C, 0x78, 0x1C, 0x3C, 0x3C, 0x0E, 0x1C, 0x1E, 0x0F, 0x1E,
  0x07, 0x8F, 0x1E, 0x03, 0xFF, 0x9E, 0x00, 0xFF, 0x8F, 0x00, 0x3F, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC7, 0xF0, 0x03,
  0xC7, 0xFC, 0x01, 0xC7, 0xFF, 0x01, 0xE7, 0x87, 0x81, 0xE3, 0x81, 0xC0,
  0xE1, 0xC0, 0xE0, 0xF1, 0xE0, 0x70, 0xF0, 0xF0, 0x38, 0xF0, 0x78, 0x1C,
  0x18, 0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x06, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00,
  0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0xF0, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE7, 0xE0, 0x00, 0x3D, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x1E, 0x1F, 0xBE, 0x03,
  0xC7, 0xE3, 0xE0, 0x79, 0xF8, 0x3C, 0x1E, 0x3E, 0x07, 0xC3, 0xCF, 0x80,
  0x7C, 0xF9, 0xF0, 0x0F, 0x9E, 0x3C, 0x00, 0xFF, 0xC7, 0x80, 0x1F, 0xF0,
  0xF0, 0x01, 0xFC, 0x1E, 0x00, 0x3F, 0x83, 0xE0, 0x07, 0xE0, 0x7E, 0x01,
  0xFE, 0x07, 0xF1, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xCF, 0xC0,
  0x3F, 0xE0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xDE, 0xF7, 0xB9, 0xDE,
  0xF7, 0xB9, 0xC0, 0x00, 0x01, 0x00, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xF0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x30, 0x00, 0x08, 0x00, 0x00, 0x80, 0x00, 0x60,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x30, 0x1C,
  0x06, 0x7E, 0x1C, 0x3E, 0x7F, 0x9C, 0xFE, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xCF, 0x00, 0x07, 0xCF, 0x00, 0x0F, 0x87, 0x80, 0x1F, 0x07,
  0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x1C, 0x03, 0xC0, 0x08, 0x01,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFC,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x87, 0xC3, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x7C, 0x3E, 0x3E, 0x1E, 0x1F,
  0x07, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x08, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9, 0xE0, 0x03, 0xFC, 0xF0, 0x03,
  0xFE, 0x78, 0x07, 0xFE, 0x7C, 0x07, 0xEF, 0x3E, 0x07, 0xE7, 0x9F, 0x0F,
  0xC7, 0xCF, 0x0F, 0xC3, 0xE7, 0x9F, 0x81, 0xF3, 0xDF, 0x80, 0xF3, 0xFF,
  0x00, 0x79, 0xFF, 0x00, 0x3C, 0xFF, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x1E, 0x00, 0x07, 0x8F, 0x80, 0x07, 0xC3, 0xC0, 0x03, 0xC1,
  0xE0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x87, 0xF0,
  0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x7C, 0x07, 0xF8, 0x3F, 0xF3, 0xFF, 0xCF, 0xFF,
  0x9F, 0xCF, 0x7C, 0x1E, 0xC0, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xF8,
  0x3F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0x83, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0x87, 0x80, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x9F, 0x00,
  0x07, 0xCF, 0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF8,
  0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC3, 0xF8, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x7C, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xE7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0xC0,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0x78, 0x07, 0x80, 0x1E, 0x03, 0xE0, 0x07, 0x81,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F,
  0x80, 0xFC, 0x01, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x0F,
  0x87, 0x80, 0x07, 0xC3, 0xE0, 0x07, 0xC0, 0xF8, 0x07, 0xE0, 0x7F, 0x0F,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x1F, 0x00, 0xF1, 0xFF, 0x03, 0xDF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xC1,
  0xF9, 0xFC, 0x03, 0xE7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0x78, 0x00, 0xF9, 0xF0, 0x03,
  0xE7, 0xC0, 0x1F, 0x0F, 0x80, 0xF8, 0x3F, 0x8F, 0xE0, 0x7F, 0xFF, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x7F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0x83, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0xFE, 0x3F, 0x80, 0xF8, 0x07, 0xC0, 0xF8, 0x01,
  0xF0, 0x78, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE1, 0xE0,
  0x01, 0xF0, 0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC3, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFF, 0xF8, 0x1F,
  0xC3, 0xF0, 0x7C, 0x03, 0xE3, 0xE0, 0x0F, 0x9F, 0x00, 0x1E, 0x7C, 0x00,
  0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x03, 0xE7, 0x80, 0x1F, 0x9F, 0x00, 0xFE, 0x7E, 0x0F, 0xF8, 0xFF, 0xFF,
  0xE1, 0xFF, 0xEF, 0x03, 0xFF, 0x3C, 0x03, 0xE1, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x06, 0x03, 0xE0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x07, 0xC0, 0x20, 0x00,
  0x00, 0x20, 0x03, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0x80, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F,
  0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x08, 0x00,
  0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x18, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF8, 0x7F, 0x3F,
  0x00, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x7C,
  0x07, 0xC0, 0x1E, 0x00, 0x38, 0x07, 0x80, 0x03, 0x81, 0xE0, 0x00, 0x70,
  0x78, 0x1E, 0x07, 0x0E, 0x0F, 0xF0, 0xE3, 0xC3, 0xFF, 0x1C, 0x70, 0xF8,
  0xE3, 0x9C, 0x1C, 0x18, 0x73, 0x87, 0x03, 0x0E, 0xF1, 0xE0, 0xE1, 0xDC,
  0x38, 0x1C, 0x3B, 0x87, 0x03, 0x87, 0x71, 0xE0, 0x60, 0xFC, 0x38, 0x1C,
  0x1F, 0x87, 0x03, 0x83, 0x70, 0xE0, 0x70, 0x6E, 0x1C, 0x0C, 0x1D, 0xC7,
  0x83, 0x83, 0xB8, 0xF0, 0x70, 0x67, 0x0E, 0x1E, 0x1C, 0xE1, 0xEF, 0xC7,
  0x1C, 0x3F, 0xFF, 0xE3, 0x87, 0xF3, 0xF8, 0x70, 0x78, 0x3C, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x04, 0x00,
  0x3F, 0x03, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3E,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x0F, 0x81, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x03,
  0xC0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0xF1, 0xF0,
  0x00, 0x1E, 0x3E, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x0F,
  0x7C, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xC0, 0x1F, 0x81, 0xE0, 0x01, 0xF0,
  0x78, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00,
  0xF0, 0xF8, 0x00, 0x7C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0xC0,
  0x07, 0xC1, 0xF0, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x78,
  0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x07, 0xF0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0x81, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x7C,
  0x00, 0x0F, 0x8F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x01, 0xF0, 0x03,
  0xE0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3C, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x87,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x1F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07,
  0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE0,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x7F, 0x03, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x80, 0x1F, 0xC3, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC1, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xFF, 0xC7, 0x80, 0x3F, 0xF8, 0xF0,
  0x07, 0xFF, 0x3E, 0x01, 0xFF, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x7E, 0x03, 0xFC, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xE0,
  0x78, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3E, 0x07, 0x80, 0x01, 0xE0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xF0,
  0x3C, 0x00, 0x0F, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0x78, 0x1F, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xC0, 0xF8,
  0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x7C, 0x0F, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x18, 0x00,
  0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC1,
  0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x9F,
  0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x06, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x7E, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x1E, 0x00,
  0xFC, 0x00, 0x78, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xC1, 0xF8, 0x00,
  0x0F, 0x0F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0x80, 0x00, 0xFE, 0x3E,
  0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00,
  0x78, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0x80, 0x3E,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x07, 0xF0, 0x7F, 0x00, 0x7F, 0x03, 0xFC, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0xC0, 0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1E, 0xF0, 0x3F,
  0xC0, 0xF7, 0x83, 0xCE, 0x0F, 0x78, 0x1E, 0x70, 0x7B, 0xC0, 0xF3, 0xC7,
  0x9E, 0x07, 0x9E, 0x3C, 0xF0, 0x3C, 0xF3, 0xC7, 0x81, 0xE7, 0xBE, 0x7C,
  0x1F, 0x3D, 0xE3, 0xC0, 0xF0, 0xFF, 0x1E, 0x07, 0x87, 0xF0, 0xF0, 0x3C,
  0x3F, 0x87, 0x81, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C,
  0x1E, 0x07, 0xC3, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x81, 0xE0, 0x70, 0x7C,
  0x0F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1E, 0x07, 0xC0, 0x00, 0xF0, 0x3C,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xE0, 0x78, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x3E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x3C,
  0x0F, 0xE0, 0x01, 0xE0, 0x7F, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0xF8, 0x1F,
  0xE0, 0x07, 0xC0, 0xFF, 0x00, 0x3E, 0x07, 0xF8, 0x01, 0xE0, 0x7F, 0xE0,
  0x0F, 0x03, 0xEF, 0x00, 0xF8, 0x1F, 0x78, 0x07, 0xC0, 0xFB, 0xE0, 0x3E,
  0x07, 0x8F, 0x01, 0xF0, 0x3C, 0x78, 0x0F, 0x03, 0xE3, 0xE0, 0x78, 0x1F,
  0x0F, 0x07, 0xC0, 0xF8, 0x78, 0x3E, 0x07, 0x83, 0xE1, 0xF0, 0x3C, 0x0F,
  0x0F, 0x81, 0xE0, 0x78, 0x78, 0x1F, 0x03, 0xE3, 0xC0, 0xF8, 0x0F, 0x3E,
  0x07, 0xC0, 0x79, 0xF0, 0x3C, 0x03, 0xEF, 0x81, 0xE0, 0x0F, 0x78, 0x1F,
  0x00, 0x7B, 0xC0, 0xF8, 0x03, 0xFE, 0x07, 0xC0, 0x0F, 0xF0, 0x3E, 0x00,
  0x7F, 0x81, 0xE0, 0x03, 0xFC, 0x0F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0x8F, 0xE0, 0x3F, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x1E, 0x1F, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0xCF, 0x80, 0x01, 0xE7, 0x80,
  0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x0F,
  0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xE0, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x0F, 0x80,
  0x01, 0xE0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0x3E,
  0x0F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x81, 0xF0,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0xFC, 0x07,
  0xE0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0xC7, 0xC0,
  0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3D, 0xF0, 0x00, 0x0F, 0x7C, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xCF, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x7C,
  0x78, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xC0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x7C, 0x3E,
  0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x1F, 0x00, 0x7F, 0x03, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x78, 0x07,
  0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x78,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xC3, 0xF8, 0x0F, 0xC0, 0x1F, 0x81,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3,
  0xF0, 0x01, 0xF0, 0x3F, 0x00, 0xFE, 0x07, 0xFC, 0xFF, 0x80, 0x7F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F,
  0x8F, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80,
  0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF0,
  0xF8, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF8, 0x78, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01,
  0xE1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xF0, 0xF0,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x3E,
  0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x9F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x7C,
  0x0F, 0x00, 0x1F, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xE0, 0x3C, 0x00,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x1E,
  0x03, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x0F, 0x80, 0x07, 0xC3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x3E, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xF7, 0x80, 0xF0, 0x1E, 0x78,
  0x0F, 0x01, 0xE7, 0x81, 0xF0, 0x1E, 0x78, 0x1F, 0x03, 0xE7, 0x81, 0xF8,
  0x3C, 0x78, 0x3F, 0x83, 0xC7, 0x83, 0xF8, 0x3C, 0x78, 0x3F, 0x87, 0xC7,
  0x87, 0xF8, 0x78, 0x78, 0x7F, 0x87, 0x87, 0x87, 0x78, 0x78, 0x78, 0xF7,
  0x8F, 0x07, 0x8F, 0x78, 0xF0, 0x78, 0xE7, 0x8F, 0x0F, 0x1E, 0x78, 0xF0,
  0xF1, 0xE7, 0x9E, 0x0F, 0x1C, 0x79, 0xE0, 0xF3, 0xC7, 0x9E, 0x0F, 0x3C,
  0x7B, 0xE0, 0xF3, 0x87, 0xBC, 0x0F, 0x78, 0x7B, 0xC0, 0xF7, 0x87, 0xBC,
  0x0F, 0x70, 0x7F, 0x80, 0xFF, 0x07, 0xF8, 0x0F, 0xF0, 0x7F, 0x80, 0xFE,
  0x07, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0x80, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1E, 0x01,
  0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x78, 0x3E,
  0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xBC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03,
  0xF0, 0xF0, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x7C,
  0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x01,
  0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x3C, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0,
  0x7F, 0xE0, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0xF0, 0x07, 0xFC,
  0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1E, 0xF0, 0x0F, 0xBC,
  0x03, 0xCF, 0x01, 0xF3, 0xC0, 0x78, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x87,
  0x81, 0xE3, 0xE0, 0x78, 0xF0, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0x80,
  0x3C, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E, 0x0E, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xF0, 0xFE, 0x0F,
  0xC0, 0x3E, 0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x3E, 0x3E, 0x00, 0x3E, 0x7C,
  0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0x78, 0x01, 0xF8, 0x7C, 0x03, 0xF8, 0x7F, 0xBF, 0xF8, 0x3F,
  0xFF, 0x78, 0x1F, 0xFE, 0x7C, 0x0F, 0xF8, 0x7C, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x9F, 0xF0, 0x0F,
  0x3F, 0xF8, 0x0F, 0x7F, 0xFC, 0x0F, 0xFD, 0xFE, 0x0F, 0xE0, 0x3E, 0x1F,
  0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3E, 0x00, 0x0F, 0x3C,
  0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7E,
  0x00, 0xFC, 0xFF, 0x01, 0xF8, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xE0, 0xF3,
  0xFF, 0xC0, 0xF1, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xF1, 0xFC, 0x0F,
  0xC0, 0x7C, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x01, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7C, 0x78,
  0x00, 0x78, 0x7C, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x3F, 0x8F, 0xE0, 0x1F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x03,
  0xFE, 0x3C, 0x03, 0xFF, 0xCF, 0x01, 0xFF, 0xFF, 0xC0, 0xFF, 0x3F, 0xF0,
  0x7E, 0x01, 0xFC, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x01,
  0xE1, 0xF0, 0x00, 0x78, 0x7C, 0x00, 0x3E, 0x1E, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE3, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x0F,
  0x00, 0x07, 0xC3, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x1E,
  0x0F, 0x80, 0x07, 0x81, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0x80,
  0xFE, 0x03, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFE, 0xF0, 0x01,
  0xFE, 0x3C, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xF1, 0xFC, 0x0F, 0xC0, 0x7C,
  0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x20,
  0x7C, 0x00, 0x70, 0x7E, 0x00, 0xF8, 0x3F, 0x87, 0xF0, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x7C, 0x03,
  0xFF, 0xCF, 0x00, 0xFF, 0xFD, 0xE0, 0x3F, 0xCF, 0xFC, 0x0F, 0xC0, 0x3F,
  0x81, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0x83, 0xE0,
  0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8,
  0x7C, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00,
  0x1F, 0x07, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x03,
  0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x0F, 0xE7, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0xF0, 0x00,
  0xFF, 0x1E, 0x00, 0x02, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E,
  0x01, 0x00, 0x07, 0xC0, 0x70, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x01, 0xF8,
  0x3F, 0x80, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x8F, 0xF0, 0x0F, 0x1F, 0xFC, 0x0F, 0x7F, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0xE0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFC, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x3F, 0x03, 0xC0, 0x1F,
  0x80, 0xF0, 0x0F, 0xC0, 0x3C, 0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xC1,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0x78, 0xFE, 0x00, 0x1E, 0x7E, 0x00, 0x07,
  0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x03, 0xFB, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x1F, 0x80, 0x78,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0,
  0xF0, 0x00, 0xFC, 0x3C, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0x0F, 0x3F, 0x0F,
  0xC0, 0xF7, 0xF9, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF, 0x0F,
  0x87, 0xE0, 0xF1, 0xF0, 0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xF1, 0xE0, 0x7C,
  0x0F, 0x1E, 0x07, 0xC0, 0xF1, 0xE0, 0x78, 0x0F, 0x1E, 0x07, 0x81, 0xF3,
  0xE0, 0x78, 0x1F, 0x3C, 0x07, 0x81, 0xE3, 0xC0, 0xF8, 0x1E, 0x3C, 0x0F,
  0x81, 0xE3, 0xC0, 0xF0, 0x1E, 0x7C, 0x0F, 0x03, 0xE7, 0xC0, 0xF0, 0x3E,
  0x78, 0x0F, 0x03, 0xC7, 0x81, 0xF0, 0x3C, 0x78, 0x1F, 0x03, 0xC7, 0x81,
  0xE0, 0x3C, 0xF8, 0x1E, 0x07, 0xCF, 0x81, 0xE0, 0x7C, 0xF0, 0x1E, 0x07,
  0x8F, 0x03, 0xE0, 0x78, 0xF0, 0x3E, 0x07, 0x80, 0x0F, 0x0F, 0xF0, 0x0F,
  0x3F, 0xFC, 0x0F, 0x7F, 0xFE, 0x0F, 0xFD, 0xFE, 0x0F, 0xE0, 0x3F, 0x1F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x1E,
  0x00, 0x0F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78,
  0x00, 0x3C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x1F, 0xC0, 0x7E, 0x01, 0xF0,
  0x3E, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x07,
  0x8F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xC0, 0x00,
  0x7D, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0,
  0x03, 0xE0, 0xF0, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x1F, 0x87, 0xF0, 0x07,
  0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x03, 0xC7, 0xFC, 0x00, 0xF7, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFE, 0x07, 0xF0, 0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x1E,
  0x00, 0x1F, 0x07, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x3C,
  0x3E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xF0, 0xF0, 0x00,
  0x7C, 0x3C, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xE1, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x83,
  0xF8, 0x07, 0xE0, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0x3F, 0xFC,
  0x03, 0xC7, 0xFC, 0x01, 0xF0, 0x08, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC7, 0xC0, 0xFF, 0xF3, 0xC0, 0xFF,
  0xFD, 0xE0, 0xFF, 0x1F, 0xF0, 0xFC, 0x03, 0xF8, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x1F, 0x00, 0x0F, 0x8F,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x00, 0xF1,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x1E,
  0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07,
  0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x8F, 0xF0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xBC, 0x00, 0xFF, 0x1E, 0x00, 0x08, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x20, 0x0F, 0x0F, 0xFC, 0x1E, 0x3F, 0xF8, 0x3D, 0xFF, 0xE0,
  0xFF, 0xFF, 0xC1, 0xFF, 0x80, 0x83, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x0F, 0xF1, 0xFC, 0x0F, 0x80, 0x7E,
  0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x78, 0x7C, 0x01, 0xF8, 0x3F, 0x87, 0xF0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x00, 0x30, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xE0, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xCF, 0x00, 0x7F, 0xFC, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x3C, 0x00,
  0x3E, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x7C, 0x00, 0x3C, 0x78, 0x00,
  0x7C, 0x78, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0xF8, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x07, 0xF0, 0x7E, 0x3F, 0xF0, 0x7F, 0xFD, 0xE0, 0x3F, 0xF9,
  0xE0, 0x1F, 0xF1, 0xE0, 0x01, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xBC, 0x00,
  0x07, 0x9E, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xC7, 0xC0, 0x03, 0xE1, 0xE0,
  0x01, 0xE0, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x0F,
  0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x7C, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F, 0x00,
  0x03, 0x8F, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0xFF,
  0x00, 0xF0, 0x1E, 0xF0, 0x0F, 0x01, 0xEF, 0x01, 0xF0, 0x1E, 0xF0, 0x1F,
  0x03, 0xCF, 0x03, 0xF0, 0x3C, 0xF0, 0x3F, 0x03, 0x87, 0x07, 0xF0, 0x78,
  0x70, 0x77, 0x07, 0x87, 0x07, 0x70, 0x70, 0x70, 0xF7, 0x0F, 0x07, 0x0E,
  0x70, 0xF0, 0x71, 0xE7, 0x0E, 0x07, 0x1C, 0x71, 0xE0, 0x71, 0xC7, 0x1C,
  0x07, 0x3C, 0x79, 0xC0, 0x73, 0x87, 0xBC, 0x07, 0x78, 0x7B, 0x80, 0x77,
  0x03, 0xB8, 0x07, 0x70, 0x3F, 0x80, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xE0, 0xFC, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x3C, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xE0, 0x3E, 0x00, 0x3F, 0x00, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x00,
  0x1F, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80,
  0x03, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x0F, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x00,
  0x7C, 0x78, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x0F,
  0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x30, 0x00, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0x80, 0x70, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0x80, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0x3F, 0xFC, 0x00, 0xF7, 0xFF,
  0xE0, 0x0E, 0x7C, 0x3F, 0x01, 0xEF, 0x01, 0xFC, 0x3E, 0xF0, 0x0F, 0xFF,
  0xCE, 0x00, 0x3F, 0xF8, 0x20, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xE0,
};

const GFXglyph RobotoMono_Italic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 10, 36, 30, 10, -36 },
  { 46, 15, 12, 30, 10, -38 },
  { 69, 29, 36, 30, 1, -36 },
  { 200, 25, 47, 30, 3, -42 },
  { 347, 25, 38, 30, 3, -37 },
  { 466, 27, 38, 30, 1, -37 },
  { 595, 5, 12, 30, 14, -38 },
  { 603, 17, 53, 30, 8, -41 },
  { 716, 17, 53, 30, 4, -41 },
  { 829, 24, 24, 30, 5, -36 },
  { 901, 25, 26, 30, 3, -30 },
  { 983, 9, 13, 30, 5, -5 },
  { 998, 19, 4, 30, 5, -18 },
  { 1008, 7, 8, 30, 10, -7 },
  { 1015, 26, 39, 30, 3, -36 },
  { 1142, 25, 38, 30, 3, -37 },
  { 1261, 15, 36, 30, 7, -36 },
  { 1329, 26, 37, 30, 0, -37 },
  { 1450, 25, 38, 30, 1, -37 },
  { 1569, 26, 36, 30, 1, -36 },
  { 1686, 25, 37, 30, 4, -36 },
  { 1802, 22, 37, 30, 3, -36 },
  { 1904, 25, 36, 30, 5, -36 },
  { 2017, 25, 38, 30, 3, -37 },
  { 2136, 22, 37, 30, 5, -37 },
  { 2238, 11, 30, 30, 11, -29 },
  { 2280, 14, 37, 30, 8, -29 },
  { 2345, 23, 23, 30, 4, -28 },
  { 2412, 24, 14, 30, 3, -23 },
  { 2454, 23, 22, 30, 3, -27 },
  { 2518, 21, 37, 30, 7, -37 },
  { 2616, 27, 36, 30, 2, -36 },
  { 2738, 27, 36, 30, -1, -36 },
  { 2860, 26, 36, 30, 2, -36 },
  { 2977, 27, 38, 30, 2, -37 },
  { 3106, 27, 36, 30, 1, -36 },
  { 3228, 28, 36, 30, 2, -36 },
  { 3354, 28, 36, 30, 2, -36 },
  { 3480, 27, 38, 30, 2, -37 },
  { 3609, 29, 36, 30, 1, -36 },
  { 3740, 27, 36, 30, 2, -36 },
  { 3862, 27, 37, 30, 2, -36 },
  { 3987, 30, 36, 30, 2, -36 },
  { 4122, 23, 36, 30, 2, -36 },
  { 4226, 29, 36, 30, 1, -36 },
  { 4357, 29, 36, 30, 1, -36 },
  { 4488, 25, 38, 30, 3, -37 },
  { 4607, 28, 36, 30, 2, -36 },
  { 4733, 26, 43, 30, 2, -37 },
  { 4873, 27, 36, 30, 2, -36 },
  { 4995, 27, 38, 30, 2, -37 },
  { 5124, 27, 36, 30, 5, -36 },
  { 5246, 27, 37, 30, 3, -36 },
  { 5371, 26, 36, 30, 5, -36 },
  { 5488, 28, 36, 30, 4, -36 },
  { 5614, 31, 36, 30, 0, -36 },
  { 5754, 27, 36, 30, 5, -36 },
  { 5876, 29, 36, 30, 0, -36 },
  { 6007, 17, 49, 30, 7, -41 },
  { 6112, 12, 39, 30, 9, -36 },
  { 6171, 18, 49, 30, 6, -41 },
  { 6282, 18, 19, 30, 6, -36 },
  { 6325, 23, 4, 30, 0, 0 },
  { 6337, 8, 7, 30, 14, -37 },
  { 6344, 24, 29, 30, 2, -28 },
  { 6431, 24, 39, 30, 2, -38 },
  { 6548, 24, 29, 30, 3, -28 },
  { 6635, 26, 39, 30, 3, -38 },
  { 6762, 24, 29, 30, 3, -28 },
  { 6849, 26, 39, 30, 5, -39 },
  { 6976, 27, 39, 30, 1, -28 },
  { 7108, 24, 38, 30, 2, -38 },
  { 7222, 23, 37, 30, 2, -37 },
  { 7329, 23, 48, 30, 1, -37 },
  { 7467, 26, 38, 30, 2, -38 },
  { 7591, 23, 38, 30, 2, -38 },
  { 7701, 28, 27, 30, 0, -27 },
  { 7796, 24, 27, 30, 2, -27 },
  { 7877, 25, 29, 30, 2, -28 },
  { 7968, 26, 37, 30, 0, -27 },
  { 8089, 25, 38, 30, 3, -28 },
  { 8208, 23, 28, 30, 5, -28 },
  { 8289, 24, 28, 30, 3, -27 },
  { 8373, 22, 34, 30, 5, -33 },
  { 8467, 24, 28, 30, 4, -27 },
  { 8551, 25, 27, 30, 4, -27 },
  { 8636, 28, 27, 30, 3, -27 },
  { 8731, 29, 27, 30, 0, -27 },
  { 8829, 31, 38, 30, -1, -27 },
  { 8977, 25, 27, 30, 2, -27 },
  { 9062, 20, 49, 30, 8, -40 },
  { 9185, 11, 46, 30, 9, -36 },
  { 9249, 20, 49, 30, 4, -40 },
  { 9372, 28, 10, 30, 1, -20 },
};

const GFXfont RobotoMono_Italic51pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic51pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _ROBOTOMONO_ITALIC51PT7B_H_
