#ifndef _ROBOTOMONO_ITALIC11PT7B_H_
#define _ROBOTOMONO_ITALIC11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x62, 0xB4, 0x14, 0x29, 0xF9, 0x42, 0x9F, 0x94, 0x28, 0x11,
  0x92, 0x94, 0x18, 0x72, 0xF2, 0x00, 0xC5, 0x6C, 0xC2, 0x3E, 0xA7, 0x38,
  0xA2, 0x8C, 0x77, 0x58, 0x9F, 0xC0, 0x25, 0x49, 0x24, 0x91, 0x20, 0x42,
  0x22, 0x12, 0x22, 0x24, 0x88, 0x11, 0x3E, 0x4D, 0x00, 0x21, 0x3E, 0x44,
  0x00, 0x58, 0xF0, 0xC0, 0x08, 0x84, 0x42, 0x21, 0x10, 0x80, 0x72, 0x63,
  0x3E, 0xC6, 0x5C, 0x3D, 0x24, 0x92, 0x39, 0x10, 0x42, 0x10, 0x84, 0x3E,
  0x39, 0x10, 0x42, 0x38, 0x28, 0x9C, 0x0C, 0x61, 0x8A, 0x4B, 0xF0, 0x84,
  0x7A, 0x11, 0xE0, 0x86, 0x5E, 0x34, 0x8F, 0x99, 0x9E, 0xF8, 0x44, 0x22,
  0x11, 0x10, 0x32, 0x52, 0xED, 0x46, 0x5E, 0x76, 0x63, 0x1F, 0x88, 0x5C,
  0x60, 0x01, 0x80, 0x60, 0x00, 0xA4, 0x0B, 0xA0, 0xC1, 0x00, 0xF8, 0x3C,
  0x83, 0x06, 0xC8, 0x00, 0x72, 0x62, 0x22, 0x10, 0x08, 0x18, 0x95, 0xEB,
  0xAE, 0xF8, 0x1C, 0x18, 0x62, 0x8A, 0x29, 0xE4, 0xA3, 0x39, 0x14, 0x5E,
  0x49, 0x14, 0xBE, 0x72, 0x63, 0x08, 0x46, 0x5E, 0x39, 0x14, 0x51, 0x45,
  0x18, 0xBC, 0x3D, 0x04, 0x1E, 0x41, 0x04, 0x3E, 0x3C, 0x84, 0x10, 0x79,
  0x04, 0x30, 0x72, 0x61, 0x0B, 0xC6, 0x3E, 0x45, 0x14, 0x5F, 0x45, 0x18,
  0xA2, 0x3C, 0x41, 0x04, 0x10, 0x42, 0x3E, 0x04, 0x10, 0x41, 0x04, 0x28,
  0x9C, 0x26, 0x99, 0x63, 0x87, 0x0A, 0x12, 0x46, 0x21, 0x10, 0x84, 0x21,
  0x1F, 0x26, 0xC9, 0xB3, 0x65, 0x4A, 0xA2, 0x44, 0x65, 0x96, 0x55, 0x55,
  0x58, 0xA2, 0x72, 0x63, 0x18, 0xC6, 0x5C, 0x38, 0x94, 0x51, 0x79, 0x04,
  0x30, 0x39, 0x94, 0x51, 0x46, 0x14, 0x9C, 0x08, 0x39, 0x14, 0x51, 0x79,
  0x24, 0xA2, 0x39, 0x94, 0x08, 0x1A, 0x14, 0x5E, 0xFC, 0x82, 0x08, 0x20,
  0x84, 0x10, 0x8C, 0x63, 0x18, 0xC6, 0x5C, 0x86, 0x28, 0x94, 0x51, 0x86,
  0x10, 0xA6, 0x9A, 0xB6, 0xDB, 0x49, 0x24, 0x46, 0x48, 0xA0, 0x83, 0x05,
  0x12, 0x46, 0x8D, 0x25, 0x14, 0x60, 0x84, 0x10, 0x7C, 0x10, 0x84, 0x21,
  0x84, 0x3E, 0x32, 0x22, 0x44, 0x44, 0x44, 0xE0, 0x92, 0x24, 0x92, 0x20,
  0x31, 0x11, 0x22, 0x22, 0x22, 0xC0, 0x23, 0x5D, 0xF8, 0xC0, 0x74, 0x5D,
  0x29, 0x78, 0x21, 0x07, 0x93, 0x45, 0x14, 0xAE, 0x74, 0x61, 0x09, 0x78,
  0x08, 0x5F, 0x18, 0xCA, 0x5E, 0x74, 0x7F, 0x08, 0x78, 0x3C, 0x8F, 0x88,
  0x41, 0x04, 0x10, 0x3D, 0x14, 0x52, 0x49, 0xE0, 0xBC, 0x21, 0x05, 0x99,
  0x45, 0x24, 0xA2, 0x08, 0x1C, 0x21, 0x08, 0x5F, 0x08, 0x0E, 0x11, 0x08,
  0x42, 0x17, 0x00, 0x21, 0x04, 0xD6, 0x61, 0x45, 0x22, 0x38, 0x44, 0x21,
  0x08, 0x5F, 0x7D, 0x59, 0x65, 0xA6, 0xA0, 0x79, 0x14, 0x52, 0x4A, 0x20,
  0x74, 0x63, 0x19, 0x70, 0x79, 0x34, 0x51, 0x4B, 0xE8, 0x20, 0x7C, 0x63,
  0x29, 0x78, 0x42, 0x7A, 0x10, 0x88, 0x40, 0x74, 0x70, 0x69, 0x78, 0x27,
  0xD0, 0x84, 0x21, 0xC0, 0x8C, 0x63, 0x29, 0x78, 0x8C, 0x64, 0xC6, 0x20,
  0xA6, 0xAE, 0xBA, 0x92, 0x40, 0x44, 0xA3, 0x0C, 0x6B, 0x20, 0x46, 0x89,
  0x21, 0x43, 0x04, 0x08, 0x60, 0x7C, 0x21, 0x08, 0x43, 0xE0, 0x12, 0x24,
  0x48, 0x44, 0x44, 0x60, 0x55, 0x5A, 0xA0, 0x42, 0x22, 0x21, 0x24, 0x44,
  0x80, 0xF6, 0x60,
};

const GFXglyph RobotoMono_Italic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 8, 6, 2, -8 },
  { 3, 3, 2, 6, 2, -8 },
  { 4, 7, 8, 6, 0, -8 },
  { 11, 5, 10, 6, 1, -9 },
  { 18, 5, 8, 6, 1, -8 },
  { 23, 6, 8, 6, 0, -8 },
  { 29, 1, 2, 6, 3, -8 },
  { 30, 3, 12, 6, 2, -9 },
  { 35, 4, 12, 6, 1, -9 },
  { 41, 5, 5, 6, 1, -8 },
  { 45, 5, 5, 6, 1, -6 },
  { 49, 2, 3, 6, 1, -1 },
  { 50, 4, 1, 6, 1, -4 },
  { 51, 2, 1, 6, 2, -1 },
  { 52, 5, 9, 6, 1, -8 },
  { 58, 5, 8, 6, 1, -8 },
  { 63, 3, 8, 6, 2, -8 },
  { 66, 6, 8, 6, 0, -8 },
  { 72, 6, 8, 6, 0, -8 },
  { 78, 6, 8, 6, 0, -8 },
  { 84, 5, 8, 6, 1, -8 },
  { 89, 4, 8, 6, 1, -8 },
  { 93, 5, 8, 6, 1, -8 },
  { 98, 5, 8, 6, 1, -8 },
  { 103, 5, 8, 6, 1, -8 },
  { 108, 3, 6, 6, 2, -6 },
  { 111, 3, 8, 6, 2, -6 },
  { 114, 5, 5, 6, 1, -6 },
  { 118, 5, 3, 6, 1, -5 },
  { 120, 5, 5, 6, 1, -6 },
  { 124, 5, 8, 6, 1, -8 },
  { 129, 6, 8, 6, 0, -8 },
  { 135, 6, 8, 6, 0, -8 },
  { 141, 6, 8, 6, 0, -8 },
  { 147, 5, 8, 6, 1, -8 },
  { 152, 6, 8, 6, 0, -8 },
  { 158, 6, 8, 6, 0, -8 },
  { 164, 6, 8, 6, 0, -8 },
  { 170, 5, 8, 6, 1, -8 },
  { 175, 6, 8, 6, 0, -8 },
  { 181, 6, 8, 6, 0, -8 },
  { 187, 6, 8, 6, 0, -8 },
  { 193, 7, 8, 6, 0, -8 },
  { 200, 5, 8, 6, 0, -8 },
  { 205, 7, 8, 6, 0, -8 },
  { 212, 6, 8, 6, 0, -8 },
  { 218, 5, 8, 6, 1, -8 },
  { 223, 6, 8, 6, 0, -8 },
  { 229, 6, 9, 6, 0, -8 },
  { 236, 6, 8, 6, 0, -8 },
  { 242, 6, 8, 6, 0, -8 },
  { 248, 6, 8, 6, 1, -8 },
  { 254, 5, 8, 6, 1, -8 },
  { 259, 6, 8, 6, 1, -8 },
  { 265, 6, 8, 6, 1, -8 },
  { 271, 7, 8, 6, 0, -8 },
  { 278, 6, 8, 6, 1, -8 },
  { 284, 6, 8, 6, 0, -8 },
  { 290, 4, 11, 6, 1, -9 },
  { 296, 3, 9, 6, 2, -8 },
  { 300, 4, 11, 6, 1, -9 },
  { 306, 4, 4, 6, 1, -8 },
  { 308, 5, 1, 6, 0, 0 },
  { 309, 2, 1, 6, 3, -8 },
  { 310, 5, 6, 6, 1, -6 },
  { 314, 6, 8, 6, 0, -8 },
  { 320, 5, 6, 6, 1, -6 },
  { 324, 5, 8, 6, 1, -8 },
  { 329, 5, 6, 6, 1, -6 },
  { 333, 6, 8, 6, 1, -8 },
  { 339, 6, 8, 6, 0, -6 },
  { 345, 6, 8, 6, 0, -8 },
  { 351, 5, 8, 6, 0, -8 },
  { 356, 5, 10, 6, 0, -8 },
  { 363, 6, 8, 6, 0, -8 },
  { 369, 5, 8, 6, 0, -8 },
  { 374, 6, 6, 6, 0, -6 },
  { 379, 6, 6, 6, 0, -6 },
  { 384, 5, 6, 6, 1, -6 },
  { 388, 6, 8, 6, 0, -6 },
  { 394, 5, 8, 6, 1, -6 },
  { 399, 5, 6, 6, 1, -6 },
  { 403, 5, 6, 6, 1, -6 },
  { 407, 5, 7, 6, 1, -7 },
  { 412, 5, 6, 6, 1, -6 },
  { 416, 5, 6, 6, 1, -6 },
  { 420, 6, 6, 6, 1, -6 },
  { 425, 6, 6, 6, 0, -6 },
  { 430, 7, 8, 6, 0, -6 },
  { 437, 6, 6, 6, 0, -6 },
  { 442, 4, 11, 6, 2, -9 },
  { 448, 2, 10, 6, 2, -8 },
  { 451, 4, 11, 6, 1, -9 },
  { 457, 6, 2, 6, 0, -4 },
};

const GFXfont RobotoMono_Italic11pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic11pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _ROBOTOMONO_ITALIC11PT7B_H_
