#ifndef _ROBOTOMONO_ITALIC65PT7B_H_
#define _ROBOTOMONO_ITALIC65PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic65pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x7E,
  0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF0, 0x00, 0x1E, 0x03,
  0xCF, 0x81, 0xF3, 0xE0, 0x7C, 0xF8, 0x1F, 0x3E, 0x07, 0xCF, 0x01, 0xE3,
  0xC0, 0x79, 0xF0, 0x3E, 0x7C, 0x0F, 0x9E, 0x03, 0xC7, 0x80, 0xF1, 0xE0,
  0x3C, 0x78, 0x0F, 0x3E, 0x07, 0xCF, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x07, 0x80, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0x80,
  0x7C, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x07,
  0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0x87, 0xFC, 0x01, 0xFE, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x08, 0x3C, 0x03, 0xC0, 0x38, 0x78, 0x07,
  0x80, 0xF9, 0xF0, 0x0F, 0x01, 0xE3, 0xE0, 0x1E, 0x07, 0xC7, 0xC0, 0x3C,
  0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x1F, 0x01, 0xE0, 0xF8, 0x3E, 0x03, 0xC3,
  0xE0, 0x3E, 0x0F, 0x8F, 0x80, 0x7E, 0x7E, 0x1E, 0x00, 0x7F, 0xF8, 0x7C,
  0x00, 0x7F, 0xE1, 0xF0, 0x00, 0x7F, 0x83, 0xC0, 0x00, 0x10, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xF8, 0x3C, 0x00, 0x03, 0xE1, 0xFF, 0x00, 0x0F, 0x87, 0xFF, 0x00,
  0x1F, 0x1F, 0xFF, 0x00, 0x7C, 0x7E, 0x3E, 0x01, 0xF1, 0xF0, 0x3E, 0x03,
  0xC3, 0xC0, 0x7C, 0x0F, 0x87, 0x80, 0xF8, 0x3E, 0x1F, 0x00, 0xF0, 0x78,
  0x3E, 0x01, 0xE1, 0xF0, 0x7C, 0x07, 0xC7, 0xC0, 0xF0, 0x0F, 0x87, 0x01,
  0xE0, 0x1F, 0x04, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0x1F, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xC0,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0xFC, 0x3F, 0x8F, 0xC0, 0x3E, 0x1F, 0xC1, 0xF8, 0x0F,
  0x8F, 0xE0, 0x7E, 0x03, 0xE3, 0xF0, 0x0F, 0xC1, 0xF9, 0xFC, 0x03, 0xF0,
  0x7C, 0x7E, 0x00, 0x7E, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xCF, 0xC0, 0x03,
  0xF7, 0xE3, 0xF0, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0x1F, 0xFC, 0x3F, 0x00,
  0x03, 0xFE, 0x0F, 0xC0, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xFC, 0x03, 0xFC, 0x1F, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xFC, 0x3F,
  0x80, 0x1F, 0xFC, 0x07, 0xF0, 0x00, 0x70, 0x00, 0x00, 0x1F, 0x1F, 0x1E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0x00, 0x00, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x20, 0x07, 0xC0, 0x09, 0xC0, 0x3E, 0x01, 0xDF, 0x81,
  0xE0, 0x3E, 0xFF, 0x0F, 0x0F, 0xFF, 0xFE, 0x79, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80,
  0xFE, 0x00, 0xFC, 0x01, 0xE0, 0x03, 0xC0, 0x06, 0x00, 0x1C, 0x00, 0x10,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0xFC, 0x0F,
  0xC1, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x38,
  0x01, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x7E, 0x7F, 0xBF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFC, 0xFC, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF1,
  0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x0F, 0xFC, 0xFC,
  0x00, 0x3F, 0xF9, 0xF8, 0x01, 0xFF, 0xF3, 0xE0, 0x07, 0xFF, 0xE7, 0xC0,
  0x3F, 0xCF, 0xDF, 0x80, 0xFF, 0x1F, 0x3F, 0x03, 0xF8, 0x3E, 0x7E, 0x1F,
  0xE0, 0xFC, 0xFC, 0x7F, 0x01, 0xF9, 0xF3, 0xFC, 0x03, 0xF3, 0xEF, 0xF0,
  0x07, 0xEF, 0xFF, 0x80, 0x0F, 0x9F, 0xFE, 0x00, 0x1F, 0x3F, 0xF0, 0x00,
  0x7E, 0x7F, 0xC0, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x7C,
  0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xF3,
  0xFF, 0xFE, 0x7F, 0xCF, 0xDF, 0xC1, 0xFB, 0xC0, 0x3F, 0x40, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFC, 0x0F, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x81, 0xFE, 0x01,
  0xFE, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x03, 0xE0, 0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF0,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x3F, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xC7, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF0, 0x3F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x07, 0xF8, 0x03, 0xF3, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0x03,
  0xEF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0x01, 0xFC, 0x7F, 0xC0,
  0x0F, 0xE7, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0x7C,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFE, 0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x07,
  0xFE, 0x3F, 0xE1, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xF7, 0xC0,
  0x7F, 0xFC, 0x7C, 0x01, 0xFF, 0x8F, 0xC0, 0x03, 0x80, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC,
  0x1F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0x08, 0x00, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFC, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xE0, 0x04, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFC, 0x3F, 0xE3, 0xF8,
  0x03, 0xF9, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x3C,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x7F,
  0xC1, 0xE0, 0x78, 0x1F, 0xFE, 0x1E, 0x07, 0x83, 0xFF, 0xE1, 0xE0, 0xF0,
  0x3F, 0x1E, 0x0E, 0x0F, 0x07, 0xC1, 0xE0, 0xE1, 0xE0, 0xF8, 0x1C, 0x0E,
  0x1E, 0x0F, 0x01, 0xC0, 0xE3, 0xC1, 0xE0, 0x1C, 0x0E, 0x3C, 0x1E, 0x03,
  0xC0, 0xE3, 0xC3, 0xC0, 0x3C, 0x0E, 0x78, 0x3C, 0x03, 0x81, 0xE7, 0x83,
  0xC0, 0x38, 0x1E, 0x78, 0x3C, 0x07, 0x81, 0xC7, 0x87, 0x80, 0x78, 0x1C,
  0x70, 0x78, 0x07, 0x01, 0xCF, 0x07, 0x80, 0x70, 0x1C, 0xF0, 0x78, 0x0F,
  0x03, 0xCF, 0x07, 0x80, 0xF0, 0x38, 0xF0, 0x78, 0x1E, 0x03, 0x8F, 0x07,
  0x81, 0xE0, 0x70, 0xF0, 0x78, 0x3E, 0x0F, 0x0F, 0x07, 0xCF, 0xF0, 0xE0,
  0xF0, 0x7F, 0xEF, 0xFE, 0x0F, 0x03, 0xFE, 0xFF, 0xC0, 0x70, 0x3F, 0x87,
  0xF8, 0x07, 0x80, 0xF0, 0x3E, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x04, 0x00, 0x01, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xC0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x03, 0xF0, 0x1F,
  0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01,
  0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x03, 0xE3, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x3F, 0xE0, 0x1F, 0x80, 0x03,
  0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x1F, 0xE0, 0x1F, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0x80, 0x1F, 0xF8, 0x03, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8, 0x3F,
  0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0x3F, 0xC1, 0xF8, 0x00, 0x1F, 0xE0, 0x7E, 0x00, 0x1F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x07,
  0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07,
  0xC1, 0xF8, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x03,
  0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01,
  0xFC, 0x01, 0xF0, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0x3E, 0x0F, 0xC0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x1F, 0xFF,
  0xCF, 0xC0, 0x07, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x7F,
  0xFE, 0x3F, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0xC7, 0xFF,
  0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x7E, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xF8,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xFC, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x3F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x1F, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE,
  0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x00, 0x7C,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x7F, 0x80,
  0x00, 0x07, 0xE1, 0xFE, 0x00, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x00, 0x1F,
  0x9F, 0xE0, 0x00, 0x00, 0x3E, 0x7F, 0x80, 0x00, 0x00, 0xFD, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFB, 0xF0,
  0x00, 0x00, 0x7F, 0xE3, 0xF0, 0x00, 0x00, 0xFF, 0x87, 0xE0, 0x00, 0x01,
  0xFE, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xFC, 0x01,
  0xFF, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x3F, 0xFC, 0x03, 0xEF, 0x80, 0xFB, 0xE0, 0x0F,
  0x9E, 0x07, 0xEF, 0x80, 0x3E, 0x78, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0xFC,
  0xF8, 0x07, 0xE7, 0xC3, 0xE7, 0xE0, 0x1F, 0x9F, 0x1F, 0x9F, 0x80, 0x7C,
  0x7C, 0x7C, 0x7C, 0x01, 0xF1, 0xF3, 0xF1, 0xF0, 0x07, 0xC7, 0xCF, 0x87,
  0xC0, 0x3F, 0x0F, 0x7C, 0x3F, 0x00, 0xFC, 0x3D, 0xF0, 0xFC, 0x03, 0xF0,
  0xFF, 0x83, 0xE0, 0x0F, 0x83, 0xFE, 0x0F, 0x80, 0x3E, 0x0F, 0xF0, 0x3E,
  0x00, 0xF8, 0x3F, 0xC1, 0xF8, 0x07, 0xE0, 0xFE, 0x07, 0xE0, 0x1F, 0x81,
  0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0x78, 0x07, 0xC0, 0x1F, 0x01, 0xE0, 0x3F, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x7E, 0x03, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x00,
  0x7E, 0x01, 0xFF, 0x80, 0x03, 0xF0, 0x1F, 0xFC, 0x00, 0x1F, 0x80, 0xFF,
  0xE0, 0x01, 0xF8, 0x07, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0xFC, 0x00, 0x7E,
  0x01, 0xFB, 0xE0, 0x03, 0xF0, 0x0F, 0x9F, 0x80, 0x1F, 0x80, 0xFC, 0xFC,
  0x00, 0xF8, 0x07, 0xE3, 0xE0, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0xFC, 0x03, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x80, 0x7C, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x7E, 0x01, 0xF8,
  0x1F, 0x83, 0xF0, 0x0F, 0xC0, 0xFC, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0xFC,
  0x07, 0xE0, 0x1F, 0x87, 0xE0, 0x3F, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x03,
  0xE3, 0xF0, 0x0F, 0xC0, 0x1F, 0x9F, 0x80, 0x7E, 0x00, 0xFC, 0xFC, 0x03,
  0xE0, 0x03, 0xE7, 0xE0, 0x3F, 0x00, 0x1F, 0xBF, 0x01, 0xF8, 0x00, 0xFF,
  0xF0, 0x0F, 0xC0, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x1F, 0xFC, 0x03, 0xF0,
  0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x03, 0xFF, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x0F, 0xC0, 0x00, 0xFF, 0x80, 0x7E, 0x00, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x1F, 0x80, 0x00, 0xFF, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFE, 0x3F, 0xE0, 0x07, 0xF8,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF8,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F,
  0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3E,
  0x7E, 0x00, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x7C, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0,
  0x1F, 0xE0, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xF0, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x0F,
  0x80, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x03, 0xFC, 0x03, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x0F, 0xC0, 0x30, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFE,
  0x3F, 0xE0, 0x07, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xC1, 0xF8,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x0F, 0x9F,
  0x80, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xFE, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x1C, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0xFE, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x0F, 0xF0, 0x0F, 0x80, 0x07, 0xFC,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x0F, 0x80,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x00, 0xFC,
  0x07, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0xFF, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x87, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7C,
  0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0x3E, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x01, 0xF8, 0x1F,
  0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00,
  0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x00,
  0xF8, 0x1F, 0x00, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x00, 0xFC, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x3E,
  0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x3F,
  0xC0, 0x03, 0xFE, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x03, 0xE0, 0x0F,
  0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x00,
  0x7C, 0x3F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03,
  0xF7, 0xE0, 0x1F, 0x80, 0x3E, 0x7E, 0x01, 0xF8, 0x07, 0xE7, 0xE0, 0x1F,
  0x80, 0x7E, 0x7E, 0x03, 0xF8, 0x07, 0xC7, 0xE0, 0x3F, 0x80, 0x7C, 0x7E,
  0x03, 0xF8, 0x0F, 0xC7, 0xC0, 0x7F, 0x80, 0xFC, 0x7C, 0x07, 0xF8, 0x0F,
  0x87, 0xC0, 0x7F, 0x80, 0xF8, 0x7C, 0x07, 0xF8, 0x1F, 0x87, 0xC0, 0xFF,
  0x81, 0xF8, 0x7C, 0x0F, 0xF8, 0x1F, 0x07, 0xC0, 0xF7, 0x81, 0xF0, 0x7C,
  0x1F, 0x78, 0x3F, 0x07, 0xC1, 0xF7, 0x83, 0xE0, 0x7C, 0x1E, 0x78, 0x3E,
  0x07, 0xC3, 0xE7, 0x83, 0xE0, 0x7C, 0x3E, 0x78, 0x7E, 0x07, 0xC3, 0xC7,
  0x87, 0xC0, 0x7C, 0x7C, 0x78, 0x7C, 0x07, 0xC7, 0xC7, 0x87, 0xC0, 0x7C,
  0x78, 0x78, 0xF8, 0x07, 0xCF, 0x87, 0x8F, 0x80, 0x7C, 0xF8, 0x78, 0xF8,
  0x07, 0xCF, 0x07, 0x8F, 0x80, 0xF9, 0xF0, 0x79, 0xF0, 0x0F, 0x9F, 0x07,
  0x9F, 0x00, 0xF9, 0xE0, 0x79, 0xF0, 0x0F, 0xBE, 0x07, 0x9F, 0x00, 0xFB,
  0xE0, 0x7B, 0xE0, 0x0F, 0xBC, 0x07, 0xBE, 0x00, 0xFF, 0xC0, 0x7B, 0xE0,
  0x0F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F,
  0x01, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00,
  0x3E, 0x3F, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x07, 0xFF, 0x80,
  0x3F, 0xFE, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x7C,
  0x07, 0xC0, 0x7C, 0x0F, 0xC0, 0x7C, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E,
  0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x00, 0xFE, 0x0F,
  0xE0, 0xFC, 0x0F, 0xC0, 0xF8, 0x1F, 0x81, 0xF0, 0x1F, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x1F, 0xE0, 0x7F, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xE0, 0x1F, 0x8F, 0xF0, 0x00, 0x7C,
  0x3F, 0x80, 0x01, 0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x3F, 0xE1, 0xFC, 0x01,
  0xFF, 0x87, 0xFE, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF7,
  0xE0, 0x3F, 0xFF, 0x1F, 0x80, 0x7F, 0xF0, 0x7E, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x03, 0xE3, 0xFF, 0xC0, 0x03, 0xE7, 0xFF, 0xE0, 0x03, 0xEF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x03, 0xFC, 0x07, 0xFC, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E,
  0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E,
  0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x7E,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x03, 0xF0,
  0x7F, 0x80, 0x07, 0xF0, 0x7F, 0xE0, 0x1F, 0xE0, 0x7F, 0xF8, 0x7F, 0xC0,
  0x7D, 0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0x00, 0xFC, 0x7F, 0xFE, 0x00,
  0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0x3F, 0xC0, 0xFF, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x05, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0xFE,
  0x01, 0xFE, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x07, 0xE0, 0x01, 0xFF, 0xF1, 0xF8, 0x00, 0xFF, 0xFE, 0x7E, 0x00,
  0x7F, 0xFF, 0xDF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0,
  0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xF0, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xF8, 0x1F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F,
  0x80, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xE3, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0xFC, 0x00, 0x1F, 0xFF, 0x3E, 0x00, 0x03,
  0xFF, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x03,
  0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x7E,
  0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0xE7, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x02, 0x01, 0xF8, 0x00, 0x0E, 0x03, 0xF8, 0x00, 0x3E,
  0x03, 0xF8, 0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE1, 0xF0, 0x01, 0xFF,
  0xFC, 0xFC, 0x00, 0xFF, 0xFF, 0xBF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0x7F, 0xE0, 0x1F, 0xE0, 0x0F, 0xF8, 0x0F, 0xE0, 0x01, 0xFE, 0x03,
  0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0,
  0x3F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xC7, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFD, 0xF8, 0x00, 0x3F, 0xFE,
  0x7E, 0x00, 0x07, 0xFE, 0x1F, 0x00, 0x00, 0x3C, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x40,
  0x00, 0x1F, 0x80, 0x38, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xE0, 0xFF, 0xE0, 0x03, 0xE3,
  0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xFC, 0x07, 0xFF,
  0x03, 0xFC, 0x07, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0,
  0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x20, 0x0F, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x04, 0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x1F,
  0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xF0, 0x00,
  0x7C, 0x07, 0xF8, 0x00, 0x1F, 0x03, 0xFC, 0x00, 0x0F, 0xC1, 0xFE, 0x00,
  0x03, 0xF0, 0xFF, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00,
  0xFC, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x1F, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF8, 0x00, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x23, 0xF0, 0x1F, 0x00, 0x7C, 0xFF,
  0x87, 0xFC, 0x07, 0xDF, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x0F, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0xFC, 0x07, 0xE0, 0x1F, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0xF8, 0x07,
  0xE0, 0x1F, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0x3F, 0x1F,
  0x80, 0x7C, 0x03, 0xF1, 0xF8, 0x07, 0xC0, 0x3E, 0x1F, 0x80, 0xFC, 0x03,
  0xE1, 0xF0, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0xFC, 0x07, 0xE1, 0xF0, 0x0F,
  0x80, 0x7E, 0x3F, 0x00, 0xF8, 0x07, 0xE3, 0xF0, 0x0F, 0x80, 0x7C, 0x3F,
  0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0x7C, 0x3E, 0x01, 0xF8, 0x0F,
  0xC3, 0xE0, 0x1F, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x0F, 0xC7, 0xE0, 0x1F,
  0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x0F, 0x87, 0xC0, 0x3F, 0x00, 0xF8, 0x7C,
  0x03, 0xE0, 0x1F, 0x87, 0xC0, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xE0, 0x1F,
  0x8F, 0xC0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xE0, 0x1F, 0x0F, 0x80, 0x7E,
  0x01, 0xF0, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x07,
  0xC3, 0xFF, 0xC0, 0x0F, 0x8F, 0xFF, 0xC0, 0x1F, 0x3F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFB, 0xE0, 0x7F, 0x81, 0xFF, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF0,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0x80, 0xFE, 0x01, 0xFC,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x3F, 0x7C, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x3F, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x7C, 0x7F, 0xF8, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xF8, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x7F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF8,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x3F, 0xC0, 0xFF, 0x80, 0x3F, 0xC0, 0x7F,
  0xF0, 0x7F, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0xC0, 0x1F,
  0x9F, 0xFF, 0xC0, 0x0F, 0xC3, 0xFF, 0x80, 0x07, 0xE0, 0x1E, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0xFC, 0x03, 0xFF, 0xF9,
  0xF8, 0x0F, 0xFF, 0xFB, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x01, 0xFF,
  0x83, 0xFC, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE3, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF1, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xF0, 0x7F,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0x9F,
  0x00, 0x0F, 0xFC, 0x3E, 0x00, 0x01, 0xC0, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x1F,
  0x07, 0xFF, 0xC1, 0xF8, 0xFF, 0xFC, 0x0F, 0xCF, 0xFF, 0xE0, 0x7E, 0xFF,
  0xFF, 0x03, 0xEF, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x80, 0xFF, 0x80, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC,
  0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF8, 0x7E,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x03, 0xFE, 0x0F, 0xFC, 0x07, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x1E, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3E,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00,
  0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00,
  0x7E, 0x1F, 0x00, 0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x83,
  0xF0, 0x01, 0xFE, 0x07, 0xF0, 0x07, 0xFC, 0x07, 0xF8, 0x7F, 0xF8, 0x0F,
  0xFF, 0xFD, 0xF0, 0x0F, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0x8F, 0x80, 0x0F,
  0xFE, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00,
  0x03, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x3E, 0x00, 0x0F, 0x80, 0xFC,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0x80,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0x03, 0xCF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0x00, 0x7F, 0xE0, 0x07, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x03,
  0xEF, 0x80, 0x3F, 0x00, 0x7D, 0xF0, 0x0F, 0xE0, 0x1F, 0x3E, 0x01, 0xFC,
  0x03, 0xE7, 0xC0, 0x3F, 0x80, 0x78, 0xF8, 0x0F, 0xF0, 0x1F, 0x0F, 0x01,
  0xFE, 0x03, 0xE1, 0xE0, 0x7B, 0xC0, 0xF8, 0x3C, 0x0F, 0x78, 0x1F, 0x07,
  0x83, 0xEF, 0x03, 0xE0, 0xF0, 0x79, 0xE0, 0xF8, 0x1E, 0x0F, 0x3E, 0x1F,
  0x03, 0xC3, 0xE7, 0xC3, 0xC0, 0x78, 0x78, 0x78, 0xF8, 0x0F, 0x1F, 0x0F,
  0x1F, 0x01, 0xE3, 0xC1, 0xE3, 0xC0, 0x3C, 0x78, 0x3C, 0xF8, 0x07, 0x9F,
  0x07, 0x9F, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x1E, 0xF8, 0x1E, 0xF8, 0x03,
  0xDE, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x00,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x01,
  0xF1, 0xFC, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x04, 0x00, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x78, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xF1, 0xFF, 0xFC, 0x00, 0x1F, 0x3F, 0xFF, 0xE0,
  0x01, 0xE3, 0xFF, 0xFF, 0x00, 0x3E, 0x7E, 0x07, 0xF8, 0x03, 0xE7, 0xC0,
  0x1F, 0xE0, 0xFC, 0xF8, 0x00, 0xFF, 0xFF, 0xCF, 0x80, 0x07, 0xFF, 0xF8,
  0xF0, 0x00, 0x3F, 0xFF, 0x01, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00,
};

const GFXglyph RobotoMono_Italic65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 38, 0, -1 },
  { 1, 14, 46, 38, 12, -46 },
  { 82, 18, 15, 38, 13, -49 },
  { 116, 38, 46, 38, 1, -46 },
  { 335, 32, 61, 38, 4, -54 },
  { 579, 31, 48, 38, 4, -47 },
  { 765, 34, 48, 38, 2, -47 },
  { 969, 8, 15, 38, 17, -49 },
  { 984, 22, 67, 38, 10, -52 },
  { 1169, 22, 67, 38, 5, -52 },
  { 1354, 29, 31, 38, 7, -46 },
  { 1467, 31, 33, 38, 4, -38 },
  { 1595, 12, 18, 38, 6, -7 },
  { 1622, 25, 5, 38, 6, -23 },
  { 1638, 9, 9, 38, 13, -8 },
  { 1649, 32, 50, 38, 4, -46 },
  { 1849, 31, 48, 38, 4, -47 },
  { 2035, 19, 46, 38, 9, -46 },
  { 2145, 33, 47, 38, 0, -47 },
  { 2339, 32, 48, 38, 1, -47 },
  { 2531, 33, 46, 38, 1, -46 },
  { 2721, 32, 47, 38, 5, -46 },
  { 2909, 28, 47, 38, 4, -46 },
  { 3074, 32, 46, 38, 6, -46 },
  { 3258, 32, 48, 38, 4, -47 },
  { 3450, 28, 47, 38, 6, -47 },
  { 3615, 14, 37, 38, 14, -36 },
  { 3680, 18, 47, 38, 10, -36 },
  { 3786, 29, 29, 38, 5, -35 },
  { 3892, 31, 18, 38, 4, -30 },
  { 3962, 30, 29, 38, 3, -35 },
  { 4071, 26, 47, 38, 9, -47 },
  { 4224, 36, 46, 38, 2, -46 },
  { 4431, 34, 46, 38, -1, -46 },
  { 4627, 34, 46, 38, 2, -46 },
  { 4823, 34, 48, 38, 3, -47 },
  { 5027, 35, 46, 38, 1, -46 },
  { 5229, 36, 46, 38, 2, -46 },
  { 5436, 35, 46, 38, 3, -46 },
  { 5638, 34, 48, 38, 3, -47 },
  { 5842, 37, 46, 38, 1, -46 },
  { 6055, 35, 46, 38, 2, -46 },
  { 6257, 35, 47, 38, 2, -46 },
  { 6463, 39, 46, 38, 2, -46 },
  { 6688, 28, 46, 38, 3, -46 },
  { 6849, 38, 46, 38, 1, -46 },
  { 7068, 37, 46, 38, 1, -46 },
  { 7281, 33, 48, 38, 3, -47 },
  { 7479, 35, 46, 38, 3, -46 },
  { 7681, 33, 55, 38, 3, -47 },
  { 7908, 35, 46, 38, 2, -46 },
  { 8110, 34, 48, 38, 3, -47 },
  { 8314, 34, 46, 38, 6, -46 },
  { 8510, 35, 47, 38, 3, -46 },
  { 8716, 34, 46, 38, 6, -46 },
  { 8912, 36, 46, 38, 5, -46 },
  { 9119, 40, 46, 38, 0, -46 },
  { 9349, 33, 46, 38, 7, -46 },
  { 9539, 36, 46, 38, 1, -46 },
  { 9746, 22, 63, 38, 9, -53 },
  { 9920, 15, 50, 38, 12, -46 },
  { 10014, 22, 63, 38, 8, -53 },
  { 10188, 24, 25, 38, 7, -46 },
  { 10263, 29, 5, 38, 1, 0 },
  { 10282, 11, 8, 38, 17, -47 },
  { 10293, 30, 36, 38, 3, -35 },
  { 10428, 32, 50, 38, 2, -49 },
  { 10628, 30, 36, 38, 4, -35 },
  { 10763, 34, 50, 38, 4, -49 },
  { 10976, 31, 36, 38, 3, -35 },
  { 11116, 34, 50, 38, 6, -50 },
  { 11329, 34, 49, 38, 1, -35 },
  { 11538, 32, 49, 38, 2, -49 },
  { 11734, 29, 47, 38, 3, -47 },
  { 11905, 30, 61, 38, 1, -47 },
  { 12134, 34, 49, 38, 2, -49 },
  { 12343, 29, 49, 38, 3, -49 },
  { 12521, 36, 35, 38, 0, -35 },
  { 12679, 31, 35, 38, 2, -35 },
  { 12815, 31, 36, 38, 3, -35 },
  { 12955, 33, 48, 38, 0, -35 },
  { 13153, 31, 48, 38, 4, -35 },
  { 13339, 29, 35, 38, 7, -35 },
  { 13466, 30, 36, 38, 4, -35 },
  { 13601, 28, 44, 38, 6, -43 },
  { 13755, 31, 35, 38, 4, -34 },
  { 13891, 31, 34, 38, 6, -34 },
  { 14023, 35, 34, 38, 4, -34 },
  { 14172, 37, 34, 38, 0, -34 },
  { 14330, 39, 48, 38, -1, -34 },
  { 14564, 33, 34, 38, 2, -34 },
  { 14705, 25, 63, 38, 10, -51 },
  { 14902, 13, 59, 38, 12, -46 },
  { 14998, 25, 63, 38, 6, -51 },
  { 15195, 36, 13, 38, 1, -26 },
};

const GFXfont RobotoMono_Italic65pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic65pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic65pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _ROBOTOMONO_ITALIC65PT7B_H_
