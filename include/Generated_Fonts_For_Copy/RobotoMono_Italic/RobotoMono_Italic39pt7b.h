#ifndef _ROBOTOMONO_ITALIC39PT7B_H_
#define _ROBOTOMONO_ITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x78, 0x3C, 0x1E, 0x0E, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x70, 0x7C, 0x3E, 0x0E, 0x00, 0x70, 0xEE, 0x19,
  0xC3, 0x30, 0xE6, 0x1D, 0xC3, 0xB8, 0x67, 0x0C, 0xC3, 0x80, 0x00, 0x0E,
  0x0C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x70, 0x00, 0xE1, 0xC0, 0x01, 0x83,
  0x80, 0x07, 0x06, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x0F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x07, 0x06, 0x00, 0x0C, 0x1C, 0x00,
  0x38, 0x38, 0x00, 0x70, 0xE0, 0x00, 0xC1, 0xC0, 0x03, 0x83, 0x00, 0x07,
  0x0E, 0x01, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x88, 0x70, 0xE0, 0x01, 0xC1,
  0xC0, 0x03, 0x83, 0x00, 0x06, 0x0E, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x70,
  0x00, 0x60, 0xE0, 0x01, 0xC1, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x01, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0,
  0x3E, 0x1E, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x03, 0x8F, 0x00, 0x71,
  0xE0, 0x0E, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x71, 0xC0, 0x0E, 0x3C,
  0x03, 0xC7, 0x80, 0xF0, 0x7F, 0xFE, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x01,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x07,
  0xF8, 0x00, 0xE7, 0x00, 0x38, 0x70, 0x06, 0x0E, 0x1C, 0xC1, 0xC3, 0x18,
  0x38, 0xE3, 0x06, 0x38, 0x61, 0xCE, 0x0E, 0x79, 0xC0, 0xFE, 0x70, 0x0F,
  0x9C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01,
  0xC7, 0x00, 0x73, 0xF8, 0x1C, 0xFF, 0x03, 0x98, 0x70, 0xE7, 0x0E, 0x38,
  0xE1, 0xC6, 0x18, 0x39, 0xC3, 0x07, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x3C, 0x38, 0x07, 0x83, 0x80, 0x70, 0x38, 0x07, 0x03, 0x80, 0x70, 0x78,
  0x07, 0x07, 0x00, 0x79, 0xF0, 0x07, 0xBC, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x07, 0x3E, 0x70, 0x77, 0xC7,
  0x87, 0x78, 0x3C, 0xF7, 0x03, 0xCE, 0xF0, 0x1F, 0xEF, 0x01, 0xFC, 0xF0,
  0x0F, 0xCF, 0x00, 0x78, 0x78, 0x1F, 0x87, 0xFF, 0xFC, 0x3F, 0xFB, 0xC0,
  0xFF, 0x1E, 0x39, 0xDC, 0xE7, 0x39, 0xCC, 0xE0, 0x00, 0x18, 0x01, 0xC0,
  0x1E, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x18, 0x00,
  0x40, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03,
  0x80, 0x78, 0x03, 0x80, 0x18, 0x00, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x10, 0x38, 0x17, 0x0E, 0x1D, 0xF3, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x70, 0x03,
  0x9C, 0x01, 0xE3, 0x80, 0xF0, 0xE0, 0x78, 0x3C, 0x0E, 0x07, 0x01, 0x01,
  0x00, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x38, 0xF1, 0xE3, 0xC7, 0x1E, 0x38, 0xF1, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xC1, 0xE0, 0xF0, 0x1E, 0x3C,
  0x01, 0xC7, 0x00, 0x39, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x00, 0x7C, 0xE0,
  0x1F, 0x9C, 0x0F, 0xF7, 0x83, 0xFE, 0xF0, 0xF3, 0xDC, 0x7C, 0x73, 0x9E,
  0x0E, 0x7F, 0x81, 0xCF, 0xC0, 0x3B, 0xF0, 0x0F, 0x7C, 0x01, 0xEF, 0x00,
  0x38, 0xE0, 0x07, 0x1C, 0x01, 0xE3, 0x80, 0x78, 0x78, 0x1E, 0x07, 0xEF,
  0xC0, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x10, 0x0F, 0x03, 0xF1, 0xFF,
  0x7F, 0xE7, 0xCE, 0x60, 0xE8, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x78,
  0x07, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0,
  0x00, 0x7F, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xC0, 0x78, 0x1E, 0x0F, 0x00,
  0xF0, 0xE0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xC1, 0xE0, 0xE0, 0x1E, 0x3C, 0x03,
  0xC7, 0x00, 0x38, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x11, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x39,
  0xC0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x78, 0x78, 0x1F, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3B, 0x80, 0x0F, 0xF0, 0x03, 0xDE,
  0x00, 0x73, 0x80, 0x1C, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x78,
  0x0E, 0x0F, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x3C, 0x07, 0x0F, 0x01, 0xE1,
  0xC0, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xF0, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0x77, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0x7C, 0x3E, 0x02, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x79, 0xC0, 0x0E, 0x38, 0x03, 0xC7, 0x80, 0x78, 0x78, 0x1E, 0x0F,
  0xDF, 0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x1F, 0x80,
  0x3F, 0xC0, 0x3F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x7F, 0x07, 0x7F, 0xC7, 0xFF, 0xF3, 0xF0,
  0x79, 0xF0, 0x1E, 0xF0, 0x0F, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3B, 0x80, 0x3D, 0xC0, 0x1C, 0xF0, 0x1E, 0x3C, 0x1E,
  0x1F, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xC1, 0xF0,
  0xF0, 0x1E, 0x1E, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x1E, 0x00, 0xE1,
  0xC0, 0x3C, 0x38, 0x07, 0x07, 0x83, 0xE0, 0x7F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0xF8, 0xF8, 0x3C, 0x07, 0x87, 0x00, 0x71, 0xE0, 0x0F, 0x38,
  0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x9C, 0x00, 0xE3, 0xC0, 0x3C, 0x78,
  0x0F, 0x07, 0xEF, 0xC0, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xC7, 0x80, 0xF3, 0xC0, 0x39, 0xC0, 0x1D,
  0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00,
  0x77, 0x80, 0x7B, 0xC0, 0x7C, 0xF8, 0xFE, 0x3F, 0xFE, 0x0F, 0xF7, 0x01,
  0xC3, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x03, 0xE0,
  0x07, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x1E, 0x1F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8, 0xF0, 0x03, 0xC0, 0xF8, 0x1F, 0x83,
  0xF0, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x0F, 0x01, 0xE0,
  0x38, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x00,
  0x80, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF,
  0x01, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x06, 0x00, 0x3F,
  0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF,
  0xFE, 0x00, 0x10, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C,
  0x1F, 0x78, 0x0F, 0x70, 0x0F, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xF0, 0x1C,
  0x07, 0x00, 0x30, 0x38, 0x00, 0xE0, 0xC1, 0xE1, 0x87, 0x1F, 0xE6, 0x18,
  0xF3, 0x18, 0xE3, 0x0C, 0x63, 0x1C, 0x31, 0x9C, 0x60, 0xC6, 0x63, 0x86,
  0x19, 0x8C, 0x18, 0x66, 0x30, 0x61, 0xB8, 0xC1, 0x86, 0xE3, 0x0E, 0x33,
  0x9C, 0x30, 0xCE, 0x31, 0xC6, 0x38, 0xFF, 0x38, 0xE3, 0xEF, 0xC1, 0x87,
  0x1E, 0x06, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x04, 0x00, 0xF8, 0xE0,
  0x01, 0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x77,
  0x00, 0x07, 0xB8, 0x00, 0x39, 0xC0, 0x03, 0xCE, 0x00, 0x1C, 0x70, 0x01,
  0xE3, 0x80, 0x0E, 0x1C, 0x00, 0xF0, 0xF0, 0x07, 0x03, 0x80, 0x38, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFF, 0x07, 0x00, 0x78, 0x78, 0x01, 0xC3, 0x80, 0x0E, 0x3C, 0x00, 0x71,
  0xC0, 0x03, 0x9E, 0x00, 0x1D, 0xE0, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xF8, 0x1E, 0x07, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x38,
  0x38, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x70, 0xF0, 0x07, 0x87, 0x80,
  0x78, 0x3C, 0x07, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xFE, 0x07,
  0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0x70,
  0x0F, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x81, 0xFF, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xE1, 0xE0,
  0x0F, 0x3C, 0x00, 0xF3, 0xC0, 0x0F, 0x38, 0x00, 0x77, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x03, 0xCF, 0x00, 0x38, 0xF0, 0x07, 0x87, 0x00, 0x70, 0x78, 0x0F,
  0x03, 0xF7, 0xE0, 0x1F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0xE0, 0x1E, 0x1F, 0x80, 0xE0, 0x1E, 0x07, 0x00, 0x70,
  0x38, 0x03, 0xC3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x00,
  0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xC7,
  0x80, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0xF0, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xC0, 0x1E, 0x0E, 0x01, 0xF0, 0xF0,
  0x3F, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x81, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x01, 0xFF, 0xF8, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0xF8, 0x07, 0xFF,
  0xC0, 0xF8, 0x3E, 0x0F, 0x01, 0xE1, 0xE0, 0x0F, 0x3C, 0x00, 0xF3, 0xC0,
  0x07, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xEF, 0x03, 0xFE, 0xE0, 0x3F, 0xEE,
  0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xF0, 0x01, 0xCF, 0x00, 0x3C,
  0x70, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x07, 0x83, 0xFF, 0xF0, 0x1F, 0xFE,
  0x00, 0x7F, 0x80, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3,
  0x80, 0x0E, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xE0, 0x03, 0x87, 0x00,
  0x1E, 0x1C, 0x00, 0x78, 0x70, 0x01, 0xC1, 0xC0, 0x07, 0x0F, 0x00, 0x1C,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0E, 0x00, 0x38, 0x38,
  0x00, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x78, 0x70, 0x01,
  0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0xC3,
  0x80, 0x0F, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE0, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFE, 0x10, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x03, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0, 0x1E, 0x0F, 0x01,
  0xE0, 0x78, 0x1F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x1C, 0x01, 0xE0, 0x78, 0x07, 0x80,
  0xF0, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0x81, 0xE0, 0x07, 0x07, 0x80, 0x0E,
  0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x79, 0xF0, 0x00, 0xF7, 0xC0, 0x01, 0xDF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x38,
  0x00, 0x7C, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xE0,
  0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x03, 0xC0, 0x70, 0x07, 0x80,
  0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x3C,
  0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xE0, 0x3F, 0x0F, 0x80, 0xF8, 0x3E,
  0x07, 0xE1, 0xFC, 0x1F, 0x87, 0x70, 0xEE, 0x1D, 0xC3, 0xB8, 0x77, 0x1D,
  0xE1, 0xDC, 0x77, 0x07, 0x33, 0x9C, 0x3C, 0xCE, 0x70, 0xF3, 0xF1, 0xC3,
  0x8F, 0xCF, 0x0E, 0x3E, 0x3C, 0x38, 0xF8, 0xE0, 0xE3, 0xC3, 0x87, 0x8F,
  0x0E, 0x1E, 0x18, 0x78, 0x70, 0x01, 0xE1, 0xC0, 0x07, 0x07, 0x00, 0x1C,
  0x1C, 0x00, 0x70, 0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0x3C, 0x38,
  0x00, 0xE0, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0,
  0x0E, 0x0F, 0x80, 0x38, 0x3F, 0x01, 0xE1, 0xFC, 0x07, 0x87, 0xF0, 0x1E,
  0x1F, 0xE0, 0x70, 0x73, 0x81, 0xC1, 0xCE, 0x07, 0x07, 0x3C, 0x3C, 0x3C,
  0x70, 0xF0, 0xF1, 0xC3, 0xC3, 0xC7, 0x8E, 0x0E, 0x0E, 0x38, 0x38, 0x38,
  0xE1, 0xE0, 0xF7, 0x87, 0x81, 0xDE, 0x1E, 0x07, 0x78, 0x70, 0x1F, 0xC1,
  0xC0, 0x3F, 0x07, 0x00, 0xFC, 0x3C, 0x03, 0xF0, 0xF0, 0x07, 0xC3, 0xC0,
  0x1F, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x80, 0xF8, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x1E, 0x1C, 0x00,
  0xE3, 0xC0, 0x0E, 0x38, 0x00, 0xE7, 0x80, 0x0F, 0x70, 0x00, 0xF7, 0x00,
  0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xE0,
  0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x03, 0xCF,
  0x00, 0x38, 0x70, 0x07, 0x87, 0x80, 0xF0, 0x78, 0x1E, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF,
  0xF8, 0x1C, 0x07, 0xC0, 0xE0, 0x0F, 0x0F, 0x00, 0x38, 0x78, 0x01, 0xC3,
  0xC0, 0x0F, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x78, 0x01,
  0xE3, 0xC0, 0x1E, 0x1C, 0x03, 0xE0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x80, 0xF8, 0x3C, 0x0F, 0x01, 0xE1, 0xE0, 0x0E, 0x3C, 0x00,
  0xE3, 0x80, 0x0F, 0x38, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xF7, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0xCF,
  0x00, 0x38, 0xF0, 0x07, 0x87, 0x00, 0xF0, 0x78, 0x1E, 0x03, 0xFF, 0xC0,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x70, 0x00, 0x02, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xFF, 0xF8, 0x0E, 0x07, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x38, 0x01,
  0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x78, 0x70, 0x03, 0xC7, 0x80, 0x1C, 0x3C,
  0x01, 0xE1, 0xC0, 0x1E, 0x0E, 0x03, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x01, 0xE0, 0xF0, 0x0E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0x80,
  0xF0, 0x3C, 0x03, 0x81, 0xE0, 0x1E, 0x0F, 0x00, 0xF0, 0x70, 0x07, 0x83,
  0x80, 0x1C, 0x1C, 0x00, 0xF1, 0xE0, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x3F,
  0xF8, 0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1F, 0x01, 0xE1, 0xE0, 0x0F, 0x1C,
  0x00, 0xF3, 0xC0, 0x07, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0xE0, 0x01,
  0xCE, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x78, 0x0F, 0x83, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x1E,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7, 0x00,
  0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x0E, 0x00, 0x38, 0xF0, 0x01, 0xC7,
  0x80, 0x1E, 0x38, 0x00, 0xF1, 0xC0, 0x07, 0x8E, 0x00, 0x38, 0x70, 0x01,
  0xC7, 0x80, 0x0E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78,
  0x01, 0xC3, 0xC0, 0x1E, 0x0E, 0x01, 0xE0, 0x78, 0x1E, 0x01, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF0,
  0x01, 0xEF, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x38, 0x70, 0x07, 0x87,
  0x00, 0x78, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0E, 0x03, 0x81, 0xE0,
  0x38, 0x1C, 0x03, 0x83, 0xC0, 0x38, 0x38, 0x03, 0x87, 0x80, 0x3C, 0x70,
  0x03, 0xCF, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1D, 0xE0, 0x01, 0xDC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x70, 0x38, 0x3B, 0x83, 0xC1, 0xDC, 0x1E, 0x0E,
  0xE0, 0xF0, 0xF7, 0x0F, 0x87, 0x38, 0x7C, 0x39, 0xC3, 0xE1, 0xCE, 0x3F,
  0x1C, 0x71, 0xF8, 0xE3, 0x8D, 0xC7, 0x1C, 0xEE, 0x79, 0xE7, 0x73, 0x8E,
  0x33, 0x9C, 0x73, 0x9C, 0xE3, 0x9C, 0xEF, 0x1C, 0xC7, 0x70, 0xEE, 0x3B,
  0x87, 0x71, 0xDC, 0x3B, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC3, 0xF0, 0x7E,
  0x1F, 0x83, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xF0,
  0x3C, 0x0F, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x3C, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0xF0,
  0x01, 0xE1, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0xE3, 0xC0, 0x00, 0xF7, 0x80,
  0x00, 0x77, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xEE, 0x00,
  0x01, 0xEF, 0x00, 0x03, 0xC7, 0x00, 0x07, 0x87, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x03, 0x80, 0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x3C, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x70,
  0x01, 0xE7, 0x80, 0x3C, 0x78, 0x07, 0x83, 0x80, 0x78, 0x38, 0x0F, 0x03,
  0xC0, 0xE0, 0x1C, 0x1E, 0x01, 0xC3, 0xC0, 0x1E, 0x38, 0x01, 0xE7, 0x80,
  0x0E, 0xF0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x03, 0xF8, 0x1F,
  0xC0, 0xFE, 0x07, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xE0,
  0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x1C, 0x03, 0xF8, 0x3F,
  0xC1, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC1, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x60, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x76, 0x01, 0xEE,
  0x03, 0x9C, 0x0F, 0x38, 0x1C, 0x70, 0x70, 0x71, 0xE0, 0xE3, 0x81, 0xCF,
  0x03, 0xBC, 0x07, 0x80, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF8,
  0x70, 0xF0, 0xE0, 0xE0, 0x01, 0xFC, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78,
  0x1E, 0x3C, 0x03, 0x8F, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7F,
  0x83, 0xFF, 0xE1, 0xFF, 0xF9, 0xF8, 0x1E, 0x78, 0x07, 0xBC, 0x01, 0xEE,
  0x00, 0x73, 0x80, 0x1C, 0xF0, 0x0F, 0x3C, 0x0F, 0xC7, 0xFF, 0xF1, 0xFF,
  0xFC, 0x1F, 0xCF, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x3E, 0x01, 0xDF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC1, 0xE1, 0xF0, 0x1C, 0x3C,
  0x03, 0xC7, 0x00, 0x78, 0xE0, 0x07, 0x3C, 0x00, 0xE7, 0x80, 0x1C, 0xF0,
  0x03, 0x9C, 0x00, 0xF3, 0x80, 0x1E, 0x70, 0x03, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x07, 0x8F, 0x81, 0xF1, 0xFF, 0xFC, 0x3B, 0xFF, 0x0F, 0x3F,
  0x80, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1E, 0x1E, 0x03,
  0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x01, 0x70, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x19, 0xC0,
  0x1E, 0x78, 0x07, 0x1E, 0x03, 0xC3, 0xF7, 0xE0, 0x7F, 0xF0, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xF9,
  0xE0, 0x3F, 0xEF, 0x03, 0xFF, 0xF8, 0x3E, 0x0F, 0xC3, 0xE0, 0x3C, 0x1E,
  0x01, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x70, 0x03, 0xC3, 0x80, 0x1C,
  0x3C, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC3, 0xC0,
  0x1E, 0x0E, 0x00, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xEE, 0x00, 0xFE, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0xFF,
  0xF0, 0x7C, 0x1E, 0x1E, 0x03, 0xCF, 0x00, 0x73, 0x80, 0x1D, 0xE0, 0x07,
  0x70, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x03, 0x1F, 0x03, 0xE3, 0xFF,
  0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x0F, 0x01, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x70,
  0x3F, 0xE7, 0x07, 0xFF, 0xF0, 0xF8, 0x3F, 0x1F, 0x01, 0xE1, 0xE0, 0x1E,
  0x3C, 0x00, 0xE3, 0xC0, 0x1E, 0x38, 0x01, 0xE3, 0x80, 0x1E, 0x78, 0x01,
  0xC7, 0x80, 0x1C, 0x78, 0x01, 0xC7, 0x80, 0x3C, 0x78, 0x03, 0xC3, 0x80,
  0x3C, 0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x07,
  0xF7, 0x80, 0x00, 0x70, 0x00, 0x07, 0x04, 0x00, 0xF0, 0x60, 0x1E, 0x0F,
  0x03, 0xE0, 0x7F, 0xFC, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x3F, 0x01, 0xCF, 0xF0, 0x7F, 0xFF,
  0x0F, 0xE1, 0xE1, 0xF0, 0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x3C, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9C, 0x00, 0xE3, 0x80, 0x1C,
  0x70, 0x03, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x71,
  0xC0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x1F, 0xF8, 0x0F, 0xFC, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE,
  0x03, 0xFF, 0x01, 0xFF, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x7F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0xE0,
  0x1E, 0x1E, 0x07, 0xC1, 0xE0, 0xF8, 0x1E, 0x1F, 0x01, 0xC3, 0xE0, 0x1C,
  0x7C, 0x01, 0xCF, 0x00, 0x3D, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0x00, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x78, 0x3C, 0x07, 0x83, 0xC0,
  0x78, 0x1E, 0x07, 0x00, 0xF0, 0x70, 0x0F, 0x07, 0x00, 0x78, 0xF0, 0x07,
  0xC0, 0x07, 0xFE, 0x03, 0xFF, 0x03, 0xFF, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x1C, 0xF0, 0xF0, 0x77, 0xEF, 0xE1, 0xFF, 0xFF, 0x87,
  0x8F, 0x8F, 0x1C, 0x3C, 0x3C, 0xF0, 0xF0, 0xF3, 0xC3, 0x83, 0x8E, 0x0E,
  0x0E, 0x38, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x83, 0x9E, 0x1E, 0x1E,
  0x70, 0x70, 0x71, 0xC1, 0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0x70,
  0x70, 0x73, 0xC3, 0xC3, 0xCE, 0x0E, 0x0E, 0x38, 0x38, 0x38, 0xE0, 0xE0,
  0xE0, 0x0E, 0x3F, 0x01, 0xDF, 0xF0, 0x7F, 0xFF, 0x0F, 0xC1, 0xE1, 0xF0,
  0x1E, 0x3C, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80,
  0x3C, 0xE0, 0x07, 0x1C, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x9E, 0x00,
  0xF3, 0xC0, 0x1E, 0x70, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x0E, 0x78, 0x01,
  0xCF, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x1E,
  0x3C, 0x03, 0x8F, 0x00, 0xF7, 0x80, 0x1D, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3B, 0xC0, 0x1E, 0x70, 0x0F, 0x1E, 0x07, 0xC3, 0xE7, 0xE0, 0x7F, 0xF0,
  0x0F, 0xF0, 0x00, 0x07, 0x1F, 0x00, 0x77, 0xFC, 0x0F, 0xFF, 0xC0, 0xFC,
  0x3E, 0x0F, 0x81, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0, 0xE0, 0x0F, 0x1E,
  0x00, 0x71, 0xE0, 0x07, 0x1C, 0x00, 0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0xF1,
  0xC0, 0x0E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C,
  0x3F, 0xBF, 0x87, 0xBF, 0xF0, 0x79, 0xFC, 0x07, 0x80, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0xE0, 0xFF, 0x9C, 0x3F, 0xFF, 0x8F,
  0x83, 0xF3, 0xE0, 0x3C, 0x78, 0x03, 0x9E, 0x00, 0x73, 0xC0, 0x1E, 0x70,
  0x03, 0xCE, 0x00, 0x73, 0xC0, 0x0E, 0x78, 0x01, 0xCF, 0x00, 0x39, 0xE0,
  0x0F, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x78, 0x0F, 0x0F, 0x03, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0xFE, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x0E, 0x1F, 0x8F, 0x3F, 0xC7, 0xFF, 0xE3, 0xBF, 0xF1, 0xF8, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC,
  0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7C, 0x1F, 0x1E, 0x03, 0xC7, 0x00, 0x73,
  0xC0, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3B, 0xC0, 0x0E, 0x70, 0x07,
  0x9E, 0x03, 0xC3, 0xF7, 0xF0, 0x7F, 0xF8, 0x0F, 0xF8, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFE, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1F,
  0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x00, 0x38, 0x01, 0xCE, 0x00, 0xF3, 0x80,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1E,
  0x70, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x73, 0xC0, 0x1C, 0xE0, 0x07, 0x38,
  0x03, 0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1E, 0x3C, 0x0F, 0x87, 0xFF,
  0xE1, 0xFF, 0xB8, 0x3F, 0x9E, 0x00, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xC0,
  0x07, 0x38, 0x01, 0xE7, 0x80, 0x38, 0x70, 0x0F, 0x0E, 0x03, 0xC1, 0xC0,
  0x70, 0x38, 0x1E, 0x03, 0x83, 0x80, 0x70, 0xF0, 0x0E, 0x1C, 0x01, 0xC7,
  0x80, 0x38, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x60, 0x7F, 0x07,
  0x03, 0xB8, 0x38, 0x1D, 0xC1, 0xC1, 0xCE, 0x1E, 0x0E, 0x70, 0xF0, 0x73,
  0x8F, 0xC7, 0x1C, 0x6E, 0x38, 0xE7, 0x71, 0xC7, 0x3B, 0x9C, 0x39, 0x9C,
  0xE1, 0xDC, 0xE6, 0x0E, 0xC7, 0x70, 0x7E, 0x1B, 0x83, 0xF0, 0xD8, 0x1B,
  0x07, 0xC0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x70,
  0x0E, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xE0, 0x78, 0x0F,
  0x80, 0xE0, 0x7C, 0x03, 0xC1, 0xE0, 0x07, 0x0F, 0x00, 0x1E, 0x78, 0x00,
  0x3B, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3C, 0xE0, 0x01, 0xE3, 0xC0,
  0x0F, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0x70, 0xF8,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07,
  0x00, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x78, 0x03, 0x80, 0x70, 0x03,
  0x80, 0xF0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xC3, 0xC0, 0x01,
  0xC3, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x00, 0x1E,
  0x00, 0x7C, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x0E, 0x0E, 0x0C, 0x1C, 0x1C, 0x1C,
  0x1C, 0x1C, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x30, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xE0, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x00, 0x60, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x01, 0xDF, 0xFC, 0x0F, 0xE1, 0xF0, 0xEE, 0x07, 0xFF, 0x60,
  0x1F, 0xF0, 0x00, 0x3F, 0x00,
};

const GFXglyph RobotoMono_Italic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 9, 28, 23, 7, -28 },
  { 33, 11, 9, 23, 8, -29 },
  { 46, 23, 28, 23, 0, -28 },
  { 127, 19, 36, 23, 2, -32 },
  { 213, 19, 28, 23, 2, -28 },
  { 280, 20, 28, 23, 1, -28 },
  { 350, 5, 9, 23, 10, -29 },
  { 356, 13, 40, 23, 6, -31 },
  { 421, 13, 40, 23, 3, -31 },
  { 486, 18, 19, 23, 4, -28 },
  { 529, 19, 20, 23, 2, -23 },
  { 577, 7, 10, 23, 4, -4 },
  { 586, 15, 3, 23, 4, -14 },
  { 592, 5, 5, 23, 8, -5 },
  { 596, 20, 30, 23, 2, -28 },
  { 671, 19, 28, 23, 2, -28 },
  { 738, 12, 28, 23, 5, -28 },
  { 780, 20, 28, 23, 0, -28 },
  { 850, 19, 28, 23, 1, -28 },
  { 917, 19, 28, 23, 1, -28 },
  { 984, 19, 28, 23, 3, -28 },
  { 1051, 17, 28, 23, 2, -28 },
  { 1111, 19, 28, 23, 4, -28 },
  { 1178, 19, 28, 23, 2, -28 },
  { 1245, 17, 28, 23, 4, -28 },
  { 1305, 8, 22, 23, 9, -22 },
  { 1327, 11, 28, 23, 6, -22 },
  { 1366, 17, 17, 23, 3, -21 },
  { 1403, 19, 11, 23, 2, -18 },
  { 1430, 18, 17, 23, 2, -21 },
  { 1469, 16, 28, 23, 5, -28 },
  { 1525, 22, 28, 23, 1, -28 },
  { 1602, 21, 28, 23, -1, -28 },
  { 1676, 21, 28, 23, 1, -28 },
  { 1750, 20, 28, 23, 2, -28 },
  { 1820, 21, 28, 23, 1, -28 },
  { 1894, 22, 28, 23, 1, -28 },
  { 1971, 21, 28, 23, 2, -28 },
  { 2045, 20, 28, 23, 2, -28 },
  { 2115, 22, 28, 23, 1, -28 },
  { 2192, 21, 28, 23, 1, -28 },
  { 2266, 21, 28, 23, 1, -28 },
  { 2340, 23, 28, 23, 1, -28 },
  { 2421, 17, 28, 23, 2, -28 },
  { 2481, 22, 28, 23, 1, -28 },
  { 2558, 22, 28, 23, 1, -28 },
  { 2635, 20, 28, 23, 2, -28 },
  { 2705, 21, 28, 23, 2, -28 },
  { 2779, 20, 33, 23, 2, -28 },
  { 2862, 21, 28, 23, 1, -28 },
  { 2936, 20, 28, 23, 2, -28 },
  { 3006, 20, 28, 23, 4, -28 },
  { 3076, 21, 28, 23, 2, -28 },
  { 3150, 20, 28, 23, 4, -28 },
  { 3220, 21, 28, 23, 3, -28 },
  { 3294, 24, 28, 23, 0, -28 },
  { 3378, 20, 28, 23, 4, -28 },
  { 3448, 22, 28, 23, 0, -28 },
  { 3525, 13, 38, 23, 5, -32 },
  { 3587, 9, 30, 23, 7, -28 },
  { 3621, 13, 38, 23, 5, -32 },
  { 3683, 15, 15, 23, 4, -28 },
  { 3712, 18, 3, 23, 0, 0 },
  { 3719, 7, 5, 23, 10, -28 },
  { 3724, 18, 21, 23, 2, -21 },
  { 3772, 19, 29, 23, 1, -29 },
  { 3841, 18, 21, 23, 2, -21 },
  { 3889, 21, 29, 23, 2, -29 },
  { 3966, 18, 21, 23, 2, -21 },
  { 4014, 20, 30, 23, 4, -30 },
  { 4089, 20, 29, 23, 1, -21 },
  { 4162, 19, 29, 23, 1, -29 },
  { 4231, 17, 28, 23, 2, -28 },
  { 4291, 17, 36, 23, 1, -28 },
  { 4368, 20, 29, 23, 1, -29 },
  { 4441, 17, 29, 23, 2, -29 },
  { 4503, 22, 21, 23, 0, -21 },
  { 4561, 19, 21, 23, 1, -21 },
  { 4611, 18, 21, 23, 2, -21 },
  { 4659, 20, 29, 23, 0, -21 },
  { 4732, 19, 29, 23, 2, -21 },
  { 4801, 17, 21, 23, 4, -21 },
  { 4846, 18, 21, 23, 2, -21 },
  { 4894, 17, 26, 23, 4, -26 },
  { 4950, 18, 21, 23, 3, -21 },
  { 4998, 19, 21, 23, 3, -21 },
  { 5048, 21, 21, 23, 3, -21 },
  { 5104, 22, 21, 23, 0, -21 },
  { 5162, 24, 29, 23, -1, -21 },
  { 5249, 20, 21, 23, 1, -21 },
  { 5302, 15, 37, 23, 6, -30 },
  { 5372, 8, 36, 23, 7, -28 },
  { 5408, 16, 37, 23, 3, -30 },
  { 5482, 21, 7, 23, 1, -15 },
};

const GFXfont RobotoMono_Italic39pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic39pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _ROBOTOMONO_ITALIC39PT7B_H_
