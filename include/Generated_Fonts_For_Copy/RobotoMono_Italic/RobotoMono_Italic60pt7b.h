#ifndef _ROBOTOMONO_ITALIC60PT7B_H_
#define _ROBOTOMONO_ITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: RobotoMono-Italic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t RobotoMono_Italic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0,
  0x1F, 0x80, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x1F, 0x00, 0x3E,
  0x0F, 0x9E, 0x07, 0xCF, 0x03, 0xC7, 0x81, 0xE3, 0xC0, 0xF3, 0xE0, 0x79,
  0xE0, 0x7C, 0xF0, 0x3C, 0x78, 0x1E, 0x3C, 0x0F, 0x1E, 0x07, 0x8E, 0x03,
  0xCF, 0x01, 0xC7, 0x81, 0xE0, 0x00, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x0F, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x3C, 0x00,
  0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x3C, 0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x1E, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xF7, 0xFC, 0x01,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x07, 0xF0, 0x3F,
  0x00, 0x3F, 0x80, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0x1E,
  0x00, 0x07, 0x81, 0xE0, 0x10, 0xF0, 0x1E, 0x01, 0xCF, 0x01, 0xE0, 0x3E,
  0xF0, 0x1E, 0x07, 0xCF, 0x01, 0xE0, 0x78, 0xF0, 0x1E, 0x0F, 0x0F, 0x01,
  0xE1, 0xF0, 0xF0, 0x1E, 0x1E, 0x0F, 0x83, 0xC3, 0xC0, 0x78, 0x7C, 0x7C,
  0x07, 0xFF, 0x8F, 0x80, 0x3F, 0xF0, 0xF0, 0x01, 0xFE, 0x1E, 0x00, 0x03,
  0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC3, 0xF0, 0x00, 0x78, 0xFF, 0xC0, 0x0F, 0x1F, 0xFE, 0x01, 0xF3,
  0xF3, 0xE0, 0x1E, 0x3C, 0x1F, 0x03, 0xC7, 0xC0, 0xF0, 0x7C, 0x78, 0x0F,
  0x0F, 0x87, 0x80, 0xF0, 0xF0, 0x78, 0x0F, 0x1E, 0x07, 0x80, 0xF3, 0xE0,
  0x78, 0x0F, 0x0C, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x03,
  0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x1F,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x07, 0xE0,
  0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xE0, 0x1F, 0x0F, 0xEF, 0xC0, 0x3E, 0x3F, 0x8F, 0xC0, 0x7C, 0xFE,
  0x0F, 0x80, 0xF3, 0xF8, 0x1F, 0x83, 0xE7, 0xE0, 0x1F, 0x87, 0xCF, 0x80,
  0x3F, 0x1F, 0x3F, 0x00, 0x3F, 0x3E, 0x7E, 0x00, 0x7E, 0xFC, 0xF8, 0x00,
  0x7F, 0xF1, 0xF0, 0x00, 0xFF, 0xC3, 0xE0, 0x00, 0xFF, 0x87, 0xE0, 0x00,
  0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xF8, 0x1F, 0xC0, 0x7F,
  0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF3, 0xF0, 0x1F, 0xFF, 0xC7,
  0xE0, 0x0F, 0xFE, 0x07, 0xE0, 0x01, 0xC0, 0x00, 0x00, 0x3E, 0x7C, 0xF1,
  0xE3, 0xCF, 0x9F, 0x3C, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x0C, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x20, 0x07, 0x80, 0x23, 0x80, 0x78, 0x0E,
  0x3E, 0x07, 0x03, 0xE7, 0xFC, 0x71, 0xFE, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xBC, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1E, 0x00, 0x7C, 0x00,
  0xE0, 0x07, 0x00, 0x04, 0x00, 0x60, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xE1,
  0xF8, 0x7E, 0x1F, 0x0F, 0xC3, 0xE1, 0xF8, 0x7C, 0x3E, 0x07, 0x00, 0x80,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xC0, 0x18, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7E, 0x10,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xC1, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0,
  0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0xE7, 0xC0, 0x01,
  0xFE, 0x3E, 0x00, 0x3F, 0xF3, 0xF0, 0x03, 0xFF, 0x9F, 0x80, 0x7F, 0xFC,
  0xF8, 0x07, 0xF3, 0xE7, 0xC0, 0xFF, 0x3F, 0x3E, 0x0F, 0xE1, 0xF9, 0xF0,
  0xFE, 0x0F, 0x9F, 0x9F, 0xC0, 0x7C, 0xFD, 0xFC, 0x03, 0xE7, 0xFF, 0x80,
  0x1F, 0x3F, 0xF8, 0x01, 0xF9, 0xFF, 0x80, 0x0F, 0xCF, 0xF0, 0x00, 0x7C,
  0x7F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70,
  0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF,
  0xFE, 0x7F, 0x8F, 0x9F, 0x07, 0xEE, 0x01, 0xF2, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80,
  0x0F, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0xFC, 0x1F,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x08, 0x7F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x40, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x3F, 0x80,
  0x1F, 0x1F, 0xFC, 0x03, 0xEF, 0xFF, 0xC0, 0xFB, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0xC3, 0xFE, 0x01, 0xF8, 0x7F, 0x80, 0x1F, 0x9F, 0xE0, 0x03, 0xF3,
  0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xF0, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFE,
  0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3,
  0xF0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x3F, 0x81, 0xFE, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0xF0, 0xFE, 0x07, 0xF0, 0x0F, 0xC1, 0xF8,
  0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x9F,
  0x00, 0x0F, 0xE7, 0xE0, 0x0F, 0xF9, 0xFC, 0x07, 0xFC, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xF7, 0xC0, 0xFF, 0xF9, 0xF0, 0x1F, 0xFC, 0xF8, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xC0, 0x1F, 0x81, 0xFC, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0x7E,
  0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0xFC, 0x07, 0xF0, 0x7F, 0x83,
  0xFC, 0x1F, 0xE0, 0xFF, 0x03, 0xF0, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x3F,
  0x80, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x1E, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x80, 0x1F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0x3F, 0xE1, 0xFC, 0x03, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0xF8, 0x03, 0xC0, 0x00, 0x3C, 0x03, 0xE0, 0x00, 0x0E, 0x03, 0xE0, 0x3E,
  0x07, 0x81, 0xE0, 0x7F, 0xC1, 0xC1, 0xE0, 0x7F, 0xF0, 0xE0, 0xF0, 0x7F,
  0xF8, 0x70, 0xF0, 0x7C, 0x3C, 0x38, 0x78, 0x7C, 0x1C, 0x1C, 0x78, 0x3C,
  0x0E, 0x0E, 0x3C, 0x3C, 0x07, 0x07, 0x1C, 0x1E, 0x07, 0x83, 0x9E, 0x0E,
  0x03, 0x81, 0xCF, 0x0F, 0x01, 0xC0, 0xE7, 0x07, 0x80, 0xE0, 0x73, 0x83,
  0x80, 0xF0, 0x3B, 0xC3, 0xC0, 0x78, 0x39, 0xE1, 0xE0, 0x38, 0x1C, 0xF0,
  0xF0, 0x1C, 0x0E, 0x78, 0x78, 0x1E, 0x07, 0x3C, 0x3C, 0x0F, 0x07, 0x1C,
  0x1E, 0x0F, 0x03, 0x8F, 0x0F, 0x0F, 0x83, 0x87, 0x87, 0xCF, 0xE3, 0xC3,
  0xC3, 0xFF, 0xFF, 0xC1, 0xE0, 0xFF, 0x3F, 0xC0, 0xF0, 0x7F, 0x1F, 0xC0,
  0x38, 0x0C, 0x03, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7E, 0x7C,
  0x00, 0x00, 0xF8, 0x78, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x7C, 0x0F, 0x80,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x3C, 0x00,
  0x1F, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xE0,
  0x00, 0x7C, 0x0F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF,
  0x80, 0x7E, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8,
  0x3F, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1,
  0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xE0, 0x3E, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0,
  0x0F, 0xF0, 0x1F, 0x00, 0x07, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0xFE, 0x0F, 0x80, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xE0,
  0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x03,
  0xE0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0xF8, 0x01, 0xF0, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x07,
  0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x07,
  0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x0F,
  0xC0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x0F,
  0x80, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x3E, 0x1F,
  0x80, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x7E, 0x1F,
  0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x3E,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0xC0, 0x7E,
  0x00, 0xFF, 0x80, 0x7E, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x0F,
  0xF9, 0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0xFE,
  0x7E, 0x00, 0x7F, 0xFC, 0xF8, 0x01, 0xFF, 0xF9, 0xF0, 0x03, 0xFF, 0xF3,
  0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0x1F, 0x1F,
  0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xFC,
  0x00, 0x03, 0xF0, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF8,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x03, 0xE0,
  0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x00, 0x00,
  0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x7F,
  0x00, 0x3F, 0x81, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x03, 0xF8, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x1F, 0xC0,
  0x03, 0xE0, 0x07, 0xF0, 0x00, 0x7C, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x7F,
  0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0x81,
  0xFC, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3E, 0x7F, 0x00, 0x00,
  0x07, 0xDF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xDF, 0x00, 0x00, 0x1F, 0xF3,
  0xF0, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x1F, 0x80, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x80, 0x1F,
  0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x01, 0xEF, 0x81, 0xF7, 0xC0, 0x7D,
  0xF0, 0x3E, 0xF8, 0x0F, 0x9E, 0x0F, 0x9E, 0x01, 0xF3, 0xC1, 0xF7, 0xC0,
  0x3E, 0x78, 0x7C, 0xF8, 0x07, 0xCF, 0x0F, 0x9F, 0x00, 0xF9, 0xE3, 0xE3,
  0xE0, 0x3E, 0x3E, 0x78, 0x78, 0x07, 0xC7, 0xDF, 0x1F, 0x00, 0xF8, 0x7B,
  0xC3, 0xE0, 0x1F, 0x0F, 0xF8, 0x7C, 0x03, 0xE1, 0xFE, 0x0F, 0x80, 0x7C,
  0x3F, 0xC1, 0xF0, 0x1F, 0x07, 0xF0, 0x7C, 0x03, 0xE0, 0xFE, 0x0F, 0x80,
  0x7C, 0x1F, 0x81, 0xF0, 0x0F, 0x83, 0xF0, 0x3E, 0x01, 0xF0, 0x3C, 0x07,
  0xC0, 0x7E, 0x07, 0x81, 0xF8, 0x0F, 0x80, 0xE0, 0x3E, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x01, 0xF0,
  0x1F, 0x80, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x7F, 0x00, 0x03, 0xE0, 0x3F, 0xE0, 0x00, 0xF8, 0x0F, 0xF8, 0x00,
  0x3E, 0x03, 0xFE, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x07, 0xE0, 0x3F, 0xF0,
  0x01, 0xF0, 0x1F, 0xFC, 0x00, 0x7C, 0x07, 0xEF, 0x80, 0x1F, 0x01, 0xFB,
  0xE0, 0x07, 0xC0, 0x7C, 0xF8, 0x03, 0xF0, 0x1F, 0x1F, 0x00, 0xFC, 0x07,
  0xC7, 0xC0, 0x3E, 0x03, 0xF1, 0xF0, 0x0F, 0x80, 0xFC, 0x3E, 0x03, 0xE0,
  0x3F, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x7E, 0x03, 0xE0, 0x7C, 0x1F,
  0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x7E, 0x07, 0xC1, 0xF0, 0x1F, 0x81, 0xF8,
  0x7C, 0x07, 0xC0, 0x3E, 0x3F, 0x01, 0xF0, 0x0F, 0x8F, 0xC0, 0x7C, 0x03,
  0xF3, 0xF0, 0x1F, 0x00, 0x7C, 0xF8, 0x0F, 0xC0, 0x1F, 0x3E, 0x03, 0xF0,
  0x07, 0xEF, 0x80, 0xF8, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x3F, 0xF8, 0x0F,
  0x80, 0x0F, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xC0,
  0x7E, 0x00, 0x1F, 0xF0, 0x1F, 0x00, 0x03, 0xFC, 0x07, 0xC0, 0x00, 0xFF,
  0x01, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3E,
  0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x3E, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0x80, 0x07, 0xF0, 0x07, 0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x07,
  0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0x80, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x3F, 0x03, 0xE0, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x1F, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7E, 0xF8, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3E, 0x00, 0x00,
  0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x06, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xF0, 0x03, 0xFC, 0x03, 0xF0, 0x00,
  0xFC, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00,
  0x3E, 0x03, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xFC, 0x0F, 0x80, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F,
  0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xCF, 0xFC, 0x01, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF8, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x1F,
  0x07, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x3E,
  0x0F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0x7C,
  0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x01, 0xF8,
  0x3E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xF0,
  0x7C, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xE0,
  0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80,
  0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x01, 0xE3, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0xCF, 0x80, 0x7C, 0x03, 0xE3,
  0xE0, 0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0xC0, 0x3E, 0x3E, 0x03, 0xF0, 0x1F,
  0x0F, 0x80, 0xFC, 0x07, 0xC3, 0xE0, 0x7F, 0x01, 0xF0, 0xF8, 0x1F, 0xC0,
  0x7C, 0x3E, 0x07, 0xF0, 0x3E, 0x0F, 0x03, 0xFC, 0x0F, 0x83, 0xC0, 0xFF,
  0x03, 0xE0, 0xF0, 0x3F, 0xC0, 0xF8, 0x3C, 0x1F, 0xF0, 0x7C, 0x1F, 0x07,
  0xBC, 0x1F, 0x07, 0xC1, 0xEF, 0x07, 0xC1, 0xF0, 0xFB, 0xC1, 0xE0, 0x7C,
  0x3C, 0xF0, 0xF8, 0x1F, 0x0F, 0x3C, 0x3E, 0x07, 0xC7, 0xCF, 0x0F, 0x81,
  0xF1, 0xE3, 0xC3, 0xC0, 0x7C, 0x78, 0xF1, 0xF0, 0x1F, 0x3E, 0x3C, 0x7C,
  0x07, 0xCF, 0x0F, 0x1F, 0x01, 0xF3, 0xC3, 0xCF, 0x80, 0x7D, 0xF0, 0xF3,
  0xE0, 0x1F, 0x7C, 0x3C, 0xF8, 0x07, 0xDE, 0x0F, 0x3C, 0x01, 0xFF, 0x83,
  0xDF, 0x00, 0x7B, 0xE0, 0xF7, 0xC0, 0x1E, 0xF0, 0x3D, 0xF0, 0x07, 0xBC,
  0x0F, 0x78, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x1F,
  0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF0, 0x01, 0xFC, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x0F, 0xE0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00,
  0x1F, 0x1F, 0x80, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x3F, 0x8F, 0xC0,
  0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0xC0,
  0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x0F,
  0x8F, 0x80, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x80, 0x1F,
  0x3E, 0x00, 0xFC, 0xF8, 0x03, 0xE1, 0xE0, 0x1F, 0x07, 0x80, 0x7C, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xC3, 0xF0, 0x0F, 0x8F,
  0x80, 0x3E, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xEF, 0x80, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x7F,
  0x83, 0xFC, 0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC7, 0xF8, 0x00, 0xF9, 0xFC, 0x00,
  0x1F, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x0F,
  0xF3, 0xF8, 0x03, 0xFE, 0x3F, 0x83, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xBE, 0x07, 0xFF, 0xE7, 0xE0, 0x3F, 0xF0, 0xFC, 0x00, 0x60, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE1, 0xFF, 0x00, 0x1F, 0x3F, 0xFE, 0x00, 0xFB, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xF9, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x1F, 0xE0,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0,
  0x07, 0xF0, 0x7F, 0xE0, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0x7F, 0xFF,
  0x81, 0xF1, 0xFF, 0xF0, 0x0F, 0x87, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F,
  0x8F, 0x80, 0x07, 0xE1, 0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0xF8,
  0x00, 0x7F, 0xF8, 0xF8, 0x01, 0xFF, 0xFC, 0xF8, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xFC, 0x3F, 0xF8, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x07, 0xF0,
  0x1F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0xC1, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xDF, 0x00,
  0x03, 0xFF, 0x1F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFC,
  0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3E,
  0x1F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x02, 0x03,
  0xF0, 0x00, 0x70, 0x3F, 0x80, 0x1F, 0xC1, 0xFC, 0x07, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0x83, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x3E, 0x00, 0x3F, 0xFC, 0x7C, 0x01,
  0xFF, 0xFC, 0xF8, 0x07, 0xFF, 0xFD, 0xF0, 0x1F, 0xF0, 0xFF, 0xE0, 0x3F,
  0x80, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xC0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x80,
  0x7F, 0x83, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFD, 0xF0, 0x00, 0x7F, 0xE3, 0xE0, 0x00, 0x0C, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x01, 0x00,
  0x01, 0xF8, 0x07, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x7F,
  0x80, 0x1F, 0x0F, 0xFE, 0x00, 0xF9, 0xFF, 0xF8, 0x07, 0xDF, 0xFF, 0xE0,
  0x3F, 0xF8, 0xFF, 0x83, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0xFE,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C,
  0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x03, 0xF1, 0xF0, 0x00,
  0x1F, 0x8F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7F, 0x03, 0xE0, 0x03,
  0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0xFE,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF0, 0x3F, 0x80,
  0x03, 0xE0, 0xFE, 0x00, 0x07, 0xC7, 0xF8, 0x00, 0x1F, 0x9F, 0xC0, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F,
  0xE3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xF8,
  0x0F, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x80, 0x7C, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xCF, 0xE0,
  0xFC, 0x03, 0xEF, 0xF9, 0xFF, 0x81, 0xEF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0x3F, 0xF3, 0xF8, 0x7E, 0x07, 0xE0, 0x7C, 0x3E, 0x03,
  0xF0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x0F, 0x8F, 0xC0,
  0x7C, 0x07, 0xC7, 0xC0, 0x3E, 0x03, 0xE3, 0xE0, 0x3E, 0x01, 0xF1, 0xF0,
  0x1F, 0x00, 0xF8, 0xF8, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC0, 0x7C, 0x7C,
  0x03, 0xE0, 0x3E, 0x3E, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF0, 0x0F, 0x8F,
  0x80, 0xF8, 0x07, 0xC7, 0xC0, 0x7C, 0x07, 0xC3, 0xE0, 0x3E, 0x03, 0xE3,
  0xE0, 0x1F, 0x01, 0xF1, 0xF0, 0x0F, 0x80, 0xF8, 0xF8, 0x0F, 0x80, 0x7C,
  0x7C, 0x07, 0xC0, 0x3E, 0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1F,
  0x1F, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x7C, 0x07, 0xC7, 0xC0, 0x7C, 0x03,
  0xE3, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xC1, 0xFF,
  0x00, 0x3E, 0x3F, 0xFC, 0x01, 0xF3, 0xFF, 0xF0, 0x0F, 0xBF, 0xFF, 0xC0,
  0x7B, 0xF1, 0xFF, 0x07, 0xFC, 0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xC1, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFC,
  0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x3F, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0xC0, 0xFE,
  0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xF0, 0xFF, 0x80, 0x03, 0xE7, 0xFF, 0x80, 0x07, 0xDF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0x00, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0xC0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F, 0x83,
  0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFF, 0x81,
  0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF,
  0x80, 0x1F, 0x0F, 0xFE, 0x00, 0x3E, 0x01, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0xF8, 0x03, 0xFF, 0xC7, 0xC0,
  0x7F, 0xFF, 0xBE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x83, 0xF8,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x3F, 0x00, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0xE0, 0x7F, 0x01, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7C, 0x00, 0x7F, 0xE3, 0xE0,
  0x00, 0x38, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x7F, 0xE0,
  0x7C, 0x7F, 0xFC, 0x1F, 0x1F, 0xFF, 0x03, 0xE7, 0xFF, 0xE0, 0x7D, 0xFF,
  0xFC, 0x0F, 0xFE, 0x01, 0x81, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x83,
  0xFC, 0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x1F,
  0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF1,
  0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF8,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x81, 0x80, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F,
  0x1F, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x3E, 0x3F, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x7E,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0xF8, 0x7C, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x3F, 0x07, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0xFF, 0x07, 0xF0, 0x3F, 0xF0,
  0x3F, 0xFF, 0xDF, 0x03, 0xFF, 0xF9, 0xE0, 0x1F, 0xFF, 0x3E, 0x00, 0x7F,
  0xC3, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0xF8, 0x07, 0x80, 0x0F, 0xC0, 0x3E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x3C, 0x03, 0xE0,
  0x01, 0xE0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0xF8, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x1F, 0xF0, 0x07,
  0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x3E, 0xF0, 0x07, 0xC0, 0x3E, 0xF0, 0x0F,
  0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x7C, 0xF0, 0x1F, 0xC0, 0x7C, 0xF0, 0x1F,
  0xC0, 0x78, 0xF0, 0x3D, 0xC0, 0xF8, 0xF8, 0x3D, 0xC0, 0xF8, 0xF8, 0x3D,
  0xC0, 0xF0, 0xF8, 0x79, 0xE1, 0xF0, 0xF8, 0x79, 0xE1, 0xE0, 0xF8, 0xF1,
  0xE1, 0xE0, 0xF8, 0xF1, 0xE3, 0xE0, 0xF8, 0xF1, 0xE3, 0xC0, 0xF9, 0xE1,
  0xE3, 0xC0, 0xF9, 0xE1, 0xE7, 0x80, 0xFB, 0xC1, 0xE7, 0x80, 0x7B, 0xC1,
  0xE7, 0x80, 0x73, 0xC1, 0xEF, 0x00, 0x77, 0x81, 0xEF, 0x00, 0x77, 0x80,
  0xEF, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03, 0xF8, 0x03,
  0xE0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x07, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0xF8, 0x1F, 0x00, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x3E,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x02,
  0x00, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xE3, 0xFF, 0xF0, 0x00, 0xF3, 0xFF, 0xFC, 0x00, 0xFB, 0xF8, 0xFF,
  0x00, 0x79, 0xF0, 0x1F, 0xE0, 0x7D, 0xF0, 0x07, 0xFF, 0xFC, 0xF0, 0x01,
  0xFF, 0xFE, 0x78, 0x00, 0x7F, 0xFE, 0x04, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00,
};

const GFXglyph RobotoMono_Italic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 13, 43, 35, 11, -43 },
  { 71, 17, 14, 35, 12, -45 },
  { 101, 35, 43, 35, 1, -43 },
  { 290, 30, 56, 35, 3, -50 },
  { 500, 28, 44, 35, 4, -43 },
  { 654, 31, 44, 35, 2, -43 },
  { 825, 7, 14, 35, 16, -45 },
  { 838, 19, 62, 35, 10, -48 },
  { 986, 20, 62, 35, 5, -48 },
  { 1141, 28, 29, 35, 6, -43 },
  { 1243, 30, 31, 35, 3, -35 },
  { 1360, 10, 16, 35, 6, -6 },
  { 1380, 23, 5, 35, 6, -21 },
  { 1395, 8, 9, 35, 12, -8 },
  { 1404, 31, 47, 35, 3, -43 },
  { 1587, 29, 44, 35, 4, -43 },
  { 1747, 18, 43, 35, 8, -43 },
  { 1844, 31, 43, 35, 0, -43 },
  { 2011, 30, 44, 35, 1, -43 },
  { 2176, 31, 43, 35, 1, -43 },
  { 2343, 31, 44, 35, 4, -43 },
  { 2514, 27, 44, 35, 3, -43 },
  { 2663, 29, 43, 35, 6, -43 },
  { 2819, 29, 44, 35, 4, -43 },
  { 2979, 26, 43, 35, 6, -43 },
  { 3119, 13, 35, 35, 13, -34 },
  { 3176, 17, 44, 35, 9, -34 },
  { 3270, 27, 26, 35, 5, -32 },
  { 3358, 28, 17, 35, 4, -28 },
  { 3418, 28, 26, 35, 3, -32 },
  { 3509, 25, 43, 35, 8, -43 },
  { 3644, 33, 43, 35, 2, -43 },
  { 3822, 31, 43, 35, -1, -43 },
  { 3989, 31, 43, 35, 2, -43 },
  { 4156, 31, 44, 35, 3, -43 },
  { 4327, 32, 43, 35, 1, -43 },
  { 4499, 33, 43, 35, 2, -43 },
  { 4677, 33, 43, 35, 2, -43 },
  { 4855, 31, 44, 35, 3, -43 },
  { 5026, 34, 43, 35, 1, -43 },
  { 5209, 32, 43, 35, 2, -43 },
  { 5381, 32, 44, 35, 2, -43 },
  { 5557, 35, 43, 35, 2, -43 },
  { 5746, 26, 43, 35, 3, -43 },
  { 5886, 35, 43, 35, 1, -43 },
  { 6075, 34, 43, 35, 1, -43 },
  { 6258, 30, 44, 35, 3, -43 },
  { 6423, 33, 43, 35, 2, -43 },
  { 6601, 30, 50, 35, 3, -43 },
  { 6789, 32, 43, 35, 2, -43 },
  { 6961, 32, 44, 35, 2, -43 },
  { 7137, 31, 43, 35, 6, -43 },
  { 7304, 32, 44, 35, 3, -43 },
  { 7480, 31, 43, 35, 6, -43 },
  { 7647, 34, 43, 35, 4, -43 },
  { 7830, 37, 43, 35, 0, -43 },
  { 8029, 31, 43, 35, 6, -43 },
  { 8196, 33, 43, 35, 1, -43 },
  { 8374, 20, 58, 35, 8, -49 },
  { 8519, 14, 47, 35, 11, -43 },
  { 8602, 21, 58, 35, 7, -49 },
  { 8755, 22, 23, 35, 7, -43 },
  { 8819, 26, 4, 35, 1, 0 },
  { 8832, 10, 7, 35, 16, -43 },
  { 8841, 27, 33, 35, 3, -32 },
  { 8953, 29, 46, 35, 2, -45 },
  { 9120, 27, 33, 35, 4, -32 },
  { 9232, 32, 46, 35, 3, -45 },
  { 9416, 28, 33, 35, 3, -32 },
  { 9532, 31, 46, 35, 6, -46 },
  { 9711, 31, 45, 35, 1, -32 },
  { 9886, 29, 45, 35, 2, -45 },
  { 10050, 26, 43, 35, 3, -43 },
  { 10190, 27, 56, 35, 1, -43 },
  { 10379, 31, 45, 35, 2, -45 },
  { 10554, 26, 45, 35, 3, -45 },
  { 10701, 33, 32, 35, 0, -32 },
  { 10833, 29, 32, 35, 2, -32 },
  { 10949, 28, 33, 35, 3, -32 },
  { 11065, 31, 44, 35, 0, -32 },
  { 11236, 29, 44, 35, 3, -32 },
  { 11396, 27, 32, 35, 6, -32 },
  { 11504, 27, 33, 35, 4, -32 },
  { 11616, 26, 40, 35, 6, -39 },
  { 11746, 28, 33, 35, 4, -32 },
  { 11862, 29, 32, 35, 5, -32 },
  { 11978, 32, 32, 35, 4, -32 },
  { 12106, 34, 32, 35, 0, -32 },
  { 12242, 37, 45, 35, -1, -32 },
  { 12451, 30, 32, 35, 2, -32 },
  { 12571, 24, 58, 35, 9, -47 },
  { 12745, 13, 55, 35, 11, -43 },
  { 12835, 24, 58, 35, 5, -47 },
  { 13009, 33, 12, 35, 1, -24 },
};

const GFXfont RobotoMono_Italic60pt7b PROGMEM = {
  (uint8_t  *)RobotoMono_Italic60pt7bBitmaps,
  (GFXglyph *)RobotoMono_Italic60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _ROBOTOMONO_ITALIC60PT7B_H_
