#ifndef _JETBRAINSMONO_REGULAR26PT7B_H_
#define _JETBRAINSMONO_REGULAR26PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x60, 0x00, 0xEF, 0xE0, 0xC7,
  0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC6, 0x04, 0x10, 0x30, 0xC0, 0xC3,
  0x03, 0x0C, 0x0C, 0x31, 0xFF, 0xF7, 0xFF, 0xC6, 0x18, 0x18, 0x60, 0x61,
  0x81, 0x86, 0x04, 0x10, 0xFF, 0xFB, 0xFF, 0xE3, 0x0C, 0x0C, 0x30, 0x20,
  0x81, 0x86, 0x06, 0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x1F,
  0x83, 0xFC, 0x76, 0xE6, 0x66, 0xE6, 0x7E, 0x60, 0x66, 0x07, 0x60, 0x3E,
  0x01, 0xF8, 0x07, 0xE0, 0x6E, 0x06, 0x70, 0x67, 0xC6, 0x7E, 0x67, 0xE6,
  0xE7, 0xFC, 0x3F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0x06,
  0xFC, 0x1B, 0x8C, 0x36, 0x18, 0xCC, 0x33, 0x18, 0x66, 0x19, 0x98, 0x3F,
  0x60, 0x18, 0x80, 0x03, 0x00, 0x0C, 0x40, 0x33, 0xE0, 0x6E, 0xE1, 0x98,
  0xC6, 0x31, 0x8C, 0x63, 0x30, 0xC6, 0xC1, 0xFF, 0x81, 0xF0, 0x1F, 0x80,
  0xFF, 0x03, 0x0E, 0x1C, 0x18, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x3C, 0x01, 0xF8, 0x16, 0x71, 0xB8, 0xCE, 0xE3, 0xB3, 0x87, 0x8E, 0x0E,
  0x38, 0x38, 0x61, 0xF1, 0xFE, 0xE3, 0xF1, 0xC0, 0xFF, 0xFE, 0xDB, 0x01,
  0x0F, 0x1E, 0x38, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x38, 0x1E, 0x0F, 0x03,
  0x80, 0xE0, 0xF8, 0x38, 0x1C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x0C, 0x1C, 0x78, 0xF0,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xE3, 0x1B, 0xED, 0xF7,
  0xFF, 0x00, 0xC0, 0x07, 0x80, 0x37, 0x01, 0xCE, 0x0E, 0x38, 0x30, 0x70,
  0x41, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF,
  0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C, 0xE3,
  0x9C, 0x71, 0xC6, 0x38, 0xFF, 0xFF, 0xEF, 0xFF, 0x00, 0x70, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x00, 0x1F, 0x87,
  0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xCE, 0x7C,
  0xE7, 0xC6, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x6E, 0x06, 0x70, 0xE7,
  0xFC, 0x1F, 0x80, 0x0F, 0x01, 0xF0, 0x7F, 0x0E, 0x70, 0xC7, 0x08, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xFC, 0x70,
  0xEE, 0x06, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0x78,
  0x0F, 0xC0, 0x3C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xF0, 0x1E, 0x03, 0xE0,
  0xEF, 0xF8, 0xFE, 0x00, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x6E, 0x0D, 0x81, 0xF0, 0x3C, 0x07, 0xFF, 0xFF,
  0xF8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x7F, 0xEF, 0xFD, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0x7E, 0x7F, 0xEE, 0x1D, 0x81, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1F, 0x03, 0x60, 0xEF, 0xF8, 0x7E, 0x00, 0x03, 0x80,
  0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x70, 0x6F, 0xCF,
  0x1E, 0xE0, 0x6C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x06, 0x70, 0xE7,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x06, 0xC0, 0x60, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0x1F, 0x87, 0xFC, 0x70,
  0xE6, 0x06, 0xE0, 0x66, 0x06, 0x60, 0xE3, 0x1C, 0x1F, 0x81, 0xF0, 0x39,
  0xC6, 0x0E, 0xE0, 0x6C, 0x06, 0xC0, 0x7E, 0x06, 0x60, 0xE7, 0xFC, 0x1F,
  0x80, 0x1F, 0x87, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x67, 0x0E, 0x7F, 0xE1, 0xCC, 0x01, 0xC0, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xC0, 0x1C, 0x00, 0x4F, 0xFF, 0x00, 0x00, 0x00, 0x06,
  0xFF, 0xF0, 0x10, 0xF3, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x38,
  0xE3, 0x1C, 0x71, 0x8E, 0x00, 0x00, 0x60, 0x3C, 0x1F, 0x0F, 0x87, 0xC1,
  0xE0, 0x30, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x02, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0,
  0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x08, 0x0F, 0x07,
  0xC3, 0xE1, 0xF0, 0x78, 0x0C, 0x00, 0xF8, 0x7F, 0x03, 0xC0, 0x60, 0x38,
  0x1C, 0x0E, 0x06, 0x07, 0x3F, 0x1F, 0x0E, 0x07, 0x03, 0x80, 0x00, 0x00,
  0x70, 0x3C, 0x1C, 0x00, 0x0F, 0xE0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0x60,
  0x1B, 0x00, 0x7C, 0x0C, 0xF0, 0xFB, 0xC7, 0x1F, 0x18, 0x7C, 0x61, 0xF1,
  0x87, 0xC6, 0x1F, 0x18, 0x7C, 0x61, 0xF0, 0xC7, 0xC3, 0xEF, 0x03, 0x0E,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xF8, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1B, 0x00, 0xDC, 0x06, 0x60, 0x33, 0x03, 0x98, 0x18,
  0xE0, 0xC3, 0x0E, 0x18, 0x70, 0xC3, 0xFF, 0x1F, 0xF9, 0xC0, 0xCE, 0x06,
  0x60, 0x3B, 0x00, 0xF8, 0x06, 0xFF, 0x8F, 0xFC, 0xE1, 0xEE, 0x06, 0xE0,
  0x6E, 0x06, 0xE0, 0x6E, 0x0E, 0xFF, 0xCF, 0xFC, 0xE0, 0xEE, 0x06, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0x80, 0x1F, 0x87,
  0xF9, 0xC3, 0xF0, 0x3E, 0x07, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x1F, 0x03, 0x70, 0xEF, 0xF8, 0x7E,
  0x00, 0xFF, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x07, 0xE1,
  0xDF, 0xFB, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xFF, 0xDF, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x1F, 0x87, 0xF9, 0xC3, 0xF0, 0x3E, 0x07, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0xFF, 0x9F, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x70, 0xEF,
  0xF8, 0x7E, 0x00, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0x80, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x3F, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0xE0, 0x7E, 0x07, 0x70, 0xE3, 0xFE, 0x1F, 0x80, 0xE0,
  0x77, 0x03, 0xB8, 0x39, 0xC1, 0xCE, 0x1C, 0x70, 0xC3, 0x8E, 0x1C, 0x60,
  0xFF, 0x07, 0xF8, 0x38, 0xC1, 0xC7, 0x0E, 0x18, 0x70, 0xE3, 0x83, 0x1C,
  0x1C, 0xE0, 0x67, 0x03, 0xB8, 0x0E, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0xE0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x1B, 0xD1, 0xBD, 0x9B, 0xD9, 0x3C, 0xB3, 0xCF, 0x7C, 0xE7,
  0xC6, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x70, 0xF0, 0x7E, 0x0F, 0xC1, 0xEC, 0x3D, 0x87, 0xF0, 0xFB, 0x1F,
  0x63, 0xEC, 0x7C, 0xCF, 0x99, 0xF3, 0xBE, 0x37, 0xC6, 0xF8, 0x7F, 0x0F,
  0xE1, 0xFC, 0x1F, 0x83, 0x80, 0x1F, 0x8F, 0xF9, 0xC3, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0x70, 0xEF, 0xF8, 0x7E, 0x00, 0xFF, 0x8F, 0xFE, 0xE0,
  0xEE, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7F, 0xFE, 0xFF,
  0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x1F, 0x87, 0xFC, 0x70, 0xEE, 0x06, 0xC0, 0x6C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x6E,
  0x06, 0x70, 0xE7, 0xFC, 0x1F, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0x07, 0xFF, 0x8F, 0xFC, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0xEF, 0xFC, 0xFF, 0x8E, 0x38, 0xE3, 0x8E, 0x1C, 0xE1, 0xCE,
  0x0C, 0xE0, 0xEE, 0x06, 0xE0, 0x70, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0xE0, 0x7E, 0x00, 0x60, 0x07, 0x00, 0x3E, 0x01, 0xF8, 0x03, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0xE7, 0xFC, 0x3F, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1B, 0x03, 0x70, 0xEF, 0xF8, 0x7E, 0x00, 0xE0, 0x1B, 0x00,
  0xD8, 0x0E, 0xE0, 0x67, 0x03, 0x18, 0x18, 0xC1, 0xC7, 0x0C, 0x38, 0x60,
  0xC3, 0x06, 0x38, 0x39, 0x80, 0xCC, 0x06, 0x60, 0x37, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0xC3, 0x0F, 0x1C, 0x3C, 0x70, 0xF1, 0xC7, 0xC7,
  0x9B, 0x16, 0x6E, 0x59, 0x99, 0x66, 0x64, 0x99, 0xB2, 0x66, 0xC9, 0x9B,
  0x26, 0x6C, 0xF1, 0xA3, 0xC6, 0x8F, 0x1A, 0x3C, 0x38, 0xF0, 0xE1, 0xC3,
  0x87, 0x00, 0xE0, 0x39, 0xC0, 0xC3, 0x07, 0x0E, 0x18, 0x18, 0xE0, 0x73,
  0x00, 0xDC, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x03, 0xE0, 0x0D,
  0xC0, 0x73, 0x01, 0x8E, 0x0E, 0x1C, 0x70, 0x31, 0x80, 0xEE, 0x01, 0xC0,
  0xE0, 0x1D, 0x80, 0x67, 0x03, 0x8C, 0x0C, 0x30, 0x70, 0x61, 0x81, 0x8E,
  0x07, 0x30, 0x0D, 0xC0, 0x3E, 0x00, 0x78, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFC, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x01, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFE, 0xC0,
  0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00,
  0x70, 0xFF, 0xFF, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xFC, 0x0E, 0x00, 0xF0, 0x0F,
  0x01, 0x98, 0x19, 0x83, 0x18, 0x30, 0xC6, 0x0C, 0x60, 0x6E, 0x07, 0xFF,
  0xFF, 0xFF, 0xE3, 0x8E, 0x04, 0x07, 0xF9, 0xFF, 0xB0, 0x78, 0x06, 0x00,
  0xC0, 0x1B, 0xFF, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0xFF, 0xDF,
  0xD8, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x31, 0xDF, 0xBF, 0xFF, 0x07,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0,
  0xFF, 0xFB, 0xBE, 0x00, 0x04, 0x07, 0xF9, 0xFF, 0xB0, 0x7E, 0x07, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x81, 0xF0, 0x37, 0x0E, 0xFF, 0x87,
  0xE0, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x86, 0x7E, 0xDF, 0xFB, 0x07,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x70,
  0xEF, 0xEC, 0xFD, 0x80, 0x04, 0x07, 0xF1, 0xEF, 0x30, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x37, 0x0E, 0xFF, 0x87,
  0xE0, 0x03, 0xF0, 0xFF, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x04, 0x07, 0xED, 0xFF, 0xB0, 0x7E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83, 0xB8, 0x77, 0xF6,
  0x3C, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x3C, 0xFF, 0x1F, 0x80, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x21, 0xDF, 0xBE, 0xFF, 0x07, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0x80, 0x07, 0x00, 0xF0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x07, 0xF9, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0xF3,
  0xF8, 0xF8, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07,
  0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x38, 0xE3, 0x0F, 0xF0, 0xFF, 0x0E, 0x38,
  0xE1, 0xCE, 0x1C, 0xE0, 0xEE, 0x07, 0xE0, 0x70, 0xFE, 0x07, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x3F, 0xC0, 0x7E, 0x08, 0xCF, 0xDE, 0xEF, 0x7C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63,
  0xC6, 0x30, 0x02, 0x1D, 0xFB, 0xFF, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x18, 0x04,
  0x07, 0xF1, 0xFF, 0x30, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x37, 0x0E, 0xFF, 0x87, 0xE0, 0x03, 0x1D, 0xFB, 0xFF,
  0xF8, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3F, 0x0F, 0xFF, 0xBB, 0xE7, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x00,
  0x08, 0x07, 0xED, 0xFF, 0xB0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x37, 0x0E, 0xFE, 0xCF, 0xD8, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x04, 0x1B, 0xF3, 0xEF, 0x70, 0x7C, 0x0F, 0x80,
  0xF0, 0x1E, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x00, 0x06, 0x03, 0xFC, 0x7F, 0xE6, 0x06, 0x60, 0x06, 0x00, 0x7C, 0x03,
  0xFC, 0x0F, 0xE0, 0x0E, 0x00, 0x7E, 0x06, 0x60, 0x67, 0xFE, 0x3F, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xFC, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0D, 0x81, 0xB8, 0x73, 0xFC,
  0x3F, 0x00, 0xE0, 0x1B, 0x01, 0xDC, 0x0C, 0x60, 0x63, 0x07, 0x1C, 0x30,
  0x61, 0x83, 0x1C, 0x1C, 0xC0, 0x66, 0x03, 0x70, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0xC3, 0x0F, 0x1C, 0x6C, 0x71, 0x99, 0x66, 0x65, 0x99, 0x96, 0x66,
  0x49, 0x9B, 0x24, 0x6C, 0xB1, 0xB2, 0xC3, 0x8F, 0x0E, 0x3C, 0x38, 0xF0,
  0xE1, 0x80, 0x70, 0x39, 0xC3, 0x86, 0x38, 0x39, 0x80, 0xDC, 0x03, 0xC0,
  0x1C, 0x00, 0xF0, 0x0F, 0xC0, 0xE6, 0x06, 0x38, 0x70, 0xE7, 0x03, 0x70,
  0x1C, 0xE0, 0x3B, 0x81, 0xCC, 0x0C, 0x60, 0xE3, 0x86, 0x0C, 0x30, 0x73,
  0x81, 0x98, 0x0C, 0xC0, 0x7E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x01, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x7F, 0xEF, 0xFC, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x3C, 0x0F, 0x83, 0x80, 0x70, 0x0E,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x07, 0x0F, 0xC1, 0xFC, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0,
  0x1F, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x1F,
  0x03, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x80, 0x3E, 0x1F, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x3F, 0xC3,
  0xCE, 0x3C, 0x77, 0xC3, 0xE0, 0x08,
};

const GFXglyph JetBrainsMono_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 8, 8, 16, 4, -19 },
  { 19, 14, 19, 16, 1, -19 },
  { 53, 12, 27, 16, 2, -23 },
  { 94, 15, 19, 16, 0, -19 },
  { 130, 14, 19, 16, 1, -19 },
  { 164, 3, 8, 16, 6, -19 },
  { 167, 8, 25, 16, 5, -22 },
  { 192, 8, 25, 16, 3, -22 },
  { 217, 14, 14, 16, 1, -16 },
  { 242, 12, 13, 16, 2, -15 },
  { 262, 6, 8, 16, 4, -4 },
  { 268, 8, 2, 16, 4, -10 },
  { 270, 4, 4, 16, 6, -4 },
  { 272, 12, 25, 16, 2, -22 },
  { 310, 12, 19, 16, 2, -19 },
  { 339, 12, 19, 16, 2, -19 },
  { 368, 12, 19, 16, 2, -19 },
  { 397, 11, 19, 16, 2, -19 },
  { 424, 11, 19, 16, 2, -19 },
  { 451, 11, 19, 16, 2, -19 },
  { 478, 12, 19, 16, 2, -19 },
  { 507, 12, 19, 16, 2, -19 },
  { 536, 12, 19, 16, 2, -19 },
  { 565, 12, 19, 16, 2, -19 },
  { 594, 4, 15, 16, 6, -15 },
  { 602, 6, 19, 16, 4, -15 },
  { 617, 11, 13, 16, 2, -15 },
  { 635, 11, 9, 16, 2, -13 },
  { 648, 11, 13, 16, 2, -15 },
  { 666, 9, 19, 16, 4, -19 },
  { 688, 14, 24, 16, 1, -19 },
  { 730, 13, 19, 16, 1, -19 },
  { 761, 12, 19, 16, 2, -19 },
  { 790, 11, 19, 16, 2, -19 },
  { 817, 11, 19, 16, 2, -19 },
  { 844, 11, 19, 16, 3, -19 },
  { 871, 12, 19, 16, 2, -19 },
  { 900, 11, 19, 16, 2, -19 },
  { 927, 11, 19, 16, 2, -19 },
  { 954, 10, 19, 16, 3, -19 },
  { 978, 12, 19, 16, 1, -19 },
  { 1007, 13, 19, 16, 2, -19 },
  { 1038, 11, 19, 16, 3, -19 },
  { 1065, 12, 19, 16, 2, -19 },
  { 1094, 11, 19, 16, 2, -19 },
  { 1121, 11, 19, 16, 2, -19 },
  { 1148, 12, 19, 16, 2, -19 },
  { 1177, 12, 24, 16, 2, -19 },
  { 1213, 12, 19, 16, 2, -19 },
  { 1242, 12, 19, 16, 2, -19 },
  { 1271, 13, 19, 16, 1, -19 },
  { 1302, 11, 19, 16, 2, -19 },
  { 1329, 13, 19, 16, 1, -19 },
  { 1360, 14, 19, 16, 1, -19 },
  { 1394, 14, 19, 16, 1, -19 },
  { 1428, 14, 19, 16, 1, -19 },
  { 1462, 11, 19, 16, 2, -19 },
  { 1489, 7, 25, 16, 5, -22 },
  { 1511, 12, 25, 16, 2, -22 },
  { 1549, 6, 25, 16, 4, -22 },
  { 1568, 12, 10, 16, 2, -19 },
  { 1583, 12, 2, 16, 2, 1 },
  { 1586, 5, 3, 16, 5, -20 },
  { 1588, 11, 15, 16, 2, -15 },
  { 1609, 11, 19, 16, 2, -19 },
  { 1636, 11, 15, 16, 2, -15 },
  { 1657, 11, 19, 16, 2, -19 },
  { 1684, 11, 15, 16, 2, -15 },
  { 1705, 12, 19, 16, 2, -19 },
  { 1734, 11, 20, 16, 2, -15 },
  { 1762, 11, 19, 16, 2, -19 },
  { 1789, 12, 20, 16, 2, -20 },
  { 1819, 10, 25, 16, 2, -20 },
  { 1851, 12, 19, 16, 2, -19 },
  { 1880, 13, 19, 16, 1, -19 },
  { 1911, 12, 15, 16, 2, -15 },
  { 1934, 11, 15, 16, 2, -15 },
  { 1955, 11, 15, 16, 2, -15 },
  { 1976, 11, 20, 16, 2, -15 },
  { 2004, 11, 20, 16, 2, -15 },
  { 2032, 11, 15, 16, 3, -15 },
  { 2053, 12, 15, 16, 2, -15 },
  { 2076, 13, 18, 16, 1, -18 },
  { 2106, 11, 14, 16, 2, -14 },
  { 2126, 13, 14, 16, 1, -14 },
  { 2149, 14, 14, 16, 1, -14 },
  { 2174, 13, 14, 16, 1, -14 },
  { 2197, 13, 19, 16, 1, -14 },
  { 2228, 11, 14, 16, 2, -14 },
  { 2248, 11, 25, 16, 2, -22 },
  { 2283, 2, 25, 16, 7, -22 },
  { 2290, 11, 25, 16, 2, -22 },
  { 2325, 12, 6, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Regular26pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular26pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular26pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _JETBRAINSMONO_REGULAR26PT7B_H_
