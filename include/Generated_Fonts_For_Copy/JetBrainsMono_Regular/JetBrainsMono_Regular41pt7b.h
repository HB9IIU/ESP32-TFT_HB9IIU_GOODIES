#ifndef _JETBRAINSMONO_REGULAR41PT7B_H_
#define _JETBRAINSMONO_REGULAR41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular41pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3,
  0x8E, 0x38, 0xE3, 0x8E, 0x38, 0x00, 0x00, 0x00, 0xE7, 0xFF, 0xFD, 0xF0,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x07,
  0xF0, 0x7F, 0x07, 0x70, 0x77, 0x07, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0,
  0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x60, 0x38, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xC0, 0xE0, 0x70, 0x03, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x60, 0x38, 0x3F, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0xE0, 0x70, 0x03, 0x81, 0xC0,
  0x1C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0xE0, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xF0,
  0x1F, 0xFF, 0x07, 0xDD, 0xF1, 0xE3, 0x8F, 0x3C, 0x71, 0xE7, 0x8E, 0x3C,
  0xE1, 0xC3, 0x9E, 0x38, 0x03, 0xC7, 0x00, 0x78, 0xE0, 0x07, 0x9C, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xE0,
  0x07, 0x7C, 0x00, 0xE7, 0xC0, 0x1C, 0x78, 0x03, 0x87, 0x00, 0x70, 0xFF,
  0x0E, 0x1F, 0xE1, 0xC3, 0xFC, 0x38, 0xF3, 0xC7, 0x1E, 0x7C, 0xE7, 0x87,
  0xFF, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E,
  0xFF, 0x80, 0x3B, 0xFF, 0x00, 0xE7, 0x0F, 0x01, 0xCE, 0x0E, 0x07, 0x1C,
  0x1C, 0x1C, 0x38, 0x38, 0x38, 0x70, 0x70, 0xE0, 0xE0, 0xE3, 0x81, 0xC1,
  0xC7, 0x03, 0xC7, 0x9C, 0x03, 0xFE, 0x70, 0x03, 0xF9, 0xE0, 0x00, 0x83,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x40, 0x01, 0xC7,
  0xF0, 0x07, 0x1F, 0xF0, 0x0E, 0x78, 0xE0, 0x38, 0xE0, 0xE0, 0xE1, 0xC1,
  0xC1, 0xC3, 0x83, 0x87, 0x07, 0x07, 0x1C, 0x0E, 0x0E, 0x38, 0x1C, 0x1C,
  0xE0, 0x38, 0x7B, 0x80, 0x7F, 0xE7, 0x00, 0x7F, 0xDC, 0x00, 0x7E, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xC0, 0x7C, 0x1E, 0x03, 0xC0,
  0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFF, 0x00, 0x0F, 0xBC, 0x0F, 0x71, 0xE0, 0xF7, 0x87, 0x87, 0xBC,
  0x1E, 0x79, 0xE0, 0xFB, 0xCF, 0x03, 0xFC, 0x78, 0x0F, 0xC3, 0xC0, 0x3E,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0xFE, 0x1E, 0x0F, 0xF8, 0xFF,
  0xFB, 0xC3, 0xFF, 0x8F, 0x0F, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0xFC, 0x0F, 0x81, 0xE0, 0x3C, 0x07,
  0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xF0, 0x0F, 0x00, 0x30,
  0xE0, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x0F, 0x00, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x07, 0x03, 0x81, 0x9F, 0x0E, 0x3F, 0x7F, 0x33, 0xFF,
  0xFF, 0xDF, 0xE0, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xB8, 0x00, 0x1C, 0xF0, 0x00, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E, 0x0F,
  0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x06, 0x00, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C,
  0x3C, 0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x7D, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF0, 0xF8,
  0x3E, 0x78, 0x07, 0xDE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x41, 0xFC, 0x78, 0x7F,
  0x1F, 0x1F, 0xC7, 0xC7, 0xF1, 0xE1, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x03,
  0xDE, 0x01, 0xF3, 0xC0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0xFC, 0xF0, 0x3E,
  0x3C, 0x0E, 0x0F, 0x03, 0x03, 0xC0, 0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xFF,
  0xC0, 0xFF, 0xFC, 0x3F, 0x07, 0xC7, 0x80, 0x79, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x9F, 0xFF,
  0xE7, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xE7, 0xC0, 0xF8, 0xFF, 0xFC, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xF3,
  0xE0, 0x3C, 0xF0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x87,
  0x01, 0xEF, 0xF8, 0x7F, 0xFF, 0x1F, 0xFF, 0xE7, 0xC0, 0x79, 0xE0, 0x0F,
  0x78, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x01, 0xE7, 0xC0,
  0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x10,
  0x03, 0xDF, 0xE0, 0x7F, 0xFE, 0x1F, 0xEF, 0xE3, 0xE0, 0x3E, 0xF8, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xCF, 0x00, 0xF9, 0xF8, 0x3E,
  0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xBC, 0x00,
  0xF7, 0x80, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xE3, 0xC0, 0x78, 0xF8, 0x3C, 0x1F,
  0x3E, 0x01, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xF0, 0x1F, 0x3F, 0x0F, 0x03,
  0xE7, 0x80, 0x79, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xDE, 0x00, 0xF7, 0xC0, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x3F,
  0x07, 0xC7, 0x80, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D, 0xF0,
  0x07, 0x9F, 0x01, 0xF3, 0xF9, 0xFE, 0x3F, 0xFF, 0x81, 0xFF, 0xF0, 0x06,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0xF7, 0xFF, 0xFF, 0xDF,
  0x00, 0x1E, 0x1F, 0x8F, 0xE7, 0xF3, 0xF8, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8F, 0x87, 0xC3, 0xC3,
  0xE1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x0C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x03,
  0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x03, 0xFF, 0x0F, 0xFF, 0x3F, 0xFC,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7C, 0x03, 0xC3, 0xC0, 0x0F, 0x3C,
  0x00, 0x39, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x07, 0xCF, 0xC0, 0xFF, 0x7E, 0x07, 0xFB, 0xF0, 0x78, 0x3F, 0x83,
  0x81, 0xFC, 0x1C, 0x07, 0xE0, 0xE0, 0x3F, 0x07, 0x01, 0xF8, 0x38, 0x0F,
  0xC1, 0xC0, 0x7E, 0x0E, 0x03, 0xF0, 0x70, 0x1F, 0x83, 0x80, 0xFC, 0x1E,
  0x0F, 0xE0, 0xF0, 0xFF, 0x03, 0xFD, 0xF8, 0x0F, 0xEF, 0xC0, 0x1C, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1D,
  0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0xC0, 0x03, 0x9E, 0x00,
  0x3C, 0x70, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x83,
  0x80, 0x3C, 0x1E, 0x01, 0xC0, 0xF0, 0x0E, 0x07, 0x80, 0xF0, 0x1C, 0x07,
  0x80, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0xF0, 0x07,
  0x87, 0x00, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x1E, 0x00, 0x3C, 0xE0,
  0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x3C, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0x81, 0xFC, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80,
  0x1E, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x3C, 0xE0, 0x3E,
  0x3F, 0xFF, 0x0F, 0xFF, 0x83, 0xFF, 0xF8, 0xE0, 0x1F, 0x38, 0x03, 0xEE,
  0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x07, 0xB8, 0x03, 0xEE, 0x03, 0xF3, 0xFF, 0xFC, 0xFF, 0xFC,
  0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0x83, 0xEF,
  0x80, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xDF, 0x07,
  0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x1C, 0x1F, 0xCE, 0x01, 0xF7, 0x00, 0x7B, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0x70, 0x0F, 0xB8, 0x1F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF,
  0xF3, 0xFF, 0xFC, 0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0x83, 0xEF, 0x80, 0xFF, 0x80, 0x3F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0xDF, 0x07, 0xCF, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0xC0, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0, 0x7F, 0xF0,
  0x1F, 0xFC, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE,
  0x03, 0xFF, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0x80, 0x1E, 0x70, 0x03,
  0xCE, 0x00, 0xF1, 0xC0, 0x1E, 0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x3C,
  0x1C, 0x07, 0x83, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x0F, 0x01, 0xFF, 0xE0,
  0x3F, 0xF8, 0x07, 0xFF, 0x80, 0xE0, 0xF0, 0x1C, 0x1F, 0x03, 0x81, 0xE0,
  0x70, 0x3E, 0x0E, 0x03, 0xC1, 0xC0, 0x7C, 0x38, 0x07, 0x87, 0x00, 0xF8,
  0xE0, 0x0F, 0x1C, 0x01, 0xF3, 0x80, 0x1E, 0x70, 0x03, 0xEE, 0x00, 0x3D,
  0xC0, 0x07, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0x7F, 0xF0, 0x1F, 0xFC, 0x0E, 0xFB, 0x83, 0xBE, 0xE0, 0xEF, 0xB8,
  0x73, 0xE7, 0x1D, 0xF9, 0xC7, 0x7E, 0x73, 0x9F, 0x8E, 0xE7, 0xE3, 0xB9,
  0xFC, 0xEC, 0x7F, 0x1F, 0x1F, 0xC7, 0xC7, 0xF1, 0xE1, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01,
  0xFC, 0x00, 0x70, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xF0, 0x3F, 0xB8, 0x1F, 0xDC, 0x0F, 0xEF, 0x07, 0xF3, 0x83,
  0xF9, 0xC1, 0xFC, 0xF0, 0xFE, 0x38, 0x7F, 0x1C, 0x3F, 0x8F, 0x1F, 0xC3,
  0x8F, 0xE1, 0xC7, 0xF0, 0x73, 0xF8, 0x39, 0xFC, 0x1E, 0xFE, 0x07, 0x7F,
  0x03, 0xBF, 0x81, 0xEF, 0xC0, 0x77, 0xE0, 0x3B, 0xF0, 0x1F, 0xF8, 0x07,
  0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x7C, 0x0F, 0xF8, 0x1F, 0xFE, 0x1F,
  0xFF, 0x8F, 0x83, 0xEF, 0x80, 0xF7, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07,
  0xF8, 0x07, 0x9F, 0x07, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x70, 0x1F, 0xCE, 0x00, 0x7D, 0xC0,
  0x07, 0xB8, 0x00, 0xF7, 0x00, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0x3F, 0xFF, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x1F, 0xFC, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0xFC, 0x03, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0x07, 0xC7, 0x80, 0x7C, 0xF0,
  0x07, 0xBC, 0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0,
  0x07, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80,
  0x0E, 0xF0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00,
  0x1D, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x1E, 0x78, 0x03, 0xCF, 0x00,
  0xF8, 0xF8, 0x3E, 0x1F, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0x80, 0xFC,
  0xE0, 0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xB8, 0x07, 0xEF, 0xFF,
  0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x38, 0x3C, 0x0E, 0x07, 0x83, 0x81, 0xE0,
  0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x0F, 0x38,
  0x03, 0xCE, 0x00, 0xFB, 0x80, 0x1E, 0xE0, 0x07, 0xF8, 0x00, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0xE0, 0xFF, 0xFE, 0x1F, 0x07, 0xC7, 0x80, 0x3C, 0xF0,
  0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0E, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xCF, 0x00,
  0x79, 0xF0, 0x3F, 0x1F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x07, 0x9F, 0x07, 0xCF,
  0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0x9C,
  0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0xF0, 0xE0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xC1, 0xE0, 0x1E, 0x07, 0x00, 0xF0, 0x3C,
  0x07, 0x81, 0xE0, 0x38, 0x07, 0x03, 0xC0, 0x38, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x00, 0x38, 0x78, 0x01, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x78,
  0xE0, 0x01, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0xF0, 0x78, 0x1F, 0xE0, 0xF0, 0x3B, 0xC1, 0xF0, 0x77, 0x83, 0xE0,
  0xE7, 0x06, 0xC1, 0xCE, 0x0D, 0x83, 0x9C, 0x1B, 0x07, 0x38, 0x36, 0x1E,
  0x70, 0xEC, 0x3C, 0xF1, 0xD8, 0x71, 0xE3, 0x38, 0xE3, 0xC6, 0x71, 0xC7,
  0x8C, 0xE3, 0x87, 0x18, 0xC7, 0x0E, 0x31, 0x8E, 0x1C, 0x63, 0x1C, 0x39,
  0xC6, 0x78, 0x73, 0x8C, 0xF0, 0xE7, 0x19, 0xC1, 0xEC, 0x3B, 0x83, 0xD8,
  0x77, 0x07, 0xB0, 0xEE, 0x07, 0x60, 0xDC, 0x0E, 0xC1, 0xB8, 0x1F, 0x83,
  0x70, 0x3F, 0x06, 0xE0, 0x7E, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xF0, 0x3E,
  0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0x9F, 0x00, 0x78,
  0x78, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x01, 0xC0, 0x3C, 0x1E, 0x01, 0xE1,
  0xE0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0x3C, 0x00, 0x78, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC1, 0xE0, 0x1E,
  0x0F, 0x00, 0x78, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7C, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0xF3, 0x80, 0x07, 0x8F, 0x00, 0x1E, 0x1C, 0x00,
  0xF0, 0x78, 0x03, 0xC0, 0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x07,
  0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0E, 0xE0, 0x03, 0xB8, 0x01, 0xCF, 0x00, 0x71, 0xC0, 0x38, 0x70, 0x0E,
  0x0E, 0x07, 0x83, 0x81, 0xC0, 0x70, 0xF0, 0x1C, 0x38, 0x07, 0x9E, 0x00,
  0xE7, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF8, 0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x03, 0xF8, 0x03, 0xFF,
  0x81, 0xFF, 0xF0, 0xFC, 0x7E, 0x7C, 0x07, 0x9E, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0xFF, 0xFC, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0x7F, 0xFF, 0xCF, 0xFE, 0xF1, 0xFF, 0x3C,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC3, 0xE0, 0xE7, 0xFC, 0x77, 0xFF, 0x3B, 0x8F, 0xDD,
  0x01, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC, 0x07, 0xFB, 0x07, 0xDD, 0xFF, 0xEE,
  0x7F, 0xE7, 0x1F, 0xC0, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFC,
  0x7E, 0x7C, 0x07, 0xDE, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x07, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x7C, 0xF8,
  0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x1F, 0x8F, 0x1F, 0xF3, 0xCF, 0xFE, 0xF3, 0xF1, 0xFD, 0xF0, 0x1F, 0x78,
  0x07, 0xDC, 0x00, 0xF7, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D,
  0xC0, 0x0F, 0x78, 0x03, 0xDE, 0x01, 0xF7, 0xC0, 0xFC, 0xFF, 0xFF, 0x1F,
  0xFB, 0xC3, 0xFC, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8,
  0x3E, 0x78, 0x07, 0x9E, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xF7, 0x80, 0x3C, 0xF0,
  0x1E, 0x3F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x07,
  0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x0F,
  0xC7, 0x9F, 0xFB, 0xDF, 0xFD, 0xEF, 0xC7, 0xFF, 0x80, 0xFF, 0x80, 0x7F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFC,
  0x0F, 0xDF, 0xFF, 0xE7, 0xFE, 0xF1, 0xFE, 0x78, 0x18, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC3, 0xFF, 0xE1, 0xFF,
  0xE0, 0xFF, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xE0, 0xE7, 0xFC, 0x77, 0xFF,
  0x3B, 0x0F, 0xDD, 0x01, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0xF3, 0xC0, 0x3E, 0x78,
  0x07, 0x8F, 0x01, 0xE1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x83, 0xC0, 0xF0,
  0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0x0F, 0x81, 0xE0,
  0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xF0, 0xF0, 0x1E, 0x1E, 0x01, 0xE3, 0xC0,
  0x3E, 0x78, 0x03, 0xCF, 0x00, 0x3D, 0xE0, 0x07, 0xC0, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0xE7, 0x87, 0x1D, 0xFB,
  0xFB, 0xFF, 0x7F, 0x78, 0xF8, 0xFE, 0x0E, 0x1F, 0xC1, 0xC3, 0xF8, 0x38,
  0x7F, 0x07, 0x0F, 0xE0, 0xE1, 0xFC, 0x1C, 0x3F, 0x83, 0x87, 0xF0, 0x70,
  0xFE, 0x0E, 0x1F, 0xC1, 0xC3, 0xF8, 0x38, 0x7F, 0x07, 0x0F, 0xE0, 0xE1,
  0xFC, 0x1C, 0x3F, 0x83, 0x87, 0xF0, 0x70, 0xFE, 0x0E, 0x1F, 0xC1, 0xC3,
  0xF8, 0x38, 0x78, 0xE1, 0xF0, 0x73, 0xFE, 0x3B, 0xFF, 0x9D, 0xC7, 0xEE,
  0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1E, 0x03, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xFE,
  0xFE, 0x7C, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x3D, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x78, 0xF8,
  0x3E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xE1, 0xF0, 0x73, 0xFE,
  0x3B, 0xFF, 0x9D, 0xC7, 0xEE, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03,
  0xFD, 0x83, 0xEE, 0xFF, 0xF7, 0x3F, 0xF3, 0x8F, 0xE1, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xC7, 0x9F, 0xF3, 0xDF, 0xFD, 0xEF, 0xC7, 0xFF, 0x80, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x03, 0xF7, 0xFF, 0xF9, 0xFF, 0xBC, 0x7F,
  0x9E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0xE3, 0xF0, 0x73, 0xFE, 0x3B, 0xFF, 0x9F, 0x87,
  0xEF, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF, 0xCF,
  0xC7, 0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF0, 0x01, 0xFC, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x01, 0xFF, 0x01, 0xF7,
  0xFF, 0xF1, 0xFF, 0xF0, 0x7F, 0xF0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x7F,
  0xF0, 0x03, 0xFE, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xCF, 0x83, 0xE7, 0xFF, 0xE1,
  0xFF, 0xE0, 0x3F, 0xC0, 0xF0, 0x00, 0x77, 0x00, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x0E, 0x38, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xC1, 0xC0, 0x3C,
  0x1E, 0x03, 0xC1, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0x07,
  0x00, 0x70, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xE0, 0x03, 0x9E, 0x00, 0x3D,
  0xE0, 0x03, 0xDC, 0x00, 0x1D, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0xF0, 0x38, 0x1D, 0xC1, 0xE0, 0x77, 0x07, 0x81, 0xDC, 0x1F,
  0x07, 0x70, 0x7C, 0x3D, 0xC1, 0xB0, 0xE7, 0x86, 0xC3, 0x8E, 0x3B, 0x0E,
  0x38, 0xCC, 0x38, 0xE3, 0x30, 0xE3, 0x8C, 0xE3, 0x0E, 0x31, 0x9C, 0x38,
  0xC6, 0x70, 0x77, 0x19, 0xC1, 0xDC, 0x67, 0x07, 0x61, 0x9C, 0x1D, 0x87,
  0x60, 0x76, 0x1D, 0x81, 0xD8, 0x3E, 0x07, 0x60, 0xF8, 0x0F, 0x83, 0xE0,
  0x3C, 0x0F, 0x80, 0xF0, 0x3C, 0x00, 0x78, 0x00, 0xF3, 0xE0, 0x0F, 0x0F,
  0x00, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x07, 0x83, 0xC0, 0x1E, 0x3C,
  0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0x8F, 0x00, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x07, 0x83, 0xC0,
  0x1E, 0x3C, 0x00, 0xFB, 0xE0, 0x03, 0xE0, 0xF0, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1C, 0x1E, 0x03,
  0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0x78,
  0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x01,
  0xDC, 0x00, 0x1D, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xFF, 0xFF,
  0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0xFC, 0x0F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x03,
  0xF0, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC,
  0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x01, 0xFF, 0xC0, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0E, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xF0, 0x3D, 0xFF, 0x07, 0xFD, 0xF0,
  0xFE, 0x1E, 0x1F, 0xC1, 0xF7, 0xF8, 0x1F, 0xF7, 0x01, 0xFC, 0xE0, 0x0F,
  0x00,
};

const GFXglyph JetBrainsMono_Regular41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 30, 25, 9, -30 },
  { 24, 12, 12, 25, 6, -30 },
  { 42, 22, 30, 25, 1, -30 },
  { 125, 19, 42, 25, 3, -36 },
  { 225, 23, 30, 25, 1, -30 },
  { 312, 21, 30, 25, 2, -30 },
  { 391, 4, 12, 25, 10, -30 },
  { 397, 12, 39, 25, 8, -34 },
  { 456, 12, 39, 25, 5, -34 },
  { 515, 22, 21, 25, 1, -25 },
  { 573, 19, 19, 25, 3, -23 },
  { 619, 8, 13, 25, 7, -6 },
  { 632, 13, 3, 25, 6, -15 },
  { 637, 7, 6, 25, 9, -6 },
  { 643, 19, 39, 25, 3, -34 },
  { 736, 18, 30, 25, 3, -30 },
  { 804, 18, 30, 25, 4, -30 },
  { 872, 19, 30, 25, 3, -30 },
  { 944, 18, 30, 25, 3, -30 },
  { 1012, 18, 30, 25, 3, -30 },
  { 1080, 18, 30, 25, 3, -30 },
  { 1148, 19, 30, 25, 3, -30 },
  { 1220, 19, 30, 25, 3, -30 },
  { 1292, 18, 30, 25, 3, -30 },
  { 1360, 19, 30, 25, 3, -30 },
  { 1432, 7, 23, 25, 9, -23 },
  { 1453, 9, 30, 25, 7, -23 },
  { 1487, 18, 21, 25, 3, -24 },
  { 1535, 18, 13, 25, 3, -20 },
  { 1565, 18, 21, 25, 3, -24 },
  { 1613, 14, 30, 25, 6, -30 },
  { 1666, 21, 37, 25, 2, -30 },
  { 1764, 21, 30, 25, 2, -30 },
  { 1843, 18, 30, 25, 4, -30 },
  { 1911, 17, 30, 25, 4, -30 },
  { 1975, 17, 30, 25, 4, -30 },
  { 2039, 17, 30, 25, 4, -30 },
  { 2103, 18, 30, 25, 4, -30 },
  { 2171, 17, 30, 25, 4, -30 },
  { 2235, 17, 30, 25, 4, -30 },
  { 2299, 16, 30, 25, 4, -30 },
  { 2359, 18, 30, 25, 2, -30 },
  { 2427, 19, 30, 25, 4, -30 },
  { 2499, 17, 30, 25, 5, -30 },
  { 2563, 18, 30, 25, 3, -30 },
  { 2631, 17, 30, 25, 4, -30 },
  { 2695, 17, 30, 25, 4, -30 },
  { 2759, 19, 30, 25, 4, -30 },
  { 2831, 19, 37, 25, 3, -30 },
  { 2919, 18, 30, 25, 4, -30 },
  { 2987, 19, 30, 25, 3, -30 },
  { 3059, 20, 30, 25, 2, -30 },
  { 3134, 17, 30, 25, 4, -30 },
  { 3198, 21, 30, 25, 2, -30 },
  { 3277, 23, 30, 25, 1, -30 },
  { 3364, 21, 30, 25, 2, -30 },
  { 3443, 22, 30, 25, 1, -30 },
  { 3526, 18, 30, 25, 3, -30 },
  { 3594, 10, 39, 25, 8, -34 },
  { 3643, 19, 39, 25, 3, -34 },
  { 3736, 10, 39, 25, 6, -34 },
  { 3785, 18, 16, 25, 3, -30 },
  { 3821, 20, 3, 25, 2, 1 },
  { 3829, 9, 6, 25, 7, -32 },
  { 3836, 18, 23, 25, 3, -23 },
  { 3888, 17, 30, 25, 4, -30 },
  { 3952, 18, 23, 25, 3, -23 },
  { 4004, 18, 30, 25, 3, -30 },
  { 4072, 18, 23, 25, 3, -23 },
  { 4124, 20, 30, 25, 2, -30 },
  { 4199, 17, 30, 25, 4, -23 },
  { 4263, 17, 30, 25, 4, -30 },
  { 4327, 20, 32, 25, 3, -32 },
  { 4407, 16, 39, 25, 3, -32 },
  { 4485, 19, 30, 25, 4, -30 },
  { 4557, 22, 30, 25, 1, -30 },
  { 4640, 19, 23, 25, 3, -23 },
  { 4695, 17, 23, 25, 4, -23 },
  { 4744, 18, 23, 25, 3, -23 },
  { 4796, 17, 30, 25, 4, -23 },
  { 4860, 17, 30, 25, 4, -23 },
  { 4924, 17, 23, 25, 5, -23 },
  { 4973, 17, 23, 25, 4, -23 },
  { 5022, 19, 29, 25, 2, -29 },
  { 5091, 17, 23, 25, 4, -23 },
  { 5140, 20, 23, 25, 2, -23 },
  { 5198, 22, 23, 25, 1, -23 },
  { 5262, 21, 23, 25, 2, -23 },
  { 5323, 20, 30, 25, 2, -23 },
  { 5398, 17, 23, 25, 4, -23 },
  { 5447, 18, 39, 25, 3, -34 },
  { 5535, 4, 39, 25, 10, -34 },
  { 5555, 18, 39, 25, 3, -34 },
  { 5643, 19, 9, 25, 3, -19 },
};

const GFXfont JetBrainsMono_Regular41pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular41pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular41pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _JETBRAINSMONO_REGULAR41PT7B_H_
