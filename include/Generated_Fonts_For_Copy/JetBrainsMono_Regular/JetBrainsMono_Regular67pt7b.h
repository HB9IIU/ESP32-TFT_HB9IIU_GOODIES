#ifndef _JETBRAINSMONO_REGULAR67PT7B_H_
#define _JETBRAINSMONO_REGULAR67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular67pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFE, 0x3F,
  0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFF, 0x3F, 0x80, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0,
  0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC, 0x03, 0xFF,
  0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F, 0x7C, 0x03, 0xF7, 0xC0, 0x3F,
  0x7C, 0x03, 0xF7, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0xE0, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x1F, 0x00,
  0x00, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0x81, 0xFE, 0x79, 0xFF, 0x0F, 0xF1, 0xE1, 0xFC, 0x3F, 0x87,
  0x83, 0xF8, 0xFC, 0x1E, 0x07, 0xE7, 0xF0, 0x78, 0x1F, 0x9F, 0x81, 0xE0,
  0x3F, 0x7E, 0x07, 0x80, 0xFD, 0xF8, 0x1E, 0x00, 0x07, 0xE0, 0x78, 0x00,
  0x1F, 0xC1, 0xE0, 0x00, 0x7F, 0x07, 0x80, 0x00, 0xFC, 0x1E, 0x00, 0x03,
  0xF8, 0x78, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0x1F, 0xF7, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1E, 0x7F, 0xC0, 0x00, 0x78, 0x7F,
  0x80, 0x01, 0xE0, 0xFE, 0x00, 0x07, 0x81, 0xFC, 0x00, 0x1E, 0x07, 0xF0,
  0x00, 0x78, 0x0F, 0xC0, 0x01, 0xE0, 0x3F, 0x00, 0x07, 0x80, 0xFF, 0xF0,
  0x1E, 0x03, 0xFF, 0xC0, 0x78, 0x0F, 0xFF, 0x01, 0xE0, 0x3F, 0xFC, 0x07,
  0x80, 0xFF, 0xF8, 0x1E, 0x07, 0xF7, 0xF0, 0x78, 0x1F, 0x9F, 0xE1, 0xE0,
  0xFE, 0x3F, 0xE7, 0x8F, 0xF0, 0x7F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7C, 0x7F, 0xF8, 0x00, 0x03, 0xE3, 0xFF, 0xF0, 0x00, 0x0F,
  0x9F, 0xFF, 0xE0, 0x00, 0x7C, 0x7F, 0x1F, 0xC0, 0x03, 0xE1, 0xF0, 0x1F,
  0x00, 0x0F, 0x8F, 0x80, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0xF8, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0x0F, 0x83, 0xE0, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x01, 0xFC, 0xFF, 0x1F, 0x00, 0x03,
  0xFF, 0xF8, 0x7C, 0x00, 0x0F, 0xFF, 0xC3, 0xE0, 0x00, 0x1F, 0xFE, 0x1F,
  0x00, 0x00, 0x1F, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0xE0, 0x00,
  0x03, 0xE1, 0xFF, 0xE0, 0x00, 0x1F, 0x0F, 0xFF, 0xC0, 0x00, 0x7C, 0x7F,
  0xFF, 0x80, 0x03, 0xE3, 0xFD, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0xFC, 0x00,
  0xF8, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0x3F, 0x1F, 0x00, 0x0F, 0xE3, 0xF8, 0xF8, 0x00, 0x1F, 0xFF,
  0xE3, 0xE0, 0x00, 0x3F, 0xFF, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x01, 0xFF, 0xF8, 0x7F,
  0x00, 0xFE, 0xFC, 0x0F, 0xC0, 0x3F, 0x3F, 0x03, 0xF8, 0x1F, 0xCF, 0xC0,
  0x7F, 0x07, 0xE3, 0xF0, 0x0F, 0xE3, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x3F,
  0x00, 0x7F, 0x7E, 0x0F, 0xC0, 0x0F, 0xFF, 0x83, 0xF0, 0x01, 0xFF, 0xC0,
  0xFC, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x0F,
  0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0x01,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x3F, 0x83, 0xFF, 0xFF, 0x87, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0x81, 0xFF, 0xE0, 0x07, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFB, 0xF7, 0xEF, 0xDF, 0xBF, 0x7E, 0xF9, 0xF3, 0xE0, 0x00, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x3F, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0xFF,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x0C,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x38,
  0x00, 0xF8, 0x01, 0xC3, 0xF0, 0x0F, 0x00, 0xFE, 0x7F, 0xC0, 0xF0, 0x3F,
  0xE7, 0xFF, 0x0F, 0x0F, 0xFE, 0xFF, 0xFC, 0xF3, 0xFF, 0xF7, 0xFF, 0xE7,
  0x7F, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00,
  0x20, 0x00, 0x20, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x83, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0xFC,
  0x03, 0xF0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x0F, 0xF3, 0xFF, 0x7F, 0xEF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF, 0xF0, 0x30, 0x00, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x0C, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x07, 0xF8,
  0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F,
  0xFF, 0x03, 0xF8, 0x3F, 0xFC, 0x0F, 0xC0, 0xFF, 0xF0, 0x04, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x3F, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F,
  0x8F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFE, 0x7E, 0x00, 0x1F, 0xF1, 0xF8,
  0x00, 0xFF, 0x87, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x00, 0x1F, 0x80, 0x08,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x3F, 0x9F, 0xE0, 0x03, 0xFC, 0x7F, 0x80, 0x3F, 0xC1, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F,
  0x1F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0xFF, 0xC0,
  0x1F, 0x9F, 0xFF, 0x80, 0xFD, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xC1, 0xFF, 0x8F, 0xF8, 0x03, 0xFC, 0x7F, 0x00,
  0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x03, 0xF8, 0xFF, 0x80, 0x7F, 0xC3, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x3F, 0xE0, 0x01, 0xFD, 0xFF, 0xF0, 0x03, 0xF7, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xE0, 0x1F, 0xF0, 0xFF, 0x00,
  0x0F, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0xFF, 0x81,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x0F,
  0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xE0, 0x01, 0xFF, 0x3F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFE, 0x3F, 0xE0, 0x0F, 0xF0, 0x7F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x07, 0xFC,
  0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF3,
  0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0xBF, 0x80,
  0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0,
  0x1F, 0xF0, 0xFF, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0x7F, 0x00, 0x7F, 0xFD, 0xFC, 0x00, 0x3F, 0xF3, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x04,
  0x07, 0xF3, 0xFF, 0x7F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xCF,
  0xF0, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x1F, 0xF7, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFC, 0xFF, 0x03, 0x00, 0x00, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xFF, 0xC7, 0xFF, 0x87, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0x00, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x40, 0xFF, 0xE0, 0x01, 0xFF, 0x1F, 0xFC, 0x00, 0x7F,
  0xFB, 0xFF, 0x80, 0x1F, 0xFF, 0x3F, 0xF0, 0x07, 0xFF, 0xF7, 0xFE, 0x00,
  0xFE, 0x07, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0xF8, 0x07, 0xE0, 0x07, 0xFF,
  0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xFC, 0x03, 0xE0, 0x03,
  0xFF, 0x80, 0x7C, 0x00, 0x7F, 0xF0, 0x0F, 0x80, 0x0F, 0xFE, 0x01, 0xF0,
  0x01, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xF8, 0x07, 0xC0, 0x07, 0xFF, 0x00,
  0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0x00, 0x1F, 0xFC, 0x03, 0xE0, 0x03, 0xFF,
  0x80, 0x7C, 0x00, 0x7F, 0xF0, 0x0F, 0xC0, 0x0F, 0xFE, 0x01, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xF8, 0x03, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xEF, 0xFC, 0x00, 0xFF, 0xF9, 0xFF, 0x80,
  0x0F, 0xFF, 0x3F, 0xF8, 0x00, 0x7F, 0x87, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x3E, 0x1F,
  0x00, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x01,
  0xFE, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFC,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFE, 0x3F, 0x00,
  0x07, 0xF0, 0xFC, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE,
  0x0F, 0xC0, 0x07, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F,
  0xCF, 0xC0, 0x01, 0xFF, 0x3F, 0x00, 0x3F, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x03, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x05, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xC0, 0x7F, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFE, 0xFC,
  0x00, 0x3F, 0xCF, 0xC0, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0x80, 0xFF, 0x8F, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0xC0,
  0x01, 0xFC, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x03, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x05, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x8F, 0xF8, 0x07, 0xFC,
  0x1F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC,
  0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x07, 0xF0, 0xFC,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF7, 0x80,
  0x07, 0xFF, 0xDF, 0x00, 0x1F, 0xFF, 0x7C, 0x00, 0xFB, 0xFF, 0xF0, 0x03,
  0xEF, 0xFB, 0xE0, 0x0F, 0xBF, 0xEF, 0x80, 0x7C, 0xFF, 0xBE, 0x01, 0xF3,
  0xFE, 0x7C, 0x07, 0xDF, 0xF9, 0xF0, 0x3E, 0x7F, 0xE7, 0xC0, 0xF9, 0xFF,
  0x8F, 0x83, 0xE7, 0xFE, 0x3E, 0x1F, 0x1F, 0xF8, 0xF8, 0x7C, 0x7F, 0xE1,
  0xF1, 0xF1, 0xFF, 0x87, 0xC7, 0x87, 0xFF, 0x1F, 0x3E, 0x1F, 0xFC, 0x3E,
  0xF8, 0x7F, 0xF0, 0xFB, 0xC1, 0xFF, 0xC3, 0xEF, 0x0F, 0xFF, 0x07, 0xFC,
  0x3F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC0, 0xFE, 0x0F,
  0xFF, 0x03, 0xF0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF,
  0xFE, 0x00, 0x3F, 0xFB, 0xE0, 0x03, 0xFF, 0xBE, 0x00, 0x3F, 0xFB, 0xF0,
  0x03, 0xFF, 0xDF, 0x00, 0x3F, 0xFD, 0xF8, 0x03, 0xFF, 0xCF, 0x80, 0x3F,
  0xFC, 0xF8, 0x03, 0xFF, 0xCF, 0xC0, 0x3F, 0xFC, 0x7C, 0x03, 0xFF, 0xC7,
  0xC0, 0x3F, 0xFC, 0x7E, 0x03, 0xFF, 0xC3, 0xE0, 0x3F, 0xFC, 0x3E, 0x03,
  0xFF, 0xC3, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0xFF, 0xC1, 0xF0, 0x3F, 0xFC,
  0x1F, 0x83, 0xFF, 0xC0, 0xF8, 0x3F, 0xFC, 0x0F, 0x83, 0xFF, 0xC0, 0xFC,
  0x3F, 0xFC, 0x07, 0xC3, 0xFF, 0xC0, 0x7E, 0x3F, 0xFC, 0x03, 0xE3, 0xFF,
  0xC0, 0x3E, 0x3F, 0xFC, 0x03, 0xF3, 0xFF, 0xC0, 0x1F, 0x3F, 0xFC, 0x01,
  0xF1, 0xFF, 0xC0, 0x1F, 0x9F, 0xFC, 0x00, 0xF9, 0xFF, 0xC0, 0x0F, 0x9F,
  0xFC, 0x00, 0xFD, 0xFF, 0xC0, 0x07, 0xDF, 0xFC, 0x00, 0x7D, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC7, 0xF8, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7F, 0x00, 0x07, 0xE7, 0xF8, 0x00,
  0xFE, 0x3F, 0xC0, 0x3F, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFE, 0x3F, 0x00, 0x03, 0xFE, 0x7E, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF,
  0x80, 0x00, 0x7F, 0x3F, 0x00, 0x03, 0xFE, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFE,
  0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF9, 0xFC, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7F, 0x7E, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC, 0x1F, 0xE0, 0x1F,
  0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x07, 0xFC, 0x7E, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xBF,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x7F, 0x9F, 0x80, 0x01, 0xFE, 0x3F, 0x00, 0x0F, 0xF8, 0x7F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFE,
  0x01, 0xF8, 0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8,
  0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F,
  0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x03,
  0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0xFE,
  0x3F, 0xE0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x0F, 0xE3, 0xFC, 0x03, 0xFC,
  0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x01, 0xFB, 0xE0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xBF,
  0x00, 0x7F, 0x00, 0x7D, 0xF8, 0x03, 0xF8, 0x03, 0xEF, 0xC0, 0x1F, 0xC0,
  0x1F, 0x7E, 0x01, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xF0, 0x0F, 0xCF, 0x80,
  0x7B, 0x80, 0x7E, 0x7C, 0x03, 0xDC, 0x03, 0xF3, 0xE0, 0x1E, 0xE0, 0x1F,
  0x1F, 0x80, 0xF7, 0x80, 0xF8, 0xFC, 0x07, 0x3C, 0x07, 0xC7, 0xE0, 0x39,
  0xE0, 0x3E, 0x3F, 0x03, 0xCF, 0x01, 0xF1, 0xF8, 0x1E, 0x78, 0x1F, 0x8F,
  0xC0, 0xF3, 0xC0, 0xFC, 0x3E, 0x07, 0x8E, 0x07, 0xE1, 0xF0, 0x3C, 0x70,
  0x3E, 0x0F, 0x81, 0xE3, 0x81, 0xF0, 0x7C, 0x0E, 0x1E, 0x0F, 0x83, 0xF0,
  0x70, 0xF0, 0x7C, 0x1F, 0x87, 0x87, 0x83, 0xE0, 0xFC, 0x3C, 0x3C, 0x1F,
  0x07, 0xE1, 0xE1, 0xE0, 0xF8, 0x3F, 0x0F, 0x0F, 0x0F, 0xC0, 0xF8, 0x78,
  0x38, 0x7E, 0x07, 0xC3, 0xC1, 0xC3, 0xE0, 0x3E, 0x1E, 0x0F, 0x1F, 0x01,
  0xF0, 0xE0, 0x78, 0xF8, 0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0x7E, 0x78, 0x1E,
  0x3E, 0x03, 0xF3, 0xC0, 0xF1, 0xF0, 0x1F, 0x9E, 0x07, 0x8F, 0x80, 0x7C,
  0xF0, 0x3C, 0xFC, 0x03, 0xE7, 0x80, 0xE7, 0xC0, 0x1F, 0x3C, 0x07, 0x3E,
  0x00, 0xF9, 0xC0, 0x3D, 0xF0, 0x07, 0xDE, 0x01, 0xEF, 0x80, 0x3E, 0xF0,
  0x0F, 0x7C, 0x01, 0xF7, 0x80, 0x7B, 0xE0, 0x0F, 0xBC, 0x03, 0xDF, 0x00,
  0x7F, 0xE0, 0x1E, 0xF8, 0x01, 0xFF, 0x00, 0xF7, 0xC0, 0x0F, 0xF8, 0x03,
  0xBC, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00,
  0x7F, 0x3F, 0x80, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x01,
  0xF9, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x3F,
  0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x80, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80,
  0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0xFF, 0x7F, 0x80, 0x0F, 0xFC, 0xFF, 0x80, 0xFF, 0xF1,
  0xFF, 0xFF, 0xEF, 0xC7, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xF8, 0xFC, 0x07,
  0xFF, 0x83, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x01, 0x00, 0x0F, 0xC1, 0xFF, 0x80, 0x7E, 0x1F, 0xFF, 0x03, 0xF3, 0xFF,
  0xFC, 0x1F, 0x9F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xC7, 0xEF, 0x01, 0xFF,
  0x3F, 0xE0, 0x03, 0xF9, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0x7F,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xF7,
  0xF8, 0x00, 0x3F, 0xBF, 0xE0, 0x03, 0xF9, 0xFB, 0x80, 0x7F, 0xCF, 0xDF,
  0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0xE3, 0xF3, 0xFF, 0xFE, 0x1F, 0x8F, 0xFF,
  0xE0, 0xFC, 0x1F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0x8F, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00,
  0x1F, 0xCF, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x1F, 0xE1, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x5E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x01, 0x80,
  0x3F, 0x01, 0xFF, 0x83, 0xF0, 0x7F, 0xFE, 0x3F, 0x0F, 0xFF, 0xF3, 0xF1,
  0xFF, 0xFF, 0xBF, 0x3F, 0xFF, 0xFB, 0xF7, 0xFC, 0x03, 0xFF, 0x7F, 0x00,
  0x1F, 0xF7, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0x7F, 0x00,
  0x1F, 0xF7, 0xFC, 0x03, 0xFF, 0x3F, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xBF,
  0x0F, 0xFF, 0xF3, 0xF0, 0x7F, 0xFE, 0x3F, 0x03, 0xFF, 0x83, 0xF0, 0x03,
  0xC0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xF0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F, 0x80,
  0x1F, 0xE1, 0xFF, 0xCF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x07,
  0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x3F, 0x1F, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF,
  0xBF, 0x3F, 0xC0, 0x3F, 0xF7, 0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFF, 0x7F, 0x00, 0x1F, 0xF7, 0xFC, 0x03,
  0xFF, 0x3F, 0xFF, 0xFB, 0xF1, 0xFF, 0xFF, 0xBF, 0x0F, 0xFF, 0xF3, 0xF0,
  0x7F, 0xFE, 0x3F, 0x03, 0xFF, 0xC3, 0xF0, 0x03, 0xC0, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x18, 0x00, 0xFC, 0x1F, 0xF8, 0x0F, 0xC7, 0xFF, 0xE0,
  0xFC, 0xFF, 0xFF, 0x0F, 0xDF, 0xFF, 0xF8, 0xFD, 0xFF, 0xFF, 0xCF, 0xDC,
  0x03, 0xFE, 0xFF, 0x80, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xFC, 0xFC,
  0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0,
  0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x7F, 0x7E,
  0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0xFE, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0x80, 0xFC, 0x7F,
  0x07, 0xF0, 0xFD, 0xFF, 0x8F, 0xF8, 0xFD, 0xFF, 0x9F, 0xFC, 0xFF, 0xFF,
  0xDF, 0xFE, 0xFF, 0x0F, 0xF8, 0xFE, 0xFE, 0x07, 0xE0, 0x7E, 0xFC, 0x07,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03, 0xE0, 0x3F, 0xFC, 0x03,
  0xE0, 0x3F, 0x00, 0x01, 0x80, 0x0F, 0xC1, 0xFF, 0x80, 0xFC, 0x7F, 0xFE,
  0x0F, 0xCF, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0x8F, 0xDF, 0xFF, 0xFC, 0xFD,
  0xC0, 0x3F, 0xEF, 0xF8, 0x00, 0xFE, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x1F, 0xF0, 0x3F,
  0xE1, 0xFE, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x03, 0xF1, 0xFE, 0x00, 0x3F, 0x87, 0xF8, 0x07, 0xF8, 0x3F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x07, 0xE0, 0xFF, 0xE0, 0x3F, 0x0F, 0xFF, 0x81, 0xF9, 0xFF, 0xFF, 0x0F,
  0xCF, 0xFF, 0xF8, 0x7E, 0xFF, 0xFF, 0xE3, 0xF7, 0x80, 0xFF, 0x9F, 0xF0,
  0x01, 0xFC, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00,
  0xFD, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8,
  0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xFB, 0xFC, 0x00,
  0x1F, 0xDF, 0xF0, 0x01, 0xFC, 0xFD, 0xC0, 0x1F, 0xE7, 0xEF, 0xFF, 0xFE,
  0x3F, 0x7F, 0xFF, 0xF1, 0xF9, 0xFF, 0xFF, 0x0F, 0xC7, 0xFF, 0xE0, 0x7E,
  0x0F, 0xFE, 0x03, 0xF0, 0x0F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x1F, 0xF8, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF,
  0x3F, 0x1F, 0xFF, 0xFB, 0xF3, 0xFF, 0xFF, 0xBF, 0x3F, 0xC0, 0x3F, 0xF7,
  0xF8, 0x01, 0xFF, 0x7F, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x0F, 0xF7,
  0xF0, 0x01, 0xFF, 0x7F, 0xC0, 0x3F, 0xF3, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF,
  0xFB, 0xF0, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xE3, 0xF0, 0x3F, 0xF8, 0x3F,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0x80, 0x07, 0xE0, 0xFF,
  0xE0, 0x3F, 0x1F, 0xFF, 0x81, 0xF9, 0xFF, 0xFF, 0x0F, 0xCF, 0xFF, 0xFC,
  0x7E, 0xFF, 0xFF, 0xE3, 0xF7, 0x00, 0x7F, 0x9F, 0xF0, 0x01, 0xFE, 0xFF,
  0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xF1, 0xFC, 0x00,
  0x1F, 0xCF, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01,
  0xFD, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x01, 0xFE, 0x3F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x0B, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFE, 0x7F, 0x80, 0x1F, 0xE3, 0xFC, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x8F,
  0xC0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF7,
  0xC0, 0x1F, 0x80, 0x1F, 0x7C, 0x01, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x80,
  0x3E, 0x7C, 0x01, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0xC0, 0x3E, 0x7E, 0x03,
  0xFC, 0x03, 0xE3, 0xE0, 0x3F, 0xC0, 0x3E, 0x3E, 0x03, 0xDC, 0x03, 0xC3,
  0xE0, 0x39, 0xC0, 0x7C, 0x3E, 0x03, 0x9E, 0x07, 0xC3, 0xE0, 0x79, 0xE0,
  0x7C, 0x3E, 0x07, 0x9E, 0x07, 0xC3, 0xF0, 0x79, 0xE0, 0x7C, 0x1F, 0x07,
  0x8E, 0x07, 0x81, 0xF0, 0x70, 0xE0, 0xF8, 0x1F, 0x07, 0x0F, 0x0F, 0x81,
  0xF0, 0xF0, 0xF0, 0xF8, 0x1F, 0x0F, 0x0F, 0x0F, 0x81, 0xF0, 0xF0, 0xF0,
  0xF8, 0x0F, 0x8F, 0x0F, 0x0F, 0x00, 0xF8, 0xE0, 0x70, 0xF0, 0x0F, 0x8E,
  0x07, 0x1F, 0x00, 0xF8, 0xE0, 0x79, 0xF0, 0x0F, 0x9E, 0x07, 0x9F, 0x00,
  0xF9, 0xE0, 0x79, 0xF0, 0x07, 0x9E, 0x07, 0x9E, 0x00, 0x7D, 0xC0, 0x39,
  0xE0, 0x07, 0xDC, 0x03, 0x9E, 0x00, 0x7D, 0xC0, 0x3F, 0xE0, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x00, 0x7F, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xC0, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xE0, 0x00,
  0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xE0,
  0x0F, 0xC0, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E,
  0x03, 0xF0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x1F,
  0xFE, 0x00, 0x3F, 0x3F, 0xFF, 0x00, 0x3F, 0x7F, 0xFF, 0x80, 0x3F, 0x7F,
  0xFF, 0xC0, 0x3F, 0x7E, 0x0F, 0xE0, 0x3F, 0xFC, 0x07, 0xF0, 0x3F, 0xFC,
  0x03, 0xF8, 0x7E, 0xFC, 0x03, 0xFF, 0xFE, 0xFC, 0x01, 0xFF, 0xFE, 0xFC,
  0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0xF8, 0xFC, 0x00, 0x1F, 0xE0,
};

const GFXglyph JetBrainsMono_Regular67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 40, 0, -1 },
  { 1, 10, 49, 40, 15, -49 },
  { 63, 20, 20, 40, 10, -49 },
  { 113, 36, 49, 40, 2, -49 },
  { 334, 30, 67, 40, 5, -58 },
  { 586, 38, 49, 40, 1, -49 },
  { 819, 34, 51, 40, 4, -50 },
  { 1036, 7, 20, 40, 16, -49 },
  { 1054, 21, 64, 40, 12, -56 },
  { 1222, 20, 64, 40, 8, -56 },
  { 1382, 36, 35, 40, 2, -41 },
  { 1540, 32, 32, 40, 4, -38 },
  { 1668, 14, 21, 40, 11, -10 },
  { 1705, 22, 6, 40, 9, -25 },
  { 1722, 11, 11, 40, 15, -10 },
  { 1738, 30, 63, 40, 5, -56 },
  { 1975, 30, 51, 40, 5, -50 },
  { 2167, 30, 49, 40, 6, -49 },
  { 2351, 30, 50, 40, 5, -50 },
  { 2539, 29, 50, 40, 5, -49 },
  { 2721, 29, 49, 40, 5, -49 },
  { 2899, 29, 50, 40, 6, -49 },
  { 3081, 31, 50, 40, 5, -49 },
  { 3275, 31, 49, 40, 5, -49 },
  { 3465, 30, 51, 40, 5, -50 },
  { 3657, 31, 50, 40, 5, -50 },
  { 3851, 11, 39, 40, 15, -38 },
  { 3905, 15, 49, 40, 11, -38 },
  { 3997, 29, 36, 40, 6, -40 },
  { 4128, 29, 22, 40, 6, -33 },
  { 4208, 29, 36, 40, 6, -40 },
  { 4339, 24, 49, 40, 9, -49 },
  { 4486, 35, 62, 40, 3, -50 },
  { 4758, 34, 49, 40, 3, -49 },
  { 4967, 30, 49, 40, 6, -49 },
  { 5151, 29, 51, 40, 6, -50 },
  { 5336, 28, 49, 40, 6, -49 },
  { 5508, 28, 49, 40, 7, -49 },
  { 5680, 29, 49, 40, 6, -49 },
  { 5858, 29, 51, 40, 6, -50 },
  { 6043, 28, 49, 40, 6, -49 },
  { 6215, 26, 49, 40, 7, -49 },
  { 6375, 30, 50, 40, 3, -49 },
  { 6563, 32, 49, 40, 6, -49 },
  { 6759, 28, 49, 40, 8, -49 },
  { 6931, 30, 49, 40, 5, -49 },
  { 7115, 28, 49, 40, 6, -49 },
  { 7287, 28, 51, 40, 6, -50 },
  { 7466, 31, 49, 40, 6, -49 },
  { 7656, 30, 62, 40, 5, -50 },
  { 7889, 31, 49, 40, 6, -49 },
  { 8079, 30, 51, 40, 5, -50 },
  { 8271, 33, 49, 40, 4, -49 },
  { 8474, 28, 50, 40, 6, -49 },
  { 8649, 34, 49, 40, 3, -49 },
  { 8858, 37, 49, 40, 2, -49 },
  { 9085, 35, 49, 40, 3, -49 },
  { 9300, 36, 49, 40, 2, -49 },
  { 9521, 29, 49, 40, 6, -49 },
  { 9699, 16, 63, 40, 14, -56 },
  { 9825, 30, 63, 40, 5, -56 },
  { 10062, 16, 63, 40, 10, -56 },
  { 10188, 30, 26, 40, 5, -49 },
  { 10286, 32, 5, 40, 4, 2 },
  { 10306, 14, 10, 40, 12, -53 },
  { 10324, 30, 39, 40, 4, -38 },
  { 10471, 29, 50, 40, 6, -49 },
  { 10653, 29, 39, 40, 6, -38 },
  { 10795, 28, 50, 40, 6, -49 },
  { 10970, 29, 39, 40, 6, -38 },
  { 11112, 32, 49, 40, 4, -49 },
  { 11308, 28, 50, 40, 6, -38 },
  { 11483, 28, 49, 40, 6, -49 },
  { 11655, 31, 52, 40, 6, -52 },
  { 11857, 25, 64, 40, 6, -52 },
  { 12057, 31, 49, 40, 6, -49 },
  { 12247, 35, 49, 40, 2, -49 },
  { 12462, 32, 38, 40, 4, -38 },
  { 12614, 28, 38, 40, 6, -38 },
  { 12747, 29, 38, 40, 6, -37 },
  { 12885, 29, 50, 40, 6, -38 },
  { 13067, 28, 50, 40, 6, -38 },
  { 13242, 29, 38, 40, 7, -38 },
  { 13380, 29, 38, 40, 6, -37 },
  { 13518, 31, 47, 40, 4, -47 },
  { 13701, 28, 38, 40, 6, -37 },
  { 13834, 33, 37, 40, 4, -37 },
  { 13987, 36, 37, 40, 2, -37 },
  { 14154, 34, 37, 40, 3, -37 },
  { 14312, 33, 49, 40, 4, -37 },
  { 14515, 28, 37, 40, 6, -37 },
  { 14645, 29, 63, 40, 6, -56 },
  { 14874, 6, 63, 40, 17, -56 },
  { 14922, 29, 63, 40, 6, -56 },
  { 15151, 32, 13, 40, 4, -30 },
};

const GFXfont JetBrainsMono_Regular67pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular67pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular67pt7bGlyphs,
  0x20, 0x7E, 88
};

#endif // _JETBRAINSMONO_REGULAR67PT7B_H_
