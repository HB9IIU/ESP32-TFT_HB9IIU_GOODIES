#ifndef _JETBRAINSMONO_REGULAR69PT7B_H_
#define _JETBRAINSMONO_REGULAR69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular69pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F,
  0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF1, 0xFC, 0x7F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0xF8,
  0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF3, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x9F, 0xC0, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x7F, 0xFE, 0x01, 0xFB, 0xF0, 0x0F, 0xDF, 0x80, 0x7E, 0xFC, 0x03, 0xF7,
  0xE0, 0x1F, 0xBF, 0x00, 0xFD, 0xF8, 0x07, 0xEF, 0xC0, 0x3F, 0x7E, 0x01,
  0xFB, 0xE0, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFC, 0x0F,
  0xF1, 0xE3, 0xFC, 0x3F, 0xC3, 0xC3, 0xFC, 0x7F, 0x07, 0x83, 0xF8, 0xFC,
  0x0F, 0x03, 0xF1, 0xF8, 0x1E, 0x07, 0xF7, 0xF0, 0x3C, 0x0F, 0xEF, 0xE0,
  0x78, 0x0F, 0xDF, 0xC0, 0xF0, 0x00, 0x3F, 0x81, 0xE0, 0x00, 0x7F, 0x03,
  0xC0, 0x00, 0x7E, 0x07, 0x80, 0x00, 0xFE, 0x0F, 0x00, 0x01, 0xFC, 0x1E,
  0x00, 0x01, 0xFC, 0x3C, 0x00, 0x03, 0xFE, 0x78, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xF7, 0xFE, 0x00, 0x01, 0xE3, 0xFE,
  0x00, 0x03, 0xC3, 0xFC, 0x00, 0x07, 0x83, 0xFC, 0x00, 0x0F, 0x03, 0xF8,
  0x00, 0x1E, 0x03, 0xF0, 0x00, 0x3C, 0x07, 0xE0, 0x00, 0x78, 0x0F, 0xC0,
  0x00, 0xF0, 0x1F, 0xFE, 0x01, 0xE0, 0x3F, 0xFC, 0x03, 0xC0, 0x7F, 0xFC,
  0x07, 0x80, 0xFF, 0xF8, 0x0F, 0x01, 0xFB, 0xF0, 0x1E, 0x07, 0xF7, 0xF0,
  0x3C, 0x1F, 0xC7, 0xF8, 0x78, 0x7F, 0x8F, 0xFC, 0xF3, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7C, 0x7F, 0xFC, 0x00, 0x01, 0xF1,
  0xFF, 0xFC, 0x00, 0x07, 0xC7, 0xFF, 0xFC, 0x00, 0x0F, 0x8F, 0xC1, 0xFC,
  0x00, 0x3E, 0x3F, 0x01, 0xF8, 0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x01, 0xF0,
  0xF8, 0x03, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x7C, 0x00, 0xFC, 0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x0F, 0xC3, 0xE0,
  0x01, 0xFC, 0x7F, 0x0F, 0x80, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0x03, 0xFF,
  0xF8, 0x7C, 0x00, 0x03, 0xFF, 0xE1, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x1F, 0xFC, 0x00,
  0x00, 0xF8, 0x7F, 0xFC, 0x00, 0x03, 0xE1, 0xFF, 0xFC, 0x00, 0x07, 0xC7,
  0xFF, 0xFC, 0x00, 0x1F, 0x0F, 0xC1, 0xFC, 0x00, 0x7C, 0x3F, 0x01, 0xF8,
  0x00, 0xF8, 0x7E, 0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x0F, 0x81,
  0xF0, 0x07, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x03,
  0xE1, 0xF0, 0x00, 0xF8, 0x0F, 0xC7, 0xC0, 0x01, 0xFE, 0xFF, 0x1F, 0x00,
  0x01, 0xFF, 0xFE, 0x3E, 0x00, 0x03, 0xFF, 0xF8, 0xF8, 0x00, 0x03, 0xFF,
  0xE3, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x07, 0xF8, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF0, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x3F, 0xBF, 0x8F, 0xE0, 0x07, 0xEF, 0xE0, 0xFE, 0x01,
  0xF9, 0xF8, 0x0F, 0xC0, 0x7F, 0x3F, 0x01, 0xFC, 0x0F, 0xC7, 0xE0, 0x1F,
  0xC3, 0xF8, 0xFC, 0x01, 0xFC, 0x7E, 0x1F, 0x80, 0x3F, 0x9F, 0xC3, 0xF0,
  0x03, 0xFB, 0xF0, 0x7E, 0x00, 0x3F, 0xFE, 0x0F, 0xC0, 0x03, 0xFF, 0x81,
  0xF8, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFE, 0x03, 0xF0, 0x00,
  0x7F, 0xE0, 0x7F, 0x00, 0x1F, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xC0, 0xFF,
  0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x9F, 0xC1, 0xFF, 0xFF, 0xE1, 0xFC,
  0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFF, 0xFC, 0x03, 0xF8, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0x7E, 0xFC, 0xF9, 0xF3, 0xE0,
  0x00, 0x00, 0x10, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x0E, 0x00, 0x3E, 0x00, 0x38, 0x7E, 0x01, 0xF0, 0x07, 0xE7, 0xFC,
  0x0F, 0x81, 0xFF, 0x3F, 0xF8, 0x3C, 0x3F, 0xF9, 0xFF, 0xF1, 0xC7, 0xFF,
  0xFF, 0xFF, 0xCE, 0x7F, 0xFE, 0x0F, 0xFF, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x00, 0x40, 0x00,
  0x40, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xC0, 0x7F, 0x81,
  0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x07, 0xF9, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xF8, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xC1, 0xFF, 0x83, 0xFC, 0x00, 0xFF, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x08, 0x03, 0xFF, 0xC0, 0xFC, 0x0F, 0xFF, 0x07, 0xF0, 0x3F, 0xFC, 0x1F,
  0xE0, 0xFF, 0xF0, 0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF0,
  0x3F, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0, 0x1E, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x00,
  0xFE, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0x00, 0x01, 0xFF, 0x7E, 0x00, 0x0F, 0xFC, 0xFC, 0x00, 0x3F, 0xE1,
  0xF8, 0x00, 0xFF, 0x83, 0xF0, 0x01, 0xFE, 0x07, 0xE0, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x0F, 0x00, 0x3F, 0x00, 0x18, 0x00, 0x7E,
  0x00, 0x20, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xDF, 0xFE, 0x0F, 0xF8, 0x03, 0xFE,
  0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x01, 0xFC,
  0x3F, 0xE0, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x3F,
  0x80, 0x0F, 0xE3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x03, 0xF9, 0xFC, 0x00,
  0x1F, 0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF1,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0xE0,
  0x07, 0xE3, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF, 0xE0, 0x7E, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0x87, 0xFE, 0x1F, 0xF0, 0x03, 0xFC, 0x7F,
  0x80, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x1F, 0xE0,
  0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xE0, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE3, 0xFE,
  0x00, 0x0F, 0xCF, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0xC0, 0x1F, 0xBF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0xF0, 0x3F, 0xF0, 0x0F, 0xF8, 0x7F, 0xC0, 0x07,
  0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x07,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF7, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0xC0, 0x1F, 0xE3, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x7F, 0xC0, 0x7F, 0x80, 0x7F, 0x83,
  0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xBF, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF9, 0xFF, 0x80, 0x7F, 0xC3,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFE, 0xFF, 0xF0, 0x3F, 0xE0,
  0x0F, 0xF8, 0x3F, 0xC0, 0x03, 0xFC, 0x7F, 0x80, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0xFE, 0x7F, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFE, 0x7F, 0x80,
  0x03, 0xFC, 0x3F, 0xE0, 0x07, 0xFC, 0x3F, 0xF8, 0x1F, 0xFC, 0x1F, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0xF7, 0xF0, 0x01, 0xFF,
  0xE7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x06, 0x07,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7, 0xF8,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0C, 0x0F, 0xF3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xCF, 0xF0, 0x78, 0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0, 0xFF,
  0xE1, 0xFF, 0xC3, 0xFF, 0xC7, 0xFF, 0x0F, 0xFE, 0x0F, 0xFC, 0x0F, 0xF0,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0xC0, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0xC0, 0x07, 0xFF, 0xBF, 0xFC,
  0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x1F, 0xFF, 0xDF, 0xFC, 0x01, 0xFC, 0x0F,
  0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x3E,
  0x00, 0x3F, 0xFC, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xFC,
  0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xFC, 0x03, 0xE0, 0x03,
  0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xFC, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x3E,
  0x00, 0x3F, 0xFC, 0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xFC,
  0x03, 0xE0, 0x03, 0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xFC, 0x03, 0xE0, 0x03,
  0xFF, 0xC0, 0x3E, 0x00, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xFF, 0xC0, 0x3F,
  0x80, 0xFF, 0xFC, 0x01, 0xFC, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xDF, 0xFC,
  0x00, 0xFF, 0xF9, 0xFF, 0xC0, 0x07, 0xFF, 0x1F, 0xFC, 0x00, 0x1F, 0xE1,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0xFD, 0xF8, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x1F, 0x9F, 0xC0,
  0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x1F,
  0x80, 0x0F, 0xFE, 0x3F, 0x00, 0x03, 0xFC, 0x7E, 0x00, 0x03, 0xFC, 0xFC,
  0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x03,
  0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x83, 0xF0, 0x07, 0xFF,
  0x87, 0xE0, 0x00, 0x7F, 0x8F, 0xC0, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x7F,
  0x3F, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0x7E,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xFB, 0xF0,
  0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x7F, 0xCF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x9F,
  0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x7F, 0xF3, 0xF8, 0x00, 0x7F, 0x9F, 0xC0,
  0x01, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x03, 0xFD, 0xFC, 0x00, 0x7F,
  0xCF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x07, 0xF0, 0xFF, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0xFE,
  0xFE, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x1F, 0xC3,
  0xFF, 0x00, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE,
  0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00,
  0x7F, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xBE, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFB, 0xFE, 0xF8, 0x01, 0xF7, 0xFD,
  0xF0, 0x03, 0xEF, 0xFB, 0xE0, 0x0F, 0x9F, 0xF3, 0xE0, 0x1F, 0x3F, 0xE7,
  0xC0, 0x3E, 0xFF, 0xCF, 0x80, 0xF9, 0xFF, 0x9F, 0x81, 0xF3, 0xFF, 0x1F,
  0x03, 0xE7, 0xFE, 0x3E, 0x0F, 0x8F, 0xFE, 0x7C, 0x1F, 0x1F, 0xFC, 0x7C,
  0x3E, 0x3F, 0xF8, 0xF8, 0x78, 0x7F, 0xF1, 0xF1, 0xF0, 0xFF, 0xE1, 0xF3,
  0xE1, 0xFF, 0xC3, 0xE7, 0x83, 0xFF, 0x87, 0xDF, 0x0F, 0xFF, 0x07, 0xFE,
  0x1F, 0xFE, 0x0F, 0xFC, 0x3F, 0xFC, 0x1F, 0xF0, 0x7F, 0xF8, 0x1F, 0xE0,
  0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0xE0, 0x7F, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFC, 0xFF, 0x80,
  0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0x80, 0x0F, 0xFF, 0x7C,
  0x00, 0x7F, 0xFB, 0xF0, 0x03, 0xFF, 0xCF, 0x80, 0x1F, 0xFE, 0x7C, 0x00,
  0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0x8F, 0x80, 0x3F, 0xFC, 0x7E, 0x01, 0xFF,
  0xE3, 0xF0, 0x0F, 0xFF, 0x0F, 0x80, 0x7F, 0xF8, 0x7E, 0x03, 0xFF, 0xC3,
  0xF0, 0x1F, 0xFE, 0x0F, 0x80, 0xFF, 0xF0, 0x7E, 0x07, 0xFF, 0x81, 0xF0,
  0x3F, 0xFC, 0x0F, 0x81, 0xFF, 0xE0, 0x7E, 0x0F, 0xFF, 0x01, 0xF0, 0x7F,
  0xF8, 0x0F, 0x83, 0xFF, 0xC0, 0x7E, 0x1F, 0xFE, 0x01, 0xF0, 0xFF, 0xF0,
  0x0F, 0xC7, 0xFF, 0x80, 0x7E, 0x3F, 0xFC, 0x01, 0xF1, 0xFF, 0xE0, 0x0F,
  0xCF, 0xFF, 0x00, 0x7E, 0x7F, 0xF8, 0x01, 0xF3, 0xFF, 0xC0, 0x0F, 0xDF,
  0xFE, 0x00, 0x7E, 0xFF, 0xF0, 0x01, 0xF3, 0xFF, 0x80, 0x0F, 0xDF, 0xFC,
  0x00, 0x3E, 0xFF, 0xE0, 0x01, 0xF7, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFE,
  0xFE, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0x1F, 0xF0, 0x1F, 0xF0, 0x7F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0xFE, 0x00, 0x03,
  0xFC, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xF7, 0xFF, 0x83, 0xFC, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x01, 0xFE, 0x7F, 0x80, 0x0F, 0xF0, 0xFF, 0x80, 0xFF, 0xC1, 0xFF, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00,
  0x3F, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x03, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xFC, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF8, 0xFE, 0x00,
  0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xEF, 0xFE, 0x07, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F,
  0xE7, 0xFC, 0x00, 0x3F, 0xC7, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x1F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xFE, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00,
  0x3F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03,
  0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E, 0x07, 0xC0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x1F, 0x87, 0xE0, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xF0, 0x03, 0xEF, 0xC0,
  0x1F, 0xC0, 0x0F, 0xBF, 0x00, 0x7F, 0x80, 0x3E, 0xFC, 0x01, 0xFE, 0x01,
  0xFB, 0xF0, 0x07, 0xF8, 0x07, 0xE7, 0xC0, 0x1F, 0xE0, 0x1F, 0x9F, 0x00,
  0x77, 0x80, 0x7E, 0x7E, 0x01, 0xDE, 0x01, 0xF9, 0xF8, 0x0F, 0x78, 0x07,
  0xE7, 0xE0, 0x3C, 0xE0, 0x1F, 0x1F, 0x80, 0xF3, 0x80, 0x7C, 0x7E, 0x03,
  0xCF, 0x01, 0xF1, 0xF8, 0x0F, 0x3C, 0x07, 0xC7, 0xE0, 0x3C, 0xF0, 0x3F,
  0x0F, 0x80, 0xF3, 0xC0, 0xFC, 0x3E, 0x03, 0x8F, 0x03, 0xF0, 0xF8, 0x1E,
  0x3C, 0x0F, 0xC3, 0xF0, 0x78, 0xF0, 0x3E, 0x0F, 0xC1, 0xE1, 0xC0, 0xF8,
  0x3F, 0x07, 0x87, 0x03, 0xE0, 0xFC, 0x1E, 0x1E, 0x0F, 0x83, 0xF0, 0x78,
  0x78, 0x3E, 0x0F, 0xC1, 0xE1, 0xE1, 0xF8, 0x1F, 0x07, 0x07, 0x87, 0xE0,
  0x7C, 0x3C, 0x1E, 0x1F, 0x81, 0xF0, 0xF0, 0x78, 0x7E, 0x07, 0xE3, 0xC1,
  0xE1, 0xF0, 0x1F, 0x8F, 0x03, 0x87, 0xC0, 0x7E, 0x3C, 0x0F, 0x1F, 0x01,
  0xF8, 0xF0, 0x3C, 0x7C, 0x07, 0xE3, 0xC0, 0xF1, 0xF0, 0x1F, 0x8E, 0x03,
  0xC7, 0xC0, 0x3E, 0x78, 0x0F, 0x3F, 0x00, 0xF9, 0xE0, 0x3C, 0xFC, 0x03,
  0xE7, 0x80, 0xF3, 0xE0, 0x0F, 0x9E, 0x03, 0xCF, 0x80, 0x3F, 0x78, 0x07,
  0x3E, 0x00, 0xFD, 0xE0, 0x1E, 0xF8, 0x03, 0xF7, 0x80, 0x7B, 0xE0, 0x0F,
  0xDC, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x07, 0xBE, 0x00, 0x7F, 0xC0, 0x1E,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00,
  0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0x80,
  0x3F, 0x80, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFE,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x01, 0xFC, 0x7F, 0x00,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0x80,
  0x00, 0x3F, 0x3E, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xF0, 0x00,
  0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x1F,
  0x80, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x01, 0xFF, 0x0F, 0xF0,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xCF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFF, 0x7F,
  0x00, 0x03, 0xFE, 0x7F, 0x80, 0x0F, 0xFC, 0xFF, 0xE0, 0xFD, 0xF8, 0xFF,
  0xFF, 0xFB, 0xF0, 0xFF, 0xFF, 0xE7, 0xE0, 0xFF, 0xFF, 0x8F, 0xC0, 0x7F,
  0xFC, 0x1F, 0x80, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x78, 0x00, 0xFE, 0x0F, 0xFE, 0x03, 0xF8, 0xFF, 0xFC, 0x0F, 0xE7,
  0xFF, 0xF8, 0x3F, 0x3F, 0xFF, 0xF0, 0xFD, 0xFF, 0xFF, 0xE3, 0xF7, 0x80,
  0x7F, 0xCF, 0xD8, 0x00, 0xFF, 0x3F, 0xC0, 0x01, 0xFE, 0xFF, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x7F, 0xBF,
  0xE0, 0x03, 0xFC, 0xFF, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0x8F, 0xEF,
  0xFF, 0xFC, 0x3F, 0x9F, 0xFF, 0xF0, 0xFE, 0x3F, 0xFF, 0x03, 0xF8, 0x7F,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xFF, 0x1F, 0xE0, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF,
  0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF0, 0xFF, 0x80,
  0x7F, 0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x7C, 0x03, 0xF0, 0x1F, 0xFC, 0x1F, 0x83,
  0xFF, 0xF8, 0xFC, 0x3F, 0xFF, 0xE7, 0xE3, 0xFF, 0xFF, 0x3F, 0x3F, 0xFF,
  0xFD, 0xF9, 0xFF, 0x01, 0xEF, 0xDF, 0xE0, 0x03, 0xFE, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xDF, 0xC0, 0x01, 0xFE,
  0xFF, 0x00, 0x1F, 0xF3, 0xFE, 0x03, 0xDF, 0x9F, 0xFF, 0xFE, 0xFC, 0x7F,
  0xFF, 0xE7, 0xE1, 0xFF, 0xFF, 0x3F, 0x07, 0xFF, 0xF1, 0xF8, 0x0F, 0xFE,
  0x0F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x83, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x3F,
  0xC1, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF, 0xFC,
  0x7E, 0x1F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0xDF, 0x9F, 0xFF, 0xFE, 0xFC,
  0xFF, 0x80, 0xF7, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x00, 0x07, 0xFB, 0xF0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7F, 0xBF,
  0xC0, 0x07, 0xFC, 0xFF, 0x80, 0xF7, 0xE7, 0xFF, 0xFF, 0xBF, 0x1F, 0xFF,
  0xFD, 0xF8, 0x7F, 0xFF, 0xCF, 0xC1, 0xFF, 0xFC, 0x7E, 0x03, 0xFF, 0x83,
  0xF0, 0x00, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x03, 0x80, 0x0F, 0xE1, 0xFF, 0xC0, 0x7F, 0x1F, 0xFF, 0x83, 0xF9, 0xFF,
  0xFE, 0x1F, 0xDF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x03, 0xFD, 0xFE, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x08,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFF, 0x7E, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x0F,
  0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x3F, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x0F, 0xF0, 0x03,
  0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xE0, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F, 0x87, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0xFF, 0x3F, 0x00,
  0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00,
  0x01, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0xC0, 0xF8, 0xFE, 0x0F, 0xF0, 0xF9, 0xFF, 0x1F, 0xF8, 0xFB,
  0xFF, 0x9F, 0xFC, 0xFB, 0xFF, 0xBF, 0xFE, 0xFE, 0x1F, 0xF0, 0xFE, 0xFC,
  0x0F, 0xE0, 0x7E, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8,
  0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0xF8, 0x07, 0xC0, 0x3F, 0x00,
  0x01, 0xC0, 0x07, 0xF0, 0xFF, 0xE0, 0x3F, 0x8F, 0xFF, 0xC1, 0xFC, 0xFF,
  0xFF, 0x0F, 0xEF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0x80, 0x7F,
  0xDF, 0xF0, 0x01, 0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF8, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xFE, 0x0F,
  0xE0, 0x03, 0xFC, 0x7F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F,
  0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0x7F, 0x80, 0x0F,
  0xF0, 0xFF, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xF8, 0x7F, 0xF8, 0x0F, 0xE3,
  0xFF, 0xF0, 0x3F, 0x9F, 0xFF, 0xE0, 0xFE, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x8F, 0xFE, 0x01, 0xFF, 0x3F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x07,
  0xFB, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x3F, 0xBF,
  0xC0, 0x01, 0xFE, 0xFD, 0x80, 0x07, 0xF3, 0xF7, 0x80, 0x7F, 0xCF, 0xDF,
  0xFF, 0xFE, 0x3F, 0x3F, 0xFF, 0xF0, 0xFE, 0x7F, 0xFF, 0xC3, 0xF8, 0xFF,
  0xFC, 0x0F, 0xE1, 0xFF, 0xE0, 0x3F, 0x80, 0xFC, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xFE, 0x0F, 0xC1, 0xFF,
  0xFC, 0x7E, 0x1F, 0xFF, 0xF3, 0xF1, 0xFF, 0xFF, 0x9F, 0x9F, 0xFF, 0xFE,
  0xFC, 0xFF, 0x80, 0xF7, 0xEF, 0xF0, 0x01, 0xFF, 0x7F, 0x00, 0x07, 0xFB,
  0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F,
  0xFF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x7F,
  0x80, 0x0F, 0xF9, 0xFF, 0x01, 0xEF, 0xCF, 0xFF, 0xFF, 0x7E, 0x3F, 0xFF,
  0xF3, 0xF0, 0xFF, 0xFF, 0x9F, 0x83, 0xFF, 0xF8, 0xFC, 0x07, 0xFF, 0x07,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0x80, 0x07,
  0xE1, 0xFF, 0xE0, 0x3F, 0x1F, 0xFF, 0x81, 0xF9, 0xFF, 0xFF, 0x0F, 0xDF,
  0xFF, 0xFC, 0x7E, 0xFF, 0xFF, 0xE3, 0xFF, 0x00, 0xFF, 0x9F, 0xF0, 0x01,
  0xFE, 0xFF, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC3, 0xFE, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x03, 0xF9, 0xFF, 0x00,
  0x3F, 0xE3, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xFE, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0xBF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE,
  0x3F, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7C,
  0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3,
  0xE0, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFB, 0xE0, 0x0F, 0xE0, 0x07, 0xDF, 0x00, 0x7F, 0x00, 0x7E, 0xF8, 0x03,
  0xF8, 0x03, 0xE7, 0xE0, 0x1F, 0xC0, 0x1F, 0x3F, 0x00, 0xFF, 0x00, 0xF9,
  0xF8, 0x07, 0x78, 0x07, 0xC7, 0xC0, 0x3B, 0xC0, 0x3E, 0x3E, 0x03, 0xDE,
  0x03, 0xF1, 0xF0, 0x1E, 0xF0, 0x1F, 0x0F, 0x80, 0xF3, 0x80, 0xF8, 0x7E,
  0x07, 0x9C, 0x07, 0xC3, 0xF0, 0x38, 0xF0, 0x3E, 0x0F, 0x81, 0xC7, 0x81,
  0xF0, 0x7C, 0x1E, 0x3C, 0x0F, 0x83, 0xE0, 0xF1, 0xE0, 0xF8, 0x1F, 0x07,
  0x8F, 0x07, 0xC0, 0xF8, 0x3C, 0x38, 0x3E, 0x07, 0xE1, 0xE1, 0xE1, 0xF0,
  0x1F, 0x0E, 0x0F, 0x0F, 0x80, 0xF8, 0x70, 0x78, 0x7C, 0x07, 0xC7, 0x83,
  0xC3, 0xC0, 0x3E, 0x3C, 0x1E, 0x3E, 0x01, 0xF1, 0xE0, 0x71, 0xF0, 0x0F,
  0x8F, 0x03, 0x8F, 0x80, 0x7E, 0x70, 0x1E, 0x7C, 0x01, 0xF3, 0x80, 0xF3,
  0xE0, 0x0F, 0xBC, 0x07, 0x9E, 0x00, 0x7D, 0xE0, 0x3C, 0xF0, 0x03, 0xEF,
  0x01, 0xEF, 0x80, 0x1F, 0x78, 0x07, 0x7C, 0x00, 0xFB, 0x80, 0x3F, 0xE0,
  0x03, 0xDC, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x03, 0xF8,
  0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07,
  0xF0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01,
  0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x01, 0xFD, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03,
  0xF8, 0x07, 0xF0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x87, 0xF0,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x87, 0xFF, 0x00, 0x0F, 0xC7,
  0xFF, 0xE0, 0x07, 0xE7, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xFC, 0x01, 0xFB,
  0xF0, 0x7F, 0x00, 0xFD, 0xF8, 0x1F, 0xC0, 0x7E, 0xF8, 0x07, 0xF0, 0x7F,
  0xFC, 0x01, 0xFE, 0xFF, 0x7E, 0x00, 0xFF, 0xFF, 0xBF, 0x00, 0x3F, 0xFF,
  0x9F, 0x80, 0x0F, 0xFF, 0x8F, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3E,
  0x00,
};

const GFXglyph JetBrainsMono_Regular69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 41, 0, -1 },
  { 1, 10, 50, 41, 16, -50 },
  { 64, 21, 20, 41, 10, -50 },
  { 117, 37, 50, 41, 2, -50 },
  { 349, 31, 70, 41, 5, -60 },
  { 621, 39, 51, 41, 1, -51 },
  { 870, 35, 52, 41, 4, -51 },
  { 1098, 7, 20, 41, 17, -50 },
  { 1116, 20, 66, 41, 13, -58 },
  { 1281, 21, 66, 41, 8, -58 },
  { 1455, 37, 36, 41, 2, -42 },
  { 1622, 33, 32, 41, 4, -39 },
  { 1754, 15, 21, 41, 11, -10 },
  { 1794, 22, 6, 41, 10, -26 },
  { 1811, 11, 12, 41, 15, -11 },
  { 1828, 31, 65, 41, 5, -57 },
  { 2080, 30, 52, 41, 6, -51 },
  { 2275, 31, 50, 41, 6, -50 },
  { 2469, 31, 51, 41, 5, -51 },
  { 2667, 30, 51, 41, 5, -50 },
  { 2859, 29, 50, 41, 6, -50 },
  { 3041, 30, 51, 41, 6, -50 },
  { 3233, 32, 51, 41, 5, -50 },
  { 3437, 31, 50, 41, 6, -50 },
  { 3631, 30, 52, 41, 6, -51 },
  { 3826, 32, 51, 41, 5, -51 },
  { 4030, 11, 40, 41, 15, -39 },
  { 4085, 15, 50, 41, 12, -39 },
  { 4179, 30, 37, 41, 6, -41 },
  { 4318, 30, 22, 41, 6, -34 },
  { 4401, 30, 37, 41, 6, -41 },
  { 4540, 25, 50, 41, 9, -50 },
  { 4697, 36, 63, 41, 3, -51 },
  { 4981, 35, 50, 41, 3, -50 },
  { 5200, 31, 50, 41, 6, -50 },
  { 5394, 30, 52, 41, 6, -51 },
  { 5589, 29, 50, 41, 6, -50 },
  { 5771, 29, 50, 41, 7, -50 },
  { 5953, 29, 50, 41, 7, -50 },
  { 6135, 30, 52, 41, 6, -51 },
  { 6330, 29, 50, 41, 6, -50 },
  { 6512, 27, 50, 41, 7, -50 },
  { 6681, 31, 51, 41, 3, -50 },
  { 6879, 33, 50, 41, 6, -50 },
  { 7086, 29, 50, 41, 8, -50 },
  { 7268, 31, 50, 41, 5, -50 },
  { 7462, 29, 50, 41, 6, -50 },
  { 7644, 29, 52, 41, 6, -51 },
  { 7833, 32, 50, 41, 6, -50 },
  { 8033, 30, 63, 41, 6, -51 },
  { 8270, 32, 50, 41, 6, -50 },
  { 8470, 31, 52, 41, 5, -51 },
  { 8672, 34, 50, 41, 4, -50 },
  { 8885, 29, 51, 41, 6, -50 },
  { 9070, 35, 50, 41, 3, -50 },
  { 9289, 38, 50, 41, 2, -50 },
  { 9527, 36, 50, 41, 3, -50 },
  { 9752, 37, 50, 41, 2, -50 },
  { 9984, 30, 50, 41, 6, -50 },
  { 10172, 17, 65, 41, 14, -57 },
  { 10311, 31, 65, 41, 5, -57 },
  { 10563, 17, 65, 41, 10, -57 },
  { 10702, 30, 27, 41, 6, -50 },
  { 10804, 33, 5, 41, 4, 2 },
  { 10825, 14, 10, 41, 13, -54 },
  { 10843, 31, 40, 41, 4, -39 },
  { 10998, 30, 51, 41, 6, -50 },
  { 11190, 30, 40, 41, 6, -39 },
  { 11340, 29, 51, 41, 6, -50 },
  { 11525, 30, 40, 41, 6, -39 },
  { 11675, 33, 50, 41, 4, -50 },
  { 11882, 29, 51, 41, 6, -39 },
  { 12067, 29, 50, 41, 6, -50 },
  { 12249, 32, 54, 41, 6, -54 },
  { 12465, 25, 66, 41, 6, -54 },
  { 12672, 31, 50, 41, 7, -50 },
  { 12866, 36, 50, 41, 2, -50 },
  { 13091, 32, 39, 41, 5, -39 },
  { 13247, 29, 39, 41, 6, -39 },
  { 13389, 30, 40, 41, 6, -39 },
  { 13539, 30, 51, 41, 6, -39 },
  { 13731, 29, 51, 41, 6, -39 },
  { 13916, 29, 39, 41, 8, -39 },
  { 14058, 30, 40, 41, 6, -39 },
  { 14208, 32, 49, 41, 4, -49 },
  { 14404, 29, 39, 41, 6, -38 },
  { 14546, 34, 38, 41, 4, -38 },
  { 14708, 37, 38, 41, 2, -38 },
  { 14884, 35, 38, 41, 3, -38 },
  { 15051, 34, 50, 41, 4, -38 },
  { 15264, 29, 38, 41, 6, -38 },
  { 15402, 30, 65, 41, 6, -57 },
  { 15646, 6, 65, 41, 18, -57 },
  { 15695, 30, 65, 41, 6, -57 },
  { 15939, 33, 14, 41, 4, -31 },
};

const GFXfont JetBrainsMono_Regular69pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular69pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular69pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _JETBRAINSMONO_REGULAR69PT7B_H_
