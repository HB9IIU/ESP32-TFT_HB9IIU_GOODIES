#ifndef _JETBRAINSMONO_REGULAR39PT7B_H_
#define _JETBRAINSMONO_REGULAR39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x00, 0x00, 0x00, 0xFB, 0xFF, 0xFE, 0xF0, 0xFF,
  0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xEF, 0x0E, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE,
  0x0E, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03,
  0x01, 0x80, 0x18, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x07, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xC1, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70,
  0x38, 0x03, 0x81, 0xC0, 0x18, 0x0C, 0x00, 0xC0, 0xE0, 0x0E, 0x07, 0x00,
  0x70, 0x38, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xC0, 0x60, 0x0E, 0x07,
  0x00, 0x70, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xC0, 0x60, 0x0E,
  0x07, 0x00, 0x70, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3E,
  0xDF, 0x1E, 0x33, 0xE7, 0x0C, 0x79, 0xC3, 0x0E, 0x70, 0xC3, 0x9C, 0x30,
  0x07, 0x8C, 0x01, 0xE3, 0x00, 0x7C, 0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00,
  0x3F, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x0C, 0xF8, 0x03, 0x1E, 0x00,
  0xC3, 0x80, 0x30, 0xF0, 0x0C, 0x3F, 0x83, 0x0F, 0xF0, 0xC3, 0xBC, 0x31,
  0xE7, 0xCC, 0xF9, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x05,
  0xFE, 0x00, 0xEF, 0xFC, 0x03, 0xB8, 0x70, 0x1C, 0xE1, 0xC0, 0xE3, 0x83,
  0x03, 0x0E, 0x0C, 0x1C, 0x38, 0x30, 0xE0, 0xE0, 0xC3, 0x03, 0x87, 0x1C,
  0x0F, 0x3C, 0xE0, 0x1F, 0xE7, 0x00, 0x3F, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0xE0, 0x07, 0x3F, 0xC0, 0x1C,
  0xFF, 0x80, 0xE7, 0x0F, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0xE1, 0xC1,
  0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0xE0, 0x70, 0x77, 0x01, 0xFF, 0x98,
  0x03, 0xFE, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x00, 0xFF, 0xC0, 0x1F, 0xFE,
  0x03, 0xE3, 0xE0, 0x3C, 0x0F, 0x03, 0x80, 0xF0, 0x38, 0x07, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xBC, 0x0F, 0xF1, 0xE1, 0xEF,
  0x0F, 0x1C, 0xF0, 0x73, 0xCF, 0x07, 0xB8, 0xF0, 0x3F, 0x8F, 0x01, 0xF0,
  0xF0, 0x1F, 0x0F, 0x01, 0xF0, 0xF0, 0x1F, 0x87, 0x83, 0xFC, 0x7F, 0xFB,
  0xC3, 0xFF, 0x1E, 0x1F, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x10, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0x81, 0xF0, 0x1E, 0x03, 0xC0, 0x38,
  0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1F,
  0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x00, 0xF0, 0x01, 0x80, 0x0F, 0x00, 0xFC,
  0x0F, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00,
  0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0xFE,
  0x0F, 0xC0, 0xF0, 0x08, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x01, 0xC1, 0xC0, 0xCF,
  0x8E, 0x3F, 0xFF, 0x37, 0xF9, 0xFF, 0x7F, 0x01, 0xFF, 0xC0, 0x00, 0xE0,
  0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x0F, 0x38, 0x00, 0xF1, 0xE0, 0x07,
  0x87, 0x80, 0x78, 0x3C, 0x07, 0x80, 0xF0, 0x0C, 0x03, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0x8F, 0x87, 0xC3, 0xC3, 0xE1, 0xE0, 0xF0, 0x78,
  0x78, 0x3C, 0x1C, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0xFD,
  0xFF, 0xF7, 0xEF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0x80, 0xF3, 0x80, 0x3F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x0C,
  0x3F, 0x8F, 0x1F, 0xCF, 0x8F, 0xE7, 0xC7, 0xF1, 0xC3, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0x78, 0x07, 0xBE, 0x07, 0x8F, 0xFF, 0x83, 0xFF, 0xC0, 0xFF, 0x80, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x0F, 0xBC, 0x0F, 0x9E, 0x07, 0x0F, 0x03,
  0x07, 0x81, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1, 0xF8, 0xFC, 0x78, 0x0F, 0x3C, 0x01,
  0xEF, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0xFD,
  0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E, 0x78, 0x1F, 0x3F, 0xFF,
  0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x79, 0xE0, 0x3D, 0xE0,
  0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCE,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x78, 0x1C, 0xFF, 0x0E, 0xFF, 0xC7, 0xF3, 0xF3, 0xE0, 0x79, 0xE0,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3F, 0xC0, 0x1E, 0xE0, 0x0F, 0x7C, 0x0F, 0x1F, 0xFF,
  0x07, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC7, 0x00, 0xFF, 0xF0, 0x7F, 0xFE, 0x1F, 0x8F,
  0xCF, 0x80, 0xFB, 0xC0, 0x1E, 0xF0, 0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x79, 0xE0, 0x1E, 0x7C,
  0x0F, 0x0F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x03,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0xC3, 0xE7, 0x80, 0xF3, 0xC0, 0x3D,
  0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0xBC, 0x03, 0x9E, 0x03, 0xC7, 0x83,
  0xC1, 0xF7, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x1F, 0xF8, 0x3E, 0x3E, 0x3C,
  0x07, 0x9E, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0x70, 0x07, 0xBE, 0x07, 0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0xFF,
  0x80, 0x03, 0xE0, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xF8, 0xFC, 0x78, 0x0F,
  0xBC, 0x01, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xBE, 0x01, 0xE7, 0xC0, 0xF9, 0xFF,
  0xFC, 0x3F, 0xFF, 0x03, 0xF7, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x00, 0x38, 0xFF, 0xFF, 0xF7, 0xE7,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF9, 0xFF,
  0xF7, 0xEF, 0x80, 0x1C, 0x3F, 0x7F, 0x7F, 0x3F, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x3E, 0x3E, 0x3C, 0x3C,
  0x7C, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x80, 0x01, 0xC0,
  0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xE0,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x00, 0xFF,
  0xC3, 0xFF, 0x8F, 0xFF, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x7F, 0xC1,
  0xFE, 0x07, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0x80,
  0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xE0, 0x7C, 0x3C, 0x01,
  0xE7, 0x80, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x3E, 0x7E, 0x07, 0xF7, 0xE0, 0xFF, 0xFE, 0x0E, 0x0F, 0xE1,
  0xE0, 0x7E, 0x1E, 0x07, 0xE1, 0xC0, 0x7E, 0x1C, 0x07, 0xE1, 0xC0, 0x7E,
  0x1C, 0x07, 0xE1, 0xC0, 0x7E, 0x1E, 0x07, 0xE1, 0xE0, 0xFE, 0x0E, 0x0F,
  0xE0, 0xFF, 0xFE, 0x07, 0xF7, 0xE0, 0x3E, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x78, 0x00, 0xE7, 0x00, 0x3C,
  0xE0, 0x07, 0x1C, 0x00, 0xE3, 0xC0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0xE0,
  0xE0, 0x1C, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x38, 0x1C, 0x07, 0x03, 0xFF,
  0xF0, 0xFF, 0xFE, 0x1F, 0xFF, 0xC3, 0x80, 0x3C, 0x70, 0x07, 0x9E, 0x00,
  0x73, 0xC0, 0x0E, 0x70, 0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00,
  0x70, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x03, 0xCE, 0x00, 0xF7,
  0x00, 0x7B, 0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F, 0x70, 0x07, 0xB8, 0x07,
  0x9C, 0x0F, 0x8F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xF9, 0xC0, 0x3C, 0xE0,
  0x0F, 0x70, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1D, 0xC0, 0x1E, 0xE0, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x1F, 0xFE,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xE7, 0xE7, 0x80, 0xF3,
  0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x1D,
  0xC0, 0x0E, 0xE0, 0x0F, 0x78, 0x07, 0xBE, 0x07, 0x8F, 0xFF, 0xC3, 0xFF,
  0xC0, 0x7F, 0x80, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0,
  0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87,
  0xE7, 0xE7, 0x80, 0xF3, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC3,
  0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x0F, 0x78, 0x07, 0xBE, 0x07,
  0x8F, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0x80, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF,
  0xC0, 0x7F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0x78,
  0x0F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xE0, 0x07, 0xB8, 0x01,
  0xCE, 0x00, 0xF3, 0x80, 0x38, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x03, 0xC3,
  0x81, 0xE0, 0xE0, 0x78, 0x38, 0x3C, 0x0E, 0x0F, 0x03, 0x87, 0x80, 0xFF,
  0xE0, 0x3F, 0xF8, 0x0F, 0xFE, 0x03, 0x83, 0xC0, 0xE0, 0xF0, 0x38, 0x1E,
  0x0E, 0x07, 0x83, 0x80, 0xF0, 0xE0, 0x3C, 0x38, 0x07, 0x8E, 0x01, 0xE3,
  0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x07, 0xFC, 0x07, 0xF7, 0x03, 0xFF, 0x81, 0xFF, 0xC1, 0xDF, 0x60, 0xEF,
  0xB8, 0x77, 0xDC, 0x73, 0xE6, 0x3B, 0xF3, 0x9D, 0xF9, 0xDC, 0xFC, 0x6E,
  0x7E, 0x3F, 0x3F, 0x1F, 0x1F, 0x87, 0x8F, 0xC3, 0xC7, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x70, 0xF8,
  0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xFC, 0x0F, 0xEE,
  0x0F, 0xEE, 0x0F, 0xEE, 0x0F, 0xE7, 0x0F, 0xE7, 0x0F, 0xE7, 0x0F, 0xE3,
  0x8F, 0xE3, 0x8F, 0xE3, 0xCF, 0xE1, 0xCF, 0xE1, 0xCF, 0xE1, 0xE7, 0xE0,
  0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x3F, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0x03, 0xF0, 0x07, 0xFE, 0x0F,
  0xFF, 0x87, 0xC7, 0xE7, 0x80, 0xF3, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x07,
  0x3E, 0x07, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF8, 0x7F,
  0xFF, 0x3F, 0xFF, 0xDC, 0x01, 0xEE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x01,
  0xF7, 0xFF, 0xFB, 0xFF, 0xF9, 0xFF, 0xF0, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0xFC, 0x78, 0x0F, 0x1C, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E,
  0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC,
  0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF, 0x00,
  0x3B, 0xC0, 0x1E, 0x78, 0x07, 0x9F, 0x03, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9C, 0x03, 0xEE, 0x00, 0xF7, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xDC, 0x01, 0xEE, 0x03, 0xE7, 0xFF, 0xF3,
  0xFF, 0xE1, 0xFF, 0xC0, 0xE0, 0xF0, 0x70, 0x78, 0x38, 0x1E, 0x1C, 0x0F,
  0x0E, 0x03, 0xC7, 0x01, 0xE3, 0x80, 0x79, 0xC0, 0x3C, 0xE0, 0x0F, 0x70,
  0x07, 0xB8, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xE0, 0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x0E,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0E,
  0xF0, 0x07, 0x9F, 0x03, 0xE7, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E, 0xF8, 0x1E, 0x7F,
  0xFC, 0x3F, 0xF8, 0x1F, 0xF0, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x07,
  0xBC, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x07, 0x8E, 0x00, 0xF1, 0xE0, 0x1C,
  0x3C, 0x03, 0x83, 0x80, 0xF0, 0x70, 0x1E, 0x0F, 0x03, 0x81, 0xE0, 0x70,
  0x1C, 0x1E, 0x03, 0x83, 0xC0, 0x78, 0x70, 0x0F, 0x0E, 0x00, 0xE3, 0xC0,
  0x1C, 0x78, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x07, 0x78, 0x00, 0xEF, 0x00,
  0x1D, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0xE0, 0x78, 0x3F, 0x83, 0xC1, 0xFC, 0x1E, 0x0F, 0xE1, 0xF0, 0x77, 0x0F,
  0x83, 0xB8, 0x6C, 0x1D, 0xC3, 0x61, 0xEE, 0x1B, 0x8F, 0x70, 0xDC, 0x73,
  0x86, 0x63, 0x9C, 0x33, 0x1C, 0xF3, 0x98, 0xE7, 0x9C, 0xC7, 0x1C, 0xC6,
  0x38, 0xE6, 0x31, 0xC7, 0x31, 0x8E, 0x39, 0x8E, 0xE1, 0xCC, 0x77, 0x0E,
  0x61, 0xB8, 0x77, 0x0D, 0xC3, 0xB8, 0x6E, 0x1F, 0x83, 0x70, 0x7C, 0x1B,
  0x83, 0xE0, 0xDC, 0x1F, 0x06, 0xE0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E,
  0x07, 0x80, 0xF8, 0x01, 0xE7, 0x80, 0x3C, 0x3C, 0x03, 0xC3, 0xC0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0xF1, 0xE0, 0x07, 0x9C,
  0x00, 0x7B, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7B, 0xC0, 0x07,
  0x9E, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1C, 0x07, 0x83,
  0xC0, 0x78, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x0F,
  0xF0, 0x00, 0x7B, 0xC0, 0x07, 0x8E, 0x00, 0x3C, 0x78, 0x01, 0xC1, 0xC0,
  0x1E, 0x0F, 0x00, 0xE0, 0x38, 0x0F, 0x01, 0xE0, 0x70, 0x07, 0x07, 0x80,
  0x3C, 0x38, 0x00, 0xE3, 0xC0, 0x07, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x38, 0x70,
  0x3C, 0x38, 0x1C, 0x1C, 0x0E, 0x07, 0x0E, 0x03, 0x87, 0x00, 0xE7, 0x00,
  0x73, 0x80, 0x1F, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x03, 0xE0, 0x07, 0xFE, 0x0F,
  0xFF, 0x87, 0xC3, 0xE7, 0x80, 0xF3, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xFC, 0x03, 0xFF,
  0xCF, 0xF7, 0xFF, 0x78, 0xFF, 0x3C, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xE0, 0xE7, 0xF8, 0xEF, 0xFC,
  0xFC, 0x7E, 0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0xEF, 0xFE, 0xEF, 0xFC,
  0xE7, 0xF8, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xC7, 0xE7, 0x80,
  0xFB, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x07,
  0x70, 0x07, 0xBC, 0x03, 0xDF, 0x03, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F,
  0xC0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x1F, 0x1E, 0x3F, 0xEF, 0x3F, 0xF7, 0xBF, 0x1F, 0xDE, 0x03,
  0xEE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F,
  0xC0, 0x1E, 0xF0, 0x1F, 0x7C, 0x1F, 0x9F, 0xFF, 0xCF, 0xFD, 0xE1, 0xFC,
  0xF0, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0xF3,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x3C, 0x03, 0xDF, 0x03, 0xC7, 0xFF, 0xE1, 0xFF, 0xE0, 0x3F, 0xC0,
  0x00, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xF0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x0F, 0xFB, 0xCF,
  0xFF, 0xEF, 0xC7, 0xF7, 0x80, 0xFB, 0xC0, 0x3D, 0xC0, 0x1F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x3D, 0xC0, 0x1E, 0xF0, 0x0F, 0x78, 0x0F, 0x9F, 0xBF, 0xCF, 0xFD, 0xE3,
  0xFC, 0xF0, 0x38, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x87, 0xFF, 0xC3, 0xFF, 0xC1, 0xFF, 0x80, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xE0, 0xE7,
  0xF8, 0xEF, 0xFC, 0xFC, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF9,
  0xFF, 0xF3, 0xFF, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xF3, 0xFF, 0xC7, 0xFF,
  0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x1E, 0xE0, 0x0F, 0x38,
  0x07, 0xCE, 0x01, 0xE3, 0x80, 0xF0, 0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x0F,
  0x03, 0xFF, 0x80, 0xFF, 0xE0, 0x3F, 0xF8, 0x0E, 0x1F, 0x03, 0x83, 0xC0,
  0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x03, 0xC3, 0x80, 0x78, 0xE0, 0x1E, 0x38,
  0x03, 0xCE, 0x00, 0x7B, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x07, 0x0E, 0x3B, 0xE7, 0xEF, 0xFF, 0xFB, 0x87,
  0x8F, 0xE1, 0xC3, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1,
  0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E,
  0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F, 0x87,
  0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x70, 0x03, 0xE0, 0xE7, 0xF8, 0xEF, 0xFC,
  0xFC, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0x03, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x87, 0xE7, 0xE7, 0x80,
  0xF3, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0x70, 0x07, 0xBC, 0x03, 0xDF, 0x07, 0xC7, 0xFF, 0xC1, 0xFF, 0xC0, 0x3F,
  0xC0, 0x01, 0xE0, 0xE7, 0xF8, 0xEF, 0xFC, 0xFC, 0x3E, 0xF0, 0x1E, 0xF0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF8, 0x1E, 0xEF, 0xFE, 0xEF, 0xFC, 0xE7, 0xF8, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07,
  0xC0, 0x0F, 0xFB, 0xCF, 0xFD, 0xEF, 0xC7, 0xF7, 0x80, 0xFB, 0xC0, 0x3D,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x70, 0x07, 0xBC,
  0x07, 0xDF, 0x07, 0xE7, 0xFF, 0xF1, 0xFF, 0x78, 0x7F, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x01, 0xF0, 0x7B, 0xFE, 0x3D, 0xFF, 0x9F, 0xC3, 0xEF, 0x80, 0xF7,
  0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xE0, 0x3F, 0xFC, 0x7F, 0xFE, 0x7C, 0x3E, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x3F, 0xF8, 0x1F, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x0F,
  0xF0, 0x0F, 0x7F, 0xFE, 0x7F, 0xFE, 0x1F, 0xF8, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x01, 0xFF, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1E, 0xF8, 0x3E, 0x7F,
  0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0xF0, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x07,
  0x3C, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x07, 0x0F, 0x01, 0xE0, 0xE0, 0x3C,
  0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x38, 0x3C, 0x07, 0x87, 0x00, 0xF0, 0xE0,
  0x0E, 0x3C, 0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x03, 0xBC, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF0, 0x78, 0x3B, 0x83, 0xC1,
  0xDC, 0x1E, 0x0E, 0xE1, 0xB0, 0xE7, 0x0D, 0x87, 0x38, 0x6C, 0x39, 0xC3,
  0x61, 0xC7, 0x1B, 0x8E, 0x38, 0xCC, 0x71, 0xCE, 0x63, 0x0E, 0x63, 0x38,
  0x73, 0x19, 0xC3, 0x98, 0xCE, 0x0C, 0xC7, 0x70, 0x76, 0x1B, 0x83, 0xB0,
  0xD8, 0x1F, 0x06, 0xC0, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x80,
  0xF0, 0x3C, 0x00, 0xF8, 0x03, 0xE7, 0x80, 0x78, 0xF0, 0x1E, 0x0F, 0x07,
  0x80, 0xF0, 0xF0, 0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0x78,
  0x03, 0xC7, 0x80, 0x78, 0x78, 0x1E, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F,
  0x3C, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F,
  0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38,
  0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x38, 0x03, 0xCF, 0x00, 0x79, 0xC0,
  0x07, 0x38, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0xFF, 0xE0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x7F, 0xF0, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x7F,
  0x80, 0x3F, 0xC0, 0x1F, 0x80, 0x00, 0x1C, 0x01, 0xDF, 0xC0, 0x7F, 0xF8,
  0x1F, 0xCF, 0x07, 0xE1, 0xE3, 0xF8, 0x3F, 0xEE, 0x07, 0xFB, 0x80, 0xFC,
};

const GFXglyph JetBrainsMono_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 28, 23, 9, -28 },
  { 22, 12, 11, 23, 6, -28 },
  { 39, 21, 28, 23, 1, -28 },
  { 113, 18, 39, 23, 3, -34 },
  { 201, 22, 29, 23, 1, -29 },
  { 281, 20, 29, 23, 2, -29 },
  { 354, 3, 11, 23, 10, -28 },
  { 359, 12, 38, 23, 7, -33 },
  { 416, 12, 38, 23, 4, -33 },
  { 473, 21, 20, 23, 1, -24 },
  { 526, 18, 18, 23, 3, -22 },
  { 567, 9, 12, 23, 6, -6 },
  { 581, 13, 3, 23, 5, -14 },
  { 586, 7, 6, 23, 8, -6 },
  { 592, 17, 36, 23, 3, -32 },
  { 669, 17, 29, 23, 3, -29 },
  { 731, 17, 28, 23, 4, -28 },
  { 791, 18, 29, 23, 3, -29 },
  { 857, 17, 28, 23, 3, -28 },
  { 917, 17, 28, 23, 3, -28 },
  { 977, 17, 28, 23, 3, -28 },
  { 1037, 18, 28, 23, 3, -28 },
  { 1100, 18, 28, 23, 3, -28 },
  { 1163, 17, 29, 23, 3, -29 },
  { 1225, 18, 29, 23, 3, -29 },
  { 1291, 7, 22, 23, 8, -22 },
  { 1311, 8, 28, 23, 7, -22 },
  { 1339, 17, 20, 23, 3, -23 },
  { 1382, 17, 12, 23, 3, -19 },
  { 1408, 17, 20, 23, 3, -23 },
  { 1451, 14, 28, 23, 5, -28 },
  { 1500, 20, 36, 23, 2, -29 },
  { 1590, 19, 28, 23, 2, -28 },
  { 1657, 17, 28, 23, 4, -28 },
  { 1717, 17, 29, 23, 3, -29 },
  { 1779, 16, 28, 23, 4, -28 },
  { 1835, 16, 28, 23, 4, -28 },
  { 1891, 16, 29, 23, 4, -29 },
  { 1949, 17, 29, 23, 3, -29 },
  { 2011, 16, 28, 23, 4, -28 },
  { 2067, 15, 28, 23, 4, -28 },
  { 2120, 17, 28, 23, 2, -28 },
  { 2180, 18, 28, 23, 4, -28 },
  { 2243, 17, 28, 23, 4, -28 },
  { 2303, 17, 28, 23, 3, -28 },
  { 2363, 16, 28, 23, 4, -28 },
  { 2419, 17, 29, 23, 3, -29 },
  { 2481, 17, 28, 23, 4, -28 },
  { 2541, 18, 36, 23, 3, -29 },
  { 2622, 17, 28, 23, 4, -28 },
  { 2682, 18, 29, 23, 3, -29 },
  { 2748, 19, 29, 23, 2, -29 },
  { 2817, 16, 28, 23, 4, -28 },
  { 2873, 19, 28, 23, 2, -28 },
  { 2940, 21, 28, 23, 1, -28 },
  { 3014, 20, 28, 23, 2, -28 },
  { 3084, 21, 28, 23, 1, -28 },
  { 3158, 17, 28, 23, 3, -28 },
  { 3218, 10, 36, 23, 8, -32 },
  { 3263, 17, 36, 23, 3, -32 },
  { 3340, 9, 36, 23, 6, -32 },
  { 3381, 17, 15, 23, 3, -28 },
  { 3413, 19, 3, 23, 2, 1 },
  { 3421, 8, 6, 23, 7, -31 },
  { 3427, 17, 22, 23, 3, -22 },
  { 3474, 16, 28, 23, 4, -28 },
  { 3530, 17, 22, 23, 3, -22 },
  { 3577, 17, 28, 23, 3, -28 },
  { 3637, 17, 22, 23, 3, -22 },
  { 3684, 19, 28, 23, 2, -28 },
  { 3751, 17, 29, 23, 3, -22 },
  { 3813, 16, 28, 23, 4, -28 },
  { 3869, 19, 30, 23, 3, -30 },
  { 3941, 15, 37, 23, 3, -30 },
  { 4011, 18, 28, 23, 4, -28 },
  { 4074, 20, 28, 23, 1, -28 },
  { 4144, 18, 22, 23, 3, -22 },
  { 4194, 16, 22, 23, 4, -22 },
  { 4238, 17, 22, 23, 3, -22 },
  { 4285, 16, 29, 23, 4, -22 },
  { 4343, 17, 29, 23, 3, -22 },
  { 4405, 17, 22, 23, 4, -22 },
  { 4452, 16, 22, 23, 4, -22 },
  { 4496, 18, 28, 23, 2, -28 },
  { 4559, 16, 21, 23, 4, -21 },
  { 4601, 19, 21, 23, 2, -21 },
  { 4651, 21, 21, 23, 1, -21 },
  { 4707, 19, 21, 23, 2, -21 },
  { 4757, 19, 28, 23, 2, -21 },
  { 4824, 16, 21, 23, 4, -21 },
  { 4866, 17, 36, 23, 3, -32 },
  { 4943, 3, 36, 23, 10, -32 },
  { 4957, 17, 36, 23, 3, -32 },
  { 5034, 18, 8, 23, 3, -18 },
};

const GFXfont JetBrainsMono_Regular39pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular39pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular39pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _JETBRAINSMONO_REGULAR39PT7B_H_
