#ifndef _JETBRAINSMONO_REGULAR52PT7B_H_
#define _JETBRAINSMONO_REGULAR52PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 52pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular52pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x38, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0xFE, 0xFE,
  0xFF, 0xFE, 0x7C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F,
  0x80, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x0F, 0x00, 0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xC0, 0x70, 0x07, 0x00,
  0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0xF0, 0x0F, 0x00, 0x1E,
  0x01, 0xE0, 0x03, 0x80, 0x38, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0,
  0x03, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x1C, 0x00, 0x78, 0x07, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE1, 0xF9, 0xC7, 0xE3, 0xE3, 0x87, 0xCF, 0x87, 0x07, 0xDF, 0x0E,
  0x0F, 0xBE, 0x1C, 0x1F, 0x78, 0x38, 0x3E, 0xF8, 0x70, 0x01, 0xF0, 0xE0,
  0x03, 0xE1, 0xC0, 0x07, 0xE3, 0x80, 0x07, 0xE7, 0x00, 0x0F, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0x1F, 0x80, 0x0E, 0x1F, 0x80,
  0x1C, 0x1F, 0x00, 0x38, 0x3E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x7F, 0x81,
  0xC0, 0xFF, 0x83, 0x81, 0xFF, 0x07, 0x07, 0xFE, 0x0E, 0x0F, 0xBE, 0x1C,
  0x3F, 0x7F, 0x38, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x79, 0xFF, 0x80, 0x03, 0x9F, 0xFE, 0x00, 0x3D, 0xF9,
  0xF8, 0x03, 0xCF, 0x03, 0xC0, 0x1C, 0x78, 0x1E, 0x01, 0xE3, 0xC0, 0xF0,
  0x1E, 0x1E, 0x07, 0x80, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0x81, 0xE0, 0xF0,
  0x3C, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x78, 0x0F, 0x03, 0xC7, 0x80, 0x7E,
  0x7E, 0x78, 0x01, 0xFF, 0xE3, 0xC0, 0x07, 0xFE, 0x3C, 0x00, 0x1F, 0xE3,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0xF1, 0xFF, 0x80,
  0x07, 0x1F, 0xFE, 0x00, 0x78, 0xF9, 0xF8, 0x07, 0x8F, 0x03, 0xC0, 0x38,
  0x78, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x3C, 0x1E, 0x03, 0x81, 0xC0, 0xF0,
  0x1C, 0x1E, 0x07, 0x80, 0xE1, 0xE0, 0x3C, 0x0F, 0x1E, 0x01, 0xE0, 0x78,
  0xF0, 0x0F, 0x03, 0xCF, 0x00, 0x3E, 0x7E, 0xF0, 0x01, 0xFF, 0xE7, 0x80,
  0x07, 0xFE, 0x78, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x1F, 0x01, 0xF0, 0x0F, 0x80,
  0x3E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x1F, 0xFC,
  0x7C, 0x07, 0xFE, 0x1F, 0x03, 0xEF, 0x83, 0xE0, 0xF3, 0xE0, 0x7C, 0x7C,
  0xF8, 0x1F, 0xBE, 0x3E, 0x03, 0xEF, 0x8F, 0x80, 0x7F, 0xC3, 0xE0, 0x0F,
  0xF0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xE0,
  0x0F, 0xF0, 0xF8, 0x07, 0xFC, 0x3F, 0x03, 0xFF, 0x87, 0xFF, 0xF9, 0xF0,
  0xFF, 0xFC, 0x7E, 0x1F, 0xFE, 0x0F, 0x83, 0xFE, 0x01, 0xF0, 0x0C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDE, 0x00,
  0x02, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x0C, 0x80, 0x00, 0xF0,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x1F, 0xC0, 0xFF, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x70, 0x0F, 0x01, 0xCF, 0xC1, 0xC1, 0xFF, 0xFE,
  0x38, 0xFF, 0xFF, 0xE7, 0x3F, 0xF7, 0xFF, 0x7F, 0xFC, 0x1F, 0xFF, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0x80, 0x04, 0x00, 0x60, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xE3, 0xF8, 0x7F, 0x0F, 0xC1, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFC, 0x7E, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1,
  0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x7C, 0x1F, 0xF0, 0xF8, 0x3F, 0xE3, 0xF8, 0x7F, 0xC3, 0xF0,
  0xFF, 0x87, 0xC1, 0xFF, 0x07, 0x83, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7E,
  0x00, 0x7C, 0x7E, 0x03, 0xF0, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x03, 0xFB, 0xE0, 0x0F, 0xE7,
  0xC0, 0x3F, 0x8F, 0x80, 0x7C, 0x1F, 0x00, 0xF0, 0x3E, 0x01, 0xC0, 0x7C,
  0x02, 0x00, 0xF8, 0x04, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xF0, 0x1F,
  0x8F, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xDE,
  0x00, 0x07, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0xFC,
  0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x7C, 0x7E, 0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1F,
  0x7E, 0x00, 0x7D, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xC7, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x1F, 0x3F, 0xF8, 0x3E, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0xFF, 0x07, 0xF1, 0xFC, 0x03, 0xF3, 0xF0, 0x03, 0xE7,
  0xC0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0x7E, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x0C, 0x00, 0x1F, 0x7F, 0xC0, 0x3E, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x7F, 0xC3, 0xFC, 0x7E, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0x7E, 0x00, 0x7C, 0x7F, 0x01,
  0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x18,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x87, 0xE0, 0x3F, 0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0xF8, 0x00, 0x79, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xC7,
  0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0xC7, 0xE0, 0x0F,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFC, 0x01, 0xFD,
  0xFC, 0x07, 0xE0, 0xFC, 0x1F, 0x80, 0x7C, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0xF9,
  0xFC, 0x07, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x3F, 0x01, 0xFC, 0x7E, 0x00, 0x7C, 0xFC,
  0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7E, 0x7E,
  0x00, 0xFC, 0x3F, 0x83, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFE, 0xF8, 0x07,
  0xFD, 0xF8, 0x00, 0x61, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xE3, 0xF0, 0x40, 0x0F, 0x83, 0xF8,
  0xFF, 0x9F, 0xF3, 0xFE, 0x3F, 0xC7, 0xF0, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xC3, 0xF0, 0xFE, 0x1F, 0x83, 0xF0, 0x7E, 0x1F, 0x83,
  0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0x00,
  0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0xFF, 0xF0, 0x3F,
  0xF8, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xF8, 0x3F, 0x81, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xF0, 0x07, 0xF3, 0xFE, 0x01, 0xFF, 0x7F, 0xC0, 0x7F, 0xFF,
  0xF8, 0x1F, 0x87, 0xFF, 0x03, 0xC0, 0x7F, 0xE0, 0x78, 0x07, 0xFC, 0x0F,
  0x00, 0xFF, 0x83, 0xE0, 0x1F, 0xF0, 0x7C, 0x03, 0xFE, 0x0F, 0x80, 0x7F,
  0xC1, 0xF0, 0x0F, 0xF8, 0x3E, 0x01, 0xFF, 0x07, 0xC0, 0x3F, 0xE0, 0xF8,
  0x07, 0xFC, 0x1F, 0x00, 0xFF, 0x81, 0xE0, 0x1F, 0xF0, 0x3C, 0x07, 0xFE,
  0x07, 0xC0, 0xFF, 0xC0, 0xFC, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF,
  0xBF, 0xE0, 0x0F, 0xE7, 0xBC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDF, 0x00, 0x01,
  0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x8F, 0x80,
  0x03, 0xE1, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x3E,
  0x03, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0xC0,
  0x7C, 0x01, 0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xF8, 0x3E, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x83, 0xC0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xCF,
  0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01,
  0xF0, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x8F, 0x00, 0xFF, 0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF,
  0x00, 0x07, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x7E, 0x78, 0x01, 0xF8, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0x00,
  0x7F, 0x1E, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x01, 0xF9,
  0xE0, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x7E, 0x03, 0xFB, 0xF0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xF9, 0xF8, 0x0F,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xF0, 0x1F, 0xF3, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0xBC, 0x00,
  0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x03, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x7E, 0xF0, 0x03, 0xF3, 0xC0, 0x3F,
  0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7E, 0x03, 0xFB, 0xF0, 0x03, 0xEF, 0x80,
  0x0F, 0xBE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3E, 0xFC, 0x00,
  0xF9, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFC, 0x00, 0x03, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x08, 0x00, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0xF8, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0,
  0x03, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0,
  0x0F, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3F, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF0,
  0x3E, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x80, 0xF0,
  0x0F, 0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xE0, 0xF0,
  0x03, 0xE0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF8, 0xF0,
  0x00, 0xF8, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0,
  0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0xFE, 0xF0, 0x0F, 0xFD, 0xE0, 0x3D, 0xFB, 0xC0, 0x7B, 0xFB, 0x80,
  0xF7, 0xF7, 0x81, 0xCF, 0xEF, 0x07, 0x9F, 0xCE, 0x0F, 0x7F, 0x9E, 0x1C,
  0xFF, 0x3C, 0x79, 0xFE, 0x38, 0xF3, 0xFC, 0x79, 0xC7, 0xF8, 0xF7, 0x8F,
  0xF0, 0xEF, 0x1F, 0xE1, 0xFC, 0x3F, 0xC3, 0xF8, 0x7F, 0x83, 0xF0, 0xFF,
  0x07, 0xC1, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xC0, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF,
  0xE0, 0x1F, 0xF7, 0x80, 0x7F, 0xDE, 0x01, 0xFF, 0x3C, 0x07, 0xFC, 0xF0,
  0x1F, 0xF3, 0xC0, 0x7F, 0xC7, 0x81, 0xFF, 0x1E, 0x07, 0xFC, 0x78, 0x1F,
  0xF0, 0xF0, 0x7F, 0xC3, 0xC1, 0xFF, 0x0F, 0x07, 0xFC, 0x1E, 0x1F, 0xF0,
  0x78, 0x7F, 0xC1, 0xF1, 0xFF, 0x03, 0xC7, 0xFC, 0x0F, 0x1F, 0xF0, 0x3E,
  0x7F, 0xC0, 0x79, 0xFF, 0x01, 0xE7, 0xFC, 0x03, 0xDF, 0xF0, 0x0F, 0x7F,
  0xC0, 0x3D, 0xFF, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC,
  0x7E, 0x03, 0xF3, 0xF0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF0,
  0x00, 0x7B, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC, 0x01, 0xF9, 0xF8, 0x0F, 0xC3, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xF0, 0x07, 0xFC, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0x7E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xF0, 0x1F, 0x8F, 0xC0, 0x1F,
  0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F,
  0xBE, 0x00, 0x3E, 0x7E, 0x00, 0xFC, 0x7E, 0x03, 0xF8, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0D, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00,
  0x7F, 0x9E, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x78, 0x00, 0x7E, 0xF0, 0x01, 0xF9,
  0xE0, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xC0, 0x3C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xE0,
  0x1F, 0x03, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0xFC, 0x78, 0x00, 0xF8, 0xF0, 0x01, 0xF9, 0xE0, 0x01,
  0xF3, 0xC0, 0x03, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xFE, 0x00, 0x07,
  0xC0, 0x00, 0x10, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x7F, 0xFF,
  0x81, 0xFF, 0xFF, 0x87, 0xE0, 0x3F, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0xFD, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xFC,
  0x01, 0xF9, 0xF8, 0x0F, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x1F,
  0x00, 0x03, 0xC7, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1E,
  0x0F, 0x80, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x1F, 0x00,
  0x3C, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x03, 0xE0,
  0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x07,
  0xC0, 0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8,
  0x0F, 0x80, 0x7F, 0xC0, 0x7C, 0x07, 0xDE, 0x03, 0xE0, 0x3E, 0xF0, 0x1F,
  0x81, 0xF7, 0x80, 0xFC, 0x0F, 0x3C, 0x06, 0xE0, 0x79, 0xE0, 0x77, 0x03,
  0xCF, 0x83, 0xB8, 0x1E, 0x7C, 0x1D, 0xC0, 0xF3, 0xE0, 0xEE, 0x07, 0x9F,
  0x07, 0x70, 0x3C, 0x78, 0x39, 0x83, 0xE3, 0xC1, 0xCE, 0x1E, 0x1E, 0x0E,
  0x70, 0xF0, 0xF0, 0xE3, 0x87, 0x87, 0x87, 0x1C, 0x3C, 0x3C, 0x38, 0xE1,
  0xE1, 0xF1, 0xC7, 0x0F, 0x0F, 0x8E, 0x38, 0x78, 0x3C, 0x71, 0xC3, 0xC1,
  0xE3, 0x86, 0x3E, 0x0F, 0x1C, 0x39, 0xE0, 0x79, 0xC1, 0xCF, 0x03, 0xCE,
  0x0E, 0x78, 0x1E, 0x70, 0x73, 0xC0, 0xF3, 0x83, 0x9E, 0x07, 0x9C, 0x1C,
  0xF0, 0x3E, 0xE0, 0xE7, 0x80, 0xF7, 0x07, 0x3C, 0x07, 0xB8, 0x1D, 0xC0,
  0x3F, 0x80, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7F,
  0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x7E, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00,
  0x7C, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xF0,
  0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7D, 0xF8, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x07, 0xC0,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x1E, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC1,
  0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF9, 0xE0, 0x00,
  0x1F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x1E,
  0x07, 0x80, 0x3C, 0x1F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0x79,
  0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0xFF, 0x3F, 0x83, 0xDF, 0x3F,
  0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x07, 0xFE, 0x1F, 0x00, 0x20, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC1, 0xFC, 0x0F, 0x1F, 0xFC, 0x3C, 0xFF, 0xF8, 0xF7, 0xFF, 0xF3, 0xDC,
  0x0F, 0xCF, 0x40, 0x1F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3E, 0xFC, 0x00, 0xFB, 0xD8, 0x0F, 0xEF, 0x7F, 0xFF, 0x3C,
  0xFF, 0xF8, 0xF3, 0xFF, 0xC3, 0xC3, 0xFE, 0x00, 0x00, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x78, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x03, 0xEF,
  0x80, 0x07, 0xDF, 0x00, 0x1F, 0x3F, 0x00, 0x3E, 0x3F, 0x01, 0xFC, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x0F, 0xE0, 0xF0, 0xFF, 0xE3, 0xC7, 0xFF, 0xCF, 0x3F,
  0xFF, 0xBC, 0xFE, 0x0E, 0xF7, 0xE0, 0x0F, 0xDF, 0x00, 0x1F, 0x7C, 0x00,
  0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0xFC, 0xFC, 0x06, 0xF3,
  0xFF, 0xFB, 0xC7, 0xFF, 0xEF, 0x0F, 0xFF, 0x3C, 0x1F, 0xF0, 0xF0, 0x06,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xF0, 0x1F, 0x87, 0xC0, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x1E, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x3F,
  0x00, 0xFC, 0x3F, 0xDF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x3F,
  0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xF8, 0x78, 0xFF, 0xE3, 0xCF, 0xFF, 0x9E,
  0xFF, 0xFE, 0xF7, 0xF0, 0x77, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0xFD, 0xF8, 0x1D, 0xEF, 0xFF, 0xEF, 0x3F, 0xFE, 0x78, 0xFF, 0xF3,
  0xC1, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC7, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC3, 0xFC, 0x0F,
  0x1F, 0xFC, 0x3C, 0xFF, 0xF8, 0xF7, 0xFF, 0xF3, 0xDC, 0x0F, 0xCF, 0x40,
  0x1F, 0xBF, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x80, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8, 0x03,
  0xF0, 0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F,
  0x80, 0xF8, 0x1F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0xF9, 0xF0, 0x7C, 0x7D, 0xFC, 0xFF, 0x3F, 0xFF,
  0x7F, 0xDF, 0xFF, 0xF7, 0xEF, 0x83, 0xE0, 0xF7, 0xC1, 0xF0, 0x7F, 0xE0,
  0x78, 0x3F, 0xF0, 0x38, 0x1F, 0xF8, 0x1C, 0x0F, 0xFC, 0x0E, 0x07, 0xFE,
  0x07, 0x03, 0xFF, 0x03, 0x81, 0xFF, 0x81, 0xC0, 0xFF, 0xC0, 0xE0, 0x7F,
  0xE0, 0x70, 0x3F, 0xF0, 0x38, 0x1F, 0xF8, 0x1C, 0x0F, 0xFC, 0x0E, 0x07,
  0xFE, 0x07, 0x03, 0xFF, 0x03, 0x81, 0xFF, 0x81, 0xC0, 0xFF, 0xC0, 0xE0,
  0x7F, 0xE0, 0x70, 0x3F, 0xF0, 0x38, 0x1F, 0xF8, 0x1C, 0x0F, 0xFC, 0x0E,
  0x07, 0xFE, 0x07, 0x03, 0xFF, 0x03, 0x81, 0xFF, 0x81, 0xC0, 0xF8, 0xF0,
  0xFF, 0x03, 0xC7, 0xFF, 0x0F, 0x3F, 0xFE, 0x3D, 0xFF, 0xFC, 0xF7, 0x03,
  0xF3, 0xD0, 0x07, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7B,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7C, 0x00, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F,
  0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07, 0x9F, 0x00,
  0x1F, 0x3F, 0x00, 0x7E, 0x3F, 0x01, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xF0, 0x7F, 0x03, 0xC7, 0xFF,
  0x0F, 0x3F, 0xFE, 0x3D, 0xFF, 0xFC, 0xF7, 0x03, 0xF3, 0xD0, 0x07, 0xEF,
  0xC0, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBF, 0x00,
  0x3E, 0xF6, 0x03, 0xFB, 0xDF, 0xFF, 0xCF, 0x3F, 0xFE, 0x3C, 0x7F, 0xF0,
  0xF0, 0xFF, 0x83, 0xC0, 0x20, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x78, 0xFF, 0xE3, 0xCF, 0xFF, 0x9E,
  0xFF, 0xFE, 0xF7, 0xF0, 0x77, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0x7E, 0x03, 0x7B, 0xFF, 0xFB,
  0xCF, 0xFF, 0xDE, 0x3F, 0xFC, 0xF0, 0xFF, 0x87, 0x80, 0x60, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xF0, 0xFF, 0x03, 0xC7,
  0xFF, 0x0F, 0x3F, 0xFE, 0x3D, 0xFF, 0xFC, 0xF7, 0x03, 0xF3, 0xF0, 0x07,
  0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF9, 0xF0, 0x03, 0xEF, 0x80, 0x07, 0xFE,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x01,
  0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1E, 0xF8, 0x00,
  0x7B, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0x9F, 0x00, 0x7E, 0x7E, 0x03, 0xF0,
  0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xE7, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x78,
  0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x1F,
  0x01, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x1E, 0x03,
  0xE0, 0x0F, 0x81, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0xF8, 0x00, 0xF8,
  0x78, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3E, 0x00, 0x0F, 0x9E, 0x00, 0x07,
  0xCF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xF0, 0x1F, 0x01,
  0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0x80, 0xFF, 0x81,
  0xB0, 0x1E, 0xF0, 0x37, 0x03, 0xDE, 0x0E, 0xE0, 0x73, 0xC1, 0xDC, 0x1E,
  0x78, 0x3B, 0x83, 0xCF, 0x07, 0x70, 0x79, 0xE0, 0xE6, 0x0F, 0x1E, 0x18,
  0xE1, 0xE3, 0xC7, 0x1C, 0x38, 0x78, 0xE3, 0x87, 0x0F, 0x1C, 0x71, 0xE1,
  0xE3, 0x8E, 0x3C, 0x3C, 0x70, 0xC7, 0x83, 0x8C, 0x1C, 0xF0, 0x79, 0x83,
  0x9C, 0x0F, 0x70, 0x73, 0x81, 0xEE, 0x0E, 0xF0, 0x3D, 0xC1, 0xDE, 0x07,
  0xB8, 0x3B, 0xC0, 0x76, 0x03, 0x78, 0x0E, 0xC0, 0x7E, 0x01, 0xF8, 0x0F,
  0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xF8,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x87,
  0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xE0,
  0x01, 0xF1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00,
  0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xE0, 0x00, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x78,
  0x00, 0x0F, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC,
  0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x0F, 0xF0, 0x07,
  0xCF, 0xFE, 0x03, 0xEF, 0xFF, 0x01, 0xF7, 0xCF, 0xC0, 0xFF, 0xC1, 0xF0,
  0x7F, 0xE0, 0x7C, 0x3D, 0xF0, 0x3F, 0xFE, 0xF8, 0x0F, 0xFF, 0x7C, 0x03,
  0xFF, 0x3E, 0x00, 0x7E, 0x00,
};

const GFXglyph JetBrainsMono_Regular52pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 38, 31, 12, -38 },
  { 39, 15, 16, 31, 8, -38 },
  { 69, 27, 38, 31, 2, -38 },
  { 198, 23, 52, 31, 4, -45 },
  { 348, 29, 38, 31, 1, -38 },
  { 486, 26, 39, 31, 3, -38 },
  { 613, 5, 16, 31, 13, -38 },
  { 623, 15, 50, 31, 10, -44 },
  { 717, 16, 50, 31, 6, -44 },
  { 817, 27, 27, 31, 2, -32 },
  { 909, 25, 24, 31, 3, -29 },
  { 984, 11, 16, 31, 9, -8 },
  { 1006, 17, 4, 31, 7, -19 },
  { 1015, 9, 9, 31, 11, -8 },
  { 1026, 23, 49, 31, 4, -43 },
  { 1167, 23, 39, 31, 4, -38 },
  { 1280, 23, 38, 31, 5, -38 },
  { 1390, 23, 38, 31, 4, -38 },
  { 1500, 23, 39, 31, 4, -38 },
  { 1613, 22, 38, 31, 4, -38 },
  { 1718, 23, 39, 31, 4, -38 },
  { 1831, 24, 39, 31, 4, -38 },
  { 1948, 24, 38, 31, 4, -38 },
  { 2062, 23, 40, 31, 4, -39 },
  { 2177, 24, 38, 31, 4, -38 },
  { 2291, 9, 30, 31, 11, -29 },
  { 2325, 11, 37, 31, 9, -29 },
  { 2376, 23, 28, 31, 4, -31 },
  { 2457, 23, 16, 31, 4, -25 },
  { 2503, 23, 28, 31, 4, -31 },
  { 2584, 18, 38, 31, 7, -38 },
  { 2670, 27, 47, 31, 2, -38 },
  { 2829, 26, 38, 31, 3, -38 },
  { 2953, 23, 38, 31, 5, -38 },
  { 3063, 22, 39, 31, 5, -38 },
  { 3171, 22, 38, 31, 5, -38 },
  { 3276, 22, 38, 31, 5, -38 },
  { 3381, 22, 38, 31, 5, -38 },
  { 3486, 22, 39, 31, 5, -38 },
  { 3594, 21, 38, 31, 5, -38 },
  { 3694, 21, 38, 31, 5, -38 },
  { 3794, 24, 39, 31, 2, -38 },
  { 3911, 24, 38, 31, 5, -38 },
  { 4025, 22, 38, 31, 6, -38 },
  { 4130, 23, 38, 31, 4, -38 },
  { 4240, 22, 38, 31, 5, -38 },
  { 4345, 22, 39, 31, 5, -38 },
  { 4453, 24, 38, 31, 5, -38 },
  { 4567, 23, 47, 31, 4, -38 },
  { 4703, 23, 38, 31, 5, -38 },
  { 4813, 23, 40, 31, 4, -39 },
  { 4928, 25, 38, 31, 3, -38 },
  { 5047, 22, 39, 31, 5, -38 },
  { 5155, 26, 38, 31, 3, -38 },
  { 5279, 29, 38, 31, 1, -38 },
  { 5417, 27, 38, 31, 2, -38 },
  { 5546, 27, 38, 31, 2, -38 },
  { 5675, 23, 38, 31, 4, -38 },
  { 5785, 12, 49, 31, 11, -43 },
  { 5859, 23, 49, 31, 4, -43 },
  { 6000, 13, 49, 31, 8, -43 },
  { 6080, 23, 20, 31, 4, -38 },
  { 6138, 25, 4, 31, 3, 1 },
  { 6151, 11, 7, 31, 9, -41 },
  { 6161, 24, 30, 31, 3, -29 },
  { 6251, 22, 39, 31, 5, -38 },
  { 6359, 23, 30, 31, 4, -29 },
  { 6446, 22, 39, 31, 4, -38 },
  { 6554, 23, 30, 31, 4, -29 },
  { 6641, 25, 38, 31, 3, -38 },
  { 6760, 21, 38, 31, 5, -29 },
  { 6860, 22, 38, 31, 5, -38 },
  { 6965, 25, 40, 31, 4, -40 },
  { 7090, 20, 49, 31, 4, -40 },
  { 7213, 24, 38, 31, 5, -38 },
  { 7327, 27, 38, 31, 2, -38 },
  { 7456, 25, 29, 31, 3, -29 },
  { 7547, 22, 29, 31, 5, -29 },
  { 7627, 23, 29, 31, 4, -29 },
  { 7711, 22, 38, 31, 5, -29 },
  { 7816, 21, 38, 31, 5, -29 },
  { 7916, 22, 29, 31, 6, -29 },
  { 7996, 22, 29, 31, 5, -29 },
  { 8076, 24, 37, 31, 3, -37 },
  { 8187, 22, 30, 31, 5, -29 },
  { 8270, 25, 29, 31, 3, -29 },
  { 8361, 27, 29, 31, 2, -29 },
  { 8459, 26, 29, 31, 3, -29 },
  { 8554, 25, 38, 31, 3, -29 },
  { 8673, 22, 29, 31, 5, -29 },
  { 8753, 23, 49, 31, 4, -43 },
  { 8894, 5, 49, 31, 13, -43 },
  { 8925, 23, 49, 31, 4, -43 },
  { 9066, 25, 11, 31, 3, -24 },
};

const GFXfont JetBrainsMono_Regular52pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular52pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular52pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _JETBRAINSMONO_REGULAR52PT7B_H_
