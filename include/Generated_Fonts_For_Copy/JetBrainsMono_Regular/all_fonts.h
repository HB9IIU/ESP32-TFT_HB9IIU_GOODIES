#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/JetBrainsMono_Regular
// Headers: 67

#include "JetBrainsMono_Regular6pt7b.h"
#include "JetBrainsMono_Regular7pt7b.h"
#include "JetBrainsMono_Regular8pt7b.h"
#include "JetBrainsMono_Regular9pt7b.h"
#include "JetBrainsMono_Regular10pt7b.h"
#include "JetBrainsMono_Regular11pt7b.h"
#include "JetBrainsMono_Regular12pt7b.h"
#include "JetBrainsMono_Regular13pt7b.h"
#include "JetBrainsMono_Regular14pt7b.h"
#include "JetBrainsMono_Regular15pt7b.h"
#include "JetBrainsMono_Regular16pt7b.h"
#include "JetBrainsMono_Regular17pt7b.h"
#include "JetBrainsMono_Regular18pt7b.h"
#include "JetBrainsMono_Regular19pt7b.h"
#include "JetBrainsMono_Regular20pt7b.h"
#include "JetBrainsMono_Regular21pt7b.h"
#include "JetBrainsMono_Regular22pt7b.h"
#include "JetBrainsMono_Regular23pt7b.h"
#include "JetBrainsMono_Regular24pt7b.h"
#include "JetBrainsMono_Regular25pt7b.h"
#include "JetBrainsMono_Regular26pt7b.h"
#include "JetBrainsMono_Regular27pt7b.h"
#include "JetBrainsMono_Regular28pt7b.h"
#include "JetBrainsMono_Regular29pt7b.h"
#include "JetBrainsMono_Regular30pt7b.h"
#include "JetBrainsMono_Regular31pt7b.h"
#include "JetBrainsMono_Regular32pt7b.h"
#include "JetBrainsMono_Regular33pt7b.h"
#include "JetBrainsMono_Regular34pt7b.h"
#include "JetBrainsMono_Regular35pt7b.h"
#include "JetBrainsMono_Regular36pt7b.h"
#include "JetBrainsMono_Regular37pt7b.h"
#include "JetBrainsMono_Regular38pt7b.h"
#include "JetBrainsMono_Regular39pt7b.h"
#include "JetBrainsMono_Regular40pt7b.h"
#include "JetBrainsMono_Regular41pt7b.h"
#include "JetBrainsMono_Regular42pt7b.h"
#include "JetBrainsMono_Regular43pt7b.h"
#include "JetBrainsMono_Regular44pt7b.h"
#include "JetBrainsMono_Regular45pt7b.h"
#include "JetBrainsMono_Regular46pt7b.h"
#include "JetBrainsMono_Regular47pt7b.h"
#include "JetBrainsMono_Regular48pt7b.h"
#include "JetBrainsMono_Regular49pt7b.h"
#include "JetBrainsMono_Regular50pt7b.h"
#include "JetBrainsMono_Regular51pt7b.h"
#include "JetBrainsMono_Regular52pt7b.h"
#include "JetBrainsMono_Regular53pt7b.h"
#include "JetBrainsMono_Regular54pt7b.h"
#include "JetBrainsMono_Regular55pt7b.h"
#include "JetBrainsMono_Regular56pt7b.h"
#include "JetBrainsMono_Regular57pt7b.h"
#include "JetBrainsMono_Regular58pt7b.h"
#include "JetBrainsMono_Regular59pt7b.h"
#include "JetBrainsMono_Regular60pt7b.h"
#include "JetBrainsMono_Regular61pt7b.h"
#include "JetBrainsMono_Regular62pt7b.h"
#include "JetBrainsMono_Regular63pt7b.h"
#include "JetBrainsMono_Regular64pt7b.h"
#include "JetBrainsMono_Regular65pt7b.h"
#include "JetBrainsMono_Regular66pt7b.h"
#include "JetBrainsMono_Regular67pt7b.h"
#include "JetBrainsMono_Regular68pt7b.h"
#include "JetBrainsMono_Regular69pt7b.h"
#include "JetBrainsMono_Regular70pt7b.h"
#include "JetBrainsMono_Regular71pt7b.h"
#include "JetBrainsMono_Regular72pt7b.h"
