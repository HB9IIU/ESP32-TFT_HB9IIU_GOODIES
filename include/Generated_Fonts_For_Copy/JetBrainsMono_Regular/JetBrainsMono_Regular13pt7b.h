#ifndef _JETBRAINSMONO_REGULAR13PT7B_H_
#define _JETBRAINSMONO_REGULAR13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0xA2, 0xC0, 0x99, 0x90, 0x12, 0x49, 0xF9, 0x22, 0x56, 0xD2,
  0x24, 0x48, 0x20, 0xC6, 0xA9, 0xA1, 0x83, 0x8B, 0x26, 0xB7, 0x88, 0x20,
  0x61, 0x92, 0x94, 0x94, 0x68, 0x10, 0x1E, 0x29, 0x49, 0x8E, 0x23, 0x68,
  0xB0, 0x42, 0x99, 0xE6, 0x9B, 0xD0, 0xE0, 0x12, 0x44, 0xCC, 0xCC, 0xC4,
  0x63, 0x10, 0xC6, 0x31, 0x11, 0x11, 0x11, 0x3E, 0x80, 0x10, 0x23, 0x59,
  0xE1, 0x84, 0x99, 0x00, 0x20, 0x8F, 0xC8, 0x20, 0x80, 0x69, 0x40, 0xF0,
  0xF0, 0x0C, 0x20, 0x86, 0x10, 0x42, 0x08, 0x61, 0x04, 0x30, 0x31, 0x28,
  0x61, 0xA6, 0xD8, 0x61, 0xCD, 0xE0, 0x72, 0x41, 0x04, 0x10, 0x41, 0x04,
  0xFC, 0x33, 0x68, 0xC3, 0x08, 0x63, 0x18, 0xC3, 0xF0, 0xF8, 0x42, 0x0E,
  0x08, 0x38, 0xE2, 0x78, 0x18, 0xC2, 0x10, 0xCE, 0x3F, 0xC3, 0x0C, 0xFA,
  0x08, 0x2E, 0xCC, 0x10, 0x63, 0x78, 0x30, 0x86, 0x1E, 0xCE, 0x18, 0x73,
  0x78, 0xFE, 0x30, 0x82, 0x10, 0x43, 0x08, 0x60, 0x31, 0x28, 0xF2, 0x79,
  0xEC, 0xE1, 0x8D, 0xE0, 0x33, 0x68, 0x61, 0x85, 0xE0, 0x84, 0x31, 0x80,
  0xF0, 0x3C, 0x6C, 0x00, 0xD2, 0x80, 0x04, 0x66, 0x20, 0xE0, 0xE0, 0xC0,
  0xFC, 0x00, 0x3F, 0x83, 0x83, 0x83, 0x19, 0x88, 0x00, 0xF1, 0x11, 0x64,
  0x04, 0xC0, 0x33, 0x38, 0x61, 0xBE, 0x9A, 0x69, 0xBE, 0x08, 0x1C, 0x30,
  0xC5, 0x12, 0x49, 0xE8, 0xE1, 0x84, 0xFA, 0x38, 0xE6, 0xFA, 0x18, 0x63,
  0xF8, 0x31, 0x68, 0xE0, 0x82, 0x08, 0x21, 0xCD, 0xE0, 0xFA, 0x38, 0xE3,
  0x8E, 0x38, 0xE2, 0xF8, 0xFE, 0x08, 0x20, 0xFA, 0x08, 0x20, 0xFC, 0xFF,
  0xF8, 0x20, 0x83, 0xE8, 0x20, 0x82, 0x00, 0x31, 0x68, 0xE0, 0x82, 0x78,
  0x61, 0xCD, 0xE0, 0x8E, 0x38, 0xE3, 0xFE, 0x38, 0xE3, 0x8C, 0xF9, 0x8C,
  0x63, 0x18, 0xC6, 0xF8, 0x38, 0x42, 0x10, 0x86, 0x31, 0x70, 0x8E, 0x29,
  0xA4, 0xF2, 0x68, 0xA3, 0x84, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC,
  0xCF, 0x3B, 0x6D, 0xB6, 0x18, 0x61, 0x84, 0xCF, 0x3A, 0xEB, 0xBE, 0x59,
  0x63, 0x8C, 0x31, 0x68, 0xE3, 0x8E, 0x38, 0xE3, 0xC9, 0xE0, 0xFE, 0x18,
  0x61, 0xFA, 0x08, 0x20, 0x80, 0x31, 0x68, 0xE1, 0x86, 0x18, 0x61, 0xCD,
  0xE1, 0x83, 0xFA, 0x18, 0x63, 0xFA, 0x48, 0xA2, 0x8C, 0x31, 0x28, 0x60,
  0x60, 0xE0, 0xC1, 0x8D, 0xE0, 0xFF, 0xF2, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x8E, 0x38, 0xE3, 0x8E, 0x38, 0xF2, 0x78, 0x86, 0x3C, 0x92, 0x49,
  0x67, 0x0C, 0x30, 0xDA, 0xB5, 0x6A, 0xD5, 0xAD, 0x5A, 0xB3, 0x64, 0xCD,
  0x27, 0x0C, 0x30, 0xC4, 0xB2, 0x84, 0xC2, 0xC8, 0x91, 0xC1, 0x82, 0x04,
  0x08, 0x10, 0xFC, 0x21, 0x04, 0x21, 0x84, 0x30, 0xFC, 0xF2, 0x49, 0x24,
  0x92, 0x70, 0x83, 0x04, 0x10, 0x20, 0x83, 0x04, 0x10, 0x60, 0x83, 0xE4,
  0x92, 0x49, 0x24, 0xF0, 0x31, 0x44, 0x92, 0x84, 0xFC, 0xC4, 0x7A, 0x30,
  0xFF, 0x8E, 0x3F, 0xC0, 0x82, 0x0B, 0xB3, 0x86, 0x18, 0x73, 0xB8, 0x7A,
  0x38, 0x20, 0x83, 0x37, 0x80, 0x0C, 0x37, 0xE3, 0x8E, 0x38, 0xF3, 0x7C,
  0x7A, 0x38, 0x7F, 0x83, 0x37, 0x80, 0x3C, 0x82, 0x3F, 0x20, 0x82, 0x08,
  0x20, 0x7F, 0x38, 0xE3, 0x8D, 0xF2, 0xC3, 0x78, 0x82, 0x0B, 0xB3, 0x8E,
  0x38, 0xE3, 0x8C, 0x30, 0x40, 0x3C, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x18,
  0x41, 0xF1, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0x82, 0x08, 0xE2, 0x93, 0xC9,
  0xA2, 0x84, 0xF0, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1E, 0xFE, 0x9A,
  0x69, 0xA6, 0x9A, 0x40, 0xBB, 0x38, 0xE3, 0x8E, 0x38, 0xC0, 0x7A, 0x38,
  0x61, 0x87, 0x27, 0x80, 0xBB, 0x38, 0x61, 0x87, 0x3B, 0xA0, 0x80, 0x7F,
  0x38, 0xE3, 0x8F, 0x37, 0xC3, 0x0C, 0xFB, 0x1C, 0x70, 0xC3, 0x0C, 0x00,
  0x7B, 0x1C, 0x1E, 0x0E, 0x37, 0x80, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08,
  0x3C, 0x8E, 0x38, 0xE3, 0x8F, 0x27, 0x80, 0x86, 0x34, 0x92, 0x58, 0xC3,
  0x00, 0xDA, 0xB5, 0x6A, 0xD6, 0xAD, 0x89, 0x00, 0xCD, 0x23, 0x0C, 0x71,
  0x28, 0xC0, 0x87, 0x24, 0x92, 0x30, 0xC3, 0x08, 0x60, 0xF8, 0x21, 0x08,
  0x63, 0x0F, 0xC0, 0x0C, 0x41, 0x04, 0x10, 0x4E, 0x04, 0x10, 0x41, 0x07,
  0xFF, 0xF0, 0xC0, 0x82, 0x08, 0x20, 0x81, 0xC8, 0x20, 0x82, 0x38, 0xE6,
  0xD9, 0x80,
};

const GFXglyph JetBrainsMono_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 3, 8, 2, -9 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 13, 8, 1, -11 },
  { 24, 8, 10, 8, 0, -10 },
  { 34, 6, 10, 8, 1, -10 },
  { 42, 1, 3, 8, 3, -9 },
  { 43, 4, 13, 8, 2, -11 },
  { 50, 4, 13, 8, 1, -11 },
  { 57, 7, 7, 8, 0, -8 },
  { 64, 6, 6, 8, 1, -7 },
  { 69, 3, 4, 8, 2, -2 },
  { 71, 4, 1, 8, 2, -5 },
  { 72, 2, 2, 8, 3, -2 },
  { 73, 6, 12, 8, 1, -11 },
  { 82, 6, 10, 8, 1, -10 },
  { 90, 6, 9, 8, 1, -9 },
  { 97, 6, 10, 8, 1, -10 },
  { 105, 6, 9, 8, 1, -9 },
  { 112, 6, 9, 8, 1, -9 },
  { 119, 6, 9, 8, 1, -9 },
  { 126, 6, 9, 8, 1, -9 },
  { 133, 6, 9, 8, 1, -9 },
  { 140, 6, 10, 8, 1, -10 },
  { 148, 6, 10, 8, 1, -10 },
  { 156, 2, 7, 8, 3, -7 },
  { 158, 3, 9, 8, 2, -7 },
  { 162, 6, 7, 8, 1, -8 },
  { 168, 6, 4, 8, 1, -6 },
  { 171, 6, 7, 8, 1, -8 },
  { 177, 4, 9, 8, 2, -9 },
  { 182, 6, 12, 8, 1, -10 },
  { 191, 6, 9, 8, 1, -9 },
  { 198, 6, 9, 8, 1, -9 },
  { 205, 6, 10, 8, 1, -10 },
  { 213, 6, 9, 8, 1, -9 },
  { 220, 6, 9, 8, 1, -9 },
  { 227, 6, 10, 8, 1, -10 },
  { 235, 6, 10, 8, 1, -10 },
  { 243, 6, 9, 8, 1, -9 },
  { 250, 5, 9, 8, 1, -9 },
  { 256, 5, 9, 8, 1, -9 },
  { 262, 6, 9, 8, 1, -9 },
  { 269, 6, 9, 8, 1, -9 },
  { 276, 6, 9, 8, 1, -9 },
  { 283, 6, 9, 8, 1, -9 },
  { 290, 6, 10, 8, 1, -10 },
  { 298, 6, 9, 8, 1, -9 },
  { 305, 6, 12, 8, 1, -10 },
  { 314, 6, 9, 8, 1, -9 },
  { 321, 6, 10, 8, 1, -10 },
  { 329, 6, 10, 8, 1, -10 },
  { 337, 6, 9, 8, 1, -9 },
  { 344, 6, 9, 8, 1, -9 },
  { 351, 7, 9, 8, 0, -9 },
  { 359, 6, 9, 8, 1, -9 },
  { 366, 7, 9, 8, 0, -9 },
  { 374, 6, 9, 8, 1, -9 },
  { 381, 3, 12, 8, 3, -11 },
  { 386, 6, 12, 8, 1, -11 },
  { 395, 3, 12, 8, 2, -11 },
  { 400, 6, 5, 8, 1, -9 },
  { 404, 6, 1, 8, 1, 0 },
  { 405, 3, 2, 8, 2, -10 },
  { 406, 6, 7, 8, 1, -7 },
  { 412, 6, 9, 8, 1, -9 },
  { 419, 6, 7, 8, 1, -7 },
  { 425, 6, 9, 8, 1, -9 },
  { 432, 6, 7, 8, 1, -7 },
  { 438, 6, 9, 8, 1, -9 },
  { 445, 6, 9, 8, 1, -7 },
  { 452, 6, 9, 8, 1, -9 },
  { 459, 6, 10, 8, 1, -10 },
  { 467, 5, 12, 8, 1, -10 },
  { 475, 6, 9, 8, 1, -9 },
  { 482, 7, 9, 8, 0, -9 },
  { 490, 6, 7, 8, 1, -7 },
  { 496, 6, 7, 8, 1, -7 },
  { 502, 6, 7, 8, 1, -7 },
  { 508, 6, 9, 8, 1, -7 },
  { 515, 6, 9, 8, 1, -7 },
  { 522, 6, 7, 8, 1, -7 },
  { 528, 6, 7, 8, 1, -7 },
  { 534, 6, 9, 8, 1, -9 },
  { 541, 6, 7, 8, 1, -7 },
  { 547, 6, 7, 8, 1, -7 },
  { 553, 7, 7, 8, 0, -7 },
  { 560, 6, 7, 8, 1, -7 },
  { 566, 6, 9, 8, 1, -7 },
  { 573, 6, 7, 8, 1, -7 },
  { 579, 6, 12, 8, 1, -11 },
  { 588, 1, 12, 8, 3, -11 },
  { 590, 6, 12, 8, 1, -11 },
  { 599, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Regular13pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular13pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular13pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _JETBRAINSMONO_REGULAR13PT7B_H_
