#ifndef _JETBRAINSMONO_REGULAR11PT7B_H_
#define _JETBRAINSMONO_REGULAR11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x53, 0xB6, 0x80, 0x24, 0x97, 0xCA, 0x4B, 0xF4, 0x94, 0x21,
  0x1D, 0x5A, 0x30, 0xC5, 0xAF, 0x88, 0x40, 0xE6, 0xAA, 0x94, 0x2C, 0xD5,
  0x63, 0xF4, 0xA1, 0x8A, 0xDA, 0x5D, 0xE0, 0x2A, 0x49, 0x24, 0x44, 0xC2,
  0x21, 0x11, 0x12, 0x2C, 0x10, 0x4F, 0xC4, 0x29, 0x20, 0x21, 0x3E, 0x42,
  0x00, 0x7A, 0xE0, 0x70, 0x18, 0x84, 0x42, 0x11, 0x08, 0xC4, 0x00, 0x74,
  0x63, 0x5A, 0xC6, 0x2E, 0x65, 0x08, 0x42, 0x10, 0x9F, 0xF4, 0x42, 0x23,
  0x33, 0x1F, 0xF0, 0x88, 0xE1, 0x86, 0x7E, 0x11, 0x10, 0x98, 0xFC, 0x21,
  0xF4, 0x21, 0xE0, 0x86, 0x2E, 0x33, 0x11, 0xE8, 0xC6, 0x2E, 0xFC, 0x44,
  0x22, 0x10, 0x88, 0x74, 0x64, 0xED, 0x46, 0x3E, 0x74, 0x63, 0x17, 0x08,
  0x88, 0xC0, 0x70, 0xC0, 0x7A, 0x08, 0x99, 0x06, 0x0C, 0xF8, 0x3E, 0x86,
  0x0C, 0x13, 0x60, 0xF1, 0x11, 0x64, 0x06, 0x39, 0x18, 0x67, 0x96, 0x59,
  0x62, 0x40, 0xC0, 0x23, 0x14, 0xA9, 0x7A, 0x31, 0xF4, 0x63, 0xE9, 0x46,
  0x3E, 0x74, 0x61, 0x08, 0x42, 0x2E, 0xF4, 0xA3, 0x18, 0xC6, 0x5E, 0xFC,
  0x21, 0xE8, 0x42, 0x1F, 0xFC, 0x21, 0xE8, 0x42, 0x10, 0x74, 0x61, 0x0B,
  0xC6, 0x2E, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF2, 0x22, 0x22, 0x2F, 0x18,
  0x42, 0x10, 0xC5, 0x2F, 0x8C, 0xA5, 0xCA, 0x4A, 0x51, 0x84, 0x21, 0x08,
  0x42, 0x1F, 0x9E, 0xF7, 0xD8, 0xC6, 0x31, 0xCE, 0x73, 0x5A, 0xD6, 0x73,
  0x74, 0x63, 0x18, 0xC6, 0x2E, 0xF4, 0x63, 0x1F, 0x42, 0x10, 0x74, 0x63,
  0x18, 0xC6, 0x2E, 0x10, 0xC0, 0xF4, 0x63, 0x3E, 0x4A, 0x51, 0x74, 0x60,
  0xC1, 0x06, 0x3E, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x8C, 0x63, 0x18, 0xC6,
  0x6E, 0x8C, 0x65, 0x25, 0x29, 0x8C, 0x96, 0x57, 0x5D, 0x6D, 0xB6, 0xD2,
  0x45, 0xA2, 0x84, 0x30, 0xA4, 0xB1, 0xC5, 0x22, 0x8A, 0x10, 0x41, 0x04,
  0xF8, 0x84, 0x44, 0x22, 0x1F, 0xF2, 0x49, 0x24, 0x9C, 0x84, 0x10, 0x82,
  0x10, 0x82, 0x10, 0xC0, 0xD5, 0x55, 0x70, 0x22, 0x95, 0x30, 0xF8, 0x90,
  0x74, 0x4F, 0x18, 0xFC, 0x84, 0x3D, 0x18, 0xC6, 0x3E, 0x74, 0x61, 0x08,
  0xB8, 0x08, 0x7B, 0x38, 0xC6, 0x7D, 0x74, 0x7F, 0x08, 0xB8, 0x3A, 0x11,
  0xF4, 0x21, 0x08, 0xEC, 0xE3, 0x19, 0xB4, 0x2E, 0x84, 0x3D, 0x18, 0xC6,
  0x31, 0x21, 0x01, 0xC2, 0x10, 0x84, 0xF8, 0x13, 0x0F, 0x11, 0x11, 0x11,
  0xE0, 0x84, 0x23, 0x2E, 0x52, 0x51, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x07,
  0xFD, 0x6B, 0x5A, 0xD4, 0xF4, 0x63, 0x18, 0xC4, 0x74, 0x63, 0x18, 0xB8,
  0xF4, 0x63, 0x18, 0xFA, 0x10, 0xEC, 0xE3, 0x19, 0xF4, 0x21, 0xF4, 0x61,
  0x08, 0x40, 0xF4, 0x78, 0x30, 0xF8, 0x42, 0x3E, 0x84, 0x21, 0x07, 0x8C,
  0x63, 0x19, 0xB8, 0x8C, 0xA4, 0xA5, 0x30, 0x95, 0x57, 0x5B, 0x69, 0xA0,
  0x9A, 0x98, 0xC5, 0x44, 0x8C, 0x94, 0xA6, 0x10, 0x88, 0xF0, 0x88, 0x8C,
  0x7C, 0x39, 0x08, 0x42, 0x70, 0x84, 0x21, 0xC0, 0xFF, 0xC0, 0xC2, 0x10,
  0x82, 0x1D, 0x08, 0x46, 0x00, 0xCD, 0xC0,
};

const GFXglyph JetBrainsMono_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 3, 7, 2, -8 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 12, 7, 1, -10 },
  { 19, 6, 8, 7, 0, -8 },
  { 25, 5, 8, 7, 1, -8 },
  { 30, 1, 3, 7, 3, -8 },
  { 31, 3, 10, 7, 2, -9 },
  { 35, 4, 10, 7, 1, -9 },
  { 40, 6, 6, 7, 0, -7 },
  { 45, 5, 5, 7, 1, -6 },
  { 49, 2, 4, 7, 2, -2 },
  { 50, 3, 1, 7, 2, -4 },
  { 51, 2, 2, 7, 2, -2 },
  { 52, 5, 10, 7, 1, -9 },
  { 59, 5, 8, 7, 1, -8 },
  { 64, 5, 8, 7, 1, -8 },
  { 69, 5, 8, 7, 1, -8 },
  { 74, 5, 8, 7, 1, -8 },
  { 79, 5, 8, 7, 1, -8 },
  { 84, 5, 8, 7, 1, -8 },
  { 89, 5, 8, 7, 1, -8 },
  { 94, 5, 8, 7, 1, -8 },
  { 99, 5, 8, 7, 1, -8 },
  { 104, 5, 8, 7, 1, -8 },
  { 109, 2, 6, 7, 2, -6 },
  { 111, 2, 8, 7, 2, -6 },
  { 113, 5, 6, 7, 1, -7 },
  { 117, 5, 3, 7, 1, -5 },
  { 119, 5, 6, 7, 1, -7 },
  { 123, 4, 8, 7, 1, -8 },
  { 127, 6, 10, 7, 0, -8 },
  { 135, 5, 8, 7, 1, -8 },
  { 140, 5, 8, 7, 1, -8 },
  { 145, 5, 8, 7, 1, -8 },
  { 150, 5, 8, 7, 1, -8 },
  { 155, 5, 8, 7, 1, -8 },
  { 160, 5, 8, 7, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 4, 8, 7, 1, -8 },
  { 179, 5, 8, 7, 0, -8 },
  { 184, 5, 8, 7, 1, -8 },
  { 189, 5, 8, 7, 1, -8 },
  { 194, 5, 8, 7, 1, -8 },
  { 199, 5, 8, 7, 1, -8 },
  { 204, 5, 8, 7, 1, -8 },
  { 209, 5, 8, 7, 1, -8 },
  { 214, 5, 10, 7, 1, -8 },
  { 221, 5, 8, 7, 1, -8 },
  { 226, 5, 8, 7, 1, -8 },
  { 231, 5, 8, 7, 1, -8 },
  { 236, 5, 8, 7, 1, -8 },
  { 241, 5, 8, 7, 1, -8 },
  { 246, 6, 8, 7, 0, -8 },
  { 252, 6, 8, 7, 0, -8 },
  { 258, 6, 8, 7, 0, -8 },
  { 264, 5, 8, 7, 1, -8 },
  { 269, 3, 10, 7, 2, -9 },
  { 273, 5, 10, 7, 1, -9 },
  { 280, 2, 10, 7, 2, -9 },
  { 283, 5, 4, 7, 1, -8 },
  { 286, 5, 1, 7, 1, 0 },
  { 287, 2, 2, 7, 2, -9 },
  { 288, 5, 6, 7, 1, -6 },
  { 292, 5, 8, 7, 1, -8 },
  { 297, 5, 6, 7, 1, -6 },
  { 301, 5, 8, 7, 1, -8 },
  { 306, 5, 6, 7, 1, -6 },
  { 310, 5, 8, 7, 1, -8 },
  { 315, 5, 8, 7, 1, -6 },
  { 320, 5, 8, 7, 1, -8 },
  { 325, 5, 9, 7, 1, -9 },
  { 331, 4, 11, 7, 1, -9 },
  { 337, 5, 8, 7, 1, -8 },
  { 342, 6, 8, 7, 0, -8 },
  { 348, 5, 6, 7, 1, -6 },
  { 352, 5, 6, 7, 1, -6 },
  { 356, 5, 6, 7, 1, -6 },
  { 360, 5, 8, 7, 1, -6 },
  { 365, 5, 8, 7, 1, -6 },
  { 370, 5, 6, 7, 1, -6 },
  { 374, 5, 6, 7, 1, -6 },
  { 378, 5, 8, 7, 1, -8 },
  { 383, 5, 6, 7, 1, -6 },
  { 387, 5, 6, 7, 1, -6 },
  { 391, 6, 6, 7, 0, -6 },
  { 396, 5, 6, 7, 1, -6 },
  { 400, 5, 8, 7, 1, -6 },
  { 405, 5, 6, 7, 1, -6 },
  { 409, 5, 10, 7, 1, -9 },
  { 416, 1, 10, 7, 3, -9 },
  { 418, 5, 10, 7, 1, -9 },
  { 425, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_Regular11pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular11pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _JETBRAINSMONO_REGULAR11PT7B_H_
