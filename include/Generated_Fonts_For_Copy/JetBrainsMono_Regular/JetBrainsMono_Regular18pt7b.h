#ifndef _JETBRAINSMONO_REGULAR18PT7B_H_
#define _JETBRAINSMONO_REGULAR18PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x24, 0x92, 0x40, 0x7E, 0x9C, 0xE7, 0x38, 0x80, 0x11, 0x08,
  0x8C, 0x5F, 0xFF, 0xF9, 0x10, 0x88, 0x44, 0xFF, 0xA3, 0x11, 0x08, 0x8C,
  0x40, 0x08, 0x04, 0x02, 0x07, 0xC6, 0xB2, 0x49, 0x20, 0xD0, 0x78, 0x0F,
  0x02, 0xC1, 0x20, 0x9E, 0x49, 0xAC, 0x7C, 0x08, 0x04, 0x02, 0x00, 0x78,
  0x79, 0x13, 0x26, 0x64, 0x85, 0xA0, 0xEC, 0x01, 0x00, 0x5E, 0x1A, 0x42,
  0x4C, 0x89, 0xB1, 0x2C, 0x3C, 0x3C, 0x33, 0x10, 0x88, 0x06, 0x01, 0x83,
  0xC1, 0xB3, 0xCF, 0x63, 0x31, 0x99, 0xE7, 0x98, 0xFF, 0x40, 0x0C, 0x63,
  0x18, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x83, 0x07, 0x0C, 0xC7,
  0x0C, 0x31, 0x84, 0x21, 0x08, 0x42, 0x11, 0x8C, 0xDC, 0xC0, 0x08, 0x04,
  0x02, 0x1D, 0x77, 0xF0, 0xC0, 0xD0, 0x4C, 0x63, 0x00, 0x08, 0x04, 0x02,
  0x1F, 0xFF, 0xF8, 0x40, 0x20, 0x10, 0x76, 0x64, 0xCC, 0xFF, 0xC0, 0xDF,
  0x80, 0x01, 0x03, 0x03, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18,
  0x30, 0x30, 0x20, 0x60, 0x60, 0xC0, 0x3E, 0x63, 0x41, 0xC1, 0xC1, 0xC9,
  0xD9, 0xC1, 0xC1, 0xC1, 0x41, 0x63, 0x3E, 0x38, 0xF8, 0x98, 0x98, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x3E, 0x63, 0xC3, 0xC1,
  0x03, 0x03, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0x7F, 0x7F, 0x03, 0x06,
  0x0C, 0x18, 0x1E, 0x03, 0x03, 0x01, 0xC1, 0xC3, 0x67, 0x3E, 0x06, 0x04,
  0x0C, 0x18, 0x10, 0x33, 0x63, 0xC3, 0xC3, 0xFF, 0x03, 0x03, 0x03, 0xFF,
  0x02, 0x04, 0x09, 0x97, 0xF1, 0x81, 0x02, 0x06, 0x1E, 0x37, 0xC0, 0x0C,
  0x04, 0x06, 0x06, 0x03, 0x03, 0xF1, 0x8D, 0x82, 0xC1, 0xE0, 0xF0, 0x4C,
  0x63, 0xE0, 0xFF, 0xE0, 0xF0, 0x40, 0x60, 0x20, 0x30, 0x18, 0x08, 0x0C,
  0x04, 0x06, 0x03, 0x03, 0x00, 0x3E, 0x63, 0x43, 0x43, 0x63, 0x3E, 0x3C,
  0x63, 0x41, 0xC1, 0x41, 0x63, 0x3E, 0x3E, 0x31, 0xB0, 0x58, 0x3C, 0x1E,
  0x09, 0x9C, 0x76, 0x06, 0x02, 0x03, 0x03, 0x03, 0x00, 0xFD, 0x00, 0x02,
  0xFC, 0x77, 0x20, 0x00, 0x07, 0x66, 0x4C, 0xC0, 0x02, 0x0C, 0x73, 0x8C,
  0x18, 0x1C, 0x0E, 0x06, 0x04, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x81,
  0x81, 0xC0, 0xE0, 0x60, 0xC7, 0x38, 0xC1, 0x00, 0xF8, 0x18, 0x18, 0x30,
  0x61, 0x8F, 0x10, 0x20, 0x00, 0x03, 0x87, 0x00, 0x3E, 0x30, 0xB0, 0x70,
  0x18, 0x6C, 0x6E, 0x63, 0x31, 0x98, 0xCC, 0x66, 0x71, 0xD8, 0x06, 0x01,
  0x80, 0x78, 0x1C, 0x0E, 0x05, 0x06, 0x83, 0x61, 0x30, 0x88, 0xC4, 0x7F,
  0x3F, 0x90, 0x58, 0x3C, 0x18, 0xFC, 0x8E, 0x86, 0x82, 0x86, 0xFC, 0xFC,
  0x86, 0x82, 0x83, 0x82, 0x8E, 0xFC, 0x7D, 0x8E, 0x0C, 0x08, 0x10, 0x20,
  0x40, 0x81, 0x06, 0x0E, 0x37, 0xC0, 0xFD, 0x1E, 0x1C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x1C, 0x6F, 0x80, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xFF,
  0xC0, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x3F,
  0xC0, 0x81, 0x02, 0x04, 0x08, 0x00, 0x7D, 0x8E, 0x0C, 0x08, 0x10, 0x27,
  0xCF, 0x83, 0x06, 0x0E, 0x37, 0xC0, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xFF,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x60, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x8F, 0xE0, 0x1F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x83, 0xC3, 0xE6, 0x7C, 0x83, 0x86, 0x86, 0x8C, 0x8C,
  0xF8, 0xF8, 0x98, 0x8C, 0x8C, 0x86, 0x86, 0x83, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xE3, 0xE3, 0xE3,
  0xF5, 0xD5, 0xD5, 0xDD, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0x87,
  0x8D, 0x1A, 0x36, 0x64, 0xCD, 0x9B, 0x16, 0x3C, 0x78, 0x60, 0x7D, 0x8E,
  0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1E, 0x37, 0xC0, 0xFC, 0x86,
  0x83, 0x83, 0x83, 0x83, 0xFE, 0xF8, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3E,
  0x63, 0x41, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x43, 0x63, 0x3E,
  0x06, 0x02, 0x03, 0xFC, 0x86, 0x82, 0x83, 0x83, 0x86, 0xFC, 0x98, 0x8C,
  0x8C, 0x86, 0x86, 0x83, 0x3E, 0x31, 0x90, 0x48, 0x06, 0x03, 0xC0, 0x78,
  0x06, 0x01, 0x00, 0xF0, 0x4C, 0x63, 0xE0, 0xFF, 0x84, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x1E, 0x37, 0xC0, 0xC1, 0xE0,
  0x90, 0x48, 0x66, 0x33, 0x10, 0x88, 0x4C, 0x36, 0x1A, 0x05, 0x03, 0x81,
  0xC0, 0xC4, 0x53, 0x14, 0xA5, 0x2B, 0x4A, 0xDA, 0xB6, 0xAD, 0xAA, 0x6A,
  0x8C, 0xA3, 0x38, 0xC6, 0x31, 0x80, 0xC1, 0xB1, 0x98, 0x86, 0xC3, 0x40,
  0xE0, 0x60, 0x38, 0x36, 0x13, 0x18, 0xC8, 0x6C, 0x18, 0xC1, 0xE0, 0x98,
  0xCC, 0x43, 0x61, 0xA0, 0x70, 0x30, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0xFE, 0x0C, 0x10, 0x60, 0x83, 0x0C, 0x18, 0x60, 0x83, 0x04, 0x0F, 0xE0,
  0xFF, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x03,
  0x03, 0x01, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x18,
  0x14, 0x34, 0x26, 0x22, 0x63, 0xC1, 0xFF, 0xFF, 0xC0, 0xE3, 0x3E, 0x67,
  0x43, 0x01, 0x3F, 0x61, 0xC1, 0xC3, 0xC3, 0x7D, 0x81, 0x02, 0x05, 0xEE,
  0xF8, 0xE0, 0xC1, 0x83, 0x06, 0x1E, 0x3B, 0xC0, 0x7D, 0xDE, 0x0C, 0x08,
  0x10, 0x20, 0x41, 0xC6, 0xF8, 0x02, 0x04, 0x0B, 0xDC, 0xB0, 0xE0, 0xC1,
  0x83, 0x06, 0x1E, 0x57, 0xA0, 0x7D, 0x8E, 0x1C, 0x1F, 0xF0, 0x20, 0x41,
  0xC6, 0xF8, 0x0F, 0x8C, 0x06, 0x03, 0x0F, 0xFF, 0xFC, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0x7B, 0x96, 0x1C, 0x18, 0x30, 0x61, 0xE3,
  0x7A, 0x0C, 0x18, 0x37, 0xC0, 0x81, 0x02, 0x05, 0xEC, 0xF0, 0xE0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x20, 0x18, 0x38, 0x00, 0x00, 0xF8, 0xF8, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x0C, 0x30, 0x00, 0xFF, 0xF0,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC6, 0xF0, 0x80, 0x80, 0x80, 0x83,
  0x86, 0x8C, 0x8C, 0xF8, 0xF8, 0x8C, 0x84, 0x86, 0x83, 0xF0, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x06, 0x03, 0x00, 0xF8,
  0xFF, 0x6C, 0xB2, 0x79, 0x3C, 0x9E, 0x4F, 0x27, 0x93, 0xC9, 0xE4, 0xC0,
  0xBD, 0xDE, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x04, 0x7D, 0xDE, 0x1C,
  0x18, 0x30, 0x60, 0xC3, 0xCE, 0xF8, 0xBD, 0xDF, 0x1C, 0x18, 0x30, 0x60,
  0xC3, 0xC7, 0x7A, 0x04, 0x08, 0x00, 0x7B, 0x96, 0x1C, 0x18, 0x30, 0x60,
  0xC3, 0xCA, 0xF4, 0x08, 0x10, 0x20, 0xFC, 0xE6, 0xC3, 0xC3, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x7D, 0x8E, 0x06, 0x0F, 0x87, 0xC0, 0x81, 0xC6,
  0xF8, 0x10, 0x10, 0x10, 0xFF, 0xFF, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x18, 0x0F, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0xC6, 0xF8, 0xC1,
  0xE0, 0x90, 0xCC, 0x66, 0x21, 0x30, 0xD8, 0x68, 0x14, 0x0E, 0x00, 0x88,
  0xCC, 0x65, 0x7A, 0xBD, 0x56, 0xA9, 0x54, 0xCA, 0x65, 0x31, 0x80, 0xC1,
  0xB1, 0x8D, 0x86, 0x81, 0xC0, 0xE0, 0xD0, 0x4C, 0x63, 0x60, 0xC0, 0xC1,
  0xA0, 0x98, 0xCC, 0x62, 0x21, 0xB0, 0x50, 0x28, 0x1C, 0x04, 0x06, 0x03,
  0x03, 0x00, 0xFF, 0xFC, 0x30, 0x61, 0x86, 0x18, 0x60, 0x81, 0xFC, 0x0E,
  0x3C, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0xE0, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0E, 0x0E, 0xFF, 0xFF, 0x80, 0xC1, 0xC0, 0xC1, 0x83, 0x06, 0x08, 0x18,
  0x0E, 0x60, 0x81, 0x83, 0x06, 0x0C, 0x30, 0xC0, 0x71, 0xEC, 0xF3, 0xC0,
  0x40,
};

const GFXglyph JetBrainsMono_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 13, 11, 4, -13 },
  { 6, 5, 5, 11, 3, -13 },
  { 10, 9, 13, 11, 1, -13 },
  { 25, 9, 19, 11, 1, -16 },
  { 47, 11, 13, 11, 0, -13 },
  { 65, 9, 13, 11, 1, -13 },
  { 80, 2, 5, 11, 4, -13 },
  { 82, 6, 17, 11, 3, -15 },
  { 95, 5, 17, 11, 2, -15 },
  { 106, 9, 9, 11, 1, -11 },
  { 117, 9, 8, 11, 1, -10 },
  { 126, 4, 6, 11, 3, -3 },
  { 129, 5, 2, 11, 3, -7 },
  { 131, 3, 3, 11, 4, -3 },
  { 133, 8, 17, 11, 1, -15 },
  { 150, 8, 13, 11, 1, -13 },
  { 163, 8, 13, 11, 2, -13 },
  { 176, 8, 13, 11, 1, -13 },
  { 189, 8, 13, 11, 1, -13 },
  { 202, 8, 13, 11, 1, -13 },
  { 215, 7, 13, 11, 2, -13 },
  { 227, 9, 13, 11, 1, -13 },
  { 242, 9, 13, 11, 1, -13 },
  { 257, 8, 13, 11, 1, -13 },
  { 270, 9, 13, 11, 1, -13 },
  { 285, 3, 10, 11, 4, -10 },
  { 289, 4, 13, 11, 3, -10 },
  { 296, 7, 10, 11, 2, -11 },
  { 305, 7, 6, 11, 2, -9 },
  { 311, 7, 10, 11, 2, -11 },
  { 320, 7, 13, 11, 2, -13 },
  { 332, 9, 16, 11, 1, -13 },
  { 350, 9, 13, 11, 1, -13 },
  { 365, 8, 13, 11, 2, -13 },
  { 378, 7, 13, 11, 2, -13 },
  { 390, 7, 13, 11, 2, -13 },
  { 402, 7, 13, 11, 2, -13 },
  { 414, 7, 13, 11, 2, -13 },
  { 426, 7, 13, 11, 2, -13 },
  { 438, 7, 13, 11, 2, -13 },
  { 450, 7, 13, 11, 2, -13 },
  { 462, 8, 13, 11, 1, -13 },
  { 475, 8, 13, 11, 2, -13 },
  { 488, 8, 13, 11, 2, -13 },
  { 501, 8, 13, 11, 1, -13 },
  { 514, 7, 13, 11, 2, -13 },
  { 526, 7, 13, 11, 2, -13 },
  { 538, 8, 13, 11, 2, -13 },
  { 551, 8, 16, 11, 1, -13 },
  { 567, 8, 13, 11, 2, -13 },
  { 580, 9, 13, 11, 1, -13 },
  { 595, 9, 13, 11, 1, -13 },
  { 610, 7, 13, 11, 2, -13 },
  { 622, 9, 13, 11, 1, -13 },
  { 637, 10, 13, 11, 0, -13 },
  { 654, 9, 13, 11, 1, -13 },
  { 669, 9, 13, 11, 1, -13 },
  { 684, 7, 13, 11, 2, -13 },
  { 696, 4, 17, 11, 4, -15 },
  { 705, 8, 17, 11, 1, -15 },
  { 722, 4, 17, 11, 3, -15 },
  { 731, 8, 7, 11, 1, -13 },
  { 738, 9, 2, 11, 1, 0 },
  { 741, 4, 2, 11, 3, -14 },
  { 742, 8, 10, 11, 1, -10 },
  { 752, 7, 13, 11, 2, -13 },
  { 764, 7, 10, 11, 2, -10 },
  { 773, 7, 13, 11, 2, -13 },
  { 785, 7, 10, 11, 2, -10 },
  { 794, 9, 13, 11, 1, -13 },
  { 809, 7, 13, 11, 2, -10 },
  { 821, 7, 13, 11, 2, -13 },
  { 833, 8, 14, 11, 2, -14 },
  { 847, 6, 17, 11, 2, -14 },
  { 860, 8, 13, 11, 2, -13 },
  { 873, 9, 13, 11, 1, -13 },
  { 888, 9, 10, 11, 1, -10 },
  { 900, 7, 10, 11, 2, -10 },
  { 909, 7, 10, 11, 2, -10 },
  { 918, 7, 13, 11, 2, -10 },
  { 930, 7, 13, 11, 2, -10 },
  { 942, 8, 10, 11, 2, -10 },
  { 952, 7, 10, 11, 2, -10 },
  { 961, 8, 13, 11, 1, -13 },
  { 974, 7, 10, 11, 2, -10 },
  { 983, 9, 10, 11, 1, -10 },
  { 995, 9, 10, 11, 1, -10 },
  { 1007, 9, 10, 11, 1, -10 },
  { 1019, 9, 13, 11, 1, -10 },
  { 1034, 7, 10, 11, 2, -10 },
  { 1043, 7, 17, 11, 2, -15 },
  { 1058, 1, 17, 11, 5, -15 },
  { 1061, 7, 17, 11, 2, -15 },
  { 1076, 9, 4, 11, 1, -8 },
};

const GFXfont JetBrainsMono_Regular18pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular18pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular18pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _JETBRAINSMONO_REGULAR18PT7B_H_
