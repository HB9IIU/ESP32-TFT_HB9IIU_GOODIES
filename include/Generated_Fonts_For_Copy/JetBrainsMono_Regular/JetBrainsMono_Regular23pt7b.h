#ifndef _JETBRAINSMONO_REGULAR23PT7B_H_
#define _JETBRAINSMONO_REGULAR23PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0xE0, 0xE7, 0xCF,
  0x9B, 0x36, 0x6C, 0xD1, 0x80, 0x0C, 0x60, 0x86, 0x08, 0x41, 0x84, 0x18,
  0xC7, 0xFF, 0x10, 0xC1, 0x0C, 0x30, 0x83, 0x08, 0x31, 0x8F, 0xFE, 0x21,
  0x82, 0x10, 0x61, 0x06, 0x30, 0x63, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x7C,
  0x7F, 0x9B, 0x7C, 0xCF, 0x30, 0xCC, 0x1B, 0x07, 0xC0, 0xFC, 0x0F, 0x83,
  0x70, 0xCC, 0x33, 0xCC, 0xF3, 0x77, 0xF8, 0xFC, 0x0C, 0x03, 0x00, 0xC0,
  0x38, 0x0B, 0xE0, 0xF1, 0x8D, 0x8C, 0x4C, 0x66, 0x63, 0x61, 0xF6, 0x07,
  0x30, 0x03, 0x00, 0x33, 0x01, 0x3E, 0x1B, 0x31, 0x98, 0x88, 0xC4, 0xC6,
  0x2C, 0x3B, 0xC0, 0xF0, 0x1F, 0x03, 0xF8, 0x71, 0x86, 0x0C, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x7C, 0x0E, 0xE7, 0xC6, 0x6C, 0x3C, 0xC3, 0xCC,
  0x18, 0xE3, 0xC7, 0xF6, 0x3E, 0x70, 0xFF, 0xFC, 0x06, 0x3C, 0xE1, 0x86,
  0x0C, 0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0x40, 0xC1, 0xC0, 0xC0, 0xC1, 0xC1, 0x83, 0x06, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x06, 0x0C, 0x30, 0xE7, 0x8E, 0x10, 0x00,
  0x06, 0x00, 0x60, 0x06, 0x08, 0x62, 0xF6, 0xF7, 0xDE, 0x06, 0x00, 0xF0,
  0x19, 0x83, 0x98, 0x70, 0xC1, 0x08, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x0F,
  0xFF, 0xFF, 0xC1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x7B, 0x98,
  0xCE, 0x63, 0x00, 0xFF, 0xFF, 0x6F, 0xFE, 0x00, 0xC0, 0x60, 0x18, 0x06,
  0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x06,
  0x03, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x00, 0x3E,
  0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x33, 0xCC, 0xF3, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0x1E, 0x0F, 0x87,
  0x63, 0x98, 0x86, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x63, 0xFF, 0xFF, 0xC0, 0x3E, 0x1F, 0xEE, 0x1B, 0x03,
  0xC0, 0xC0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xBF, 0xE0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xC0, 0x7C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0xC0, 0xF0, 0x7C, 0x19,
  0xFE, 0x3F, 0x00, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x80,
  0xC7, 0x61, 0xF8, 0x7C, 0x1F, 0xFF, 0xFF, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xF3, 0xFE, 0xE1,
  0xB0, 0x30, 0x0C, 0x03, 0x00, 0xF0, 0x3E, 0x19, 0xFE, 0x3F, 0x00, 0x07,
  0x03, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x07, 0x01, 0xFC, 0xF3, 0xB0, 0x7C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0xFC,
  0x0F, 0x03, 0xC1, 0x80, 0x60, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x38,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x00, 0x3E, 0x1F, 0xEE, 0x1B, 0x03,
  0xC0, 0xF8, 0x66, 0x18, 0xFC, 0x1E, 0x1C, 0xEE, 0x1B, 0x03, 0xC0, 0xF0,
  0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0x3E, 0x1F, 0xEE, 0x1F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE1, 0xDF, 0xE1, 0xB8, 0x0C, 0x06, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x00, 0x6F, 0xF4, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x33, 0xDE,
  0x60, 0x00, 0x00, 0x00, 0x4C, 0xE6, 0x33, 0x98, 0xC0, 0x00, 0x40, 0x70,
  0x78, 0x78, 0x78, 0x38, 0x0C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0x00, 0x40, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x80,
  0x30, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0C, 0x0F, 0x0F, 0x0F, 0x0F,
  0x03, 0x00, 0x80, 0x00, 0xF8, 0xFE, 0x07, 0x03, 0x03, 0x03, 0x03, 0x07,
  0x3E, 0x3C, 0x30, 0x30, 0x00, 0x00, 0x30, 0x78, 0x70, 0x1F, 0x83, 0xFC,
  0x60, 0x66, 0x03, 0xC0, 0x3C, 0x03, 0xC3, 0xFC, 0x67, 0xC4, 0x3C, 0x43,
  0xC4, 0x3C, 0x43, 0xC4, 0x3C, 0x63, 0xC7, 0xFC, 0x3B, 0xC0, 0x06, 0x00,
  0x70, 0x03, 0xF0, 0x1F, 0x00, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x1B,
  0x01, 0x98, 0x19, 0x81, 0x98, 0x31, 0x83, 0x0C, 0x30, 0xC3, 0xFC, 0x7F,
  0xC6, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x70, 0xFE, 0x3F, 0xEC, 0x1B, 0x03,
  0xC0, 0xF0, 0x3C, 0x1B, 0xFE, 0xFF, 0x30, 0x6C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x1F, 0xFE, 0xFF, 0x00, 0x3E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0, 0x3E, 0x1D,
  0xFE, 0x3F, 0x00, 0xFE, 0x3F, 0xCC, 0x3B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x1B, 0xFC, 0xFE,
  0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF,
  0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0xBF, 0xEC,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3E, 0x1F, 0xEE,
  0x1B, 0x03, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xCF, 0xF3, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0xFF, 0xFF, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x31, 0xFF, 0xFF,
  0x80, 0x0F, 0xC3, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0xC0, 0xF0, 0x3E, 0x0D, 0xFE, 0x3F, 0x00, 0xC0,
  0xF8, 0x1B, 0x06, 0x60, 0xCC, 0x31, 0x86, 0x31, 0x87, 0xF0, 0xFE, 0x18,
  0xC3, 0x1C, 0x61, 0x8C, 0x39, 0x83, 0x30, 0x76, 0x06, 0xC0, 0xE0, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0xE1, 0xF8, 0x7A, 0x16, 0xCD,
  0xB3, 0xFC, 0xBD, 0x6F, 0x7B, 0xDC, 0xF3, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xD0, 0xF6,
  0x3D, 0x8F, 0x23, 0xCC, 0xF3, 0x3C, 0x4F, 0x1B, 0xC6, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC1, 0xC0, 0x3E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x19, 0xFE, 0x3F,
  0x00, 0xFE, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x3E, 0x06,
  0xFF, 0x9F, 0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x00, 0x3E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0xC0, 0xFE, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x0D, 0x81,
  0xB0, 0x36, 0x0E, 0xFF, 0x9F, 0xC3, 0x18, 0x61, 0x8C, 0x31, 0x83, 0x30,
  0x66, 0x0E, 0xC0, 0xE0, 0x3F, 0x1F, 0xEE, 0x1F, 0x03, 0xC0, 0x30, 0x06,
  0x01, 0xE0, 0x3F, 0x01, 0xE0, 0x1C, 0x03, 0x00, 0xF0, 0x3C, 0x1D, 0xFE,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x19, 0xFE,
  0x3F, 0x00, 0xC0, 0x7E, 0x06, 0x60, 0x66, 0x06, 0x60, 0xE3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC1, 0x98, 0x19, 0x81, 0x98, 0x19, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0E, 0x00, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0xE3, 0xCF, 0x3C,
  0xF3, 0xCB, 0x2C, 0x92, 0x49, 0x64, 0x96, 0x69, 0x67, 0x96, 0x79, 0x67,
  0x9E, 0x71, 0xE7, 0x1C, 0x70, 0xC0, 0xE0, 0x76, 0x06, 0x70, 0xC3, 0x0C,
  0x19, 0x81, 0x98, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0xF0, 0x0F, 0x01, 0x98,
  0x39, 0x83, 0x0C, 0x70, 0xC6, 0x06, 0xC0, 0x70, 0xC0, 0x3E, 0x06, 0x60,
  0x67, 0x0C, 0x30, 0xC3, 0x98, 0x19, 0x81, 0xB0, 0x0F, 0x00, 0xF0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF,
  0xF0, 0x18, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x38, 0x0C, 0x06, 0x01, 0x80,
  0xC0, 0x70, 0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF1, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xFC, 0xC0, 0x38,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x07, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x00,
  0xC0, 0x30, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xF0, 0x0C, 0x07, 0x01, 0xE0, 0xC8,
  0x33, 0x08, 0xC6, 0x19, 0x06, 0xC0, 0xC0, 0xFF, 0xE0, 0xE3, 0x8E, 0x0F,
  0x07, 0xF9, 0xC3, 0x30, 0x30, 0x06, 0x00, 0xCF, 0xFB, 0x83, 0x60, 0x7C,
  0x0D, 0x83, 0xB9, 0xB3, 0xF6, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xCE, 0x37,
  0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1F,
  0xFE, 0xDF, 0x00, 0x1E, 0x1F, 0xEE, 0x1B, 0x03, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x3C, 0xDF, 0xBE, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x7E, 0x1D, 0xFB, 0x3E, 0xC0, 0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0xC0,
  0xF0, 0x3F, 0xFF, 0x00, 0xC0, 0x30, 0x0E, 0x1D, 0xFE, 0x3F, 0x00, 0x03,
  0xE0, 0xFC, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0xFF, 0xFF, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x3C,
  0xDF, 0xBE, 0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF8, 0x77,
  0xEC, 0xFB, 0x00, 0xC0, 0x30, 0x1C, 0xFE, 0x3F, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xCE, 0x37, 0xEE, 0x1B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x0C, 0x01, 0xC0, 0x38, 0x00,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFC, 0x03, 0x07, 0x07, 0x00,
  0x00, 0x7F, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x07, 0xFE, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x0F, 0x81, 0xB0, 0x66, 0x1C, 0xC7, 0x18, 0xC3, 0xF8, 0x63, 0x0C, 0x71,
  0x87, 0x30, 0x66, 0x0E, 0xC0, 0xE0, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x7F, 0x03, 0xF0, 0xB9, 0xAE, 0xFC, 0xCE,
  0x33, 0x8C, 0xE3, 0x38, 0xCE, 0x33, 0x8C, 0xE3, 0x38, 0xCE, 0x33, 0x8C,
  0xC0, 0xCE, 0x37, 0xEE, 0x1B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x1E, 0x1F, 0xE6, 0x1B, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x19, 0xFE, 0x3F, 0x00, 0xCF,
  0x37, 0xEE, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E,
  0x1F, 0xFE, 0xDF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3C, 0xDF, 0xBE,
  0x1F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x7E, 0x1D, 0xFB,
  0x3E, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xDE, 0x7F, 0xB8, 0xF8, 0x3C,
  0x1E, 0x0F, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x1F, 0x1F,
  0xE6, 0x1F, 0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x1E, 0x00, 0xC0, 0x3C, 0x0D,
  0xFE, 0x3F, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x7F, 0xFF, 0xFE, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8,
  0x3F, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3E, 0x19, 0xFE, 0x3F, 0x00, 0xC0, 0x76, 0x06, 0x60, 0x66, 0x0C,
  0x30, 0xC3, 0x0C, 0x31, 0x81, 0x98, 0x19, 0x81, 0x90, 0x0F, 0x00, 0xF0,
  0x0E, 0x00, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0xE2, 0xCB, 0x24, 0xB6, 0x69,
  0x66, 0x96, 0x69, 0x67, 0x94, 0x79, 0x43, 0x1C, 0x30, 0xC0, 0xE0, 0x67,
  0x0E, 0x30, 0xC1, 0x98, 0x1F, 0x80, 0xF0, 0x06, 0x00, 0xF0, 0x1F, 0x81,
  0x98, 0x30, 0xC7, 0x0E, 0xE0, 0x70, 0xE0, 0x76, 0x06, 0x60, 0x63, 0x0C,
  0x30, 0xC3, 0x9C, 0x19, 0x81, 0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x1C, 0x00, 0xFF, 0xBF, 0xE0, 0x18,
  0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E, 0x03, 0xFF, 0xFF,
  0xC0, 0x03, 0xC1, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x0F, 0x83, 0xF0, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x1C, 0x03, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x3E, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00,
  0x7C, 0x3F, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0,
  0xF0, 0x30, 0x00, 0x7C, 0x6D, 0xCF, 0x1D, 0xE1, 0xE0,
};

const GFXglyph JetBrainsMono_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 7, 7, 14, 3, -17 },
  { 17, 12, 17, 14, 1, -17 },
  { 43, 10, 23, 14, 2, -20 },
  { 72, 13, 17, 14, 0, -17 },
  { 100, 12, 17, 14, 1, -17 },
  { 126, 2, 7, 14, 6, -17 },
  { 128, 7, 22, 14, 4, -19 },
  { 148, 7, 22, 14, 3, -19 },
  { 168, 12, 12, 14, 1, -14 },
  { 186, 11, 11, 14, 1, -13 },
  { 202, 5, 7, 14, 4, -3 },
  { 207, 8, 2, 14, 3, -9 },
  { 209, 4, 4, 14, 5, -4 },
  { 211, 10, 22, 14, 2, -19 },
  { 239, 10, 17, 14, 2, -17 },
  { 261, 10, 17, 14, 2, -17 },
  { 283, 10, 17, 14, 2, -17 },
  { 305, 10, 17, 14, 2, -17 },
  { 327, 10, 17, 14, 2, -17 },
  { 349, 10, 17, 14, 2, -17 },
  { 371, 10, 17, 14, 2, -17 },
  { 393, 10, 17, 14, 2, -17 },
  { 415, 10, 17, 14, 2, -17 },
  { 437, 10, 17, 14, 2, -17 },
  { 459, 4, 13, 14, 5, -13 },
  { 466, 5, 17, 14, 4, -13 },
  { 477, 10, 13, 14, 2, -14 },
  { 494, 10, 7, 14, 2, -11 },
  { 503, 10, 13, 14, 2, -14 },
  { 520, 8, 17, 14, 3, -17 },
  { 537, 12, 21, 14, 1, -17 },
  { 569, 12, 17, 14, 1, -17 },
  { 595, 10, 17, 14, 2, -17 },
  { 617, 10, 17, 14, 2, -17 },
  { 639, 10, 17, 14, 2, -17 },
  { 661, 10, 17, 14, 2, -17 },
  { 683, 10, 17, 14, 2, -17 },
  { 705, 10, 17, 14, 2, -17 },
  { 727, 10, 17, 14, 2, -17 },
  { 749, 9, 17, 14, 2, -17 },
  { 769, 10, 17, 14, 1, -17 },
  { 791, 11, 17, 14, 2, -17 },
  { 815, 9, 17, 14, 3, -17 },
  { 835, 10, 17, 14, 2, -17 },
  { 857, 10, 17, 14, 2, -17 },
  { 879, 10, 17, 14, 2, -17 },
  { 901, 11, 17, 14, 2, -17 },
  { 925, 10, 21, 14, 2, -17 },
  { 952, 11, 17, 14, 2, -17 },
  { 976, 10, 17, 14, 2, -17 },
  { 998, 12, 17, 14, 1, -17 },
  { 1024, 10, 17, 14, 2, -17 },
  { 1046, 12, 17, 14, 1, -17 },
  { 1072, 12, 17, 14, 1, -17 },
  { 1098, 12, 17, 14, 1, -17 },
  { 1124, 12, 17, 14, 1, -17 },
  { 1150, 10, 17, 14, 2, -17 },
  { 1172, 5, 22, 14, 5, -19 },
  { 1186, 10, 22, 14, 2, -19 },
  { 1214, 6, 22, 14, 3, -19 },
  { 1231, 10, 9, 14, 2, -17 },
  { 1243, 11, 1, 14, 1, 1 },
  { 1245, 5, 3, 14, 4, -18 },
  { 1247, 11, 13, 14, 1, -13 },
  { 1265, 10, 17, 14, 2, -17 },
  { 1287, 10, 13, 14, 2, -13 },
  { 1304, 10, 17, 14, 2, -17 },
  { 1326, 10, 13, 14, 2, -13 },
  { 1343, 11, 17, 14, 1, -17 },
  { 1367, 10, 17, 14, 2, -13 },
  { 1389, 10, 17, 14, 2, -17 },
  { 1411, 11, 18, 14, 2, -18 },
  { 1436, 8, 22, 14, 2, -18 },
  { 1458, 11, 17, 14, 2, -17 },
  { 1482, 12, 17, 14, 1, -17 },
  { 1508, 10, 13, 14, 2, -13 },
  { 1525, 10, 13, 14, 2, -13 },
  { 1542, 10, 13, 14, 2, -13 },
  { 1559, 10, 17, 14, 2, -13 },
  { 1581, 10, 17, 14, 2, -13 },
  { 1603, 9, 13, 14, 3, -13 },
  { 1618, 10, 13, 14, 2, -13 },
  { 1635, 11, 16, 14, 1, -16 },
  { 1657, 10, 13, 14, 2, -13 },
  { 1674, 12, 13, 14, 1, -13 },
  { 1694, 12, 13, 14, 1, -13 },
  { 1714, 12, 13, 14, 1, -13 },
  { 1734, 12, 17, 14, 1, -13 },
  { 1760, 10, 13, 14, 2, -13 },
  { 1777, 10, 22, 14, 2, -19 },
  { 1805, 2, 22, 14, 6, -19 },
  { 1811, 10, 22, 14, 2, -19 },
  { 1839, 11, 4, 14, 1, -10 },
};

const GFXfont JetBrainsMono_Regular23pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular23pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular23pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _JETBRAINSMONO_REGULAR23PT7B_H_
