#ifndef _JETBRAINSMONO_REGULAR43PT7B_H_
#define _JETBRAINSMONO_REGULAR43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x1C, 0x70, 0xC0, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF,
  0x80, 0xF8, 0x7F, 0xC3, 0xFE, 0x1F, 0xF0, 0xF7, 0x87, 0xBC, 0x3D, 0xC1,
  0xEE, 0x0F, 0x70, 0x7B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0x80, 0x00,
  0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0x1C,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x3F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x78, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x0F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0x83, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C,
  0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0xE0, 0x07, 0x03, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x1F, 0x80, 0x07, 0xFE, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC3, 0xE6, 0x7C, 0x7C, 0x61, 0xE7, 0x86, 0x1E, 0x78,
  0x61, 0xE7, 0x86, 0x1E, 0x78, 0x60, 0x07, 0x86, 0x00, 0x7C, 0x60, 0x03,
  0xE6, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0x80, 0x06, 0xFC, 0x00, 0x63, 0xE0, 0x06, 0x1E, 0x00, 0x61,
  0xE0, 0x06, 0x0F, 0x00, 0x60, 0xFF, 0x06, 0x0F, 0xF0, 0x60, 0xFF, 0x86,
  0x1E, 0x78, 0x63, 0xE7, 0xE6, 0x7C, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0x7F,
  0xE0, 0x0E, 0xF1, 0xE0, 0x1C, 0xE0, 0xE0, 0x3C, 0xE0, 0xF0, 0x38, 0xE0,
  0xF0, 0x70, 0xE0, 0xF0, 0xF0, 0xE0, 0xF0, 0xE0, 0xE0, 0xF1, 0xC0, 0xE0,
  0xE3, 0x80, 0xF1, 0xE3, 0x80, 0x7F, 0xE7, 0x00, 0x3F, 0xCE, 0x00, 0x0F,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x71, 0xF8, 0x00, 0xE3, 0xFE, 0x01, 0xE7, 0xFE, 0x01, 0xCF, 0x0F, 0x03,
  0x8E, 0x07, 0x07, 0x8E, 0x07, 0x07, 0x0E, 0x07, 0x0E, 0x0E, 0x07, 0x1E,
  0x0E, 0x07, 0x1C, 0x0E, 0x07, 0x38, 0x0F, 0x0F, 0x78, 0x07, 0xFE, 0x70,
  0x03, 0xFE, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xE0, 0x3E, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xE3, 0xC0, 0xFF, 0x0F, 0x87, 0xBC, 0x1E, 0x3C,
  0xF0, 0x3C, 0xF3, 0xC0, 0xFF, 0x8F, 0x01, 0xFE, 0x3C, 0x03, 0xF0, 0xF0,
  0x07, 0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0xFC, 0x1E, 0x03, 0xF8, 0x7C, 0x3E,
  0xF1, 0xFF, 0xF3, 0xE3, 0xFF, 0x87, 0x83, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEE, 0xE0, 0x00, 0x18, 0x03, 0xC0, 0x7E, 0x07, 0xF0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0xFE, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x18, 0xC0,
  0x07, 0x80, 0x3F, 0x01, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x7F,
  0x03, 0xF0, 0x1E, 0x00, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x0C,
  0x0F, 0x03, 0x3E, 0x1C, 0x3F, 0x7F, 0x19, 0xFF, 0xFF, 0xB7, 0xFC, 0x3F,
  0xFF, 0xC0, 0x07, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x39,
  0xC0, 0x00, 0xF3, 0xC0, 0x03, 0xC7, 0xC0, 0x0F, 0x87, 0x80, 0x1E, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0x70, 0x0E, 0x00, 0x40, 0x08, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x0F, 0x8F, 0xC7, 0xC3, 0xE3, 0xE1, 0xF0, 0xF8, 0x78, 0x7C, 0x3C, 0x1E,
  0x0F, 0x0F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18,
  0xFD, 0xFF, 0xFF, 0xEF, 0xDF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xE3, 0xE0,
  0x7C, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x3C,
  0x3F, 0x8F, 0x87, 0xF1, 0xF0, 0xFE, 0x1E, 0x1F, 0xC3, 0x83, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xE3, 0xE0, 0x7C, 0x3F, 0xFF,
  0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0x03, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0,
  0x1F, 0xF8, 0x0F, 0xCF, 0x01, 0xF1, 0xE0, 0x3C, 0x3C, 0x06, 0x07, 0x80,
  0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7C, 0x07, 0xC7, 0x80, 0x3C, 0x78, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x79, 0xE0, 0x0F, 0x3F, 0x07, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x3E, 0x03, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x7C, 0x01, 0xEF, 0x00, 0x3F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x07, 0x03, 0xCF, 0xF8, 0xF7, 0xFF,
  0x3F, 0xFF, 0xEF, 0xC0, 0xFB, 0xE0, 0x1F, 0xF0, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x79, 0xF0, 0x7E, 0x3F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0xC7, 0xE0, 0x7E, 0x78, 0x03, 0xEF,
  0x80, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x03,
  0xE3, 0xE0, 0xFC, 0x1F, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xE0, 0x7C, 0xF8, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0x1E, 0x01, 0xE1, 0xE0, 0x78,
  0x3E, 0x3E, 0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xE0,
  0x7C, 0x3E, 0x1E, 0x01, 0xE7, 0x80, 0x3E, 0xF0, 0x03, 0xDC, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xF3,
  0xE0, 0x7C, 0x7F, 0xFF, 0x87, 0xFF, 0xC0, 0x3F, 0xF0, 0x01, 0xF8, 0x00,
  0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xC7, 0x80, 0x3E,
  0xF8, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x78, 0x01, 0xE7, 0xC0,
  0x3E, 0x3E, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x7E, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x3C, 0xFF, 0xFF, 0xF7, 0xEF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF3, 0xFF, 0xFF,
  0xDF, 0xBF, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0x87, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1,
  0xE0, 0x78, 0x1C, 0x0F, 0x00, 0x00, 0x00, 0x40, 0x00, 0x30, 0x00, 0x3C,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x03,
  0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xC1, 0xFF,
  0xE3, 0xFF, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x87,
  0xFE, 0x0F, 0xF8, 0x1F, 0xE0, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x3E, 0x00, 0xF0, 0xF0, 0x01,
  0xE7, 0x80, 0x03, 0x9C, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x03, 0xC7, 0xE0, 0x3F, 0xDF, 0x81, 0xFF, 0x7E, 0x07,
  0x87, 0xF8, 0x1C, 0x0F, 0xE0, 0xF0, 0x1F, 0x83, 0xC0, 0x7E, 0x0F, 0x01,
  0xF8, 0x3C, 0x07, 0xE0, 0xF0, 0x1F, 0x83, 0xC0, 0x7E, 0x0F, 0x01, 0xF8,
  0x3C, 0x07, 0xE0, 0xF0, 0x3F, 0x81, 0xC0, 0xFE, 0x07, 0x87, 0xF8, 0x1F,
  0xF7, 0xE0, 0x3F, 0xDF, 0xC0, 0x1C, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0x78, 0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0E,
  0x3C, 0x00, 0x78, 0x70, 0x01, 0xE1, 0xE0, 0x07, 0x87, 0x80, 0x1C, 0x1E,
  0x00, 0xF0, 0x38, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x1C, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xFF,
  0xFE, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC7, 0x80, 0x07,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xEF, 0x00, 0x03, 0xC0,
  0xFF, 0xFC, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x0F, 0xCF, 0x00, 0x7D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x01, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xF8, 0xF0, 0x3F, 0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x3F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x3F,
  0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C,
  0x0F, 0xBE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3D, 0xE0, 0x1F, 0x7E, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x3F, 0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x7C, 0xF0,
  0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01,
  0xEF, 0x00, 0xFB, 0xC3, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xFF, 0xFF, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFE, 0x7C, 0x0F, 0xBE,
  0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3D, 0xE0, 0x1F, 0x7E, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3D, 0xE0, 0x0F, 0x3F, 0x07, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFF, 0x00, 0xF0, 0x01, 0xFF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0, 0x1E,
  0x0F, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0x80, 0xF0,
  0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x0F,
  0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3C,
  0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x03, 0xFF, 0xC0, 0x3F, 0xFC,
  0x03, 0xFF, 0xE0, 0x77, 0xEE, 0x07, 0x7E, 0xE0, 0x77, 0xEF, 0x0E, 0x7E,
  0x70, 0xEF, 0xE7, 0x0E, 0xFF, 0x79, 0xEF, 0xF3, 0x9C, 0xFF, 0x39, 0xCF,
  0xF3, 0x9C, 0xFF, 0x1F, 0x8F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF0, 0xF0,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF0,
  0xF8, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFE, 0x03, 0xFB,
  0x80, 0xFE, 0xE0, 0x3F, 0xBC, 0x0F, 0xE7, 0x03, 0xFD, 0xE0, 0xFF, 0x78,
  0x3F, 0xCE, 0x0F, 0xF3, 0xC3, 0xFC, 0x70, 0xFF, 0x1C, 0x3F, 0xC7, 0x8F,
  0xF0, 0xE3, 0xFC, 0x38, 0xFF, 0x0F, 0x3F, 0xC1, 0xCF, 0xF0, 0x73, 0xFC,
  0x1E, 0xFF, 0x03, 0xBF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x07, 0x7F, 0x01,
  0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x7C, 0x03, 0xF0,
  0x03, 0xFF, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0x7C, 0x0F, 0xBE, 0x01, 0xEF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7D, 0xE0,
  0x1E, 0x7E, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x1F, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0xC0, 0x3C, 0x3E, 0x0F, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x78, 0x07, 0xEF, 0x00, 0x7D, 0xE0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3D, 0xE0, 0x1F, 0xBF, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE,
  0x1F, 0xFF, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x3C,
  0x3C, 0x07, 0x87, 0x80, 0xF8, 0xF0, 0x0F, 0x1E, 0x01, 0xF3, 0xC0, 0x1E,
  0x78, 0x03, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x01, 0xF8,
  0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3E, 0x07, 0xC7, 0xC0,
  0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xC3, 0xFF,
  0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x01, 0xF7, 0x80, 0x79, 0xF0, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80,
  0xFF, 0xC0, 0xF0, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00,
  0x1E, 0x78, 0x00, 0x70, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78, 0x1E,
  0x01, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x03,
  0x80, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x00,
  0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0x80, 0x01, 0xCE, 0x00, 0x07,
  0x78, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3C,
  0x0E, 0x70, 0x3C, 0x0E, 0x70, 0x7E, 0x0E, 0x70, 0x7E, 0x0E, 0x70, 0x7E,
  0x1E, 0x78, 0x66, 0x1E, 0x78, 0x66, 0x1E, 0x78, 0x66, 0x1E, 0x78, 0x66,
  0x1C, 0x78, 0x66, 0x1C, 0x38, 0xE6, 0x1C, 0x38, 0xE7, 0x1C, 0x38, 0xE7,
  0x1C, 0x38, 0xC7, 0x1C, 0x38, 0xC3, 0x3C, 0x3C, 0xC3, 0x3C, 0x3C, 0xC3,
  0x3C, 0x3D, 0xC3, 0x38, 0x3D, 0xC3, 0x38, 0x1D, 0xC3, 0xB8, 0x1D, 0xC3,
  0xB8, 0x1D, 0x83, 0xB8, 0x1D, 0x83, 0xB8, 0x1D, 0x81, 0xF8, 0x1D, 0x81,
  0xF8, 0x1D, 0x81, 0xF0, 0x1F, 0x81, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81,
  0xF0, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x0F, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x7C, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xCF, 0x00, 0x1E,
  0x1E, 0x00, 0x78, 0x78, 0x03, 0xC0, 0xF0, 0x1F, 0x03, 0xC0, 0x78, 0x07,
  0x83, 0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF9, 0xE0, 0x01, 0xEF,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF1,
  0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0x78, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x0F, 0x0F, 0x00, 0x1E,
  0x1E, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFE,
  0x00, 0x39, 0xC0, 0x0F, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x0E, 0x0F,
  0x01, 0xC0, 0xE0, 0x78, 0x1E, 0x0E, 0x01, 0xC3, 0xC0, 0x3C, 0x70, 0x03,
  0x9E, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x7C, 0x03, 0xFC, 0x01, 0xFF,
  0xE0, 0x7F, 0xFE, 0x1F, 0x8F, 0xE3, 0xC0, 0x3C, 0xF0, 0x07, 0xDE, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0xFF, 0x8F, 0xFF,
  0xF3, 0xFF, 0xFE, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7E, 0xFF, 0xFB,
  0xCF, 0xFF, 0x78, 0xFF, 0x8F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC7, 0xE0, 0xF3,
  0xFE, 0x3D, 0xFF, 0xCF, 0xF3, 0xFB, 0xF0, 0x1E, 0xF8, 0x07, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3E, 0xFF, 0xFF, 0x3D, 0xFF,
  0xCF, 0x3F, 0xC0, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFC, 0xFE,
  0x78, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0x7E, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x3F, 0x8F, 0x1F, 0xF3, 0xCF, 0xFE, 0xF7, 0xE3, 0xFF, 0xE0, 0x3F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x80, 0x7D, 0xF0, 0x7F,
  0x7F, 0xFB, 0xCF, 0xFE, 0xF0, 0xFE, 0x3C, 0x07, 0xF8, 0x07, 0xFF, 0x83,
  0xFF, 0xF1, 0xF8, 0x7E, 0x78, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x3F, 0xE0, 0x0F, 0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xE3, 0xC7, 0xFC, 0xF3,
  0xFF, 0xBD, 0xF8, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xF7,
  0xC1, 0xFD, 0xFF, 0xEF, 0x3F, 0xFB, 0xC3, 0xFC, 0xF0, 0x10, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0xFF,
  0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x7F, 0xC0, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC7,
  0xE0, 0xF7, 0xFE, 0x3D, 0xFF, 0xCF, 0xE1, 0xFB, 0xE0, 0x1E, 0xF8, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0xFC, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0,
  0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x01,
  0xEF, 0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x0F, 0x0F, 0x01,
  0xE0, 0xF0, 0x3E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0xFF, 0x80, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0xF0, 0x3C, 0x0F,
  0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x8F, 0x00, 0x7C,
  0xF0, 0x03, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xF0, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0xE7, 0x87, 0xCE, 0xFC, 0xFE, 0xEF, 0xEF, 0xEF, 0x1F, 0x0F,
  0xF0, 0xF0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0,
  0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E,
  0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0,
  0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE, 0x0E, 0x0F, 0xE0, 0xE0, 0xFE,
  0x0E, 0x0F, 0xF1, 0xF8, 0x3D, 0xFF, 0x8F, 0x7F, 0xF3, 0xFC, 0xFE, 0xFC,
  0x07, 0xBE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x07, 0xF0, 0x07, 0xFF,
  0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0x78, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xE0, 0x1E, 0x7E, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xE0, 0xF1, 0xFC, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xFC, 0xFE, 0xFC,
  0x07, 0xBE, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F, 0xFE,
  0x0F, 0xBD, 0xFF, 0xCF, 0x7F, 0xF3, 0xCF, 0xF0, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xE3, 0xC7, 0xFC, 0xF3, 0xFF, 0xBD, 0xF8, 0xFF, 0xF8,
  0x0F, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0x7C,
  0x1F, 0xDF, 0xFE, 0xF3, 0xFF, 0xBC, 0x3F, 0x8F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xF1, 0xF8, 0x3D, 0xFF, 0x8F, 0xFF, 0xF3, 0xF8, 0x7E, 0xF8,
  0x07, 0xBC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFF,
  0x83, 0xFF, 0xF9, 0xFC, 0x7E, 0x78, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x7C, 0x0F, 0xDF, 0xFF, 0xE3, 0xFF, 0xF0,
  0x3F, 0xF8, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7D,
  0xE0, 0x1E, 0x7C, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0xF0,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x38, 0x03, 0xC3, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0xF0, 0x3C, 0x0E, 0xE0, 0x78, 0x1D, 0xC0, 0xF0, 0x3B, 0x81,
  0xE0, 0x77, 0x87, 0xC1, 0xEF, 0x0F, 0xC3, 0x9E, 0x1B, 0x87, 0x1C, 0x33,
  0x0E, 0x38, 0x66, 0x1C, 0x70, 0xCC, 0x38, 0xE3, 0x98, 0x71, 0xE7, 0x39,
  0xC3, 0xCC, 0x73, 0x83, 0x98, 0xE7, 0x07, 0x30, 0xCE, 0x0E, 0x61, 0x9C,
  0x1C, 0xC3, 0x38, 0x3B, 0x86, 0x60, 0x76, 0x0F, 0xC0, 0x7C, 0x1F, 0x80,
  0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x78,
  0x00, 0x79, 0xF0, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x0F, 0x03,
  0xC0, 0x3E, 0x1F, 0x00, 0x78, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xDF, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x1E, 0x1E,
  0x00, 0xF0, 0x7C, 0x07, 0xC0, 0xF8, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0xC7,
  0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x1F, 0x00, 0xF8, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x0F,
  0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x01,
  0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xFB,
  0xFF, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x3C, 0x00, 0x1F, 0x03, 0xFF, 0x80, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xFF, 0x00, 0x3F, 0xC0, 0x7F, 0xF0, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xF0,
  0x00, 0x00, 0x04, 0x00, 0x03, 0xF8, 0x0F, 0x7F, 0xC0, 0xFF, 0xFE, 0x0F,
  0xF1, 0xF0, 0xFE, 0x0F, 0x8F, 0xE0, 0x7F, 0xEE, 0x03, 0xFE, 0xE0, 0x1F,
  0x80,
};

const GFXglyph JetBrainsMono_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 6, 31, 26, 10, -31 },
  { 25, 13, 13, 26, 6, -31 },
  { 47, 23, 31, 26, 1, -31 },
  { 137, 20, 43, 26, 3, -37 },
  { 245, 24, 32, 26, 1, -32 },
  { 341, 22, 32, 26, 2, -32 },
  { 429, 4, 13, 26, 11, -31 },
  { 436, 13, 41, 26, 8, -36 },
  { 503, 13, 41, 26, 5, -36 },
  { 570, 23, 22, 26, 1, -26 },
  { 634, 20, 20, 26, 3, -24 },
  { 684, 9, 14, 26, 7, -7 },
  { 700, 14, 4, 26, 6, -16 },
  { 707, 7, 7, 26, 9, -7 },
  { 714, 20, 41, 26, 3, -36 },
  { 817, 19, 32, 26, 3, -32 },
  { 893, 19, 31, 26, 4, -31 },
  { 967, 20, 32, 26, 3, -32 },
  { 1047, 19, 31, 26, 3, -31 },
  { 1121, 19, 31, 26, 3, -31 },
  { 1195, 18, 31, 26, 4, -31 },
  { 1265, 20, 31, 26, 3, -31 },
  { 1343, 20, 31, 26, 3, -31 },
  { 1421, 19, 32, 26, 3, -32 },
  { 1497, 20, 32, 26, 3, -32 },
  { 1577, 7, 24, 26, 9, -24 },
  { 1598, 10, 31, 26, 7, -24 },
  { 1637, 18, 23, 26, 4, -26 },
  { 1689, 18, 14, 26, 4, -21 },
  { 1721, 18, 23, 26, 4, -26 },
  { 1773, 15, 31, 26, 6, -31 },
  { 1832, 22, 40, 26, 2, -32 },
  { 1942, 22, 31, 26, 2, -31 },
  { 2028, 19, 31, 26, 4, -31 },
  { 2102, 18, 32, 26, 4, -32 },
  { 2174, 18, 31, 26, 4, -31 },
  { 2244, 18, 31, 26, 4, -31 },
  { 2314, 19, 31, 26, 4, -31 },
  { 2388, 18, 32, 26, 4, -32 },
  { 2460, 18, 31, 26, 4, -31 },
  { 2530, 16, 31, 26, 5, -31 },
  { 2592, 19, 31, 26, 2, -31 },
  { 2666, 20, 31, 26, 4, -31 },
  { 2744, 18, 31, 26, 5, -31 },
  { 2814, 20, 31, 26, 3, -31 },
  { 2892, 18, 31, 26, 4, -31 },
  { 2962, 18, 32, 26, 4, -32 },
  { 3034, 20, 31, 26, 4, -31 },
  { 3112, 20, 40, 26, 3, -32 },
  { 3212, 19, 31, 26, 4, -31 },
  { 3286, 20, 32, 26, 3, -32 },
  { 3366, 21, 31, 26, 2, -31 },
  { 3448, 18, 31, 26, 4, -31 },
  { 3518, 22, 31, 26, 2, -31 },
  { 3604, 24, 31, 26, 1, -31 },
  { 3697, 22, 31, 26, 2, -31 },
  { 3783, 23, 31, 26, 1, -31 },
  { 3873, 18, 31, 26, 4, -31 },
  { 3943, 10, 41, 26, 9, -36 },
  { 3995, 20, 41, 26, 3, -36 },
  { 4098, 11, 41, 26, 6, -36 },
  { 4155, 19, 16, 26, 3, -31 },
  { 4193, 20, 3, 26, 3, 1 },
  { 4201, 9, 6, 26, 8, -34 },
  { 4208, 19, 24, 26, 3, -24 },
  { 4265, 18, 31, 26, 4, -31 },
  { 4335, 18, 24, 26, 4, -24 },
  { 4389, 18, 31, 26, 4, -31 },
  { 4459, 18, 24, 26, 4, -24 },
  { 4513, 20, 31, 26, 3, -31 },
  { 4591, 18, 32, 26, 4, -24 },
  { 4663, 18, 31, 26, 4, -31 },
  { 4733, 20, 33, 26, 4, -33 },
  { 4816, 16, 41, 26, 4, -33 },
  { 4898, 20, 31, 26, 4, -31 },
  { 4976, 23, 31, 26, 1, -31 },
  { 5066, 20, 24, 26, 3, -24 },
  { 5126, 18, 24, 26, 4, -24 },
  { 5180, 18, 24, 26, 4, -24 },
  { 5234, 18, 32, 26, 4, -24 },
  { 5306, 18, 32, 26, 4, -24 },
  { 5378, 18, 24, 26, 5, -24 },
  { 5432, 18, 24, 26, 4, -24 },
  { 5486, 20, 30, 26, 2, -30 },
  { 5561, 18, 24, 26, 4, -24 },
  { 5615, 21, 24, 26, 2, -24 },
  { 5678, 23, 24, 26, 1, -24 },
  { 5747, 22, 24, 26, 2, -24 },
  { 5813, 21, 32, 26, 2, -24 },
  { 5897, 18, 24, 26, 4, -24 },
  { 5951, 18, 41, 26, 4, -36 },
  { 6044, 4, 41, 26, 11, -36 },
  { 6065, 18, 41, 26, 4, -36 },
  { 6158, 20, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_Regular43pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular43pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular43pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _JETBRAINSMONO_REGULAR43PT7B_H_
