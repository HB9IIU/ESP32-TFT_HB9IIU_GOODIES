#ifndef _JETBRAINSMONO_REGULAR17PT7B_H_
#define _JETBRAINSMONO_REGULAR17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFD, 0x0F, 0x9C, 0xE7, 0x39, 0x00, 0x13, 0x19, 0x08, 0x9F,
  0xF2, 0x21, 0x11, 0x99, 0xFE, 0xFF, 0x22, 0x11, 0x19, 0x80, 0x08, 0x08,
  0x18, 0x7E, 0x4B, 0x4B, 0x48, 0x68, 0x3C, 0x0E, 0x0B, 0x0B, 0xCB, 0x6B,
  0x3E, 0x08, 0x08, 0x20, 0x5E, 0x2C, 0x9B, 0x24, 0xCA, 0x1D, 0x80, 0x40,
  0x24, 0x1F, 0xC5, 0x12, 0x45, 0x9B, 0xC3, 0x80, 0x18, 0x3E, 0x11, 0x88,
  0x06, 0x01, 0x01, 0xC3, 0xB2, 0x8B, 0x47, 0x21, 0x99, 0xE7, 0x98, 0xFF,
  0xC0, 0x19, 0x98, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x84, 0x30, 0xE1, 0xC3,
  0x0C, 0x31, 0x8C, 0x21, 0x08, 0x46, 0x31, 0x1B, 0x90, 0x18, 0x0C, 0x26,
  0x5D, 0xF1, 0x81, 0xE0, 0x98, 0xCC, 0x18, 0x18, 0x18, 0x18, 0xFF, 0x18,
  0x18, 0x18, 0x6D, 0xED, 0x00, 0xFC, 0xDF, 0x00, 0x03, 0x02, 0x06, 0x06,
  0x04, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x20, 0x60, 0x40, 0xC0,
  0x18, 0x7E, 0x43, 0xC3, 0xC3, 0xC3, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0x66,
  0x3C, 0x71, 0xA2, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x47, 0xF0,
  0x18, 0x7E, 0x42, 0xC3, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40,
  0x7F, 0x7E, 0x06, 0x0C, 0x18, 0x1C, 0x1E, 0x03, 0x03, 0x03, 0xC3, 0x66,
  0x3C, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x63, 0x43, 0xC3, 0xFF, 0x03, 0x03,
  0x03, 0x7E, 0x40, 0x40, 0x40, 0x5E, 0x66, 0x03, 0x03, 0x03, 0xC3, 0x66,
  0x3C, 0x0C, 0x18, 0x10, 0x30, 0x6C, 0x7E, 0xC3, 0xC3, 0xC1, 0xC3, 0x66,
  0x3C, 0xFF, 0xC3, 0xC3, 0x02, 0x06, 0x04, 0x0C, 0x0C, 0x08, 0x18, 0x10,
  0x30, 0x18, 0x7E, 0x42, 0x43, 0x42, 0x66, 0x18, 0x66, 0x43, 0xC3, 0xC3,
  0x66, 0x3E, 0x18, 0x7E, 0x43, 0xC3, 0xC1, 0xC3, 0x63, 0x7E, 0x06, 0x0C,
  0x08, 0x18, 0x30, 0x5F, 0x00, 0x00, 0xF8, 0x27, 0x60, 0x00, 0x06, 0x66,
  0xCC, 0x80, 0x01, 0x06, 0x18, 0x60, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x0E, 0x38, 0xE0,
  0x80, 0xF8, 0x30, 0x41, 0x0C, 0xF3, 0x08, 0x20, 0x06, 0x1C, 0x18, 0x3F,
  0x30, 0x50, 0x28, 0x1C, 0x7E, 0x67, 0x23, 0x91, 0xC8, 0xE6, 0x71, 0xF8,
  0x06, 0x01, 0x80, 0x78, 0x18, 0x1C, 0x3C, 0x34, 0x24, 0x26, 0x66, 0x7E,
  0x7E, 0xC3, 0xC3, 0xC1, 0xFD, 0x0A, 0x1C, 0x38, 0xDF, 0x23, 0x43, 0x87,
  0x0E, 0x3F, 0xC0, 0x18, 0x7E, 0x43, 0x43, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x43, 0x66, 0x3C, 0xFD, 0x1A, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x37, 0xC0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02,
  0x07, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x1F, 0xA0, 0x40, 0x81, 0x02, 0x04,
  0x00, 0x18, 0x7E, 0x43, 0x43, 0xC0, 0xC0, 0xC0, 0xCF, 0xC3, 0xC3, 0x43,
  0x66, 0x3C, 0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x30, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3F, 0x1E, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x83, 0x07, 0x1B, 0xE0, 0x86, 0x84, 0x8C,
  0x88, 0x98, 0xF0, 0x98, 0x88, 0x8C, 0x84, 0x86, 0x83, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x07, 0xF0, 0xE3, 0xA7, 0xE5, 0xF5,
  0xDD, 0xDB, 0xDB, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC7, 0x8F, 0x9D, 0x3A,
  0x76, 0xE5, 0xCB, 0x9F, 0x1E, 0x3C, 0x70, 0x18, 0x7E, 0x42, 0x43, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x66, 0x3C, 0xFD, 0x0E, 0x0C, 0x18,
  0x71, 0xFE, 0x40, 0x81, 0x02, 0x04, 0x00, 0x18, 0x7E, 0x43, 0xC3, 0xC3,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x66, 0x3C, 0x04, 0x06, 0x03, 0xFD,
  0x0E, 0x1C, 0x38, 0x7F, 0xBE, 0x4C, 0x8D, 0x1A, 0x1C, 0x30, 0x18, 0x7E,
  0x43, 0x43, 0x40, 0x60, 0x3C, 0x0E, 0x03, 0x03, 0xC3, 0x63, 0x3E, 0xFF,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x33, 0xC0, 0xC1, 0xC3,
  0x43, 0x42, 0x62, 0x66, 0x26, 0x24, 0x34, 0x3C, 0x1C, 0x18, 0xCC, 0xD3,
  0x34, 0xC9, 0x32, 0x4A, 0x92, 0xA7, 0x29, 0xCA, 0x73, 0x8C, 0xE3, 0x30,
  0xCC, 0xC3, 0x31, 0x19, 0x86, 0x81, 0xC0, 0xC0, 0x60, 0x78, 0x26, 0x33,
  0x10, 0xD8, 0x70, 0xC1, 0xA1, 0x98, 0x8C, 0xC3, 0x41, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0x7F, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x10,
  0x30, 0x20, 0x60, 0xC0, 0xFF, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0x8C, 0x63, 0x1F, 0xC0, 0x40, 0x60, 0x20, 0x30, 0x30, 0x10, 0x18, 0x08,
  0x0C, 0x0C, 0x04, 0x06, 0x06, 0x02, 0x03, 0xF3, 0x33, 0x33, 0x33, 0x33,
  0x33, 0x33, 0x3F, 0x18, 0x1C, 0x24, 0x26, 0x42, 0xC3, 0xFF, 0xFF, 0xC3,
  0x08, 0x7E, 0x43, 0x03, 0x03, 0x7F, 0xC3, 0xC3, 0xC7, 0x7B, 0x81, 0x02,
  0x47, 0xEC, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x35, 0xE0, 0x08, 0x7E, 0x43,
  0xC3, 0xC0, 0xC0, 0xC0, 0x43, 0x66, 0x3E, 0x03, 0x03, 0x13, 0x7F, 0x43,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x67, 0x3B, 0x08, 0x7E, 0x42, 0xC3, 0xC3,
  0xFF, 0xC0, 0x40, 0x63, 0x3E, 0x1F, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x7F, 0x43, 0x43, 0xC3, 0xC3, 0x43,
  0x63, 0x7F, 0x03, 0x03, 0x02, 0x3E, 0x81, 0x02, 0x47, 0xEC, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x30, 0x1C, 0x18, 0x00, 0x00, 0x78, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x0E, 0x1C, 0x00, 0x07, 0xC0, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x7C, 0x81, 0x02, 0x04, 0x38,
  0xD1, 0x26, 0x7C, 0x99, 0x1A, 0x14, 0x30, 0xF0, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x0F, 0x12, 0xBF, 0xD9, 0xD9, 0xD9,
  0xD9, 0xD9, 0xD9, 0xD9, 0xD9, 0x11, 0xFB, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0C, 0x7E, 0x42, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x66, 0x3C, 0x11,
  0xFB, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xCD, 0x7A, 0x04, 0x08, 0x00, 0x10,
  0x7F, 0x43, 0x43, 0xC3, 0xC3, 0xC3, 0x43, 0x67, 0x3B, 0x03, 0x03, 0x03,
  0x11, 0x7B, 0x1C, 0x18, 0x10, 0x20, 0x40, 0x81, 0x00, 0xFD, 0x0E, 0x07,
  0x07, 0xC0, 0xC1, 0xE3, 0x7C, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x18, 0x1F, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE6,
  0x78, 0xC3, 0x43, 0x42, 0x66, 0x26, 0x24, 0x34, 0x1C, 0x18, 0x99, 0xCC,
  0xA6, 0x53, 0x2D, 0x53, 0x39, 0x98, 0xCC, 0x66, 0x00, 0xC3, 0x66, 0x34,
  0x1C, 0x18, 0x3C, 0x26, 0x62, 0xC3, 0xC3, 0x43, 0x62, 0x66, 0x24, 0x34,
  0x1C, 0x18, 0x18, 0x18, 0x10, 0x30, 0xFC, 0x18, 0x20, 0xC3, 0x0C, 0x30,
  0x40, 0xFE, 0x07, 0x0C, 0x08, 0x08, 0x08, 0x0C, 0x08, 0xF8, 0xF8, 0x0C,
  0x0C, 0x08, 0x08, 0x08, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x30,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x1F, 0x1F, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x70, 0xE0, 0x61, 0xF9, 0xCF, 0xC6,
};

const GFXglyph JetBrainsMono_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 5, 5, 10, 3, -12 },
  { 8, 9, 12, 10, 1, -12 },
  { 22, 8, 17, 10, 1, -15 },
  { 39, 10, 13, 10, 0, -13 },
  { 56, 9, 13, 10, 1, -13 },
  { 71, 2, 5, 10, 4, -12 },
  { 73, 5, 16, 10, 3, -14 },
  { 83, 5, 16, 10, 2, -14 },
  { 93, 9, 8, 10, 1, -10 },
  { 102, 8, 8, 10, 1, -10 },
  { 110, 3, 6, 10, 3, -3 },
  { 113, 6, 1, 10, 2, -6 },
  { 114, 3, 3, 10, 4, -3 },
  { 116, 8, 16, 10, 1, -14 },
  { 132, 8, 13, 10, 1, -13 },
  { 145, 7, 12, 10, 2, -12 },
  { 156, 8, 13, 10, 1, -13 },
  { 169, 8, 12, 10, 1, -12 },
  { 181, 8, 12, 10, 1, -12 },
  { 193, 8, 12, 10, 1, -12 },
  { 205, 8, 12, 10, 1, -12 },
  { 217, 8, 12, 10, 1, -12 },
  { 229, 8, 13, 10, 1, -13 },
  { 242, 8, 13, 10, 1, -13 },
  { 255, 3, 10, 10, 4, -10 },
  { 259, 4, 13, 10, 3, -10 },
  { 266, 8, 9, 10, 1, -10 },
  { 275, 8, 5, 10, 1, -8 },
  { 280, 8, 9, 10, 1, -10 },
  { 289, 6, 12, 10, 2, -12 },
  { 298, 9, 16, 10, 1, -13 },
  { 316, 8, 12, 10, 1, -12 },
  { 328, 7, 12, 10, 2, -12 },
  { 339, 8, 13, 10, 1, -13 },
  { 352, 7, 12, 10, 2, -12 },
  { 363, 7, 12, 10, 2, -12 },
  { 374, 7, 12, 10, 2, -12 },
  { 385, 8, 13, 10, 1, -13 },
  { 398, 7, 12, 10, 2, -12 },
  { 409, 6, 12, 10, 2, -12 },
  { 418, 7, 12, 10, 1, -12 },
  { 429, 8, 12, 10, 2, -12 },
  { 441, 7, 12, 10, 2, -12 },
  { 452, 8, 12, 10, 1, -12 },
  { 464, 7, 12, 10, 2, -12 },
  { 475, 8, 13, 10, 1, -13 },
  { 488, 7, 12, 10, 2, -12 },
  { 499, 8, 16, 10, 1, -13 },
  { 515, 7, 12, 10, 2, -12 },
  { 526, 8, 13, 10, 1, -13 },
  { 539, 8, 12, 10, 1, -12 },
  { 551, 7, 12, 10, 2, -12 },
  { 562, 8, 12, 10, 1, -12 },
  { 574, 10, 12, 10, 0, -12 },
  { 589, 9, 12, 10, 1, -12 },
  { 603, 9, 12, 10, 1, -12 },
  { 617, 8, 12, 10, 1, -12 },
  { 629, 5, 16, 10, 3, -14 },
  { 639, 8, 16, 10, 1, -14 },
  { 655, 4, 16, 10, 3, -14 },
  { 663, 8, 6, 10, 1, -12 },
  { 669, 8, 2, 10, 1, 0 },
  { 671, 4, 2, 10, 3, -13 },
  { 672, 8, 10, 10, 1, -10 },
  { 682, 7, 12, 10, 2, -12 },
  { 693, 8, 10, 10, 1, -10 },
  { 703, 8, 12, 10, 1, -12 },
  { 715, 8, 10, 10, 1, -10 },
  { 725, 8, 12, 10, 1, -12 },
  { 737, 8, 13, 10, 1, -10 },
  { 750, 7, 12, 10, 2, -12 },
  { 761, 8, 13, 10, 1, -13 },
  { 774, 7, 16, 10, 1, -13 },
  { 788, 7, 12, 10, 2, -12 },
  { 799, 8, 12, 10, 1, -12 },
  { 811, 8, 10, 10, 1, -10 },
  { 821, 7, 10, 10, 2, -10 },
  { 830, 8, 9, 10, 1, -9 },
  { 839, 7, 13, 10, 2, -10 },
  { 851, 8, 13, 10, 1, -10 },
  { 864, 7, 10, 10, 2, -10 },
  { 873, 7, 9, 10, 2, -9 },
  { 881, 8, 12, 10, 1, -12 },
  { 893, 7, 9, 10, 2, -9 },
  { 901, 8, 9, 10, 1, -9 },
  { 910, 9, 9, 10, 1, -9 },
  { 921, 8, 9, 10, 1, -9 },
  { 930, 8, 12, 10, 1, -9 },
  { 942, 7, 9, 10, 2, -9 },
  { 950, 8, 16, 10, 1, -14 },
  { 966, 2, 16, 10, 4, -14 },
  { 970, 8, 16, 10, 1, -14 },
  { 986, 8, 4, 10, 1, -8 },
};

const GFXfont JetBrainsMono_Regular17pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular17pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular17pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _JETBRAINSMONO_REGULAR17PT7B_H_
