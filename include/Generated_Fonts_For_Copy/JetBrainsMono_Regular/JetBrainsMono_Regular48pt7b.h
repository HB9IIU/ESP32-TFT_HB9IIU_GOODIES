#ifndef _JETBRAINSMONO_REGULAR48PT7B_H_
#define _JETBRAINSMONO_REGULAR48PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9E, 0x3C, 0x78, 0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x00,
  0x00, 0x00, 0x07, 0x3F, 0x7F, 0xFF, 0xFD, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0x7C, 0x1E, 0xF8,
  0x3C, 0xF0, 0x79, 0xE0, 0xF3, 0x81, 0xE7, 0x03, 0xCE, 0x07, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80,
  0x0E, 0x01, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0x80, 0x70,
  0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x1F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xF8, 0x1C, 0x03, 0x80, 0x0E, 0x01, 0xC0, 0x07, 0x00,
  0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x1C, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x07, 0x03, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xCE, 0x3E, 0x3E, 0x38,
  0x78, 0xF0, 0xE1, 0xF7, 0xC3, 0x87, 0xDF, 0x0E, 0x0F, 0x7C, 0x38, 0x00,
  0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0x8E, 0x00, 0x3F, 0x38, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0E, 0x7E, 0x00, 0x38, 0xF8, 0x00, 0xE1, 0xF0,
  0x03, 0x83, 0xC0, 0x0E, 0x0F, 0x00, 0x38, 0x3F, 0xE0, 0xE0, 0xF7, 0x83,
  0x83, 0xDE, 0x0E, 0x0F, 0x7C, 0x38, 0x7C, 0xF8, 0xE3, 0xE3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x1F, 0xC0, 0x01, 0xE7, 0xFC, 0x00, 0x39, 0xFF,
  0xC0, 0x0E, 0x78, 0x7C, 0x03, 0xCF, 0x07, 0x80, 0xF1, 0xC0, 0x70, 0x1C,
  0x38, 0x0E, 0x07, 0x87, 0x01, 0xC1, 0xE0, 0xE0, 0x38, 0x38, 0x1C, 0x07,
  0x0F, 0x03, 0x81, 0xE3, 0xC0, 0x78, 0x3C, 0x70, 0x0F, 0xDF, 0x1E, 0x00,
  0xFF, 0xE7, 0x80, 0x0F, 0xF8, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x1F, 0x00,
  0x03, 0x8F, 0xF8, 0x00, 0xE3, 0xFF, 0x80, 0x3C, 0xFD, 0xF0, 0x07, 0x1E,
  0x0F, 0x01, 0xC3, 0x81, 0xE0, 0x78, 0x70, 0x3C, 0x1E, 0x0E, 0x07, 0x83,
  0x81, 0xC0, 0xF0, 0xF0, 0x38, 0x1E, 0x3C, 0x07, 0x03, 0xC7, 0x00, 0xF0,
  0x79, 0xE0, 0x1F, 0x1F, 0x78, 0x01, 0xFF, 0xCE, 0x00, 0x3F, 0xF3, 0xC0,
  0x01, 0xFC, 0x00, 0x00, 0x20, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x3F, 0x8F, 0xC0, 0x3E, 0x03, 0xE0, 0x3C, 0x03, 0xE0,
  0x3C, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xF9, 0xF0, 0x1F, 0xF0, 0xF8, 0x3E, 0xF0, 0x7C, 0x3C, 0xF0, 0x3C, 0x7C,
  0xF0, 0x3E, 0x78, 0xF0, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0,
  0xF0, 0x07, 0xE0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xE0, 0xF0, 0x07, 0xF0,
  0xF8, 0x1F, 0xF8, 0xFE, 0x7F, 0x7C, 0x7F, 0xFE, 0x3C, 0x3F, 0xFC, 0x3E,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x07, 0xF0, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0,
  0x1F, 0xC0, 0x1F, 0x00, 0x1C, 0x00, 0x10, 0xC0, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x1F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x3F, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x00,
  0xE0, 0x02, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x01, 0x00,
  0xF0, 0x04, 0xE0, 0x38, 0x0E, 0xFE, 0x1C, 0x3F, 0x7F, 0x8E, 0x7F, 0xFF,
  0xF6, 0x7F, 0xE3, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xF7, 0x80, 0x01, 0xF1, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07,
  0xC0, 0x7C, 0x01, 0xF0, 0x0C, 0x00, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC7, 0xE1, 0xF8, 0x7C, 0x1F, 0x0F, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07,
  0xC1, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3E, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF8, 0xFE, 0x3E, 0x01, 0xF9,
  0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x04, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0,
  0xFF, 0x0F, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7D, 0xE0, 0x07, 0xCF, 0x80, 0x7E, 0x3F, 0x8F, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x00, 0x3F, 0xBC, 0x01, 0xF8, 0xF0, 0x0F,
  0xC3, 0xC0, 0x3E, 0x0F, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0xF0, 0x08, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x10, 0x00, 0x0F,
  0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xCF, 0xF0, 0xF8, 0x07,
  0xE7, 0xC0, 0x0F, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0xBE, 0x00, 0x7C, 0xF8, 0x07, 0xC7, 0xF9, 0xFE, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x1E,
  0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x8F, 0xE0, 0x3C, 0xFF, 0xC1,
  0xEF, 0xFF, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00,
  0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x80, 0x0F, 0x3C, 0x00, 0xF9, 0xF0, 0x0F, 0xC7, 0xF3, 0xFC, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE3, 0xC0, 0x07,
  0xDF, 0xF0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFE, 0x03, 0xF1, 0xF8,
  0x03, 0xE3, 0xE0, 0x03, 0xE7, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xBE, 0x00,
  0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x0F, 0x80, 0x7E,
  0x0F, 0xE3, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83,
  0xF8, 0xFE, 0x3E, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x1E, 0x78, 0x00,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0xC0, 0x1F, 0x1E,
  0x01, 0xF0, 0xF8, 0x1F, 0x03, 0xF1, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xF8, 0xFC, 0x1F, 0x01, 0xF1, 0xF0,
  0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xCF, 0x80,
  0x3E, 0x7F, 0x9F, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x10, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x01,
  0xFC, 0x7F, 0x07, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x78,
  0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0x3C, 0x00, 0x3E, 0x7C, 0x00,
  0x7C, 0xFC, 0x01, 0xF8, 0xFC, 0x07, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xEF,
  0x00, 0xFF, 0xBE, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x7F, 0x7F, 0xFF,
  0xFF, 0x7F, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x7F, 0x7F, 0xFF, 0xFF, 0x7F, 0x3E, 0x0F,
  0x87, 0xF3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC3, 0xF1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x3E, 0x1F,
  0x07, 0xC1, 0xE0, 0x78, 0x3E, 0x0F, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x00, 0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFC, 0x01, 0xFF, 0x03, 0xFF, 0x80,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x81, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x3F, 0xC0, 0x7F,
  0xDF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3E, 0x0F, 0xF8, 0x1E, 0x03, 0xFC, 0x0F,
  0x01, 0xFE, 0x07, 0x00, 0xFF, 0x03, 0x80, 0x7F, 0x81, 0xC0, 0x3F, 0xC0,
  0xE0, 0x1F, 0xE0, 0x70, 0x0F, 0xF0, 0x38, 0x07, 0xF8, 0x1C, 0x03, 0xFC,
  0x0E, 0x01, 0xFE, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xF0, 0x7F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xEF, 0xF0, 0x0F, 0xE7, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x01,
  0xE7, 0xC0, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xE3, 0xC0, 0x03,
  0xC3, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0xC1, 0xE0, 0x07,
  0x81, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x80, 0xF0, 0x0F,
  0x00, 0xF8, 0x0F, 0x00, 0x78, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x3C, 0x3C,
  0x00, 0x3E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0x7C, 0x00, 0xFB,
  0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x1F, 0x9F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xF9, 0xF0, 0x07,
  0xEF, 0x80, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFC, 0x3F, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xCF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xF0,
  0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0xDF, 0xE0, 0xFF, 0xFE, 0x03, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1E,
  0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF,
  0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80, 0x1F, 0x7C, 0x01, 0xF3, 0xE0, 0x1F,
  0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F, 0x01, 0xF9, 0xF0,
  0x07, 0xCF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x87, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBC,
  0x00, 0x79, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0xDF, 0xE0, 0xFF, 0xFE,
  0x03, 0xFF, 0xE0, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F,
  0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xF0, 0x03, 0xE7, 0xE0, 0x1F, 0x0F,
  0xF3, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xF8,
  0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x07, 0xC0, 0x78, 0x0F, 0x81, 0xF0,
  0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC1, 0xF0,
  0x0F, 0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xFB, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x3F, 0xF7, 0x01, 0xDF,
  0xB8, 0x1E, 0xFD, 0xE0, 0xF7, 0xE7, 0x07, 0x3F, 0x38, 0x39, 0xF9, 0xE3,
  0xCF, 0xC7, 0x1C, 0xFE, 0x38, 0xE7, 0xF1, 0xEF, 0x3F, 0xC7, 0x71, 0xFE,
  0x3B, 0x8F, 0xF1, 0xFC, 0x7F, 0x8F, 0xC3, 0xFC, 0x3E, 0x1F, 0xE1, 0xF0,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xE0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF7, 0x00, 0xFF, 0x78, 0x0F,
  0xF7, 0x80, 0xFF, 0x38, 0x0F, 0xF3, 0xC0, 0xFF, 0x3C, 0x0F, 0xF1, 0xE0,
  0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x8F, 0x0F, 0xF8, 0xF0, 0xFF, 0x8F,
  0x0F, 0xF8, 0x78, 0xFF, 0x87, 0x8F, 0xF8, 0x38, 0xFF, 0x83, 0xCF, 0xF8,
  0x3C, 0xFF, 0x81, 0xCF, 0xF8, 0x1E, 0xFF, 0x81, 0xEF, 0xF8, 0x0F, 0x7F,
  0x80, 0xF7, 0xF8, 0x0F, 0x7F, 0x80, 0x7F, 0xF8, 0x07, 0xFF, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0x80, 0x3F, 0xF8, 0x01, 0xF0, 0x00, 0x20, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xFD, 0xFE, 0x3F, 0x01, 0xF9,
  0xF0, 0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0x3C, 0x00, 0x79, 0xF0, 0x07, 0xCF, 0xC0, 0x7C, 0x3F, 0xDF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF8, 0x01, 0xFB, 0xE0, 0x03, 0xEF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3E, 0xF8, 0x07, 0xFB, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x20, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF9, 0xFE, 0x3F, 0x01, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0xDF, 0xE0, 0xFF,
  0xFE, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFF, 0xFE, 0x03, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0xF8, 0x03, 0xF3, 0xE0, 0x03, 0xEF,
  0x80, 0x0F, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7B, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x3F,
  0xFF, 0x80, 0xF8, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03,
  0xE0, 0xF8, 0x0F, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x00, 0xF8,
  0xF8, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x3C, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0x00, 0x18, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xFC, 0x1F, 0xC7, 0xF0, 0xFC, 0x03,
  0xE3, 0xE0, 0x07, 0x8F, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x00, 0xF7,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x3E,
  0x3F, 0xEF, 0xF8, 0x7F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x1F, 0x7E, 0x03, 0xF3, 0xFD, 0xFE,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xF8, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E,
  0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x78, 0x0F, 0x00, 0x78, 0x0F,
  0x00, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0xC1, 0xF0, 0x07, 0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x03,
  0xC1, 0xE0, 0x03, 0xE3, 0xE0, 0x03, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x01,
  0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01, 0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x77, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7E, 0x00, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x7B,
  0xE0, 0x7C, 0x0F, 0x3C, 0x0D, 0x81, 0xE7, 0x81, 0xB0, 0x3C, 0xF0, 0x36,
  0x07, 0x9E, 0x0E, 0xE0, 0xF3, 0xC1, 0xDC, 0x1E, 0x78, 0x3B, 0x83, 0xCF,
  0x07, 0x70, 0x71, 0xE0, 0xEE, 0x0E, 0x1E, 0x1D, 0xC3, 0xC3, 0xC3, 0x18,
  0x78, 0x78, 0x63, 0x0F, 0x0F, 0x1C, 0x61, 0xE1, 0xE3, 0x8E, 0x3C, 0x3C,
  0x71, 0xC7, 0x87, 0x8E, 0x38, 0xF0, 0xF1, 0xC7, 0x1C, 0x1E, 0x38, 0xE3,
  0x81, 0xC6, 0x1C, 0xF0, 0x3C, 0xC1, 0x9E, 0x07, 0xB8, 0x33, 0xC0, 0xF7,
  0x06, 0x78, 0x1E, 0xE0, 0xEF, 0x03, 0xDC, 0x1D, 0xE0, 0x7B, 0x83, 0xB8,
  0x0F, 0x70, 0x77, 0x01, 0xEC, 0x0E, 0xE0, 0x1D, 0x81, 0xDC, 0x03, 0xB0,
  0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0,
  0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x0F, 0x80,
  0x0F, 0x87, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x3E,
  0x03, 0xE0, 0x0F, 0x01, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0x9F, 0x00, 0x07, 0xC7, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE0,
  0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3E,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0x9E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xF0, 0x01,
  0xE0, 0x78, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x7C, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E,
  0x38, 0x00, 0xF1, 0xE0, 0x07, 0x07, 0x00, 0x78, 0x3C, 0x03, 0x80, 0xE0,
  0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00,
  0x1E, 0x78, 0x00, 0xF7, 0x80, 0x03, 0xBC, 0x00, 0x1E, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE3, 0xF0, 0x3F, 0x1F, 0x00, 0x7C, 0xF0, 0x01,
  0xEF, 0x80, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x80, 0x0F,
  0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x7D, 0xF0, 0x07, 0xEF, 0xC0, 0xFF, 0x3F, 0xFF, 0x78,
  0xFF, 0xF3, 0xC3, 0xFF, 0x1E, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x3E, 0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0xF0, 0x7F, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xDF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0x7E, 0x00, 0xFB,
  0xF8, 0x0F, 0xDF, 0xF1, 0xFC, 0xFB, 0xFF, 0xE7, 0xDF, 0xFE, 0x3E, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3,
  0xF0, 0x7F, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x79, 0xF8,
  0x07, 0xC7, 0xF9, 0xFC, 0x1F, 0xFF, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0xF0, 0xFF,
  0xCF, 0x1F, 0xFE, 0xF3, 0xFF, 0xEF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0xF8,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xF7, 0x80, 0x1F, 0x7C, 0x03, 0xF7, 0xF8, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF,
  0xCF, 0x07, 0xF8, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0,
  0x7F, 0xFF, 0x83, 0xE0, 0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00,
  0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x0F, 0xBC,
  0x00, 0x79, 0xF0, 0x07, 0xC7, 0xE0, 0xFC, 0x1F, 0xFF, 0xE0, 0x7F, 0xFC,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xCF, 0x1F, 0xFE, 0xF3, 0xFF, 0xEF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0x78,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x1F, 0x7E, 0x03,
  0xF3, 0xFD, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF, 0x07, 0xF8, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x7E,
  0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFE, 0x03, 0xEF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF,
  0xE3, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x7F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3F, 0xC0,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x03,
  0xE3, 0xC0, 0x1F, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x03,
  0xC0, 0xF8, 0x0F, 0x03, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x3E, 0x03, 0xC0, 0xFC,
  0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x0F, 0xC3, 0xC0, 0x1F, 0x0F,
  0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00,
  0x0F, 0xC0, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x01, 0xC1, 0xE1, 0xEF, 0xE7, 0xF3, 0xDF, 0xDF,
  0xF7, 0xFF, 0xFF, 0xEF, 0x87, 0xC3, 0xDE, 0x07, 0x07, 0xFC, 0x0E, 0x07,
  0xF8, 0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F,
  0x81, 0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8,
  0x1C, 0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x7F, 0x81,
  0xC0, 0xFF, 0x03, 0x81, 0xFE, 0x07, 0x03, 0xFC, 0x0E, 0x07, 0xF8, 0x1C,
  0x0F, 0xF0, 0x38, 0x1F, 0xE0, 0x70, 0x3F, 0xC0, 0xE0, 0x78, 0x00, 0x7E,
  0x0F, 0x9F, 0xF8, 0xFB, 0xFF, 0xCF, 0xFF, 0xFE, 0xFF, 0x07, 0xEF, 0xC0,
  0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x83, 0xF0, 0x7E, 0x3E, 0x00, 0xF9, 0xE0, 0x07,
  0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0x3E, 0x00, 0xF9, 0xF8, 0x0F, 0xC7, 0xFB, 0xFC, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x07, 0xCF, 0xFC, 0x3E, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0xF0, 0x7F, 0x7E, 0x00, 0xFB, 0xF0, 0x03, 0xDF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0x7E, 0x00, 0xFB, 0xF8, 0x0F, 0xDF, 0xF1, 0xFC, 0xFB, 0xFF, 0xE7, 0xCF,
  0xFE, 0x3E, 0x3F, 0xC1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xCF, 0x1F, 0xFE, 0xF3,
  0xFF, 0xEF, 0x7E, 0x07, 0xF7, 0xC0, 0x3F, 0x78, 0x01, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x7C,
  0x03, 0xF3, 0xF8, 0xFF, 0x3F, 0xFE, 0xF1, 0xFF, 0xCF, 0x07, 0xF8, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x7C,
  0x07, 0xCF, 0xFC, 0x3E, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xE0, 0x3E, 0x7E,
  0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC7, 0xE0, 0x3F, 0x3E, 0x00,
  0x79, 0xE0, 0x03, 0xEF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0xF1, 0xFE,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFE,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xF7, 0xE0,
  0x3E, 0x3F, 0x9F, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0xC0,
  0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x7C, 0x1E, 0x00,
  0xF0, 0x3C, 0x01, 0xE0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x1E,
  0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0xC7, 0xC0,
  0x07, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xFE,
  0x07, 0xC0, 0xEF, 0x03, 0x60, 0x73, 0x83, 0xB0, 0x39, 0xC1, 0xDC, 0x3C,
  0xF0, 0xEE, 0x1E, 0x78, 0x77, 0x0F, 0x3C, 0x33, 0x87, 0x1E, 0x18, 0xC3,
  0x87, 0x1C, 0x61, 0xC3, 0x8E, 0x30, 0xE1, 0xC7, 0x1C, 0xF0, 0xF3, 0x8E,
  0x78, 0x79, 0x87, 0x38, 0x3C, 0xC3, 0x9C, 0x0E, 0x60, 0xCE, 0x07, 0x70,
  0x67, 0x03, 0xB8, 0x3B, 0x81, 0xDC, 0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7E,
  0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x7C, 0x00,
  0x7E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0xF8,
  0x0F, 0x80, 0xF8, 0x07, 0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0x03, 0xE3, 0xC0,
  0x01, 0xF7, 0xC0, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF7, 0x80,
  0x01, 0xF7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0xC1, 0xF0,
  0x0F, 0x80, 0xF8, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x79,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0xC0, 0x1F, 0x0F,
  0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xC0, 0x3E,
  0x07, 0x80, 0x7C, 0x1F, 0x00, 0x78, 0x3C, 0x00, 0xF8, 0x78, 0x00, 0xF1,
  0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xBC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7F,
  0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x00,
  0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x1E, 0x7F, 0xC0,
  0x3D, 0xFF, 0xC0, 0x7B, 0xFF, 0xC0, 0xFF, 0x8F, 0x81, 0xFE, 0x0F, 0x87,
  0xBC, 0x0F, 0xFF, 0x78, 0x0F, 0xFE, 0xF0, 0x0F, 0xF9, 0xE0, 0x07, 0xC0,
};

const GFXglyph JetBrainsMono_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 7, 35, 29, 11, -35 },
  { 32, 15, 14, 29, 7, -35 },
  { 59, 25, 35, 29, 2, -35 },
  { 169, 22, 49, 29, 3, -42 },
  { 304, 27, 35, 29, 1, -35 },
  { 423, 24, 36, 29, 3, -36 },
  { 531, 4, 14, 29, 12, -35 },
  { 538, 14, 46, 29, 9, -40 },
  { 619, 14, 46, 29, 6, -40 },
  { 700, 25, 24, 29, 2, -29 },
  { 775, 23, 22, 29, 3, -27 },
  { 839, 10, 15, 29, 8, -7 },
  { 858, 15, 4, 29, 7, -18 },
  { 866, 8, 7, 29, 10, -7 },
  { 873, 21, 45, 29, 4, -40 },
  { 992, 21, 36, 29, 4, -36 },
  { 1087, 22, 35, 29, 4, -35 },
  { 1184, 22, 36, 29, 3, -36 },
  { 1283, 21, 35, 29, 3, -35 },
  { 1375, 20, 35, 29, 4, -35 },
  { 1463, 21, 35, 29, 4, -35 },
  { 1555, 23, 35, 29, 3, -35 },
  { 1656, 22, 35, 29, 4, -35 },
  { 1753, 21, 36, 29, 4, -36 },
  { 1848, 23, 36, 29, 3, -36 },
  { 1952, 8, 27, 29, 10, -27 },
  { 1979, 10, 35, 29, 8, -27 },
  { 2023, 21, 26, 29, 4, -29 },
  { 2092, 21, 16, 29, 4, -24 },
  { 2134, 21, 26, 29, 4, -29 },
  { 2203, 18, 35, 29, 6, -35 },
  { 2282, 25, 45, 29, 2, -36 },
  { 2423, 24, 35, 29, 2, -35 },
  { 2528, 21, 35, 29, 4, -35 },
  { 2620, 21, 36, 29, 4, -36 },
  { 2715, 21, 35, 29, 4, -35 },
  { 2807, 20, 35, 29, 5, -35 },
  { 2895, 20, 35, 29, 5, -35 },
  { 2983, 21, 36, 29, 4, -36 },
  { 3078, 20, 35, 29, 4, -35 },
  { 3166, 19, 35, 29, 5, -35 },
  { 3250, 22, 35, 29, 2, -35 },
  { 3347, 23, 35, 29, 4, -35 },
  { 3448, 20, 35, 29, 6, -35 },
  { 3536, 21, 35, 29, 4, -35 },
  { 3628, 20, 35, 29, 4, -35 },
  { 3716, 21, 36, 29, 4, -36 },
  { 3811, 22, 35, 29, 4, -35 },
  { 3908, 21, 45, 29, 4, -36 },
  { 4027, 22, 35, 29, 4, -35 },
  { 4124, 22, 36, 29, 3, -36 },
  { 4223, 23, 35, 29, 3, -35 },
  { 4324, 20, 35, 29, 4, -35 },
  { 4412, 24, 35, 29, 2, -35 },
  { 4517, 27, 35, 29, 1, -35 },
  { 4636, 25, 35, 29, 2, -35 },
  { 4746, 25, 35, 29, 2, -35 },
  { 4856, 21, 35, 29, 4, -35 },
  { 4948, 12, 45, 29, 10, -40 },
  { 5016, 21, 45, 29, 4, -40 },
  { 5135, 12, 45, 29, 7, -40 },
  { 5203, 21, 19, 29, 4, -35 },
  { 5253, 23, 4, 29, 3, 1 },
  { 5265, 10, 7, 29, 9, -38 },
  { 5274, 21, 27, 29, 3, -27 },
  { 5345, 21, 35, 29, 4, -35 },
  { 5437, 21, 27, 29, 4, -27 },
  { 5508, 20, 35, 29, 4, -35 },
  { 5596, 21, 27, 29, 4, -27 },
  { 5667, 23, 35, 29, 3, -35 },
  { 5768, 20, 36, 29, 4, -27 },
  { 5858, 20, 35, 29, 4, -35 },
  { 5946, 23, 37, 29, 4, -37 },
  { 6053, 18, 46, 29, 4, -37 },
  { 6157, 22, 35, 29, 5, -35 },
  { 6254, 25, 35, 29, 1, -35 },
  { 6364, 23, 27, 29, 3, -27 },
  { 6442, 20, 27, 29, 4, -27 },
  { 6510, 21, 27, 29, 4, -27 },
  { 6581, 21, 36, 29, 4, -27 },
  { 6676, 20, 36, 29, 4, -27 },
  { 6766, 21, 27, 29, 5, -27 },
  { 6837, 21, 27, 29, 4, -27 },
  { 6908, 22, 34, 29, 3, -34 },
  { 7002, 20, 26, 29, 4, -26 },
  { 7067, 23, 26, 29, 3, -26 },
  { 7142, 25, 26, 29, 2, -26 },
  { 7224, 24, 26, 29, 2, -26 },
  { 7302, 23, 35, 29, 3, -26 },
  { 7403, 20, 26, 29, 4, -26 },
  { 7468, 21, 45, 29, 4, -40 },
  { 7587, 5, 45, 29, 12, -40 },
  { 7616, 21, 45, 29, 4, -40 },
  { 7735, 23, 10, 29, 3, -22 },
};

const GFXfont JetBrainsMono_Regular48pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular48pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular48pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _JETBRAINSMONO_REGULAR48PT7B_H_
