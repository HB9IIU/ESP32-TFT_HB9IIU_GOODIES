#ifndef _JETBRAINSMONO_REGULAR27PT7B_H_
#define _JETBRAINSMONO_REGULAR27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x0F, 0xFF, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0xC3, 0xC3, 0x06, 0x18, 0x18, 0x60, 0xC1,
  0x83, 0x0C, 0x0C, 0x30, 0x30, 0xC7, 0xFF, 0xC2, 0x0C, 0x18, 0x20, 0x61,
  0x81, 0x86, 0x06, 0x18, 0x18, 0x63, 0xFF, 0xEF, 0xFF, 0x8C, 0x30, 0x30,
  0xC0, 0xC3, 0x06, 0x0C, 0x18, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xF8,
  0x3F, 0xC7, 0xEE, 0x66, 0x76, 0x67, 0xE6, 0x06, 0x60, 0x76, 0x07, 0xE0,
  0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x67, 0x06, 0x30, 0x63, 0xC6, 0x3E, 0x67,
  0x76, 0x77, 0xFE, 0x1F, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x3C,
  0x03, 0x7E, 0x06, 0x63, 0x0C, 0xC3, 0x0C, 0xC3, 0x18, 0xC3, 0x30, 0x63,
  0x30, 0x7E, 0x60, 0x3E, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x3C, 0x07,
  0x7E, 0x06, 0xE7, 0x0C, 0xC3, 0x18, 0xC3, 0x18, 0xC3, 0x30, 0xC3, 0x60,
  0x7E, 0xE0, 0x3C, 0x0F, 0x80, 0x7F, 0x03, 0x8E, 0x0C, 0x18, 0x30, 0x70,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xF8, 0x07, 0x61, 0xD9, 0xC6,
  0xE3, 0xBB, 0x87, 0xCE, 0x0F, 0x38, 0x38, 0x60, 0xF1, 0xC7, 0xC7, 0xF9,
  0x8F, 0xC7, 0xFF, 0xFF, 0x01, 0x07, 0x0F, 0x1C, 0x38, 0x70, 0x60, 0xE0,
  0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60,
  0x70, 0x70, 0x38, 0x1E, 0x0F, 0x03, 0x80, 0xE0, 0xF8, 0x3C, 0x1C, 0x0E,
  0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x07, 0x07, 0x06, 0x0E, 0x1C, 0x78, 0xF0, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x20, 0xC1, 0xF3, 0x3F, 0xFD, 0xF1, 0xFF, 0x00, 0xC0, 0x07, 0x80,
  0x33, 0x01, 0xCE, 0x0E, 0x1C, 0x38, 0x30, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x3C, 0xE3, 0x8E, 0x71, 0xC6, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x1C,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0,
  0x00, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE2, 0x3E, 0x73, 0xEF, 0x3E, 0x63, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0x07, 0x00, 0xF8, 0x0F, 0xC0,
  0xE6, 0x0E, 0x30, 0x61, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFC, 0x70, 0xEE, 0x07, 0xE0, 0x7C,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x0F, 0x80,
  0xFE, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x07, 0xE0, 0x67,
  0x0E, 0x7F, 0xC1, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07, 0x00,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x87, 0x70, 0x7E, 0x07, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x7F, 0xE7,
  0xFE, 0x7F, 0xE6, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x78, 0x7F, 0xE7,
  0x8E, 0x70, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x77,
  0x0E, 0x3F, 0xE1, 0xF8, 0x03, 0x80, 0x30, 0x07, 0x00, 0xE0, 0x0E, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x7F, 0xC7, 0xFE, 0xF0, 0xFE, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00,
  0xE0, 0x0C, 0x01, 0xC0, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60, 0x76,
  0x07, 0x60, 0x67, 0x0E, 0x39, 0xC0, 0xF8, 0x1F, 0x83, 0x8E, 0x60, 0x6E,
  0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x77, 0x0E, 0x7F, 0xE1, 0xF8, 0x1F, 0x83,
  0xFC, 0x78, 0xEE, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7E,
  0x07, 0x7F, 0xF3, 0xFE, 0x0C, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00,
  0x60, 0x0E, 0x01, 0xC0, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x06, 0xFF, 0xF0,
  0x7B, 0xDE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x77, 0xB9, 0xCC, 0xE7, 0x30,
  0x00, 0x10, 0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x0E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x07, 0x01, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xF0, 0x0C, 0x00, 0xF8, 0x7F, 0x3F, 0xC0, 0x70, 0x38,
  0x0C, 0x06, 0x03, 0x03, 0x87, 0x8F, 0x87, 0x03, 0x01, 0x80, 0x00, 0x00,
  0x00, 0x3C, 0x1E, 0x0F, 0x00, 0x07, 0xC0, 0x7F, 0xC3, 0x83, 0x9C, 0x07,
  0x60, 0x0F, 0x80, 0x3C, 0x00, 0xF0, 0x7B, 0xC3, 0xFF, 0x0C, 0x3C, 0x70,
  0xF1, 0xC3, 0xC7, 0x0F, 0x1C, 0x3C, 0x70, 0xF0, 0xC3, 0xC3, 0x9F, 0x0F,
  0xFC, 0x04, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x0E, 0xC0, 0x33, 0x00,
  0xCC, 0x03, 0x38, 0x1C, 0x60, 0x61, 0x81, 0x86, 0x06, 0x1C, 0x38, 0x30,
  0xFF, 0xC3, 0xFF, 0x1C, 0x0E, 0x70, 0x19, 0x80, 0x66, 0x01, 0xB8, 0x07,
  0xFE, 0x1F, 0xF3, 0x1F, 0x60, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC3,
  0xDF, 0xE3, 0xFF, 0x60, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xF8,
  0x3F, 0xFF, 0x7F, 0x80, 0x0F, 0x83, 0xFC, 0x78, 0xE6, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x07, 0x60, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0xFE, 0x0F,
  0xFC, 0xE3, 0xEE, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x6E,
  0x1E, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xFB, 0xFF, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x00,
  0x0F, 0x83, 0xFC, 0x78, 0xE6, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE3, 0xFE, 0x3F, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07,
  0x60, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x70, 0xFF, 0xFF,
  0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x07,
  0xF0, 0x7F, 0x07, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x77, 0x0F, 0x3F, 0xE1, 0xFC, 0xE0, 0x3F, 0x01, 0xB8, 0x1D, 0xC0, 0xCE,
  0x0E, 0x70, 0xE3, 0x87, 0x1C, 0x70, 0xE3, 0x87, 0xF8, 0x3F, 0xC1, 0xC7,
  0x0E, 0x18, 0x70, 0xE3, 0x83, 0x1C, 0x1C, 0xE0, 0x67, 0x03, 0xB8, 0x0D,
  0xC0, 0x70, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xFF, 0xFF, 0xF0, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F,
  0xD8, 0xFD, 0x9B, 0xD9, 0xBC, 0xDB, 0xCF, 0x3C, 0xF3, 0xC7, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xF0, 0x7F, 0x07, 0xF0, 0x7F, 0x87, 0xF8, 0x7F, 0xC7, 0xEC, 0x7E, 0xC7,
  0xEE, 0x7E, 0x67, 0xE6, 0x7E, 0x37, 0xE3, 0x7E, 0x37, 0xE1, 0xFE, 0x1B,
  0xE1, 0xBE, 0x0F, 0xE0, 0xFE, 0x0F, 0x1F, 0x83, 0xFC, 0x78, 0xE6, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x0E, 0x3F, 0xE1, 0xF8,
  0xFF, 0x87, 0xFF, 0x38, 0x7D, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x37, 0x07, 0xBF, 0xF9, 0xFF, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1F, 0x83, 0xFC,
  0x78, 0xE6, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x77, 0x0E,
  0x3F, 0xE1, 0xF8, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0xFF,
  0x07, 0xFE, 0x38, 0x79, 0xC0, 0xEE, 0x03, 0x70, 0x1B, 0x80, 0xDC, 0x06,
  0xE0, 0x77, 0xFF, 0x3F, 0xF1, 0xFF, 0x0E, 0x38, 0x70, 0xE3, 0x87, 0x1C,
  0x1C, 0xE0, 0xE7, 0x03, 0xB8, 0x1D, 0xC0, 0x70, 0x0F, 0x83, 0xFC, 0x78,
  0xE6, 0x07, 0x60, 0x7E, 0x00, 0x60, 0x07, 0x00, 0x7C, 0x03, 0xF8, 0x0F,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x00, 0x3C, 0x03, 0xE0, 0x77, 0x0F, 0x7F,
  0xE1, 0xFC, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0x60, 0x77, 0x0E, 0x3F, 0xE1, 0xF8, 0xE0, 0x1D, 0x80, 0x76, 0x01,
  0x9C, 0x06, 0x70, 0x38, 0xC0, 0xE3, 0x03, 0x0E, 0x0C, 0x38, 0x70, 0x61,
  0x81, 0x86, 0x07, 0x18, 0x1C, 0xE0, 0x33, 0x00, 0xCC, 0x03, 0xB0, 0x07,
  0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xC3, 0x0F, 0x87, 0x1B, 0x0E, 0x36,
  0x3C, 0x6C, 0x78, 0xDC, 0xD1, 0xB9, 0xA3, 0x73, 0x46, 0x64, 0x9C, 0xC9,
  0x31, 0x93, 0x63, 0x66, 0xC6, 0xCD, 0x8D, 0x9B, 0x1B, 0x16, 0x3E, 0x2C,
  0x38, 0x58, 0x70, 0xB0, 0xE1, 0xC1, 0xC3, 0x80, 0xE0, 0x1D, 0xC0, 0xE3,
  0x03, 0x8E, 0x1C, 0x18, 0x60, 0x73, 0x80, 0xCC, 0x03, 0xF0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0xC0, 0x33, 0x81, 0xCE, 0x06, 0x1C,
  0x38, 0x71, 0xC0, 0xE7, 0x01, 0xB8, 0x07, 0xE0, 0x0D, 0x80, 0x77, 0x01,
  0x9C, 0x0E, 0x30, 0x30, 0xE1, 0xC1, 0x86, 0x07, 0x38, 0x0C, 0xC0, 0x3F,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F, 0xFC, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0xFF, 0xFC, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0xFF, 0xFE, 0x06, 0x00, 0xF0, 0x0F, 0x00,
  0xD8, 0x19, 0x81, 0x8C, 0x30, 0xC3, 0x0E, 0x60, 0x66, 0x06, 0xE0, 0x30,
  0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x87, 0x1F, 0x83, 0xFE, 0x70, 0xE6,
  0x07, 0x00, 0x70, 0x07, 0x0F, 0xF7, 0xFF, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0xF7, 0xFF, 0x3F, 0x70, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x78, 0xFF, 0xEF, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0E, 0xFF, 0xEE, 0xFC,
  0x1F, 0x83, 0xFE, 0x70, 0xE6, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x36, 0x07, 0x70, 0xE3, 0xFE, 0x1F, 0x80, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x71, 0xF7, 0x3F, 0xF7, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x77, 0x0F, 0x7F, 0xF3, 0xF7, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x07, 0xE0,
  0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x07, 0x70,
  0x63, 0xFE, 0x1F, 0xC0, 0x01, 0xF0, 0x7F, 0x0F, 0xF0, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x0F, 0xFF, 0xFF, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1F, 0x73,
  0xFF, 0x70, 0xF6, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0x60, 0x77, 0x0F, 0x3F, 0xF1, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x0E, 0x3F, 0xE3, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0xF8, 0xFF, 0xEF, 0x0E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xC0, 0xF0,
  0x1C, 0x00, 0x00, 0x00, 0x07, 0xFD, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x18, 0x1E, 0xFF, 0x3F, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x07, 0xC0, 0xEC, 0x0C, 0xC1, 0xCC, 0x38, 0xC7, 0x0F, 0xE0,
  0xFE, 0x0C, 0x70, 0xC3, 0x0C, 0x38, 0xC1, 0xCC, 0x0C, 0xC0, 0xEC, 0x07,
  0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3F, 0xC0, 0x7F, 0xDC,
  0xEF, 0xFF, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6,
  0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x30, 0xEF, 0x8F,
  0xFE, 0xF0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0x1F, 0x83, 0xFC,
  0x70, 0xE6, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x76, 0x07, 0x70, 0xE3, 0xFE, 0x1F, 0x80, 0xE7, 0x8F, 0xFE, 0xF0,
  0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0xEF, 0xFE, 0xEF, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x1F, 0x73, 0xFF, 0x70, 0xF6, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0xF7, 0xFF, 0x3F,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xCF, 0x9B, 0xFB, 0xC3,
  0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x00, 0x1F, 0xC3, 0xFE, 0x70, 0x76, 0x07, 0x60,
  0x07, 0x00, 0x7F, 0x03, 0xFE, 0x03, 0xE0, 0x07, 0x00, 0x3E, 0x03, 0x70,
  0x77, 0xFE, 0x3F, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x0F, 0xFF,
  0xFF, 0xFC, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x3F, 0xC0, 0xFE, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x76, 0x07, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0xE0, 0x1D,
  0x80, 0x67, 0x03, 0x8C, 0x0E, 0x30, 0x30, 0xE0, 0xC1, 0x87, 0x06, 0x18,
  0x1C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0xB0, 0x07, 0xC0, 0x1E, 0x00, 0x78,
  0x00, 0xC3, 0x0F, 0x0C, 0x3C, 0x38, 0xF9, 0xE3, 0x67, 0x8D, 0x9A, 0x66,
  0x49, 0x99, 0x26, 0x64, 0xD9, 0xB3, 0x63, 0xCD, 0x8F, 0x14, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x00, 0x70, 0x3C, 0xC0, 0xE3, 0x87, 0x07, 0x18, 0x0C,
  0xE0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x01, 0xCE, 0x07,
  0x18, 0x38, 0x71, 0xC0, 0xEF, 0x01, 0xC0, 0xE0, 0x1D, 0xC0, 0x67, 0x03,
  0x8C, 0x0C, 0x38, 0x30, 0x61, 0xC1, 0xC6, 0x07, 0x38, 0x0C, 0xE0, 0x3B,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x7F, 0xE7, 0xFE, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x3F, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0F, 0xE0, 0xFC,
  0x00, 0xF0, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x1F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0x0C, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x7F, 0x03, 0xF0, 0xF0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xC0, 0x1C,
  0x0F, 0xC0, 0xF0, 0x00, 0x7C, 0x3F, 0xE3, 0xC7, 0x3C, 0x3F, 0xC1, 0xE0,
};

const GFXglyph JetBrainsMono_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 8, 8, 16, 4, -20 },
  { 19, 14, 20, 16, 1, -20 },
  { 54, 12, 27, 16, 2, -23 },
  { 95, 16, 20, 16, 0, -20 },
  { 135, 14, 20, 16, 1, -20 },
  { 170, 2, 8, 16, 7, -20 },
  { 172, 8, 26, 16, 5, -23 },
  { 198, 8, 26, 16, 3, -23 },
  { 224, 14, 13, 16, 1, -16 },
  { 247, 12, 12, 16, 2, -15 },
  { 265, 6, 8, 16, 4, -4 },
  { 271, 8, 2, 16, 4, -10 },
  { 273, 4, 4, 16, 6, -4 },
  { 275, 12, 25, 16, 2, -22 },
  { 313, 12, 20, 16, 2, -20 },
  { 343, 13, 20, 16, 2, -20 },
  { 376, 12, 20, 16, 2, -20 },
  { 406, 12, 20, 16, 2, -20 },
  { 436, 12, 20, 16, 2, -20 },
  { 466, 12, 20, 16, 2, -20 },
  { 496, 12, 20, 16, 2, -20 },
  { 526, 12, 20, 16, 2, -20 },
  { 556, 12, 20, 16, 2, -20 },
  { 586, 12, 20, 16, 2, -20 },
  { 616, 4, 15, 16, 6, -15 },
  { 624, 5, 19, 16, 5, -15 },
  { 636, 12, 14, 16, 2, -16 },
  { 657, 12, 8, 16, 2, -13 },
  { 669, 12, 14, 16, 2, -16 },
  { 690, 9, 20, 16, 4, -20 },
  { 713, 14, 25, 16, 1, -20 },
  { 757, 14, 20, 16, 1, -20 },
  { 792, 11, 20, 16, 3, -20 },
  { 820, 12, 20, 16, 2, -20 },
  { 850, 12, 20, 16, 2, -20 },
  { 880, 11, 20, 16, 3, -20 },
  { 908, 11, 20, 16, 3, -20 },
  { 936, 12, 20, 16, 2, -20 },
  { 966, 11, 20, 16, 3, -20 },
  { 994, 10, 20, 16, 3, -20 },
  { 1019, 12, 20, 16, 1, -20 },
  { 1049, 13, 20, 16, 2, -20 },
  { 1082, 11, 20, 16, 3, -20 },
  { 1110, 12, 20, 16, 2, -20 },
  { 1140, 12, 20, 16, 2, -20 },
  { 1170, 12, 20, 16, 2, -20 },
  { 1200, 13, 20, 16, 2, -20 },
  { 1233, 12, 25, 16, 2, -20 },
  { 1271, 13, 20, 16, 2, -20 },
  { 1304, 12, 20, 16, 2, -20 },
  { 1334, 14, 20, 16, 1, -20 },
  { 1369, 12, 20, 16, 2, -20 },
  { 1399, 14, 20, 16, 1, -20 },
  { 1434, 15, 20, 16, 1, -20 },
  { 1472, 14, 20, 16, 1, -20 },
  { 1507, 14, 20, 16, 1, -20 },
  { 1542, 12, 20, 16, 2, -20 },
  { 1572, 6, 25, 16, 6, -22 },
  { 1591, 12, 25, 16, 2, -22 },
  { 1629, 7, 25, 16, 4, -22 },
  { 1651, 12, 11, 16, 2, -20 },
  { 1668, 13, 2, 16, 2, 1 },
  { 1672, 6, 4, 16, 5, -21 },
  { 1675, 12, 15, 16, 2, -15 },
  { 1698, 12, 20, 16, 2, -20 },
  { 1728, 12, 15, 16, 2, -15 },
  { 1751, 12, 20, 16, 2, -20 },
  { 1781, 12, 15, 16, 2, -15 },
  { 1804, 12, 20, 16, 2, -20 },
  { 1834, 12, 20, 16, 2, -15 },
  { 1864, 12, 20, 16, 2, -20 },
  { 1894, 13, 21, 16, 2, -21 },
  { 1929, 10, 26, 16, 2, -21 },
  { 1962, 12, 20, 16, 3, -20 },
  { 1992, 14, 20, 16, 1, -20 },
  { 2027, 12, 15, 16, 2, -15 },
  { 2050, 12, 15, 16, 2, -15 },
  { 2073, 12, 15, 16, 2, -15 },
  { 2096, 12, 20, 16, 2, -15 },
  { 2126, 12, 20, 16, 2, -15 },
  { 2156, 11, 15, 16, 3, -15 },
  { 2177, 12, 15, 16, 2, -15 },
  { 2200, 13, 19, 16, 1, -19 },
  { 2231, 12, 15, 16, 2, -15 },
  { 2254, 14, 15, 16, 1, -15 },
  { 2281, 14, 15, 16, 1, -15 },
  { 2308, 14, 15, 16, 1, -15 },
  { 2335, 14, 20, 16, 1, -15 },
  { 2370, 12, 15, 16, 2, -15 },
  { 2393, 12, 25, 16, 2, -22 },
  { 2431, 2, 25, 16, 7, -22 },
  { 2438, 12, 25, 16, 2, -22 },
  { 2476, 12, 5, 16, 2, -12 },
};

const GFXfont JetBrainsMono_Regular27pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular27pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular27pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _JETBRAINSMONO_REGULAR27PT7B_H_
