#ifndef _JETBRAINSMONO_REGULAR34PT7B_H_
#define _JETBRAINSMONO_REGULAR34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x79, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0x8C, 0x63,
  0x00, 0x00, 0x7B, 0xFF, 0xF0, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x70, 0x03, 0x83, 0x80, 0xE0, 0xC0, 0x30,
  0x30, 0x0C, 0x0C, 0x03, 0x07, 0x01, 0xC1, 0xC0, 0x70, 0x61, 0xFF, 0xFF,
  0x7F, 0xFF, 0xC1, 0x83, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x0E, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0xC0, 0x30, 0x70, 0xFF, 0xFF, 0xBF, 0xFF, 0xE1, 0x81,
  0x80, 0x60, 0x60, 0x18, 0x38, 0x0E, 0x0E, 0x03, 0x83, 0x00, 0xE0, 0xC0,
  0x30, 0x30, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x39, 0x9E, 0x79, 0x8E, 0x71,
  0x8F, 0x71, 0x80, 0x71, 0x80, 0x79, 0x80, 0x3D, 0x80, 0x3F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF8, 0x01, 0xFC, 0x01, 0xBE, 0x01, 0x8E, 0x01, 0x8F, 0x01,
  0x87, 0x81, 0x87, 0x71, 0x87, 0x71, 0x8F, 0x79, 0x8E, 0x3F, 0xBE, 0x1F,
  0xFC, 0x0F, 0xF0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x1F, 0x00, 0x73, 0xF8, 0x0E, 0x73, 0xC0, 0xC6, 0x1C, 0x1C, 0x61,
  0xC3, 0x86, 0x1C, 0x30, 0x61, 0xC7, 0x06, 0x1C, 0xE0, 0x71, 0xCC, 0x07,
  0xF9, 0xC0, 0x3F, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0xCF, 0xC0, 0x19, 0xFE, 0x03, 0x9C, 0x70, 0x33, 0x87, 0x06, 0x38,
  0x70, 0xE3, 0x87, 0x0C, 0x38, 0x71, 0x83, 0x87, 0x38, 0x1C, 0xF7, 0x01,
  0xFE, 0xE0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF8, 0x0F, 0xFE, 0x0F, 0x07,
  0x07, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0x9C, 0x3F, 0x8F, 0x1D,
  0xC3, 0x9E, 0xE0, 0xEE, 0x70, 0x7E, 0x38, 0x1F, 0x1C, 0x07, 0x0E, 0x03,
  0xC7, 0x03, 0xF3, 0xE7, 0xB8, 0xFF, 0x8E, 0x3F, 0x83, 0x80, 0xFF, 0xFF,
  0xFF, 0xF7, 0x66, 0x00, 0x40, 0x30, 0x3C, 0x1F, 0x0F, 0x07, 0x83, 0xC0,
  0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70, 0x1E, 0x03,
  0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0x40, 0x80, 0x38, 0x0F,
  0x83, 0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x83,
  0xC0, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x18, 0x38, 0x27, 0x8C, 0x7F, 0xFB, 0x7F, 0x3F, 0xFF, 0x00,
  0xFE, 0x00, 0x1E, 0x00, 0x0E, 0xC0, 0x07, 0x38, 0x03, 0xCF, 0x00, 0xE1,
  0xE0, 0x78, 0x38, 0x1C, 0x0F, 0x01, 0x01, 0x00, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x3E, 0x78, 0xF3, 0xC7, 0x8E, 0x1C, 0x78, 0xE1,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x79, 0xFF, 0xFF, 0x78, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0x0F, 0xE0,
  0x7F, 0xE1, 0xFF, 0xE3, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x84, 0x3F, 0x3C, 0x7E, 0x78, 0xFC, 0xF1,
  0xF8, 0xC3, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xDE, 0x07, 0x9F, 0x3E, 0x1F, 0xFC, 0x1F, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x7F, 0x03, 0xEE, 0x0F, 0x1C, 0x1C, 0x38, 0x30, 0x70, 0x40, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x3F, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x77,
  0x00, 0xEF, 0x03, 0xCF, 0x9F, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x78, 0x01,
  0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x0E, 0x07, 0x78, 0x1D, 0xC0, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF3, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xCF, 0xE3,
  0xBF, 0xE7, 0xE7, 0xEF, 0x03, 0xDE, 0x03, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xEE, 0x01, 0xDE, 0x07, 0x9F, 0x3E,
  0x1F, 0xFC, 0x1F, 0xE0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x0E, 0x70, 0x0F, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x70, 0x07, 0x70, 0x0F, 0x78, 0x1E,
  0x3F, 0x7C, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xB8, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0x81,
  0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0x70, 0x3C, 0xF0, 0x70,
  0xF3, 0xC0, 0x7F, 0x00, 0xFC, 0x07, 0xFE, 0x1E, 0x1E, 0x38, 0x1E, 0xE0,
  0x1D, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDE, 0x03, 0x9F, 0x3F,
  0x1F, 0xFC, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xF8, 0x3F, 0xFC, 0x78, 0x1E,
  0x70, 0x0F, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0x70, 0x0F, 0x78, 0x0F, 0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xDC, 0x03, 0x3C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x79, 0xFF, 0xDF, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0xFF, 0xF7, 0x80, 0x3C, 0xFD, 0xFB,
  0xF3, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x9E, 0x3C,
  0x71, 0xE3, 0xC7, 0x0E, 0x38, 0x70, 0x00, 0x06, 0x00, 0x3C, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1E, 0x00, 0x3C, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x00, 0xE0, 0x01, 0x00, 0x00, 0xFC,
  0x0F, 0xF8, 0xFF, 0xC0, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x3E, 0x3F, 0xC3, 0xF0, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x3C,
  0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0x87, 0x8F, 0x00, 0xE7, 0x00, 0x77,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x7F, 0xF0, 0x7F,
  0x78, 0x78, 0x7C, 0x38, 0x3E, 0x1C, 0x1F, 0x0E, 0x0F, 0x87, 0x07, 0xC3,
  0x83, 0xE1, 0xC1, 0xF0, 0xE0, 0xF8, 0x70, 0x7C, 0x1C, 0x7E, 0x0F, 0xEF,
  0x03, 0xE7, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x76, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x1C, 0xE0,
  0x0E, 0x70, 0x07, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE0,
  0xE0, 0xE0, 0x70, 0x70, 0x38, 0x3F, 0xFE, 0x1F, 0xFF, 0x1C, 0x03, 0x8E,
  0x01, 0xC7, 0x00, 0xF3, 0x80, 0x3B, 0x80, 0x1D, 0xC0, 0x0E, 0xE0, 0x07,
  0x80, 0xFF, 0x81, 0xFF, 0xE3, 0xFF, 0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x7B, 0x81, 0xE7, 0xFF, 0x8F,
  0xFF, 0x1C, 0x1F, 0x38, 0x07, 0x70, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x07, 0xBF, 0xFF, 0x7F, 0xFC, 0xFF, 0xE0,
  0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0x81, 0xEF, 0x01, 0xDC, 0x03, 0xB8,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x3F,
  0x00, 0xFF, 0x01, 0xCE, 0x07, 0x9F, 0xBE, 0x1F, 0xFC, 0x1F, 0xE0, 0xFF,
  0x83, 0xFF, 0x8F, 0xFF, 0xB8, 0x1E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F,
  0x81, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0xFF, 0xCF, 0xFF, 0x9C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xB8, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0x81,
  0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x1F, 0xFC, 0x3F, 0xF8, 0x7F, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0x01, 0xCE, 0x07, 0x9F, 0xBE,
  0x1F, 0xFC, 0x1F, 0xE0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x0F, 0xF8, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xDE, 0x07, 0x9F, 0x3E,
  0x1F, 0xFC, 0x1F, 0xE0, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x1C,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE1, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xE1, 0xE0, 0xE0, 0xE0,
  0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C,
  0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0xC1, 0xBD, 0x87, 0x7B,
  0x0F, 0xF7, 0x1B, 0xEE, 0x37, 0xCC, 0xEF, 0x9D, 0x9F, 0x3B, 0x3E, 0x3E,
  0x7C, 0x78, 0xFC, 0xF1, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0E, 0xF0, 0x1F, 0xE0, 0x7F, 0x81, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x7E,
  0xC1, 0xFB, 0x87, 0xEE, 0x1F, 0x98, 0x7E, 0x71, 0xF9, 0xC7, 0xE3, 0x9F,
  0x8E, 0x7E, 0x19, 0xF8, 0x77, 0xE1, 0xDF, 0x83, 0x7E, 0x0E, 0xF8, 0x3B,
  0xE0, 0x6F, 0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3C, 0x0F, 0xE0, 0xFF,
  0xC7, 0xFF, 0x9C, 0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xF7,
  0xEF, 0x8F, 0xFC, 0x1F, 0xE0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xE0,
  0x3E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF,
  0xE3, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x01, 0xDE, 0x07,
  0x9F, 0x3E, 0x1F, 0xFC, 0x1F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8,
  0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xE1, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38,
  0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0F, 0x07, 0xF0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x0F, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0xF8, 0x01, 0xFC,
  0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x70, 0x07,
  0x70, 0x0F, 0x78, 0x0E, 0x3F, 0x7E, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xF0, 0x1D, 0xC0, 0xF7, 0xCF, 0x8F, 0xFC, 0x1F, 0xE0,
  0xE0, 0x03, 0xF0, 0x03, 0xB8, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80,
  0x71, 0xC0, 0x38, 0x70, 0x1C, 0x38, 0x0E, 0x1C, 0x0E, 0x0E, 0x07, 0x03,
  0x83, 0x81, 0xC1, 0xC0, 0xE1, 0xC0, 0x70, 0xE0, 0x1C, 0x70, 0x0E, 0x30,
  0x07, 0x38, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x76, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0xE0, 0xFC, 0x1C, 0x1B, 0x87,
  0x83, 0x70, 0xF0, 0xEE, 0x1E, 0x1D, 0xC3, 0x43, 0x98, 0x6C, 0x73, 0x8D,
  0x8E, 0x71, 0xB1, 0xCE, 0x26, 0x31, 0xCC, 0xC6, 0x39, 0x98, 0xC7, 0x33,
  0x38, 0xE6, 0x67, 0x1C, 0xC4, 0xE1, 0x98, 0xDC, 0x33, 0x1B, 0x87, 0x43,
  0x70, 0xF8, 0x6C, 0x1F, 0x0D, 0x83, 0xE1, 0xB0, 0x7C, 0x36, 0x0F, 0x87,
  0xC0, 0xF0, 0x78, 0x1E, 0x0F, 0x00, 0x70, 0x03, 0xDE, 0x00, 0xE3, 0x80,
  0x70, 0x70, 0x1C, 0x1E, 0x0E, 0x03, 0x87, 0x80, 0xF1, 0xC0, 0x1C, 0xF0,
  0x07, 0xB8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0x38, 0x01, 0xCF, 0x00, 0xE1,
  0xC0, 0x78, 0x38, 0x1C, 0x0F, 0x0F, 0x01, 0xC3, 0x80, 0x79, 0xE0, 0x0E,
  0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x38, 0xE0, 0x1E,
  0x38, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x1C, 0x01,
  0xC7, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x76, 0x00, 0xCE,
  0x03, 0x9C, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x30, 0x60, 0x71, 0xC0, 0x63,
  0x00, 0xEE, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0xE0, 0xE0,
  0xE0, 0x07, 0xF0, 0x3F, 0xF0, 0xFF, 0xF1, 0xC0, 0xF7, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x0F, 0xFE, 0x7F, 0xFD, 0xF0, 0x3B, 0x80, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x78, 0x3E, 0x7F, 0xDC, 0x7F,
  0x38, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0xF8, 0x77, 0xF8, 0xEF, 0xF9, 0xF0, 0x7B, 0xC0, 0x77, 0x00, 0xEE,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xEF, 0x01, 0xDE, 0x07, 0xBF, 0x3F, 0x77, 0xFC, 0xE7, 0xF0,
  0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xF8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x03, 0xF8, 0x07, 0x38, 0x1E, 0x7E, 0xFC, 0x7F, 0xF0, 0x7F, 0x80,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x71, 0xF9,
  0xCF, 0xF7, 0x7F, 0xFD, 0xC0, 0xFF, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0xC0, 0xF7, 0xCF, 0xCF, 0xF7, 0x1F, 0x9C, 0x0F, 0xC0, 0x7F, 0xE1,
  0xFF, 0xE3, 0x81, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x07,
  0x38, 0x0E, 0x7C, 0x7C, 0x7F, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x1F, 0x9C,
  0xFF, 0x77, 0xFF, 0xDC, 0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0xF7, 0x83,
  0xDF, 0xFF, 0x3F, 0xDC, 0x3C, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x73, 0xFF, 0xCF, 0xFE, 0x3F, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x3E, 0x3B, 0xFC, 0xEF, 0xFB, 0xE0, 0xFF,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1C, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x7F, 0xF3, 0xFF, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x7F, 0xE3, 0xFE, 0x1F, 0xE0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0F,
  0xE0, 0x1E, 0xE0, 0x1C, 0xE0, 0x3C, 0xE0, 0x78, 0xE0, 0x70, 0xE0, 0xE0,
  0xE1, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0,
  0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0F,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x7F, 0xC0, 0xEF, 0x1C, 0xFF,
  0xBE, 0xF3, 0xEF, 0xE1, 0xC7, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1,
  0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE3,
  0xE3, 0xBF, 0xCE, 0xFF, 0xBE, 0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x0F, 0xC0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xB8,
  0x07, 0x38, 0x1E, 0x7E, 0xF8, 0x7F, 0xE0, 0x7F, 0x80, 0xE3, 0xE1, 0xDF,
  0xF3, 0xBF, 0xE7, 0xC1, 0xEF, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xBC,
  0x07, 0x78, 0x1E, 0xFC, 0xFD, 0xDF, 0xF3, 0x9F, 0xC7, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x1F, 0x9C, 0xFF, 0x77,
  0xFF, 0xDC, 0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x0F,
  0x7C, 0xFC, 0xFF, 0x71, 0xF9, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0xE7, 0xE3, 0xBF, 0xCF, 0xFF, 0xBC, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x0F, 0xE0, 0x7F, 0xF1, 0xFF, 0xF3, 0x80, 0xE7, 0x01, 0xDE,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x03, 0xF8, 0x0E, 0x7C, 0xFC, 0xFF, 0xF0,
  0x7F, 0xC0, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0xFE, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x01, 0xDC, 0x0F, 0x7C, 0xF8, 0xFF, 0xC1, 0xFE, 0x00,
  0xE0, 0x07, 0xF0, 0x03, 0x9C, 0x01, 0xCE, 0x01, 0xC7, 0x00, 0xE1, 0xC0,
  0x70, 0xE0, 0x70, 0x70, 0x38, 0x1C, 0x1C, 0x0E, 0x1C, 0x07, 0x0E, 0x01,
  0xC7, 0x00, 0xE3, 0x00, 0x73, 0x80, 0x1D, 0xC0, 0x0E, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0xE0, 0xF8, 0x38, 0x76, 0x1E, 0x1D,
  0x87, 0x87, 0x71, 0xE1, 0xDC, 0x68, 0x67, 0x1B, 0x19, 0xC4, 0xC6, 0x33,
  0x33, 0x8C, 0xCC, 0xE3, 0x33, 0x38, 0xCC, 0x4C, 0x3B, 0x1B, 0x0E, 0x86,
  0xC3, 0xA1, 0xB0, 0x78, 0x7C, 0x1E, 0x1F, 0x07, 0x87, 0x81, 0xE0, 0xE0,
  0xF0, 0x07, 0x38, 0x07, 0x8E, 0x07, 0x87, 0x83, 0x81, 0xC3, 0x80, 0x73,
  0xC0, 0x3D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xF7, 0x00, 0xF3, 0xC0, 0x70, 0xF0, 0x78, 0x38, 0x78, 0x1E,
  0x38, 0x07, 0xBC, 0x01, 0xE0, 0xE0, 0x07, 0xF8, 0x03, 0x9C, 0x03, 0xCE,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xF0, 0xF0, 0x70, 0x38, 0x38, 0x1C, 0x38,
  0x07, 0x1C, 0x03, 0x8E, 0x01, 0xCE, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x01,
  0xFC, 0x07, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x3F,
  0xE0, 0x7F, 0x80, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xFF, 0x80, 0xFF, 0x03, 0xFE, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x78, 0x00, 0x3F, 0x07, 0x7F,
  0x87, 0xF3, 0xC7, 0xE1, 0xC7, 0xE0, 0xFF, 0xE0, 0x7E, 0x00, 0x10,
};

const GFXglyph JetBrainsMono_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 25, 20, 8, -25 },
  { 17, 10, 10, 20, 5, -25 },
  { 30, 18, 25, 20, 1, -25 },
  { 87, 16, 35, 20, 2, -30 },
  { 157, 20, 25, 20, 0, -25 },
  { 220, 17, 25, 20, 2, -25 },
  { 274, 4, 10, 20, 8, -25 },
  { 279, 10, 33, 20, 6, -29 },
  { 321, 10, 33, 20, 4, -29 },
  { 363, 18, 18, 20, 1, -21 },
  { 404, 16, 16, 20, 2, -19 },
  { 436, 7, 10, 20, 6, -5 },
  { 445, 11, 3, 20, 5, -13 },
  { 450, 6, 5, 20, 7, -5 },
  { 454, 15, 32, 20, 3, -28 },
  { 514, 15, 25, 20, 3, -25 },
  { 561, 15, 25, 20, 3, -25 },
  { 608, 16, 25, 20, 2, -25 },
  { 658, 15, 25, 20, 2, -25 },
  { 705, 14, 25, 20, 3, -25 },
  { 749, 15, 25, 20, 3, -25 },
  { 796, 16, 25, 20, 2, -25 },
  { 846, 15, 25, 20, 3, -25 },
  { 893, 15, 25, 20, 3, -25 },
  { 940, 16, 25, 20, 2, -25 },
  { 990, 6, 19, 20, 7, -19 },
  { 1005, 7, 24, 20, 6, -19 },
  { 1026, 15, 18, 20, 3, -20 },
  { 1060, 15, 11, 20, 3, -17 },
  { 1081, 15, 18, 20, 3, -20 },
  { 1115, 12, 25, 20, 5, -25 },
  { 1153, 17, 31, 20, 2, -25 },
  { 1219, 17, 25, 20, 2, -25 },
  { 1273, 15, 25, 20, 3, -25 },
  { 1320, 15, 25, 20, 3, -25 },
  { 1367, 14, 25, 20, 3, -25 },
  { 1411, 15, 25, 20, 3, -25 },
  { 1458, 15, 25, 20, 3, -25 },
  { 1505, 15, 25, 20, 3, -25 },
  { 1552, 14, 25, 20, 3, -25 },
  { 1596, 13, 25, 20, 4, -25 },
  { 1637, 15, 25, 20, 2, -25 },
  { 1684, 16, 25, 20, 3, -25 },
  { 1734, 14, 25, 20, 4, -25 },
  { 1778, 15, 25, 20, 3, -25 },
  { 1825, 14, 25, 20, 3, -25 },
  { 1869, 14, 25, 20, 3, -25 },
  { 1913, 16, 25, 20, 3, -25 },
  { 1963, 15, 31, 20, 3, -25 },
  { 2022, 16, 25, 20, 3, -25 },
  { 2072, 16, 25, 20, 2, -25 },
  { 2122, 17, 25, 20, 2, -25 },
  { 2176, 14, 25, 20, 3, -25 },
  { 2220, 17, 25, 20, 2, -25 },
  { 2274, 19, 25, 20, 1, -25 },
  { 2334, 18, 25, 20, 1, -25 },
  { 2391, 18, 25, 20, 1, -25 },
  { 2448, 15, 25, 20, 3, -25 },
  { 2495, 8, 32, 20, 7, -28 },
  { 2527, 15, 32, 20, 3, -28 },
  { 2587, 8, 32, 20, 5, -28 },
  { 2619, 15, 13, 20, 3, -25 },
  { 2644, 16, 2, 20, 2, 1 },
  { 2648, 7, 5, 20, 6, -27 },
  { 2653, 15, 19, 20, 2, -19 },
  { 2689, 15, 25, 20, 3, -25 },
  { 2736, 15, 19, 20, 3, -19 },
  { 2772, 14, 25, 20, 3, -25 },
  { 2816, 15, 19, 20, 3, -19 },
  { 2852, 16, 25, 20, 2, -25 },
  { 2902, 14, 25, 20, 3, -19 },
  { 2946, 14, 25, 20, 3, -25 },
  { 2990, 16, 26, 20, 3, -26 },
  { 3042, 13, 32, 20, 3, -26 },
  { 3094, 16, 25, 20, 3, -25 },
  { 3144, 18, 25, 20, 1, -25 },
  { 3201, 16, 19, 20, 2, -19 },
  { 3239, 14, 19, 20, 3, -19 },
  { 3273, 15, 19, 20, 3, -19 },
  { 3309, 15, 25, 20, 3, -19 },
  { 3356, 14, 25, 20, 3, -19 },
  { 3400, 14, 19, 20, 4, -19 },
  { 3434, 15, 19, 20, 3, -19 },
  { 3470, 16, 24, 20, 2, -24 },
  { 3518, 14, 19, 20, 3, -19 },
  { 3552, 17, 19, 20, 2, -19 },
  { 3593, 18, 19, 20, 1, -19 },
  { 3636, 17, 19, 20, 2, -19 },
  { 3677, 17, 25, 20, 2, -19 },
  { 3731, 14, 19, 20, 3, -19 },
  { 3765, 15, 32, 20, 3, -28 },
  { 3825, 3, 32, 20, 9, -28 },
  { 3837, 15, 32, 20, 3, -28 },
  { 3897, 16, 7, 20, 2, -15 },
};

const GFXfont JetBrainsMono_Regular34pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular34pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular34pt7bGlyphs,
  0x20, 0x7E, 45
};

#endif // _JETBRAINSMONO_REGULAR34PT7B_H_
