#ifndef _JETBRAINSMONO_REGULAR60PT7B_H_
#define _JETBRAINSMONO_REGULAR60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular60pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC7, 0xF9, 0xFE, 0xFF, 0xDF, 0xE7, 0xF8, 0xFC, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF,
  0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xF7, 0x80, 0x7D, 0xE0, 0x1F, 0x78, 0x07, 0x9E, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xE0, 0x00, 0x7C, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x78, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x0F,
  0x00, 0x03, 0xC0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x1E,
  0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x07, 0x80, 0x3E,
  0x00, 0x0F, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFC, 0xF1, 0xFC, 0x3F, 0x0F,
  0x0F, 0xC3, 0xF0, 0xF0, 0x7E, 0x3E, 0x0F, 0x07, 0xE3, 0xE0, 0xF0, 0x3E,
  0x3E, 0x0F, 0x03, 0xE3, 0xE0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE0,
  0xF0, 0x00, 0x3F, 0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x8F, 0x00,
  0x01, 0xFE, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xF7, 0xFC, 0x00, 0x0F, 0x1F, 0xC0,
  0x00, 0xF0, 0xFE, 0x00, 0x0F, 0x07, 0xE0, 0x00, 0xF0, 0x3E, 0x00, 0x0F,
  0x03, 0xF0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xFF, 0xC0, 0xF0, 0x3F,
  0xFC, 0x0F, 0x03, 0xF7, 0xC0, 0xF0, 0x3E, 0x7E, 0x0F, 0x07, 0xE7, 0xF0,
  0xF0, 0x7E, 0x3F, 0x8F, 0x1F, 0xC3, 0xFF, 0xF7, 0xFC, 0x1F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xC7, 0xFF, 0x00, 0x01, 0xE3,
  0xFF, 0xE0, 0x00, 0xF9, 0xFF, 0xFC, 0x00, 0x7C, 0x7C, 0x1F, 0x00, 0x1E,
  0x3E, 0x03, 0xC0, 0x0F, 0x8F, 0x80, 0xF8, 0x07, 0xC3, 0xC0, 0x3E, 0x01,
  0xE0, 0xF0, 0x0F, 0x80, 0xF8, 0x3C, 0x03, 0xE0, 0x7C, 0x0F, 0x00, 0xF8,
  0x1E, 0x03, 0xC0, 0x3E, 0x0F, 0x00, 0xF0, 0x0F, 0x87, 0xC0, 0x3E, 0x03,
  0xE1, 0xE0, 0x0F, 0x80, 0xF0, 0xF0, 0x01, 0xF0, 0xFC, 0x7C, 0x00, 0x7F,
  0xFE, 0x1E, 0x00, 0x0F, 0xFF, 0x8F, 0x00, 0x01, 0xFF, 0xC7, 0xC0, 0x00,
  0x1F, 0xC1, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x03, 0xE1, 0xFF, 0x80, 0x00, 0xF1, 0xFF, 0xF0, 0x00, 0x7C,
  0x7F, 0xFE, 0x00, 0x3E, 0x3F, 0x1F, 0x80, 0x0F, 0x0F, 0x81, 0xF0, 0x07,
  0xC7, 0xC0, 0x7C, 0x03, 0xE1, 0xF0, 0x0F, 0x00, 0xF0, 0x7C, 0x03, 0xC0,
  0x78, 0x1F, 0x00, 0xF0, 0x3E, 0x07, 0xC0, 0x3C, 0x0F, 0x01, 0xF0, 0x0F,
  0x07, 0x80, 0x7C, 0x03, 0xC3, 0xE0, 0x1F, 0x01, 0xF0, 0xF0, 0x03, 0xC0,
  0x7C, 0x78, 0x00, 0xF8, 0x3F, 0x3E, 0x00, 0x3F, 0xFF, 0x8F, 0x00, 0x07,
  0xFF, 0xC7, 0x80, 0x00, 0xFF, 0xE3, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0xFF, 0x1F, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xBF, 0x1F, 0x80, 0x7E, 0x7C, 0x1F, 0x80, 0xFD, 0xF8,
  0x1F, 0x83, 0xF3, 0xF0, 0x3F, 0x07, 0xC7, 0xE0, 0x3F, 0x1F, 0x8F, 0xC0,
  0x3F, 0x3E, 0x1F, 0x80, 0x7E, 0xFC, 0x3F, 0x00, 0x7F, 0xF0, 0x7E, 0x00,
  0x7F, 0xE0, 0xFC, 0x00, 0x7F, 0x81, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x00,
  0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xFC, 0x0F, 0x80, 0x1F,
  0xF8, 0x1F, 0x80, 0x7F, 0xF8, 0x3F, 0xC3, 0xFD, 0xF8, 0x3F, 0xFF, 0xF3,
  0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x3F, 0xFE, 0x03, 0xF0, 0x3F, 0xF8, 0x03,
  0xF0, 0x07, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFB, 0xEF, 0xBE, 0xFB, 0xE0, 0x00, 0x01, 0xC0, 0x01, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00,
  0x1F, 0x00, 0x00, 0xC0, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x30, 0x03, 0xC0, 0x0C, 0x7E, 0x03, 0xC0, 0x7E, 0x7F, 0x83, 0xC1,
  0xFE, 0x7F, 0xE3, 0xC7, 0xFE, 0xFF, 0xF1, 0x9F, 0xFF, 0x3F, 0xFD, 0xBF,
  0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x0F,
  0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x00, 0x80, 0x03, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x7F, 0x83, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x81, 0xFC, 0x0F,
  0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0x1F, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x3F, 0x03, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF8, 0x3F, 0xE1, 0xFF, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF9, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0xC0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x1F, 0xE1, 0xFF,
  0x87, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x03, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F,
  0x9F, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF8, 0xFF, 0x03, 0xFC, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xDF, 0x80, 0x0F,
  0xF3, 0xF0, 0x03, 0xFC, 0x7E, 0x00, 0xFE, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xE0, 0x3F, 0x00, 0x70, 0x07, 0xE0, 0x0C, 0x00, 0xFC, 0x01, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xF9,
  0xFF, 0x83, 0xF8, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x01, 0xF1, 0xFC, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0xFC,
  0x00, 0x3E, 0xFE, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x7F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x00,
  0x7C, 0x7F, 0xF0, 0x1F, 0x3F, 0xFF, 0x07, 0xDF, 0xFF, 0xE1, 0xF7, 0xFF,
  0xFC, 0x7F, 0xC0, 0xFF, 0x1F, 0xE0, 0x0F, 0xE7, 0xF0, 0x01, 0xF9, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE7,
  0xF0, 0x03, 0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0xFF, 0x00, 0x1F, 0xBF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x83, 0xFF, 0x0F, 0xF8, 0x7F, 0x80, 0x1F, 0xC7, 0xF0, 0x00, 0xFE, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0xC1, 0xFF, 0x0F, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0x0F, 0xE0,
  0x1F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x1F, 0x80,
  0x7E, 0x07, 0xF0, 0x3F, 0x80, 0xFF, 0x3F, 0xC0, 0x0F, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x0F, 0xE1, 0xFE, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xF0, 0x03,
  0xF8, 0xFF, 0x87, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xF9, 0xFF, 0x83, 0xFC, 0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xF8,
  0x01, 0xFE, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0x7F, 0xFD, 0xF8, 0x01, 0xFF, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0C, 0x0F, 0xC7, 0xFB, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF1, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x8F, 0xC0, 0xC0, 0x03, 0xC0, 0x7F, 0x83, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xE1, 0xFE, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xFC, 0x1F,
  0xE0, 0xFE, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x7C,
  0x7E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x1F, 0xF8, 0x03, 0xFF, 0x3F, 0xF0,
  0x0F, 0xFF, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7E, 0x07, 0xFF, 0x80,
  0xF8, 0x07, 0xFF, 0x01, 0xF0, 0x0F, 0xFE, 0x07, 0xC0, 0x0F, 0xFC, 0x0F,
  0x80, 0x1F, 0xF8, 0x1F, 0x00, 0x3F, 0xF0, 0x3E, 0x00, 0x7F, 0xE0, 0x7C,
  0x00, 0xFF, 0xC0, 0xF8, 0x01, 0xFF, 0x81, 0xF0, 0x03, 0xFF, 0x03, 0xE0,
  0x07, 0xFE, 0x07, 0xC0, 0x0F, 0xFC, 0x0F, 0x80, 0x1F, 0xF8, 0x1F, 0x00,
  0x3F, 0xF0, 0x1E, 0x00, 0xFF, 0xE0, 0x3E, 0x01, 0xFF, 0xC0, 0x7C, 0x03,
  0xFF, 0x80, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0xF7, 0xFE, 0x00, 0xFF, 0xEF,
  0xFC, 0x00, 0xFF, 0x9F, 0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3E, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x7F, 0x8F, 0x80, 0x07, 0xF3, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01,
  0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x3F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x7F, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0xEF, 0x80, 0x0F, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFB, 0xFF, 0x0F, 0xE0, 0x1F, 0xE7, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0x3E, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0x9F,
  0x80, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0xE3, 0xE0, 0x03, 0xF9,
  0xF0, 0x00, 0xFE, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xF7, 0xC0, 0x07,
  0xF3, 0xE0, 0x07, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFB, 0xFF, 0x0F, 0xE0, 0x1F, 0xE7, 0xF0, 0x01, 0xF9,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0x9F, 0x80, 0x07, 0xE3, 0xF8, 0x03, 0xF8, 0xFF, 0x83, 0xFC, 0x1F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE1, 0xFF, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xC0, 0x00,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xF8, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x3F,
  0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x0F, 0x80, 0x3F,
  0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x07, 0xE0, 0x0F,
  0x80, 0xFC, 0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80,
  0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0x01, 0xF8,
  0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0xC0, 0xF8,
  0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xEF, 0x00, 0x3F, 0xFB, 0xC0, 0x0F, 0x7F,
  0xF8, 0x07, 0xDF, 0xDE, 0x01, 0xF7, 0xF7, 0x80, 0x7B, 0xFD, 0xF0, 0x1E,
  0xFF, 0x3C, 0x0F, 0xBF, 0xCF, 0x03, 0xCF, 0xF3, 0xE0, 0xF3, 0xFC, 0x78,
  0x7C, 0xFF, 0x1E, 0x1E, 0x3F, 0xC7, 0xC7, 0x8F, 0xF0, 0xF3, 0xE3, 0xFC,
  0x3C, 0xF0, 0xFF, 0x0F, 0x3C, 0x3F, 0xE1, 0xEF, 0x1F, 0xF8, 0x7F, 0x87,
  0xFE, 0x1F, 0xE1, 0xFF, 0x87, 0xF8, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x3F,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFB, 0xE0, 0x0F, 0xFE, 0xF8, 0x03, 0xFF,
  0x9E, 0x00, 0xFF, 0xE7, 0xC0, 0x3F, 0xF9, 0xF0, 0x0F, 0xFE, 0x3C, 0x03,
  0xFF, 0xCF, 0x80, 0xFF, 0xF3, 0xE0, 0x3F, 0xFC, 0x78, 0x0F, 0xFF, 0x1F,
  0x03, 0xFF, 0xC7, 0xC0, 0xFF, 0xF0, 0xF0, 0x3F, 0xFC, 0x3E, 0x0F, 0xFF,
  0x0F, 0x83, 0xFF, 0xC1, 0xF0, 0xFF, 0xF0, 0x7C, 0x3F, 0xFC, 0x1F, 0x0F,
  0xFF, 0x03, 0xE3, 0xFF, 0xC0, 0xF8, 0xFF, 0xF0, 0x1E, 0x3F, 0xFC, 0x07,
  0xCF, 0xFF, 0x01, 0xF3, 0xFF, 0xC0, 0x3C, 0x7F, 0xF0, 0x0F, 0x9F, 0xFC,
  0x03, 0xE7, 0xFF, 0x00, 0x79, 0xFF, 0xC0, 0x1F, 0x7F, 0xF0, 0x07, 0xDF,
  0xFC, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xF3, 0xFF, 0x0F, 0xE0, 0x1F, 0xC7, 0xF0, 0x03,
  0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7E,
  0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF0, 0xFF, 0x87, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF0, 0x01,
  0xFF, 0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x0F,
  0xEF, 0x80, 0x07, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0x3F, 0xF0, 0x7F, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01,
  0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0xC0, 0x0F, 0xE1, 0xFF, 0x0F,
  0xF8, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0x01, 0xFE,
  0x3E, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x3F, 0x8F,
  0x80, 0x3F, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0x01, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0xFC,
  0x07, 0xC0, 0x0F, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x83, 0xE0,
  0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xE1, 0xF0, 0x00, 0xFE,
  0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00,
  0x03, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFD, 0xFF, 0x81, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE3,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x7E, 0x3F, 0x80,
  0x1F, 0xC3, 0xFF, 0x8F, 0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3,
  0xF0, 0x03, 0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xC0, 0xF8,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x7E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00,
  0xFC, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F,
  0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x07,
  0xDF, 0x00, 0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0xF9, 0xF0, 0x0F, 0xC0,
  0x3E, 0x7C, 0x03, 0xF0, 0x0F, 0x9F, 0x00, 0xFE, 0x03, 0xE7, 0xC0, 0x3F,
  0x80, 0xF9, 0xF0, 0x1F, 0xE0, 0x3E, 0x7E, 0x07, 0xB8, 0x0F, 0x8F, 0x81,
  0xEE, 0x03, 0xC3, 0xE0, 0x73, 0x81, 0xF0, 0xF8, 0x1C, 0xE0, 0x7C, 0x3E,
  0x07, 0x38, 0x1F, 0x0F, 0x81, 0xCE, 0x07, 0xC3, 0xE0, 0x73, 0xC1, 0xF0,
  0xF8, 0x3C, 0xF0, 0x7C, 0x3E, 0x0F, 0x3C, 0x1F, 0x0F, 0x83, 0xC7, 0x07,
  0x81, 0xF0, 0xE1, 0xC1, 0xE0, 0x7C, 0x38, 0x70, 0x78, 0x1F, 0x0E, 0x1C,
  0x3E, 0x07, 0xC3, 0x87, 0x0F, 0x81, 0xF0, 0xE1, 0xC3, 0xE0, 0x7C, 0x78,
  0x78, 0xF8, 0x1F, 0x1E, 0x1E, 0x3E, 0x07, 0xC7, 0x87, 0x8F, 0x80, 0xF1,
  0xC0, 0xE3, 0xC0, 0x3C, 0x70, 0x38, 0xF0, 0x0F, 0x9C, 0x0E, 0x3C, 0x03,
  0xE7, 0x03, 0x9F, 0x00, 0xF9, 0xC0, 0xE7, 0xC0, 0x3E, 0xF0, 0x3D, 0xF0,
  0x0F, 0xBC, 0x0F, 0x7C, 0x03, 0xEF, 0x03, 0xDF, 0x00, 0xFB, 0x80, 0xF7,
  0x80, 0x1E, 0xE0, 0x1D, 0xE0, 0x07, 0xB8, 0x07, 0x78, 0x01, 0xEE, 0x01,
  0xDE, 0x00, 0x7B, 0x80, 0x77, 0x80, 0x1E, 0xE0, 0x1D, 0xE0, 0x07, 0xF8,
  0x07, 0xF8, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x80, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F,
  0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3F,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7E, 0x3E,
  0x00, 0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00,
  0x7E, 0x3E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0xCF, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0x00,
  0x1F, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x07,
  0xF1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xBF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF7,
  0xE0, 0x01, 0xFE, 0xFE, 0x00, 0xFF, 0xCF, 0xFF, 0xFD, 0xF9, 0xFF, 0xFF,
  0xBF, 0x0F, 0xFF, 0xE7, 0xE0, 0xFF, 0xF0, 0xFC, 0x00, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x1F, 0x0F,
  0xFC, 0x0F, 0x8F, 0xFF, 0x87, 0xCF, 0xFF, 0xE3, 0xEF, 0xFF, 0xF9, 0xFF,
  0x83, 0xFC, 0xFF, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xF7, 0xF0, 0x01, 0xFB, 0xFC,
  0x01, 0xFD, 0xFF, 0x83, 0xFC, 0xFB, 0xFF, 0xFE, 0x7D, 0xFF, 0xFE, 0x3E,
  0x7F, 0xFE, 0x1F, 0x0F, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x0F, 0xF8, 0x7F, 0xC3, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0x7E,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0xFD, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x8F, 0xF8, 0x7F, 0xC1, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x0E,
  0x03, 0xE0, 0x7F, 0xE1, 0xF0, 0xFF, 0xF8, 0xF8, 0xFF, 0xFE, 0x7C, 0xFF,
  0xFF, 0xBE, 0x7F, 0x83, 0xFF, 0x7F, 0x00, 0x7F, 0xBF, 0x00, 0x1F, 0xDF,
  0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x01, 0xFB, 0xF0,
  0x01, 0xFD, 0xFC, 0x01, 0xFE, 0x7F, 0x81, 0xFF, 0x3F, 0xFF, 0xEF, 0x8F,
  0xFF, 0xF7, 0xC3, 0xFF, 0xF3, 0xE0, 0x7F, 0xE1, 0xF0, 0x03, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xF0,
  0x1F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x01, 0xFF, 0x87, 0xC3, 0xFF,
  0xF3, 0xE3, 0xFF, 0xFD, 0xF1, 0xFF, 0xFE, 0xF9, 0xFE, 0x0F, 0xFD, 0xFC,
  0x01, 0xFE, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x80,
  0x1F, 0xCF, 0xE0, 0x3F, 0xE7, 0xFF, 0xFD, 0xF1, 0xFF, 0xFE, 0xF8, 0x7F,
  0xFE, 0x7C, 0x1F, 0xFE, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x03, 0x80, 0x1F,
  0x0F, 0xFC, 0x0F, 0x9F, 0xFF, 0x87, 0xDF, 0xFF, 0xE3, 0xEF, 0xFF, 0xF9,
  0xFF, 0x03, 0xFC, 0xFE, 0x00, 0x7F, 0x7F, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xC0,
  0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0xC3, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x07, 0xE0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01, 0xF0, 0x1F,
  0x80, 0x3E, 0x03, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x1F,
  0x00, 0x7F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F,
  0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03,
  0xF0, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x20, 0x0C, 0x0F, 0x9F, 0xC3, 0xF8, 0xFB,
  0xFE, 0x7F, 0xCF, 0xFF, 0xEF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xC1, 0xF8,
  0x3F, 0xF8, 0x1F, 0x81, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F,
  0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F,
  0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80,
  0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01,
  0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8,
  0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0,
  0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0x00, 0x0E, 0x00, 0x7C, 0x3F, 0xF0, 0x3E, 0x7F, 0xFE,
  0x1F, 0x7F, 0xFF, 0x8F, 0xBF, 0xFF, 0xE7, 0xFC, 0x0F, 0xF3, 0xFC, 0x01,
  0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xF1, 0xFF, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0xFC, 0x3F, 0xE3, 0xFF,
  0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x7C, 0x3F, 0xF0, 0x3E, 0x3F, 0xFE, 0x1F,
  0x3F, 0xFF, 0x8F, 0xBF, 0xFF, 0xE7, 0xFE, 0x0F, 0xF3, 0xFC, 0x01, 0xFD,
  0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xDF, 0xC0, 0x07, 0xEF, 0xF0, 0x07, 0xF7, 0xFE, 0x0F, 0xF3,
  0xEF, 0xFF, 0xF9, 0xF3, 0xFF, 0xF8, 0xF8, 0xFF, 0xF8, 0x7C, 0x3F, 0xF0,
  0x3E, 0x01, 0xC0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xFF, 0x87, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xF9, 0xF1,
  0xFF, 0xFE, 0xF9, 0xFE, 0x0F, 0xFD, 0xFC, 0x01, 0xFE, 0xFC, 0x00, 0x7F,
  0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xF7, 0xF0, 0x07, 0xF9, 0xFE, 0x07, 0xFC, 0x7F, 0xFF, 0xBE,
  0x3F, 0xFF, 0x9F, 0x0F, 0xFF, 0x8F, 0x81, 0xFF, 0x87, 0xC0, 0x0C, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x7C,
  0x3F, 0xF0, 0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xBF, 0xFF, 0xE7,
  0xFC, 0x0F, 0xF3, 0xFC, 0x01, 0xFD, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x8F,
  0xC0, 0x07, 0xE7, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xFC,
  0x00, 0x7F, 0x3F, 0xC0, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFD, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xE7, 0xE0,
  0x03, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xF0, 0x01, 0xF0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF8, 0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0xF8, 0x07, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xE0,
  0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x7C, 0x0F, 0xF0, 0x3E, 0x7C, 0x0E, 0xF0,
  0x3E, 0x7C, 0x0E, 0x70, 0x3E, 0x3C, 0x0E, 0x70, 0x3C, 0x3C, 0x0E, 0x70,
  0x3C, 0x3E, 0x0E, 0x70, 0x3C, 0x3E, 0x1E, 0x78, 0x7C, 0x3E, 0x1E, 0x78,
  0x7C, 0x3E, 0x1C, 0x38, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x1E, 0x1C, 0x38,
  0x78, 0x1E, 0x1C, 0x38, 0x78, 0x1F, 0x1C, 0x38, 0x78, 0x1F, 0x3C, 0x3C,
  0xF8, 0x1F, 0x38, 0x3C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C,
  0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x0F, 0x78, 0x1E,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x07,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80,
  0x7E, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x00,
  0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x01, 0xF3, 0xFF, 0x80, 0x1F, 0x7F, 0xFC, 0x01, 0xF7,
  0xFF, 0xE0, 0x1F, 0xFE, 0x7F, 0x01, 0xFF, 0x81, 0xF8, 0x1F, 0xF8, 0x1F,
  0xC3, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xEF, 0x80, 0x3F, 0xFC,
  0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x07, 0xE0,
};

const GFXglyph JetBrainsMono_Regular60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 10, 44, 36, 13, -44 },
  { 56, 18, 18, 36, 9, -44 },
  { 97, 32, 44, 36, 2, -44 },
  { 273, 28, 60, 36, 4, -52 },
  { 483, 34, 44, 36, 1, -44 },
  { 670, 31, 45, 36, 3, -44 },
  { 845, 6, 18, 36, 15, -44 },
  { 859, 18, 57, 36, 11, -50 },
  { 988, 18, 57, 36, 7, -50 },
  { 1117, 32, 31, 36, 2, -37 },
  { 1241, 28, 28, 36, 4, -34 },
  { 1339, 13, 19, 36, 10, -9 },
  { 1370, 20, 5, 36, 8, -22 },
  { 1383, 10, 10, 36, 13, -9 },
  { 1396, 28, 57, 36, 4, -50 },
  { 1596, 26, 45, 36, 5, -44 },
  { 1743, 27, 44, 36, 5, -44 },
  { 1892, 28, 44, 36, 4, -44 },
  { 2046, 27, 45, 36, 4, -44 },
  { 2198, 25, 44, 36, 5, -44 },
  { 2336, 26, 45, 36, 5, -44 },
  { 2483, 28, 45, 36, 4, -44 },
  { 2641, 27, 44, 36, 5, -44 },
  { 2790, 26, 45, 36, 5, -44 },
  { 2937, 28, 44, 36, 4, -44 },
  { 3091, 10, 35, 36, 13, -34 },
  { 3135, 13, 44, 36, 10, -34 },
  { 3207, 26, 32, 36, 5, -36 },
  { 3311, 26, 19, 36, 5, -29 },
  { 3373, 26, 32, 36, 5, -36 },
  { 3477, 21, 44, 36, 8, -44 },
  { 3593, 31, 55, 36, 3, -44 },
  { 3807, 30, 44, 36, 3, -44 },
  { 3972, 26, 44, 36, 6, -44 },
  { 4115, 26, 45, 36, 5, -44 },
  { 4262, 25, 44, 36, 6, -44 },
  { 4400, 25, 44, 36, 6, -44 },
  { 4538, 26, 44, 36, 6, -44 },
  { 4681, 26, 45, 36, 5, -44 },
  { 4828, 24, 44, 36, 6, -44 },
  { 4960, 24, 44, 36, 6, -44 },
  { 5092, 27, 45, 36, 3, -44 },
  { 5244, 28, 44, 36, 6, -44 },
  { 5398, 25, 44, 36, 7, -44 },
  { 5536, 26, 44, 36, 5, -44 },
  { 5679, 26, 44, 36, 5, -44 },
  { 5822, 26, 45, 36, 5, -44 },
  { 5969, 27, 44, 36, 6, -44 },
  { 6118, 27, 55, 36, 5, -44 },
  { 6304, 27, 44, 36, 6, -44 },
  { 6453, 28, 45, 36, 4, -44 },
  { 6611, 30, 44, 36, 3, -44 },
  { 6776, 26, 45, 36, 5, -44 },
  { 6923, 30, 44, 36, 3, -44 },
  { 7088, 34, 44, 36, 1, -44 },
  { 7275, 32, 44, 36, 2, -44 },
  { 7451, 32, 44, 36, 2, -44 },
  { 7627, 26, 44, 36, 5, -44 },
  { 7770, 15, 57, 36, 12, -50 },
  { 7877, 28, 57, 36, 4, -50 },
  { 8077, 15, 57, 36, 9, -50 },
  { 8184, 26, 24, 36, 5, -44 },
  { 8262, 28, 5, 36, 4, 1 },
  { 8280, 13, 8, 36, 11, -47 },
  { 8293, 27, 35, 36, 4, -34 },
  { 8412, 25, 45, 36, 6, -44 },
  { 8553, 26, 35, 36, 5, -34 },
  { 8667, 25, 45, 36, 5, -44 },
  { 8808, 26, 35, 36, 5, -34 },
  { 8922, 28, 44, 36, 4, -44 },
  { 9076, 25, 45, 36, 5, -34 },
  { 9217, 25, 44, 36, 6, -44 },
  { 9355, 28, 47, 36, 5, -47 },
  { 9520, 22, 58, 36, 5, -47 },
  { 9680, 27, 44, 36, 6, -44 },
  { 9829, 31, 44, 36, 2, -44 },
  { 10000, 28, 34, 36, 4, -34 },
  { 10119, 25, 34, 36, 6, -34 },
  { 10226, 26, 33, 36, 5, -33 },
  { 10334, 25, 45, 36, 6, -34 },
  { 10475, 25, 45, 36, 5, -34 },
  { 10616, 25, 34, 36, 7, -34 },
  { 10723, 26, 33, 36, 5, -33 },
  { 10831, 28, 42, 36, 3, -42 },
  { 10978, 26, 34, 36, 5, -33 },
  { 11089, 30, 33, 36, 3, -33 },
  { 11213, 32, 33, 36, 2, -33 },
  { 11345, 30, 33, 36, 3, -33 },
  { 11469, 30, 44, 36, 3, -33 },
  { 11634, 26, 33, 36, 5, -33 },
  { 11742, 26, 57, 36, 5, -50 },
  { 11928, 6, 57, 36, 15, -50 },
  { 11971, 26, 57, 36, 5, -50 },
  { 12157, 28, 12, 36, 4, -27 },
};

const GFXfont JetBrainsMono_Regular60pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular60pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular60pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _JETBRAINSMONO_REGULAR60PT7B_H_
