#ifndef _JETBRAINSMONO_REGULAR37PT7B_H_
#define _JETBRAINSMONO_REGULAR37PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 37pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular37pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3,
  0x8C, 0x30, 0xC3, 0x00, 0x00, 0x00, 0x1E, 0xFF, 0xF7, 0x80, 0xE1, 0xFC,
  0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x77, 0x0E, 0xE1, 0xDC, 0x3B,
  0x87, 0x00, 0x01, 0xC1, 0xC0, 0x18, 0x1C, 0x01, 0x81, 0xC0, 0x38, 0x18,
  0x03, 0x81, 0x80, 0x38, 0x38, 0x03, 0x03, 0x83, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x07, 0x03, 0x00, 0x70, 0x70, 0x06, 0x07, 0x00, 0x60,
  0x70, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x0F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x1C, 0x0C, 0x01, 0xC0, 0xC0, 0x1C, 0x1C, 0x01,
  0x81, 0xC0, 0x18, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x18, 0x00, 0x01, 0x80,
  0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x7F, 0x80, 0x7F,
  0xF0, 0x7F, 0xFC, 0x79, 0x9E, 0x38, 0xC7, 0xBC, 0x61, 0xDE, 0x30, 0xEF,
  0x18, 0x03, 0x8C, 0x01, 0xE6, 0x00, 0xFB, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x1B, 0xE0, 0x0C, 0x78, 0x06, 0x3C, 0x03,
  0x0E, 0x01, 0x87, 0xF0, 0xC3, 0xF8, 0x61, 0xDE, 0x30, 0xE7, 0x98, 0xF3,
  0xFF, 0xF0, 0xFF, 0xF0, 0x1F, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x3F, 0x00, 0x3B, 0xFC, 0x03, 0xBC, 0xE0,
  0x39, 0xC3, 0x81, 0x8C, 0x1C, 0x1C, 0x60, 0xE1, 0xC3, 0x07, 0x1C, 0x18,
  0x38, 0xE0, 0xE1, 0xCE, 0x07, 0x9C, 0xE0, 0x1F, 0xE7, 0x00, 0x7E, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x38, 0xF8, 0x01,
  0x9F, 0xF0, 0x1C, 0xE3, 0x81, 0xCE, 0x0C, 0x0C, 0x70, 0x70, 0xE3, 0x83,
  0x8E, 0x1C, 0x1C, 0x60, 0xE0, 0xE7, 0x07, 0x06, 0x70, 0x1E, 0xF3, 0x00,
  0xFF, 0xB8, 0x01, 0xF0, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x1E,
  0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFF,
  0x00, 0x7C, 0xF0, 0x77, 0x8F, 0x1E, 0xE0, 0xE3, 0x9C, 0x1E, 0xF3, 0x81,
  0xFC, 0x70, 0x1F, 0x0E, 0x01, 0xE1, 0xC0, 0x3C, 0x3C, 0x0F, 0xC7, 0x83,
  0xF8, 0x7F, 0xF7, 0x8F, 0xFC, 0x78, 0x7F, 0x07, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEE, 0xE0, 0x00, 0x60, 0x3C, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x0F,
  0x03, 0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x7C, 0x07,
  0xE0, 0x7C, 0x03, 0x80, 0xC0, 0x1E, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0,
  0xFC, 0x1F, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x70, 0x60, 0xE7, 0xC6,
  0x3E, 0xFF, 0x6F, 0xF1, 0xFF, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x39, 0xC0, 0x07, 0x9E, 0x00, 0x70, 0xF0, 0x0F, 0x0F, 0x01,
  0xE0, 0x78, 0x0C, 0x03, 0x00, 0x40, 0x20, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x1F, 0x1E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x31, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x78, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE1, 0x87, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7,
  0xE1, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0x03, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xDC, 0x0F, 0x8E, 0x07, 0x87,
  0x03, 0x83, 0x81, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0,
  0x3F, 0xFC, 0x7F, 0xFE, 0x78, 0x1E, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x0E, 0xF8, 0x1E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x0F, 0x3C, 0x0F,
  0x38, 0x0F, 0x78, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x71, 0xE0,
  0x77, 0xF8, 0x7F, 0xFC, 0x7C, 0x3E, 0x78, 0x0F, 0x70, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x3C, 0x0F, 0x7F, 0x87,
  0xFF, 0xE7, 0xE0, 0xF3, 0xC0, 0x3D, 0xE0, 0x0E, 0xE0, 0x07, 0x70, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0xC0, 0x3C, 0xF0,
  0x3C, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x77, 0x00, 0x7B, 0x80, 0x3C, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE,
  0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0F, 0x70, 0x0E,
  0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF8,
  0x3C, 0x3C, 0x78, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1F, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xFE, 0x1F, 0xFF, 0x8F, 0x03, 0xCF, 0x00, 0xF7, 0x00,
  0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0xEF, 0x00, 0xF3, 0xE0, 0xF9, 0xFF, 0xF8, 0x3F, 0xFC, 0x07, 0xBC,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x33, 0xFF,
  0xFF, 0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0x78, 0x0E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C,
  0x78, 0x78, 0x70, 0x70, 0xE0, 0x00, 0x01, 0x00, 0x07, 0x00, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x00, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0x07, 0xFE, 0x3F, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x3F, 0x0F, 0xF0,
  0x7F, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFC, 0x03,
  0xFF, 0xE0, 0xFC, 0x3E, 0x3C, 0x01, 0xC7, 0x00, 0x1D, 0xE0, 0x03, 0xB8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0x9F, 0x83, 0xFB, 0xF0,
  0x79, 0xFE, 0x1C, 0x1F, 0xC3, 0x81, 0xF8, 0x70, 0x3F, 0x0E, 0x07, 0xE1,
  0xC0, 0xFC, 0x38, 0x1F, 0x87, 0x03, 0xF0, 0xE0, 0x7E, 0x1C, 0x0F, 0xC3,
  0x83, 0xF8, 0x7C, 0xFF, 0x07, 0xF7, 0xE0, 0x3C, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x1C, 0xE0,
  0x07, 0x3C, 0x03, 0xC7, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1E, 0x07,
  0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0x0F, 0xFF, 0xC3, 0xFF,
  0xF0, 0xFF, 0xFC, 0x38, 0x07, 0x9E, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E,
  0xF0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x1C, 0xFF, 0xF0, 0x7F, 0xFC, 0x3F,
  0xFF, 0x9E, 0x07, 0xCF, 0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0E,
  0xF0, 0x07, 0x78, 0x07, 0xBC, 0x07, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF,
  0xE3, 0xC1, 0xF9, 0xE0, 0x1E, 0xF0, 0x07, 0x78, 0x03, 0xBC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3B, 0xC0, 0x3D, 0xE0, 0x3E, 0xFF, 0xFE,
  0x7F, 0xFE, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x78,
  0x1E, 0x70, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0xF0,
  0x07, 0x70, 0x0F, 0x78, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1E, 0xF0, 0x3E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xB8, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x0F,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E, 0x70, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF1, 0xFF, 0xF1, 0xFF, 0xF1, 0xFF, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x1E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xF3,
  0xC0, 0x3C, 0xF0, 0x1E, 0x3C, 0x07, 0x8F, 0x03, 0xC3, 0xC0, 0xE0, 0xF0,
  0x78, 0x3C, 0x1C, 0x0F, 0x0F, 0x03, 0xC3, 0x80, 0xFF, 0xE0, 0x3F, 0xF8,
  0x0F, 0xFE, 0x03, 0xC3, 0xC0, 0xF0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0x83,
  0xC0, 0xF0, 0xF0, 0x1C, 0x3C, 0x07, 0x8F, 0x00, 0xE3, 0xC0, 0x3C, 0xF0,
  0x07, 0x3C, 0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xF8, 0x0F, 0xF8, 0x1F, 0xD8, 0x1F, 0xDC, 0x1B, 0xDC, 0x3B,
  0xCC, 0x3B, 0xEE, 0x33, 0xEE, 0x73, 0xE6, 0x77, 0xE7, 0x67, 0xE7, 0x67,
  0xE3, 0xE7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07,
  0xFC, 0x07, 0xFC, 0x07, 0xEE, 0x07, 0xEE, 0x07, 0xE6, 0x07, 0xE7, 0x07,
  0xE7, 0x07, 0xF3, 0x87, 0xF3, 0x87, 0xF3, 0x87, 0xF1, 0xC7, 0xF1, 0xC7,
  0xF1, 0xC7, 0xF0, 0xE7, 0xF0, 0xE7, 0xF0, 0xE7, 0xF0, 0x77, 0xF0, 0x77,
  0xF0, 0x77, 0xF0, 0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F,
  0x0F, 0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E, 0x70, 0x0F, 0xF0, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0F, 0x78, 0x1E,
  0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF,
  0x9E, 0x03, 0xEF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x01, 0xF7, 0xFF, 0xF3,
  0xFF, 0xF1, 0xFF, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x78, 0x1E,
  0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x0F, 0x78, 0x1E, 0x3F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE,
  0x01, 0xEF, 0x07, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF0, 0x70,
  0x78, 0x3C, 0x3C, 0x1E, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x80, 0xF3, 0xC0,
  0x79, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xBC, 0x01, 0xE0, 0x0F, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x03, 0xC7, 0x00, 0xF7, 0x80, 0x3B, 0xC0,
  0x1D, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3B, 0xC0, 0x1D, 0xF0,
  0x1E, 0x7F, 0xFE, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFE, 0x1F,
  0xFC, 0x0F, 0xF0, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3D, 0xC0, 0x0E,
  0x70, 0x03, 0x9E, 0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1C, 0x38, 0x07, 0x0F,
  0x01, 0xC1, 0xC0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE1,
  0xE0, 0x38, 0x70, 0x0E, 0x1C, 0x03, 0xC7, 0x00, 0x73, 0xC0, 0x1C, 0xE0,
  0x07, 0x38, 0x01, 0xEE, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0xE0, 0xF0, 0x7E,
  0x0F, 0x07, 0xF0, 0xF0, 0x77, 0x0F, 0x87, 0x70, 0xD8, 0x77, 0x0D, 0x8E,
  0x71, 0x98, 0xE7, 0x19, 0x8E, 0x71, 0x98, 0xE7, 0x19, 0x8E, 0x71, 0x98,
  0xE7, 0x19, 0x8E, 0x39, 0x9C, 0xE3, 0x98, 0xCC, 0x3B, 0x8D, 0xC3, 0xB0,
  0xDC, 0x3B, 0x0D, 0xC3, 0xB0, 0xDC, 0x3B, 0x0D, 0xC3, 0xB0, 0xDC, 0x1B,
  0x0F, 0xC1, 0xB0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x07, 0x80,
  0x78, 0x01, 0xE3, 0xC0, 0x1C, 0x3C, 0x03, 0xC1, 0xE0, 0x38, 0x1E, 0x07,
  0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0x78, 0xE0, 0x03, 0x9E, 0x00, 0x3D,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x39, 0xC0, 0x07, 0x9E, 0x00,
  0x70, 0xF0, 0x0F, 0x0F, 0x00, 0xE0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x3C,
  0x3C, 0x01, 0xC7, 0x80, 0x1E, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF7, 0x00,
  0x0E, 0x78, 0x01, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1E,
  0x07, 0x80, 0xE0, 0x70, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00,
  0x39, 0xC0, 0x03, 0xDC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xFF, 0xFF,
  0xFF, 0xE0, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0x60,
  0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C,
  0x38, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x78, 0x38, 0x1C, 0x1F, 0x00, 0xE0, 0x07, 0xFE,
  0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0x73, 0xC0, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0x83, 0xFF, 0xC7, 0xFF, 0xE7, 0xFF, 0xF7, 0x80, 0x3B,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x07, 0xDF, 0x0E,
  0xE7, 0xFF, 0x71, 0xFE, 0x38, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF1, 0xE0, 0xF7, 0xF8, 0xF7, 0xFC, 0xFC,
  0x3E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0xFF, 0xFE, 0xF7, 0xFC, 0xF3, 0xF8, 0x03,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x3E, 0x78, 0x0F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x1E, 0x3F,
  0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x07, 0x0F, 0x1F, 0xEF, 0x3F, 0xF7, 0x7C,
  0x37, 0x78, 0x17, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x1F, 0x7F, 0xFF, 0x3F, 0xEF, 0x1F, 0xCF, 0x03,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x0E, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x0F, 0x78, 0x0E, 0x3F,
  0x7E, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1F, 0xEF, 0x3F, 0xFF,
  0x7C, 0x3F, 0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF, 0x1F, 0xEF, 0x07, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x3E, 0x1F, 0xFE, 0x1F, 0xFC,
  0x1F, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0xC0, 0xF7, 0xF8, 0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x0E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x01, 0xC0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE7, 0xFF, 0x9F, 0xFE, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x03, 0xF3,
  0xFF, 0x8F, 0xFC, 0x3F, 0x80, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x1E, 0xE0, 0x1E,
  0x70, 0x0F, 0x38, 0x0F, 0x1C, 0x0F, 0x0E, 0x07, 0x07, 0x07, 0x83, 0x87,
  0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x38, 0x78, 0x1C, 0x1E, 0x0E,
  0x0F, 0x07, 0x03, 0xC3, 0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x1E, 0x70, 0x07,
  0xB8, 0x03, 0xE0, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x00, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0x0E, 0x3B, 0xE7,
  0xEE, 0xFF, 0xFB, 0xC7, 0x8F, 0xF0, 0xE1, 0xFC, 0x30, 0x7F, 0x0C, 0x1F,
  0xC3, 0x07, 0xF0, 0xC1, 0xFC, 0x30, 0x7F, 0x0C, 0x1F, 0xC3, 0x07, 0xF0,
  0xC1, 0xFC, 0x30, 0x7F, 0x0C, 0x1F, 0xC3, 0x07, 0xF0, 0xC1, 0xFC, 0x30,
  0x7F, 0x0C, 0x1F, 0xC3, 0x07, 0xF0, 0xC1, 0xC0, 0x00, 0xC0, 0xF7, 0xF8,
  0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0x01, 0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7E, 0x7E, 0x78, 0x1E,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0x70, 0x0F,
  0x78, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0x00, 0xE0, 0xF7, 0xF8,
  0xFF, 0xFC, 0xFC, 0x3E, 0xF8, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1E, 0xFF, 0xFE, 0xF7, 0xFC,
  0xF3, 0xF8, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x1F, 0xEF, 0x3F, 0xFF, 0x7C, 0x3F,
  0x78, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x70, 0x0F, 0x78, 0x17, 0x7F, 0xF7, 0x3F, 0xEF, 0x1F, 0xCF, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0xE7, 0xF8, 0xEF, 0xFC, 0xEC, 0x3E, 0xF8, 0x1E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x1F, 0xFC, 0x3F, 0xFE,
  0x7C, 0x1E, 0x78, 0x0F, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x7C, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0xF0, 0x07, 0x78, 0x0F, 0x7F, 0xFE, 0x3F, 0xFE, 0x0F, 0xF8,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x81, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F,
  0xF0, 0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x1F, 0xFC, 0x0F, 0xF0,
  0xF0, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x39, 0xE0, 0x0E, 0x38, 0x07, 0x8E,
  0x01, 0xC3, 0xC0, 0x70, 0x70, 0x3C, 0x1C, 0x0E, 0x07, 0x83, 0x80, 0xE1,
  0xE0, 0x38, 0x70, 0x0F, 0x1C, 0x01, 0xCF, 0x00, 0x73, 0x80, 0x1E, 0xE0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0xE0, 0xF0, 0x77,
  0x0F, 0x07, 0x70, 0xF0, 0x67, 0x0F, 0x06, 0x70, 0xF0, 0xE7, 0x0D, 0x8E,
  0x71, 0x98, 0xE3, 0x19, 0x8E, 0x39, 0x98, 0xC3, 0x99, 0x8C, 0x39, 0x99,
  0xC3, 0x98, 0xDC, 0x3B, 0x0D, 0xC1, 0xB0, 0xDC, 0x1B, 0x0D, 0x81, 0xB0,
  0xD8, 0x1F, 0x0D, 0x81, 0xF0, 0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0xF8,
  0x07, 0xCE, 0x01, 0xE3, 0xC0, 0xF0, 0x78, 0x38, 0x0E, 0x1E, 0x03, 0xCF,
  0x00, 0x7B, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x07, 0xB8, 0x03, 0xCF, 0x00, 0xE1, 0xE0, 0x78, 0x78, 0x3C,
  0x0F, 0x0E, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x00,
  0xF7, 0x80, 0x38, 0xE0, 0x1E, 0x3C, 0x07, 0x0F, 0x01, 0xC1, 0xC0, 0xF0,
  0x78, 0x38, 0x0E, 0x1E, 0x03, 0x87, 0x80, 0xF1, 0xC0, 0x1C, 0xF0, 0x07,
  0xB8, 0x00, 0xEE, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0xFF, 0xC0, 0xFF,
  0x00, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0xF8, 0x00, 0x1E, 0x01, 0xCF, 0xE0, 0x77, 0xFC, 0x1D, 0xC7, 0x87,
  0xF0, 0xF3, 0xFC, 0x3F, 0xEF, 0x07, 0xF3, 0xC0, 0x30,
};

const GFXglyph JetBrainsMono_Regular37pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 11, 11, 22, 6, -27 },
  { 38, 20, 27, 22, 1, -27 },
  { 106, 17, 37, 22, 3, -32 },
  { 185, 21, 27, 22, 1, -27 },
  { 256, 19, 27, 22, 2, -27 },
  { 321, 4, 11, 22, 9, -27 },
  { 327, 11, 35, 22, 7, -31 },
  { 376, 11, 35, 22, 4, -31 },
  { 425, 20, 20, 22, 1, -23 },
  { 475, 18, 17, 22, 2, -21 },
  { 514, 8, 12, 22, 6, -6 },
  { 526, 12, 3, 22, 5, -14 },
  { 531, 6, 6, 22, 8, -6 },
  { 536, 16, 35, 22, 3, -31 },
  { 606, 16, 27, 22, 3, -27 },
  { 660, 17, 27, 22, 3, -27 },
  { 718, 16, 27, 22, 3, -27 },
  { 772, 16, 27, 22, 3, -27 },
  { 826, 16, 27, 22, 3, -27 },
  { 880, 16, 27, 22, 3, -27 },
  { 934, 17, 27, 22, 3, -27 },
  { 992, 17, 27, 22, 3, -27 },
  { 1050, 16, 27, 22, 3, -27 },
  { 1104, 17, 27, 22, 3, -27 },
  { 1162, 6, 21, 22, 8, -21 },
  { 1178, 8, 27, 22, 6, -21 },
  { 1205, 16, 20, 22, 3, -22 },
  { 1245, 16, 12, 22, 3, -18 },
  { 1269, 16, 20, 22, 3, -22 },
  { 1309, 13, 27, 22, 5, -27 },
  { 1353, 19, 34, 22, 2, -27 },
  { 1434, 18, 27, 22, 2, -27 },
  { 1495, 17, 27, 22, 3, -27 },
  { 1553, 16, 27, 22, 3, -27 },
  { 1607, 16, 27, 22, 3, -27 },
  { 1661, 15, 27, 22, 4, -27 },
  { 1712, 15, 27, 22, 4, -27 },
  { 1763, 16, 27, 22, 3, -27 },
  { 1817, 16, 27, 22, 3, -27 },
  { 1871, 14, 27, 22, 4, -27 },
  { 1919, 16, 27, 22, 2, -27 },
  { 1973, 18, 27, 22, 3, -27 },
  { 2034, 16, 27, 22, 4, -27 },
  { 2088, 16, 27, 22, 3, -27 },
  { 2142, 16, 27, 22, 3, -27 },
  { 2196, 16, 27, 22, 3, -27 },
  { 2250, 17, 27, 22, 3, -27 },
  { 2308, 16, 34, 22, 3, -27 },
  { 2376, 17, 27, 22, 3, -27 },
  { 2434, 17, 27, 22, 3, -27 },
  { 2492, 18, 27, 22, 2, -27 },
  { 2553, 16, 27, 22, 3, -27 },
  { 2607, 18, 27, 22, 2, -27 },
  { 2668, 20, 27, 22, 1, -27 },
  { 2736, 20, 27, 22, 1, -27 },
  { 2804, 20, 27, 22, 1, -27 },
  { 2872, 16, 27, 22, 3, -27 },
  { 2926, 9, 35, 22, 8, -31 },
  { 2966, 16, 35, 22, 3, -31 },
  { 3036, 9, 35, 22, 6, -31 },
  { 3076, 16, 14, 22, 3, -27 },
  { 3104, 18, 3, 22, 2, 1 },
  { 3111, 8, 5, 22, 7, -29 },
  { 3116, 17, 21, 22, 2, -21 },
  { 3161, 16, 27, 22, 3, -27 },
  { 3215, 16, 21, 22, 3, -21 },
  { 3257, 16, 27, 22, 3, -27 },
  { 3311, 16, 21, 22, 3, -21 },
  { 3353, 18, 27, 22, 2, -27 },
  { 3414, 16, 28, 22, 3, -21 },
  { 3470, 16, 27, 22, 3, -27 },
  { 3524, 18, 29, 22, 3, -29 },
  { 3590, 14, 36, 22, 3, -29 },
  { 3653, 17, 27, 22, 4, -27 },
  { 3711, 19, 27, 22, 1, -27 },
  { 3776, 18, 21, 22, 2, -21 },
  { 3824, 16, 21, 22, 3, -21 },
  { 3866, 16, 21, 22, 3, -21 },
  { 3908, 16, 28, 22, 3, -21 },
  { 3964, 16, 28, 22, 3, -21 },
  { 4020, 16, 21, 22, 4, -21 },
  { 4062, 16, 21, 22, 3, -21 },
  { 4104, 17, 26, 22, 2, -26 },
  { 4160, 16, 20, 22, 3, -20 },
  { 4200, 18, 20, 22, 2, -20 },
  { 4245, 20, 20, 22, 1, -20 },
  { 4295, 18, 20, 22, 2, -20 },
  { 4340, 18, 27, 22, 2, -20 },
  { 4401, 16, 20, 22, 3, -20 },
  { 4441, 16, 35, 22, 3, -31 },
  { 4511, 4, 35, 22, 9, -31 },
  { 4529, 16, 35, 22, 3, -31 },
  { 4599, 18, 8, 22, 2, -17 },
};

const GFXfont JetBrainsMono_Regular37pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular37pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular37pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _JETBRAINSMONO_REGULAR37PT7B_H_
