#ifndef _JETBRAINSMONO_REGULAR14PT7B_H_
#define _JETBRAINSMONO_REGULAR14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0xF5, 0x54, 0x70, 0x99, 0x99, 0x12, 0x12, 0x12, 0x6F, 0x24, 0x24,
  0xFE, 0x24, 0x44, 0x48, 0x10, 0x47, 0xF5, 0xD3, 0x47, 0x07, 0x16, 0x5D,
  0x5E, 0x10, 0x40, 0x71, 0x92, 0x94, 0xF4, 0x08, 0x16, 0x1D, 0x29, 0x49,
  0xC7, 0x79, 0x93, 0x12, 0x0E, 0x16, 0xE5, 0x44, 0x9D, 0xEC, 0xFD, 0x17,
  0xC8, 0x88, 0x88, 0x88, 0x84, 0x71, 0x8C, 0x62, 0x31, 0x11, 0x13, 0x26,
  0xC8, 0x08, 0x08, 0x89, 0xFF, 0x08, 0x14, 0x26, 0x24, 0x10, 0x41, 0x3F,
  0x10, 0x41, 0x00, 0x6D, 0x60, 0xF0, 0xF0, 0x04, 0x10, 0xC2, 0x18, 0x41,
  0x0C, 0x20, 0x86, 0x10, 0xC2, 0x00, 0x7F, 0x18, 0x61, 0xB6, 0x58, 0x61,
  0xC5, 0xE0, 0x31, 0xA2, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFC, 0x7B,
  0x18, 0x41, 0x0C, 0x63, 0x18, 0xC3, 0xF0, 0xFC, 0x21, 0x08, 0x38, 0x10,
  0x61, 0xCD, 0xE0, 0x0C, 0x43, 0x08, 0x47, 0x18, 0x7F, 0x04, 0x10, 0xFF,
  0x0C, 0x3E, 0xEC, 0x10, 0x41, 0xC5, 0xE0, 0x18, 0xC2, 0x10, 0xFF, 0x18,
  0x61, 0xC5, 0xE0, 0xFE, 0x10, 0x43, 0x08, 0x61, 0x04, 0x30, 0x80, 0x7B,
  0x1C, 0x53, 0x39, 0xAC, 0x61, 0xC5, 0xE0, 0x7F, 0x18, 0x61, 0xC5, 0xF0,
  0x86, 0x10, 0x80, 0xF0, 0x0F, 0x6C, 0x00, 0x1B, 0x58, 0x04, 0x66, 0x20,
  0x70, 0x70, 0x40, 0xFC, 0x00, 0x3F, 0xFC, 0xC1, 0xC1, 0xC1, 0x19, 0x88,
  0x00, 0xF0, 0xC2, 0x33, 0x31, 0x00, 0x43, 0x00, 0x7D, 0x0E, 0x0C, 0xDB,
  0x74, 0x68, 0xD9, 0x9F, 0x02, 0x03, 0xC1, 0x80, 0x30, 0x60, 0xA3, 0x44,
  0x89, 0x9F, 0x62, 0x85, 0x0C, 0xFB, 0x1C, 0x71, 0xFB, 0x3C, 0x71, 0xC7,
  0xE0, 0x7F, 0x18, 0x60, 0x82, 0x08, 0x21, 0xC5, 0xE0, 0xFB, 0x3C, 0x71,
  0xC7, 0x1C, 0x71, 0xCF, 0xE0, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC3,
  0xF0, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30, 0xC3, 0x00, 0x7F, 0x18, 0x60,
  0x82, 0x78, 0x61, 0xC5, 0xE0, 0xC7, 0x1C, 0x71, 0xFF, 0x1C, 0x71, 0xC7,
  0x10, 0xFC, 0x41, 0x04, 0x10, 0x41, 0x04, 0x13, 0xF0, 0x3C, 0x10, 0x41,
  0x04, 0x10, 0x61, 0x8D, 0xE0, 0xC7, 0x9B, 0x26, 0xCF, 0x1B, 0x32, 0x66,
  0xC5, 0x8C, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xC0, 0xCF, 0x3A, 0xEB,
  0xB6, 0x58, 0x61, 0x86, 0x10, 0xC7, 0x9A, 0x69, 0x96, 0x59, 0x63, 0x8E,
  0x30, 0x7B, 0x18, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xE0, 0xFD, 0x8B, 0x1E,
  0x3C, 0xDF, 0x30, 0x60, 0xC1, 0x80, 0x7F, 0x18, 0x61, 0x86, 0x18, 0x61,
  0xC5, 0xE0, 0x83, 0x04, 0xFD, 0x8B, 0x16, 0x2C, 0xDF, 0x32, 0x64, 0xCD,
  0x8C, 0x7F, 0x1C, 0x30, 0x70, 0x70, 0x61, 0xC5, 0xE0, 0xFE, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0x71,
  0xCD, 0xE0, 0x87, 0x0B, 0x12, 0x24, 0x89, 0x1A, 0x14, 0x30, 0x60, 0xD9,
  0x59, 0x59, 0x59, 0x56, 0x56, 0x56, 0x56, 0x66, 0x66, 0xC6, 0x99, 0xA1,
  0xC3, 0x06, 0x0A, 0x24, 0xC5, 0x0C, 0xC3, 0x62, 0x26, 0x34, 0x1C, 0x18,
  0x08, 0x08, 0x08, 0x08, 0xFC, 0x30, 0x86, 0x10, 0x82, 0x10, 0xC3, 0xF0,
  0xFE, 0x49, 0x24, 0x92, 0x4F, 0xC0, 0x83, 0x04, 0x18, 0x20, 0x83, 0x04,
  0x10, 0x60, 0x83, 0x04, 0x10, 0xFF, 0x33, 0x33, 0x33, 0x33, 0x33, 0xFF,
  0x30, 0xA4, 0x92, 0xC4, 0xFE, 0x90, 0x3B, 0x30, 0x4F, 0xC6, 0x18, 0xDD,
  0xC3, 0x0F, 0xB3, 0xC7, 0x1C, 0x71, 0xC7, 0xE0, 0x39, 0x3C, 0x60, 0x82,
  0x1C, 0x5E, 0x04, 0x17, 0x53, 0xC6, 0x18, 0x61, 0xCD, 0xD0, 0x39, 0x38,
  0x7F, 0x82, 0x0C, 0x5E, 0x3C, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x80,
  0x75, 0x3C, 0x61, 0x87, 0x17, 0xC9, 0x05, 0xF7, 0x00, 0xC3, 0x0F, 0xB3,
  0xC7, 0x1C, 0x71, 0xC7, 0x10, 0x10, 0x60, 0x03, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x23, 0xF8, 0x08, 0xC0, 0xF0, 0x84, 0x21, 0x08, 0x42, 0x1F, 0x60,
  0xC1, 0x83, 0x1E, 0x6C, 0x9F, 0x3E, 0x64, 0xCD, 0x8C, 0xF0, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x0F, 0xEE, 0x59, 0x65, 0x96, 0x59,
  0x65, 0xFB, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0x39, 0x3C, 0x61, 0x86, 0x1C,
  0x5E, 0xFB, 0x3C, 0x71, 0xC7, 0x1C, 0x7E, 0xC3, 0x0C, 0x00, 0x75, 0x3C,
  0x61, 0x86, 0x1C, 0xDD, 0x04, 0x10, 0x40, 0xB6, 0x63, 0x08, 0x42, 0x10,
  0x79, 0x3C, 0x1C, 0x3C, 0x1C, 0x5F, 0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08,
  0x20, 0x70, 0xC7, 0x1C, 0x71, 0xC7, 0x1C, 0xDE, 0x87, 0x09, 0x12, 0x64,
  0x85, 0x0E, 0x18, 0xC9, 0x59, 0x59, 0x5A, 0x56, 0x56, 0x66, 0x26, 0x86,
  0x99, 0xA1, 0x83, 0x0D, 0x13, 0x63, 0x87, 0x89, 0x32, 0x46, 0x87, 0x0C,
  0x08, 0x30, 0x41, 0x80, 0xFC, 0x10, 0x84, 0x31, 0x8C, 0x3F, 0x04, 0x71,
  0x04, 0x10, 0x4F, 0x3C, 0x10, 0x41, 0x04, 0x1C, 0x10, 0xFF, 0xFC, 0xC3,
  0x82, 0x08, 0x20, 0x83, 0xCF, 0x20, 0x82, 0x08, 0xE2, 0x00, 0xE6, 0x70,
  0x80,
};

const GFXglyph JetBrainsMono_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 14, 8, 1, -12 },
  { 27, 8, 10, 8, 0, -10 },
  { 37, 7, 10, 8, 1, -10 },
  { 46, 2, 4, 8, 3, -10 },
  { 47, 4, 14, 8, 3, -12 },
  { 54, 4, 14, 8, 2, -12 },
  { 61, 8, 8, 8, 0, -9 },
  { 69, 6, 7, 8, 1, -8 },
  { 75, 3, 4, 8, 2, -2 },
  { 77, 4, 1, 8, 2, -5 },
  { 78, 2, 2, 8, 3, -2 },
  { 79, 6, 14, 8, 1, -12 },
  { 90, 6, 10, 8, 1, -10 },
  { 98, 7, 10, 8, 1, -10 },
  { 107, 6, 10, 8, 1, -10 },
  { 115, 6, 10, 8, 1, -10 },
  { 123, 6, 10, 8, 1, -10 },
  { 131, 6, 10, 8, 1, -10 },
  { 139, 6, 10, 8, 1, -10 },
  { 147, 6, 10, 8, 1, -10 },
  { 155, 6, 10, 8, 1, -10 },
  { 163, 6, 10, 8, 1, -10 },
  { 171, 2, 8, 8, 3, -8 },
  { 173, 3, 10, 8, 2, -8 },
  { 177, 6, 7, 8, 1, -8 },
  { 183, 6, 5, 8, 1, -7 },
  { 187, 6, 7, 8, 1, -8 },
  { 193, 5, 10, 8, 2, -10 },
  { 200, 7, 13, 8, 1, -10 },
  { 212, 7, 10, 8, 1, -10 },
  { 221, 6, 10, 8, 1, -10 },
  { 229, 6, 10, 8, 1, -10 },
  { 237, 6, 10, 8, 1, -10 },
  { 245, 6, 10, 8, 1, -10 },
  { 253, 6, 10, 8, 1, -10 },
  { 261, 6, 10, 8, 1, -10 },
  { 269, 6, 10, 8, 1, -10 },
  { 277, 6, 10, 8, 1, -10 },
  { 285, 6, 10, 8, 1, -10 },
  { 293, 7, 10, 8, 1, -10 },
  { 302, 5, 10, 8, 2, -10 },
  { 309, 6, 10, 8, 1, -10 },
  { 317, 6, 10, 8, 1, -10 },
  { 325, 6, 10, 8, 1, -10 },
  { 333, 7, 10, 8, 1, -10 },
  { 342, 6, 13, 8, 1, -10 },
  { 352, 7, 10, 8, 1, -10 },
  { 361, 6, 10, 8, 1, -10 },
  { 369, 7, 10, 8, 1, -10 },
  { 378, 6, 10, 8, 1, -10 },
  { 386, 7, 10, 8, 1, -10 },
  { 395, 8, 10, 8, 0, -10 },
  { 405, 7, 10, 8, 1, -10 },
  { 414, 8, 10, 8, 0, -10 },
  { 424, 6, 10, 8, 1, -10 },
  { 432, 3, 14, 8, 3, -12 },
  { 438, 6, 14, 8, 1, -12 },
  { 449, 4, 14, 8, 2, -12 },
  { 456, 6, 5, 8, 1, -10 },
  { 460, 7, 1, 8, 1, 0 },
  { 461, 2, 2, 8, 3, -11 },
  { 462, 6, 8, 8, 1, -8 },
  { 468, 6, 10, 8, 1, -10 },
  { 476, 6, 8, 8, 1, -8 },
  { 482, 6, 10, 8, 1, -10 },
  { 490, 6, 8, 8, 1, -8 },
  { 496, 6, 10, 8, 1, -10 },
  { 504, 6, 11, 8, 1, -8 },
  { 513, 6, 10, 8, 1, -10 },
  { 521, 7, 11, 8, 1, -11 },
  { 531, 5, 14, 8, 1, -11 },
  { 540, 7, 10, 8, 1, -10 },
  { 549, 8, 10, 8, 0, -10 },
  { 559, 6, 8, 8, 1, -8 },
  { 565, 6, 8, 8, 1, -8 },
  { 571, 6, 8, 8, 1, -8 },
  { 577, 6, 11, 8, 1, -8 },
  { 586, 6, 11, 8, 1, -8 },
  { 595, 5, 8, 8, 2, -8 },
  { 600, 6, 8, 8, 1, -8 },
  { 606, 6, 10, 8, 1, -10 },
  { 614, 6, 8, 8, 1, -8 },
  { 620, 7, 8, 8, 1, -8 },
  { 627, 8, 8, 8, 0, -8 },
  { 635, 7, 8, 8, 1, -8 },
  { 642, 7, 11, 8, 1, -8 },
  { 652, 6, 8, 8, 1, -8 },
  { 658, 6, 14, 8, 1, -12 },
  { 669, 1, 14, 8, 4, -12 },
  { 671, 6, 14, 8, 1, -12 },
  { 682, 6, 3, 8, 1, -6 },
};

const GFXfont JetBrainsMono_Regular14pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular14pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular14pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _JETBRAINSMONO_REGULAR14PT7B_H_
