#ifndef _JETBRAINSMONO_REGULAR12PT7B_H_
#define _JETBRAINSMONO_REGULAR12PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular12pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA0, 0xC0, 0xB6, 0xD0, 0x24, 0x48, 0x93, 0xF2, 0x85, 0x3F,
  0x24, 0x48, 0x23, 0xAB, 0x4E, 0x38, 0xA5, 0xAB, 0xC8, 0x40, 0x63, 0x2A,
  0x57, 0x41, 0x05, 0xCA, 0xA5, 0x8E, 0x72, 0x68, 0x10, 0xE6, 0xA9, 0xA6,
  0xEC, 0xF0, 0x36, 0x48, 0x88, 0x88, 0xC4, 0x30, 0xC2, 0x31, 0x11, 0x11,
  0x12, 0xC0, 0x11, 0x25, 0xF0, 0x82, 0x8C, 0x80, 0x21, 0x09, 0xF2, 0x10,
  0x6B, 0x40, 0xF0, 0xB0, 0x08, 0x44, 0x23, 0x10, 0x88, 0x42, 0x20, 0x74,
  0x63, 0x1A, 0xC6, 0x31, 0x70, 0x37, 0xAC, 0x63, 0x18, 0xC6, 0xF8, 0x74,
  0x62, 0x11, 0x99, 0x98, 0xF8, 0xF8, 0xCC, 0x41, 0x84, 0x31, 0x70, 0x18,
  0x88, 0x84, 0xC7, 0xE1, 0x08, 0xFC, 0x21, 0x6C, 0x84, 0x31, 0x70, 0x11,
  0x18, 0x8F, 0xC6, 0x31, 0x70, 0xFC, 0x62, 0x31, 0x08, 0x84, 0x60, 0x74,
  0x62, 0xB3, 0x66, 0x31, 0x78, 0x74, 0x63, 0x1C, 0xBC, 0x44, 0x60, 0xB0,
  0x2C, 0x4C, 0x00, 0xD6, 0x80, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x01, 0xF0,
  0x83, 0x06, 0x36, 0x40, 0xC3, 0x11, 0x64, 0x40, 0xC0, 0x72, 0x28, 0x6F,
  0xA6, 0x9A, 0x6F, 0x82, 0x07, 0x00, 0x20, 0xC5, 0x14, 0x51, 0x2F, 0xA2,
  0x8C, 0xF4, 0x63, 0x1F, 0x46, 0x31, 0xF0, 0x76, 0x63, 0x08, 0x42, 0x11,
  0x70, 0xF4, 0xE3, 0x18, 0xC6, 0x31, 0xF0, 0xFC, 0x21, 0x0F, 0xC2, 0x10,
  0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x76, 0x63, 0x08, 0x5E, 0x31,
  0x70, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42, 0x10, 0x84,
  0xF8, 0x38, 0x42, 0x10, 0x86, 0x31, 0xF0, 0x8E, 0x29, 0x24, 0xE2, 0x49,
  0x22, 0x8C, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x8E, 0xF7, 0xBA, 0xC6,
  0x31, 0x88, 0xCE, 0x73, 0x5A, 0xD6, 0x73, 0x88, 0x76, 0x63, 0x18, 0xC6,
  0x31, 0x70, 0xF2, 0x28, 0xE3, 0xFA, 0x08, 0x20, 0x80, 0x74, 0x63, 0x18,
  0xC6, 0x31, 0x70, 0x82, 0xF2, 0x28, 0xA2, 0xFA, 0x49, 0x22, 0x8C, 0x74,
  0x61, 0x87, 0x04, 0x31, 0x78, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x8E, 0x28, 0xB2, 0x51, 0x45, 0x14,
  0x20, 0x93, 0x25, 0x4B, 0x56, 0xCD, 0x9B, 0x36, 0x6C, 0x46, 0xC8, 0xA1,
  0xC1, 0x07, 0x0A, 0x22, 0xC6, 0xC2, 0x88, 0x91, 0x43, 0x82, 0x04, 0x08,
  0x10, 0xF8, 0x44, 0x22, 0x31, 0x10, 0xF8, 0xFB, 0x6D, 0xB6, 0xDB, 0x80,
  0x86, 0x10, 0x82, 0x10, 0x82, 0x10, 0xC2, 0xE4, 0x92, 0x49, 0x27, 0x80,
  0x22, 0x94, 0x98, 0x80, 0xF8, 0xE0, 0x76, 0x42, 0xF8, 0xC7, 0xE0, 0x84,
  0x2D, 0x98, 0xC6, 0x31, 0xF8, 0x76, 0x63, 0x08, 0x45, 0xC0, 0x08, 0x5B,
  0xB8, 0xC6, 0x31, 0x78, 0x76, 0x63, 0xF8, 0x45, 0xE0, 0x39, 0x09, 0xF2,
  0x10, 0x84, 0x20, 0x6E, 0xE3, 0x18, 0xEC, 0xA1, 0x78, 0x84, 0x2D, 0x98,
  0xC6, 0x31, 0x88, 0x30, 0x0E, 0x08, 0x20, 0x82, 0x08, 0xFC, 0x10, 0xF1,
  0x11, 0x11, 0x11, 0xE0, 0x82, 0x08, 0xE2, 0x93, 0x89, 0x26, 0x8C, 0xF0,
  0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x1E, 0xFD, 0x6B, 0x5A, 0xD6, 0xA0,
  0xB6, 0x63, 0x18, 0xC6, 0x20, 0x76, 0x63, 0x18, 0xC5, 0xC0, 0xB6, 0x63,
  0x18, 0xC7, 0xF0, 0x80, 0x6E, 0xE3, 0x18, 0xC5, 0xE1, 0x08, 0xB6, 0x63,
  0x08, 0x42, 0x00, 0x76, 0x60, 0xE0, 0xC5, 0xE0, 0x27, 0xC8, 0x42, 0x10,
  0x87, 0x8C, 0x63, 0x18, 0xC5, 0xC0, 0x8E, 0x28, 0x96, 0x51, 0x42, 0x00,
  0x92, 0xA5, 0x53, 0x66, 0xCD, 0x9B, 0x00, 0x8B, 0x65, 0x08, 0x51, 0x68,
  0xC0, 0x8E, 0x2C, 0x94, 0x50, 0xC2, 0x08, 0x60, 0xF8, 0x44, 0x44, 0x63,
  0xE0, 0x19, 0x8C, 0x21, 0x70, 0x82, 0x31, 0x06, 0xFF, 0xE0, 0xC1, 0x08,
  0x42, 0x1C, 0x84, 0x21, 0x30, 0xEC, 0xC0,
};

const GFXglyph JetBrainsMono_Regular12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 9, 7, 3, -9 },
  { 4, 3, 4, 7, 2, -9 },
  { 6, 7, 9, 7, 0, -9 },
  { 14, 5, 12, 7, 1, -10 },
  { 22, 7, 9, 7, 0, -9 },
  { 30, 6, 9, 7, 1, -9 },
  { 37, 1, 4, 7, 3, -9 },
  { 38, 4, 11, 7, 2, -10 },
  { 44, 4, 11, 7, 1, -10 },
  { 50, 7, 6, 7, 0, -7 },
  { 56, 5, 6, 7, 1, -7 },
  { 60, 3, 4, 7, 2, -2 },
  { 62, 4, 1, 7, 2, -4 },
  { 63, 2, 2, 7, 3, -2 },
  { 64, 5, 11, 7, 1, -10 },
  { 71, 5, 9, 7, 1, -9 },
  { 77, 5, 9, 7, 1, -9 },
  { 83, 5, 9, 7, 1, -9 },
  { 89, 5, 9, 7, 1, -9 },
  { 95, 5, 9, 7, 1, -9 },
  { 101, 5, 9, 7, 1, -9 },
  { 107, 5, 9, 7, 1, -9 },
  { 113, 5, 9, 7, 1, -9 },
  { 119, 5, 9, 7, 1, -9 },
  { 125, 5, 9, 7, 1, -9 },
  { 131, 2, 7, 7, 3, -7 },
  { 133, 3, 9, 7, 2, -7 },
  { 137, 5, 6, 7, 1, -7 },
  { 141, 5, 4, 7, 1, -6 },
  { 144, 5, 6, 7, 1, -7 },
  { 148, 4, 9, 7, 2, -9 },
  { 153, 6, 11, 7, 1, -9 },
  { 162, 6, 9, 7, 1, -9 },
  { 169, 5, 9, 7, 1, -9 },
  { 175, 5, 9, 7, 1, -9 },
  { 181, 5, 9, 7, 1, -9 },
  { 187, 5, 9, 7, 1, -9 },
  { 193, 5, 9, 7, 1, -9 },
  { 199, 5, 9, 7, 1, -9 },
  { 205, 5, 9, 7, 1, -9 },
  { 211, 5, 9, 7, 1, -9 },
  { 217, 5, 9, 7, 1, -9 },
  { 223, 6, 9, 7, 1, -9 },
  { 230, 5, 9, 7, 1, -9 },
  { 236, 5, 9, 7, 1, -9 },
  { 242, 5, 9, 7, 1, -9 },
  { 248, 5, 9, 7, 1, -9 },
  { 254, 6, 9, 7, 1, -9 },
  { 261, 5, 11, 7, 1, -9 },
  { 268, 6, 9, 7, 1, -9 },
  { 275, 5, 9, 7, 1, -9 },
  { 281, 6, 9, 7, 1, -9 },
  { 288, 5, 9, 7, 1, -9 },
  { 294, 6, 9, 7, 1, -9 },
  { 301, 7, 9, 7, 0, -9 },
  { 309, 7, 9, 7, 0, -9 },
  { 317, 7, 9, 7, 0, -9 },
  { 325, 5, 9, 7, 1, -9 },
  { 331, 3, 11, 7, 2, -10 },
  { 336, 5, 11, 7, 1, -10 },
  { 343, 3, 11, 7, 2, -10 },
  { 348, 5, 5, 7, 1, -9 },
  { 352, 5, 1, 7, 1, 0 },
  { 353, 3, 1, 7, 2, -9 },
  { 354, 5, 7, 7, 1, -7 },
  { 359, 5, 9, 7, 1, -9 },
  { 365, 5, 7, 7, 1, -7 },
  { 370, 5, 9, 7, 1, -9 },
  { 376, 5, 7, 7, 1, -7 },
  { 381, 5, 9, 7, 1, -9 },
  { 387, 5, 9, 7, 1, -7 },
  { 393, 5, 9, 7, 1, -9 },
  { 399, 6, 9, 7, 1, -9 },
  { 406, 4, 11, 7, 1, -9 },
  { 412, 6, 9, 7, 1, -9 },
  { 419, 7, 9, 7, 0, -9 },
  { 427, 5, 7, 7, 1, -7 },
  { 432, 5, 7, 7, 1, -7 },
  { 437, 5, 7, 7, 1, -7 },
  { 442, 5, 9, 7, 1, -7 },
  { 448, 5, 9, 7, 1, -7 },
  { 454, 5, 7, 7, 1, -7 },
  { 459, 5, 7, 7, 1, -7 },
  { 464, 5, 8, 7, 1, -8 },
  { 469, 5, 7, 7, 1, -7 },
  { 474, 6, 7, 7, 1, -7 },
  { 480, 7, 7, 7, 0, -7 },
  { 487, 6, 7, 7, 1, -7 },
  { 493, 6, 9, 7, 1, -7 },
  { 500, 5, 7, 7, 1, -7 },
  { 505, 5, 11, 7, 1, -10 },
  { 512, 1, 11, 7, 3, -10 },
  { 514, 5, 11, 7, 1, -10 },
  { 521, 5, 2, 7, 1, -5 },
};

const GFXfont JetBrainsMono_Regular12pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular12pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _JETBRAINSMONO_REGULAR12PT7B_H_
