#ifndef _JETBRAINSMONO_REGULAR59PT7B_H_
#define _JETBRAINSMONO_REGULAR59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xFB, 0xFF, 0xFF, 0xFF, 0xBF,
  0xDF, 0xC0, 0xFC, 0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03,
  0xEF, 0x80, 0xFB, 0xE0, 0x3E, 0xF8, 0x0F, 0xBE, 0x03, 0xEF, 0x80, 0xFB,
  0xE0, 0x3E, 0x78, 0x0F, 0x9E, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF8, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x03,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0xF0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0,
  0x0F, 0x80, 0x03, 0xC0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xF0, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00,
  0x0F, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x03, 0xC0, 0x0F, 0x00, 0x07,
  0x80, 0x3E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x78,
  0x01, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x80, 0x03, 0xC0,
  0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x1F, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFE,
  0xF7, 0xF8, 0x3F, 0x1E, 0x3F, 0x0F, 0xC3, 0xC3, 0xF1, 0xF0, 0x78, 0x3E,
  0x3E, 0x0F, 0x07, 0xCF, 0xC1, 0xE0, 0xFD, 0xF8, 0x3C, 0x1F, 0xBF, 0x07,
  0x80, 0x07, 0xE0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x0F, 0xC3, 0xC0, 0x01,
  0xFC, 0x78, 0x00, 0x1F, 0xCF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xE7,
  0xF8, 0x00, 0x3C, 0x3F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF0, 0x7E, 0x00,
  0x1E, 0x0F, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0x78, 0x1F, 0xFC, 0x0F, 0x03,
  0xFF, 0x81, 0xE0, 0x7D, 0xF0, 0x3C, 0x1F, 0xBF, 0x07, 0x83, 0xF7, 0xE0,
  0xF0, 0xFC, 0x7F, 0x1E, 0x3F, 0x8F, 0xFB, 0xDF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xCF, 0xFF, 0x00, 0x03, 0xE7, 0xFF,
  0xE0, 0x01, 0xF1, 0xFF, 0xF8, 0x00, 0x78, 0xF8, 0x1F, 0x00, 0x3C, 0x3E,
  0x03, 0xC0, 0x1F, 0x0F, 0x00, 0xF0, 0x07, 0x83, 0xC0, 0x3C, 0x03, 0xC0,
  0xF0, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x3C,
  0x03, 0xC0, 0x3C, 0x1F, 0x00, 0xF0, 0x0F, 0x07, 0x80, 0x3E, 0x03, 0xC3,
  0xC0, 0x0F, 0x81, 0xF1, 0xF0, 0x01, 0xFF, 0xF8, 0x78, 0x00, 0x7F, 0xFE,
  0x3C, 0x00, 0x0F, 0xFF, 0x1F, 0x00, 0x00, 0xFF, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x87, 0xFC,
  0x00, 0x03, 0xC7, 0xFF, 0x80, 0x01, 0xE1, 0xFF, 0xF0, 0x00, 0xF8, 0xFF,
  0xFE, 0x00, 0x3C, 0x7C, 0x0F, 0x80, 0x1E, 0x1F, 0x01, 0xE0, 0x0F, 0x87,
  0x80, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF8,
  0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x1E, 0x0F,
  0x80, 0x7C, 0x07, 0x83, 0xC0, 0x1F, 0x01, 0xE1, 0xE0, 0x03, 0xE0, 0xF8,
  0xF8, 0x00, 0xFF, 0xFE, 0x3C, 0x00, 0x1F, 0xFF, 0x1E, 0x00, 0x03, 0xFF,
  0x8F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x3F, 0x7C,
  0x3F, 0x00, 0xFB, 0xF0, 0x7E, 0x07, 0xEF, 0xC0, 0xFC, 0x1F, 0x3F, 0x01,
  0xF0, 0xF8, 0xFC, 0x07, 0xE7, 0xE3, 0xF0, 0x0F, 0xDF, 0x0F, 0xC0, 0x1F,
  0xFC, 0x3F, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0xFF, 0x83, 0xF0, 0x01, 0xFC,
  0x0F, 0xC0, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x83,
  0xF0, 0x03, 0xFF, 0x07, 0xE0, 0x1F, 0xFC, 0x1F, 0xE1, 0xFD, 0xF8, 0x3F,
  0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0x07, 0xE0, 0xFF, 0xF8, 0x1F, 0x81, 0xFF,
  0x80, 0x3F, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x40, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x00, 0xC0, 0x80, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x0F,
  0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x07, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF0, 0x01,
  0xE0, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x20, 0x07, 0xC0, 0x04, 0xF0, 0x0F, 0x80, 0x79, 0xFC, 0x0F, 0x07, 0xF3,
  0xFE, 0x1C, 0x3F, 0xFF, 0xFF, 0x38, 0xFF, 0xEF, 0xFF, 0x77, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1, 0xFC, 0x1F, 0x81,
  0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x0F,
  0xC0, 0xF8, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x1F, 0xEF, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFB, 0xFE, 0x7F, 0x06, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFE, 0x0F, 0xE0, 0x3F, 0xC7, 0xF0, 0x03, 0xF1, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0xF8, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x1F, 0xC1, 0xFF, 0x87,
  0xF0, 0x7F, 0xE1, 0xFC, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x07, 0x81, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x1F, 0xE3,
  0xE0, 0x07, 0xF8, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03,
  0xC0, 0x3E, 0x00, 0x60, 0x07, 0xC0, 0x08, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE,
  0x0F, 0xE0, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x01,
  0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x0F,
  0xE3, 0xFC, 0x0F, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x07, 0xE1, 0xF8, 0x03, 0xF1, 0xF8,
  0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x7F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF3, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x7F,
  0xC0, 0x7C, 0xFF, 0xF8, 0x3E, 0xFF, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xFE,
  0x7F, 0xE7, 0xF8, 0x07, 0xF3, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xF3, 0xF8, 0x03, 0xF8, 0xFF, 0x07,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC3, 0xC0, 0x01, 0xF3, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x1F, 0xBF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF8, 0x7F, 0x80, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD,
  0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0x7F, 0x00,
  0x7F, 0x07, 0xF8, 0x3F, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0x87, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE7, 0xE0, 0x01,
  0xF0, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x80, 0xFE,
  0x1F, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE3, 0xFC, 0x07, 0xE0, 0x3F,
  0x83, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xBF, 0x80, 0x07, 0xE7, 0xF0, 0x03, 0xF9, 0xFF, 0x07, 0xFC, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00,
  0x2C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFF, 0x0F,
  0xE0, 0x07, 0xE3, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0xFE, 0xFE, 0x00, 0x3F, 0x8F, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFB, 0xE0, 0x0F, 0xFC, 0xFC, 0x00, 0x1C,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x1F, 0xEF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xEF, 0xF9, 0xFC, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE,
  0x7F, 0x06, 0x00, 0x07, 0xC0, 0x7F, 0x87, 0xFC, 0x3F, 0xF1, 0xFF, 0x8F,
  0xFC, 0x7F, 0xC1, 0xFE, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x1F,
  0xC0, 0xFE, 0x0F, 0xE0, 0x7F, 0x03, 0xF0, 0x1F, 0x81, 0xFC, 0x0F, 0xC0,
  0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0xFF, 0xC0, 0x7F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x07, 0xFC, 0x00, 0x0E, 0x1F, 0xF0, 0x01, 0xFE, 0x3F, 0xC0,
  0x1F, 0xFC, 0xFF, 0x00, 0x7F, 0xFB, 0xFC, 0x03, 0xF0, 0x7F, 0xF0, 0x0F,
  0x80, 0xFF, 0xC0, 0x7C, 0x01, 0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x07, 0xC0,
  0x1F, 0xF0, 0x1F, 0x00, 0x7F, 0xC0, 0x7C, 0x01, 0xFF, 0x01, 0xF0, 0x07,
  0xFC, 0x07, 0xC0, 0x1F, 0xF0, 0x1F, 0x00, 0x7F, 0xC0, 0x7C, 0x01, 0xFF,
  0x01, 0xF0, 0x07, 0xFC, 0x07, 0xC0, 0x1F, 0xF0, 0x1F, 0x00, 0x7F, 0xC0,
  0x7C, 0x01, 0xFF, 0x01, 0xF0, 0x07, 0xFC, 0x03, 0xE0, 0x3F, 0xF0, 0x0F,
  0xC1, 0xFF, 0xC0, 0x3F, 0xFE, 0xFF, 0x00, 0x7F, 0xF3, 0xFC, 0x00, 0xFF,
  0x8F, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E,
  0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x7E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E,
  0x03, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x7C,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x7C, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x8F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xE3, 0xF0, 0x03, 0xFC, 0xFC, 0x00, 0x3F, 0xBF, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x1F, 0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03,
  0xF0, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xC7, 0xE0, 0x07, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xEF, 0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF8,
  0x3F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xE3, 0xF0, 0x03,
  0xF0, 0xFF, 0x03, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x30, 0x00, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0x80, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x78, 0x01, 0xFF, 0xEF, 0x00, 0x7F, 0xFD, 0xF0, 0x0F,
  0x7F, 0x9E, 0x01, 0xEF, 0xFB, 0xC0, 0x7D, 0xFF, 0x7C, 0x0F, 0x3F, 0xE7,
  0x81, 0xE7, 0xFC, 0xF0, 0x7C, 0xFF, 0x9F, 0x0F, 0x1F, 0xF1, 0xE1, 0xE7,
  0xFE, 0x3C, 0x7C, 0xFF, 0xC7, 0x8F, 0x1F, 0xF8, 0xF9, 0xE3, 0xFF, 0x0F,
  0x3C, 0x7F, 0xE1, 0xEF, 0x0F, 0xFC, 0x3F, 0xE1, 0xFF, 0x83, 0xFC, 0x3F,
  0xF8, 0x7F, 0x07, 0xFF, 0x0F, 0xE0, 0xFF, 0xE0, 0xFC, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0x80, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFB, 0xC0, 0x0F, 0xFD, 0xF0, 0x07, 0xFE, 0xF8,
  0x03, 0xFF, 0x3E, 0x01, 0xFF, 0x9F, 0x00, 0xFF, 0xC7, 0x80, 0x7F, 0xE3,
  0xE0, 0x3F, 0xF1, 0xF0, 0x1F, 0xF8, 0x78, 0x0F, 0xFC, 0x3E, 0x07, 0xFE,
  0x1F, 0x03, 0xFF, 0x07, 0x81, 0xFF, 0x83, 0xE0, 0xFF, 0xC1, 0xF0, 0x7F,
  0xE0, 0x78, 0x3F, 0xF0, 0x3E, 0x1F, 0xF8, 0x1F, 0x0F, 0xFC, 0x07, 0xC7,
  0xFE, 0x03, 0xE3, 0xFF, 0x00, 0xF1, 0xFF, 0x80, 0x7C, 0xFF, 0xC0, 0x3E,
  0x7F, 0xE0, 0x0F, 0x3F, 0xF0, 0x07, 0xDF, 0xF8, 0x03, 0xEF, 0xFC, 0x00,
  0xF7, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0x7F, 0xC0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F,
  0xF1, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0,
  0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xFC, 0x01, 0xFC, 0x7F, 0x83, 0xFC, 0x1F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x7F, 0xBF,
  0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xEF, 0xC0,
  0x3F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F,
  0xC7, 0xF0, 0x07, 0xF1, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFB, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7, 0xF0, 0x07, 0xF0,
  0xFF, 0x07, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0xFF,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x03, 0xFB, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0xCF,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x7F,
  0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F,
  0xC0, 0xFF, 0x07, 0xE0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC,
  0x00, 0x1F, 0x8F, 0xE0, 0x07, 0xF1, 0xFF, 0x87, 0xFC, 0x1F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x03, 0xF1, 0xF8, 0x03,
  0xF8, 0xFF, 0x07, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0x80, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x7E, 0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8,
  0x3E, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x3E,
  0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xFC, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x1F, 0x1F, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xBE, 0x01, 0xF8, 0x07, 0xDF, 0x00, 0xFC, 0x03, 0xEF, 0x80, 0x7E, 0x01,
  0xF7, 0xC0, 0x3F, 0x00, 0xF3, 0xE0, 0x3F, 0x80, 0xF9, 0xF0, 0x1D, 0xC0,
  0x7C, 0xF8, 0x0E, 0xE0, 0x3E, 0x7C, 0x07, 0x78, 0x1F, 0x1F, 0x03, 0xBC,
  0x0F, 0x8F, 0x81, 0xCE, 0x07, 0xC7, 0xC0, 0xE7, 0x03, 0xE3, 0xE0, 0x73,
  0x81, 0xE1, 0xF0, 0x79, 0xC0, 0xF0, 0xF8, 0x3C, 0xE0, 0x78, 0x7C, 0x1C,
  0x70, 0x7C, 0x3E, 0x0E, 0x38, 0x3E, 0x1F, 0x07, 0x1E, 0x1F, 0x07, 0x83,
  0x8F, 0x0F, 0x83, 0xE1, 0xC3, 0x87, 0xC1, 0xF1, 0xE1, 0xC3, 0xE0, 0xF8,
  0xF0, 0xE1, 0xE0, 0x7C, 0x78, 0x70, 0xF0, 0x3E, 0x38, 0x38, 0x78, 0x1F,
  0x1C, 0x1C, 0x7C, 0x0F, 0x8E, 0x0F, 0x3E, 0x03, 0xC7, 0x07, 0x9F, 0x01,
  0xE3, 0x83, 0xCF, 0x80, 0xF3, 0xC0, 0xE7, 0xC0, 0x7D, 0xE0, 0x73, 0xC0,
  0x3E, 0xF0, 0x39, 0xE0, 0x1F, 0x78, 0x1C, 0xF0, 0x0F, 0xB8, 0x0E, 0x78,
  0x07, 0xDC, 0x07, 0x3C, 0x03, 0xEE, 0x03, 0xFE, 0x00, 0xF7, 0x01, 0xFF,
  0x00, 0x7B, 0x80, 0xFF, 0x80, 0x3F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0xFC, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x7C,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01,
  0xFB, 0xF8, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x00,
  0xFD, 0xF8, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x00,
  0xF8, 0x7C, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0x8F, 0x80,
  0x03, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x03,
  0xC0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x7C,
  0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xF1,
  0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x07,
  0xF0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xD0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0x7F, 0x00, 0x77, 0xDF, 0xFF, 0xFD, 0xF3, 0xFF, 0xFE, 0x7C,
  0x7F, 0xFF, 0x1F, 0x07, 0xFF, 0x07, 0xC0, 0x1C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x1F, 0x8F, 0xFE, 0x0F,
  0xCF, 0xFF, 0xC7, 0xEF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0x00, 0xFE,
  0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFB, 0xFF, 0x03, 0xFD,
  0xFB, 0xFF, 0xFC, 0xFD, 0xFF, 0xFC, 0x7E, 0x7F, 0xFC, 0x3F, 0x0F, 0xFC,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xC7,
  0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xF9, 0xFC, 0x00, 0xFC, 0x3F,
  0xC0, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x7F, 0x03, 0xE0, 0xFF, 0xE1, 0xF0, 0xFF, 0xFC, 0xF8,
  0xFF, 0xFE, 0x7C, 0xFF, 0xFF, 0xBE, 0xFF, 0x01, 0xDF, 0x7E, 0x00, 0x3F,
  0xBF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xF7,
  0xE0, 0x03, 0xFB, 0xF8, 0x03, 0x7C, 0xFF, 0x07, 0xBE, 0x7F, 0xFF, 0xDF,
  0x1F, 0xFF, 0xCF, 0x87, 0xFF, 0xC7, 0xC0, 0xFF, 0xC3, 0xE0, 0x07, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x83, 0xFE, 0x3F, 0xE1, 0xF8, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xDF, 0x80,
  0x07, 0xEF, 0xE0, 0x07, 0xE3, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFF,
  0xC7, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xFD, 0xF3, 0xFF, 0xFE, 0xF9, 0xFC,
  0x07, 0x7D, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0x7F, 0x00,
  0x3F, 0x9F, 0xC0, 0x77, 0xCF, 0xFF, 0xFB, 0xE3, 0xFF, 0xF9, 0xF0, 0xFF,
  0xFC, 0xF8, 0x3F, 0xFC, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x1F,
  0x8F, 0xFE, 0x0F, 0xCF, 0xFF, 0xC7, 0xEF, 0xFF, 0xF3, 0xFF, 0xDF, 0xF9,
  0xFF, 0x00, 0xFE, 0xFF, 0x00, 0x3F, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0xFE, 0x1F, 0x00, 0x1F, 0x83, 0xE0,
  0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0xC0,
  0x3E, 0x03, 0xF0, 0x07, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x01,
  0xF0, 0x1F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x7F, 0x03, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC7, 0xC0, 0x01,
  0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0x80,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0xBF, 0xC7,
  0xF8, 0xFB, 0xFE, 0xFF, 0xCF, 0xFF, 0xEF, 0xFE, 0xFC, 0x3F, 0x87, 0xEF,
  0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x03, 0xEF, 0x80, 0xF0, 0x1E, 0xF8, 0x0F,
  0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F,
  0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80,
  0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01,
  0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8,
  0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0,
  0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF,
  0x80, 0xF0, 0x1F, 0xF8, 0x0F, 0x01, 0xFF, 0x80, 0xF0, 0x1F, 0xF8, 0x0F,
  0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x7E, 0x3F, 0xF8, 0x3F, 0x3F, 0xFF, 0x1F,
  0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFC, 0x03, 0xFB, 0xFC, 0x00, 0xFD,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x7F,
  0x80, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE1, 0xFC, 0x07, 0xF9, 0xFC, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x0F, 0xCF, 0xE0,
  0x0F, 0xE3, 0xFE, 0x3F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x3F, 0xF8,
  0x3F, 0x3F, 0xFF, 0x1F, 0xBF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFC, 0x03,
  0xFB, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xEF, 0xFC, 0x0F,
  0xF7, 0xEF, 0xFF, 0xF3, 0xF7, 0xFF, 0xF1, 0xF9, 0xFF, 0xF0, 0xFC, 0x3F,
  0xF0, 0x7E, 0x03, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0x87, 0xC3, 0xFF, 0xF3, 0xE3, 0xFF, 0xF9,
  0xF3, 0xFF, 0xFE, 0xFB, 0xFC, 0x07, 0x7D, 0xF8, 0x00, 0xFE, 0xFC, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x0F,
  0xEF, 0xE0, 0x0D, 0xF3, 0xFC, 0x1E, 0xF9, 0xFF, 0xFF, 0x7C, 0x7F, 0xFF,
  0x3E, 0x1F, 0xFF, 0x1F, 0x03, 0xFF, 0x0F, 0x80, 0x1C, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0x7C, 0x7F, 0xF0,
  0x3E, 0x7F, 0xFE, 0x1F, 0x7F, 0xFF, 0x8F, 0xFE, 0x7F, 0xE7, 0xF8, 0x07,
  0xF3, 0xF8, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x0F, 0xC0, 0x0F, 0xE7, 0xE0, 0x01,
  0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x7F, 0x80, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x3F,
  0x00, 0x1F, 0x8F, 0xC0, 0x1F, 0xC7, 0xF8, 0x3F, 0xC1, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7C,
  0x7C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x00, 0x7C, 0x03, 0xE0, 0x03,
  0xE0, 0x3F, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0,
  0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0xF0, 0x0F, 0xC0, 0x3D, 0xE0, 0x1F, 0x80, 0xFB, 0xC0, 0x3F, 0x01,
  0xF7, 0x80, 0xFE, 0x03, 0xEF, 0x81, 0xDC, 0x07, 0x9F, 0x03, 0xB8, 0x0F,
  0x3E, 0x07, 0x70, 0x1E, 0x7C, 0x0E, 0xF0, 0x3C, 0x78, 0x1C, 0xE0, 0xF8,
  0xF0, 0x79, 0xC1, 0xF1, 0xE0, 0xE3, 0x83, 0xC3, 0xE1, 0xC7, 0x07, 0x87,
  0xC3, 0x8E, 0x0F, 0x0F, 0x87, 0x1E, 0x1E, 0x0F, 0x0E, 0x3C, 0x3C, 0x1E,
  0x3C, 0x38, 0xF8, 0x3C, 0x70, 0x71, 0xE0, 0x78, 0xE0, 0xE3, 0xC0, 0xF9,
  0xC1, 0xC7, 0x81, 0xF3, 0x83, 0xCF, 0x01, 0xE7, 0x07, 0x9E, 0x03, 0xCE,
  0x07, 0x7C, 0x07, 0xB8, 0x0E, 0xF0, 0x0F, 0x70, 0x1D, 0xE0, 0x1E, 0xE0,
  0x3B, 0xC0, 0x3F, 0xC0, 0x77, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x7F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F,
  0x80, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x01, 0xF0, 0x03,
  0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x01, 0xF1,
  0xFF, 0x00, 0x1F, 0x3F, 0xF8, 0x01, 0xF7, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xC3, 0xF0, 0x3F, 0xF8, 0x1F, 0x83, 0xEF, 0x80, 0xFC, 0x7E,
  0xF8, 0x07, 0xFF, 0xEF, 0x80, 0x7F, 0xFC, 0xF8, 0x01, 0xFF, 0x8F, 0x80,
  0x0F, 0xF0,
};

const GFXglyph JetBrainsMono_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 43, 35, 13, -43 },
  { 50, 18, 18, 35, 9, -43 },
  { 91, 31, 43, 35, 2, -43 },
  { 258, 27, 59, 35, 4, -51 },
  { 458, 34, 43, 35, 1, -43 },
  { 641, 30, 45, 35, 3, -44 },
  { 810, 5, 18, 35, 15, -43 },
  { 822, 18, 57, 35, 11, -50 },
  { 951, 17, 57, 35, 7, -50 },
  { 1073, 31, 30, 35, 2, -36 },
  { 1190, 28, 27, 35, 4, -33 },
  { 1285, 12, 18, 35, 10, -9 },
  { 1312, 19, 5, 35, 8, -22 },
  { 1324, 10, 10, 35, 13, -9 },
  { 1337, 27, 55, 35, 4, -49 },
  { 1523, 26, 45, 35, 5, -44 },
  { 1670, 27, 43, 35, 5, -43 },
  { 1816, 27, 44, 35, 4, -44 },
  { 1965, 26, 44, 35, 4, -43 },
  { 2108, 25, 43, 35, 5, -43 },
  { 2243, 25, 44, 35, 5, -43 },
  { 2381, 27, 44, 35, 4, -43 },
  { 2530, 27, 43, 35, 5, -43 },
  { 2676, 26, 45, 35, 5, -44 },
  { 2823, 27, 44, 35, 4, -44 },
  { 2972, 10, 34, 35, 13, -33 },
  { 3015, 13, 42, 35, 10, -33 },
  { 3084, 25, 31, 35, 5, -35 },
  { 3181, 25, 19, 35, 5, -29 },
  { 3241, 25, 31, 35, 5, -35 },
  { 3338, 21, 43, 35, 8, -43 },
  { 3451, 30, 55, 35, 3, -44 },
  { 3658, 29, 43, 35, 3, -43 },
  { 3814, 26, 43, 35, 5, -43 },
  { 3954, 26, 45, 35, 5, -44 },
  { 4101, 25, 43, 35, 5, -43 },
  { 4236, 25, 43, 35, 6, -43 },
  { 4371, 25, 43, 35, 6, -43 },
  { 4506, 26, 45, 35, 5, -44 },
  { 4653, 25, 43, 35, 5, -43 },
  { 4788, 23, 43, 35, 6, -43 },
  { 4912, 26, 44, 35, 3, -43 },
  { 5055, 28, 43, 35, 5, -43 },
  { 5206, 25, 43, 35, 7, -43 },
  { 5341, 27, 43, 35, 4, -43 },
  { 5487, 25, 43, 35, 5, -43 },
  { 5622, 25, 45, 35, 5, -44 },
  { 5763, 27, 43, 35, 5, -43 },
  { 5909, 26, 55, 35, 5, -44 },
  { 6088, 27, 43, 35, 5, -43 },
  { 6234, 27, 45, 35, 4, -44 },
  { 6386, 29, 43, 35, 3, -43 },
  { 6542, 25, 44, 35, 5, -43 },
  { 6680, 29, 43, 35, 3, -43 },
  { 6836, 33, 43, 35, 1, -43 },
  { 7014, 31, 43, 35, 2, -43 },
  { 7181, 31, 43, 35, 2, -43 },
  { 7348, 25, 43, 35, 5, -43 },
  { 7483, 15, 55, 35, 12, -49 },
  { 7587, 27, 55, 35, 4, -49 },
  { 7773, 14, 55, 35, 9, -49 },
  { 7870, 26, 23, 35, 5, -43 },
  { 7945, 28, 5, 35, 4, 1 },
  { 7963, 12, 8, 35, 11, -46 },
  { 7975, 26, 34, 35, 4, -33 },
  { 8086, 25, 44, 35, 5, -43 },
  { 8224, 26, 34, 35, 5, -33 },
  { 8335, 25, 44, 35, 5, -43 },
  { 8473, 25, 34, 35, 5, -33 },
  { 8580, 28, 43, 35, 4, -43 },
  { 8731, 25, 44, 35, 5, -33 },
  { 8869, 25, 43, 35, 5, -43 },
  { 9004, 28, 46, 35, 5, -46 },
  { 9165, 22, 57, 35, 5, -46 },
  { 9322, 27, 43, 35, 6, -43 },
  { 9468, 30, 43, 35, 2, -43 },
  { 9630, 28, 33, 35, 4, -33 },
  { 9746, 25, 33, 35, 5, -33 },
  { 9850, 25, 33, 35, 5, -33 },
  { 9954, 25, 44, 35, 5, -33 },
  { 10092, 25, 44, 35, 5, -33 },
  { 10230, 25, 33, 35, 7, -33 },
  { 10334, 26, 33, 35, 5, -33 },
  { 10442, 28, 42, 35, 3, -42 },
  { 10589, 25, 33, 35, 5, -32 },
  { 10693, 29, 32, 35, 3, -32 },
  { 10809, 31, 32, 35, 2, -32 },
  { 10933, 29, 32, 35, 3, -32 },
  { 11049, 29, 43, 35, 3, -32 },
  { 11205, 25, 32, 35, 5, -32 },
  { 11305, 25, 55, 35, 5, -49 },
  { 11477, 5, 55, 35, 15, -49 },
  { 11512, 25, 55, 35, 5, -49 },
  { 11684, 28, 12, 35, 4, -27 },
};

const GFXfont JetBrainsMono_Regular59pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular59pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular59pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _JETBRAINSMONO_REGULAR59PT7B_H_
