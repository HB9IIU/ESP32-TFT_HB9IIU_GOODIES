#ifndef _JETBRAINSMONO_REGULAR16PT7B_H_
#define _JETBRAINSMONO_REGULAR16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xEA, 0x8F, 0xCE, 0x72, 0x94, 0x80, 0x32, 0x22, 0x22, 0x22,
  0xFF, 0x24, 0x44, 0x44, 0xFE, 0x4C, 0x48, 0xC8, 0x10, 0x20, 0xF3, 0xB5,
  0x3A, 0x14, 0x3C, 0x1C, 0x2C, 0x4E, 0x95, 0x6F, 0x84, 0x08, 0x70, 0xEC,
  0xE2, 0x51, 0x4D, 0x61, 0x20, 0x20, 0x2F, 0x14, 0x92, 0x51, 0x38, 0xF0,
  0x38, 0x6C, 0x44, 0x40, 0x60, 0x60, 0xF3, 0x9A, 0x8E, 0x84, 0xCE, 0x7B,
  0xF8, 0x1B, 0x11, 0x8C, 0x42, 0x10, 0x84, 0x30, 0x86, 0x1C, 0x20, 0xC3,
  0x0C, 0x21, 0x8C, 0x63, 0x18, 0xC4, 0x23, 0x72, 0x00, 0x18, 0x18, 0x91,
  0xD7, 0x3C, 0x38, 0x2C, 0x66, 0x44, 0x18, 0x18, 0x18, 0xFF, 0x18, 0x18,
  0x18, 0x7B, 0x48, 0xF8, 0x5D, 0x80, 0x02, 0x0C, 0x10, 0x60, 0xC1, 0x06,
  0x08, 0x10, 0x60, 0x83, 0x06, 0x08, 0x30, 0x00, 0x3C, 0xCF, 0x0E, 0x1C,
  0x3B, 0x76, 0xE1, 0xC3, 0x85, 0x19, 0xE0, 0x18, 0x78, 0xC8, 0x88, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x38, 0xDF, 0x0E, 0x10, 0x20,
  0xC3, 0x0C, 0x30, 0xC3, 0x07, 0xF0, 0x7E, 0xFC, 0x30, 0xC3, 0x07, 0x81,
  0x81, 0x03, 0x85, 0x1B, 0xE0, 0x04, 0x18, 0x60, 0x83, 0x0C, 0x50, 0xE1,
  0xFE, 0x04, 0x08, 0x10, 0x7E, 0xFD, 0x02, 0x05, 0x8F, 0xD0, 0x81, 0x03,
  0x85, 0x19, 0xE0, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x7C, 0xC6, 0xC2, 0xC3,
  0xC2, 0x66, 0x3C, 0xFF, 0xFF, 0xC2, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x18,
  0x18, 0x10, 0x30, 0x3C, 0xDD, 0x0A, 0x14, 0x67, 0x8F, 0x23, 0xC3, 0x85,
  0x1B, 0xE0, 0x38, 0x6E, 0xC2, 0xC2, 0xC3, 0xC2, 0x7E, 0x14, 0x0C, 0x08,
  0x18, 0x30, 0x7C, 0x00, 0x07, 0x60, 0x7C, 0x00, 0x03, 0x5A, 0x40, 0x02,
  0x0C, 0x73, 0x8C, 0x1C, 0x0E, 0x07, 0x02, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x81, 0x80, 0xC0, 0x60, 0x20, 0xC6, 0x70, 0x80, 0xF3, 0xE0, 0xC3, 0x0C,
  0x27, 0x18, 0x60, 0x06, 0x18, 0x3C, 0x66, 0xC3, 0x81, 0x8D, 0x9B, 0x91,
  0x91, 0x91, 0x91, 0x9F, 0x80, 0xC0, 0x60, 0x38, 0x18, 0x18, 0x38, 0x2C,
  0x2C, 0x64, 0x64, 0x46, 0x7E, 0xC2, 0xC2, 0x83, 0xF9, 0xFF, 0x0E, 0x1C,
  0x7F, 0xBF, 0xE1, 0xC3, 0x87, 0x1F, 0xE0, 0x3C, 0xDD, 0x0E, 0x1C, 0x18,
  0x30, 0x60, 0xC1, 0x85, 0x99, 0xE0, 0xF9, 0xFB, 0x1E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x1F, 0xE0, 0xFF, 0xF8, 0x20, 0x83, 0xFF, 0xE0, 0x82,
  0x08, 0x3F, 0xFF, 0xF8, 0x20, 0x83, 0xFF, 0xE0, 0x82, 0x08, 0x20, 0x3C,
  0xDD, 0x0E, 0x1C, 0x18, 0x37, 0xE1, 0xC3, 0x85, 0x99, 0xE0, 0xC3, 0x87,
  0x0E, 0x1C, 0x3F, 0xFF, 0xE1, 0xC3, 0x87, 0x0E, 0x10, 0xFF, 0xF3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3F, 0x1E, 0x3C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x07, 0x0F, 0x13, 0xE0, 0xC3, 0xC2, 0xC6, 0xC4, 0xCC, 0xF8, 0xF8,
  0xCC, 0xC4, 0xC6, 0xC2, 0xC3, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x07, 0xF0, 0xC7, 0x8E, 0x9D, 0x3A, 0xBB, 0x76, 0xE1, 0xC3,
  0x87, 0x0E, 0x10, 0xC3, 0xC7, 0x8F, 0x1D, 0x3A, 0x76, 0xE5, 0xCB, 0x9F,
  0x1E, 0x30, 0x3C, 0xDD, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x85, 0x99,
  0xE0, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC2, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x3C, 0xDF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x85, 0x99, 0xE0,
  0xC0, 0xC0, 0x80, 0xF8, 0xFE, 0xC2, 0xC3, 0xC2, 0xC6, 0xFC, 0xCC, 0xCC,
  0xC6, 0xC6, 0xC3, 0x3C, 0xDD, 0x0E, 0x04, 0x0F, 0x07, 0x03, 0x03, 0x85,
  0x1B, 0xE0, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x85, 0x99,
  0xE0, 0x83, 0xC2, 0xC2, 0x42, 0x46, 0x64, 0x64, 0x24, 0x2C, 0x38, 0x38,
  0x18, 0xCC, 0xA6, 0x53, 0x29, 0x94, 0xDA, 0xAD, 0x54, 0xEA, 0x73, 0x39,
  0x8C, 0xC6, 0x60, 0xC3, 0xC2, 0x66, 0x24, 0x38, 0x18, 0x18, 0x38, 0x2C,
  0x66, 0xC2, 0xC3, 0x83, 0xC2, 0x42, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0xFC, 0x18, 0x20, 0x83, 0x04, 0x18, 0x20, 0xC3,
  0x07, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCC, 0xCF, 0xF0, 0xC0, 0x81,
  0x81, 0x03, 0x06, 0x04, 0x0C, 0x08, 0x10, 0x30, 0x20, 0x60, 0xC0, 0x80,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0xF0, 0x18, 0x30, 0xA1, 0x26,
  0x48, 0x70, 0x80, 0xFF, 0xFF, 0xC8, 0x80, 0x3C, 0xCF, 0x08, 0x17, 0xF8,
  0x60, 0xE3, 0x7A, 0xC1, 0x83, 0x06, 0xEE, 0x78, 0x70, 0xE1, 0xC3, 0x87,
  0x9F, 0xE0, 0x3C, 0xCF, 0x0E, 0x0C, 0x18, 0x30, 0xB3, 0x3C, 0x02, 0x04,
  0x09, 0xD6, 0x78, 0x70, 0xE1, 0xC3, 0x85, 0x1B, 0xD0, 0x3C, 0xCF, 0x0E,
  0x1F, 0xF8, 0x30, 0x23, 0x3C, 0x0F, 0x1F, 0x10, 0x10, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x3A, 0xCF, 0x0E, 0x1C, 0x38, 0x51, 0xBD,
  0x02, 0x04, 0x19, 0xE0, 0xC1, 0x83, 0x06, 0xEE, 0x78, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x10, 0x18, 0x18, 0x00, 0x78, 0x78, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xFF, 0x0C, 0x10, 0x1F, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x0C, 0x6F, 0x00, 0x81, 0x02, 0x04, 0x38, 0xD1, 0x26, 0x78, 0x99, 0x12,
  0x34, 0x30, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x02, 0x01, 0xF0, 0xB6, 0xDA, 0x93, 0x93, 0x93, 0x93, 0x93, 0x93,
  0x93, 0xDD, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x3C, 0xCF, 0x0E,
  0x1C, 0x38, 0x70, 0xB3, 0x3C, 0xDD, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xF3,
  0xDD, 0x83, 0x06, 0x00, 0x3A, 0xCF, 0x0E, 0x1C, 0x38, 0x70, 0xA3, 0x7A,
  0x04, 0x08, 0x10, 0xB9, 0x9A, 0x14, 0x38, 0x10, 0x20, 0x40, 0x80, 0x3C,
  0xCD, 0x03, 0x03, 0xC0, 0xC0, 0xE3, 0x7C, 0x30, 0x63, 0xFF, 0xF3, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0x78, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xB3,
  0x3C, 0x83, 0xC2, 0x42, 0x46, 0x64, 0x24, 0x2C, 0x38, 0x18, 0x99, 0x99,
  0x9B, 0x9A, 0xAA, 0xEA, 0x66, 0x66, 0x66, 0xC3, 0x66, 0x2C, 0x38, 0x18,
  0x38, 0x2C, 0x46, 0xC3, 0xC3, 0xC2, 0x46, 0x64, 0x24, 0x2C, 0x38, 0x18,
  0x18, 0x10, 0x30, 0x30, 0x7E, 0xFC, 0x10, 0x41, 0x86, 0x18, 0x60, 0xFE,
  0x0E, 0x10, 0x20, 0x40, 0x81, 0x06, 0x78, 0x08, 0x10, 0x20, 0x40, 0x81,
  0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x60, 0x40, 0x83, 0x06, 0x06,
  0x0F, 0x10, 0x60, 0xC0, 0x81, 0x1E, 0x38, 0x00, 0xF3, 0x9A, 0x8E,
};

const GFXglyph JetBrainsMono_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 5, 5, 10, 2, -12 },
  { 8, 8, 12, 10, 1, -12 },
  { 20, 7, 16, 10, 1, -14 },
  { 34, 9, 12, 10, 0, -12 },
  { 48, 8, 12, 10, 1, -12 },
  { 60, 1, 5, 10, 4, -12 },
  { 61, 5, 15, 10, 3, -13 },
  { 71, 5, 15, 10, 2, -13 },
  { 81, 8, 9, 10, 1, -10 },
  { 90, 8, 7, 10, 1, -9 },
  { 97, 3, 5, 10, 3, -2 },
  { 99, 5, 1, 10, 2, -6 },
  { 100, 3, 3, 10, 3, -3 },
  { 102, 7, 15, 10, 1, -13 },
  { 116, 7, 12, 10, 1, -12 },
  { 127, 8, 12, 10, 1, -12 },
  { 139, 7, 12, 10, 1, -12 },
  { 150, 7, 12, 10, 1, -12 },
  { 161, 7, 12, 10, 1, -12 },
  { 172, 7, 12, 10, 1, -12 },
  { 183, 8, 12, 10, 1, -12 },
  { 195, 8, 12, 10, 1, -12 },
  { 207, 7, 12, 10, 1, -12 },
  { 218, 8, 12, 10, 1, -12 },
  { 230, 3, 9, 10, 3, -9 },
  { 234, 3, 12, 10, 3, -9 },
  { 239, 7, 9, 10, 1, -10 },
  { 247, 7, 5, 10, 1, -8 },
  { 252, 7, 9, 10, 1, -10 },
  { 260, 6, 12, 10, 2, -12 },
  { 269, 8, 15, 10, 1, -12 },
  { 284, 8, 12, 10, 1, -12 },
  { 296, 7, 12, 10, 1, -12 },
  { 307, 7, 12, 10, 1, -12 },
  { 318, 7, 12, 10, 1, -12 },
  { 329, 6, 12, 10, 2, -12 },
  { 338, 6, 12, 10, 2, -12 },
  { 347, 7, 12, 10, 1, -12 },
  { 358, 7, 12, 10, 1, -12 },
  { 369, 6, 12, 10, 2, -12 },
  { 378, 7, 12, 10, 1, -12 },
  { 389, 8, 12, 10, 1, -12 },
  { 401, 7, 12, 10, 2, -12 },
  { 412, 7, 12, 10, 1, -12 },
  { 423, 7, 12, 10, 1, -12 },
  { 434, 7, 12, 10, 1, -12 },
  { 445, 8, 12, 10, 1, -12 },
  { 457, 7, 15, 10, 1, -12 },
  { 471, 8, 12, 10, 1, -12 },
  { 483, 7, 12, 10, 1, -12 },
  { 494, 8, 12, 10, 1, -12 },
  { 506, 7, 12, 10, 1, -12 },
  { 517, 8, 12, 10, 1, -12 },
  { 529, 9, 12, 10, 0, -12 },
  { 543, 8, 12, 10, 1, -12 },
  { 555, 8, 12, 10, 1, -12 },
  { 567, 7, 12, 10, 1, -12 },
  { 578, 4, 15, 10, 3, -13 },
  { 586, 7, 15, 10, 1, -13 },
  { 600, 4, 15, 10, 2, -13 },
  { 608, 7, 7, 10, 1, -12 },
  { 615, 8, 2, 10, 1, 0 },
  { 617, 3, 3, 10, 3, -13 },
  { 619, 7, 9, 10, 1, -9 },
  { 627, 7, 12, 10, 1, -12 },
  { 638, 7, 9, 10, 1, -9 },
  { 646, 7, 12, 10, 1, -12 },
  { 657, 7, 9, 10, 1, -9 },
  { 665, 8, 12, 10, 1, -12 },
  { 677, 7, 12, 10, 1, -9 },
  { 688, 7, 12, 10, 1, -12 },
  { 699, 8, 12, 10, 1, -12 },
  { 711, 6, 15, 10, 1, -12 },
  { 723, 7, 12, 10, 2, -12 },
  { 734, 9, 12, 10, 0, -12 },
  { 748, 8, 9, 10, 1, -9 },
  { 757, 7, 9, 10, 1, -9 },
  { 765, 7, 9, 10, 1, -9 },
  { 773, 7, 12, 10, 1, -9 },
  { 784, 7, 12, 10, 1, -9 },
  { 795, 7, 9, 10, 2, -9 },
  { 803, 7, 9, 10, 1, -9 },
  { 811, 7, 11, 10, 1, -11 },
  { 821, 7, 9, 10, 1, -9 },
  { 829, 8, 9, 10, 1, -9 },
  { 838, 8, 9, 10, 1, -9 },
  { 847, 8, 9, 10, 1, -9 },
  { 856, 8, 12, 10, 1, -9 },
  { 868, 7, 9, 10, 1, -9 },
  { 876, 7, 15, 10, 1, -13 },
  { 890, 2, 15, 10, 4, -13 },
  { 894, 7, 15, 10, 1, -13 },
  { 908, 8, 3, 10, 1, -7 },
};

const GFXfont JetBrainsMono_Regular16pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular16pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular16pt7bGlyphs,
  0x20, 0x7E, 21
};

#endif // _JETBRAINSMONO_REGULAR16PT7B_H_
