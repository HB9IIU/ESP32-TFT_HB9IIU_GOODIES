#ifndef _JETBRAINSMONO_REGULAR53PT7B_H_
#define _JETBRAINSMONO_REGULAR53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0xF8, 0x1E, 0xF8, 0x1E, 0x78, 0x1E,
  0x00, 0x78, 0x03, 0x80, 0x07, 0x80, 0x78, 0x00, 0x78, 0x07, 0x80, 0x07,
  0x80, 0x78, 0x00, 0x70, 0x07, 0x80, 0x07, 0x00, 0x70, 0x00, 0xF0, 0x07,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xE0, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x1E, 0x00, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00,
  0x3C, 0x01, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0,
  0x3C, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x38, 0x00, 0x78, 0x07, 0x80,
  0x07, 0x80, 0x78, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xFC, 0x0F, 0x00, 0x70, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x01, 0xE0, 0x0E, 0x00, 0x1E,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xC0, 0x1E,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0x9D, 0xFC, 0x3E, 0x1C, 0x7E, 0x7E, 0x1C, 0x3E, 0x7C,
  0x1C, 0x3E, 0x7C, 0x1C, 0x1E, 0x7C, 0x1C, 0x1E, 0x7C, 0x1C, 0x01, 0x7C,
  0x1C, 0x00, 0x7C, 0x1C, 0x00, 0x7E, 0x1C, 0x00, 0x3F, 0x1C, 0x00, 0x3F,
  0x9C, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1C, 0xFE, 0x00, 0x1C, 0x3E, 0x00, 0x1C, 0x3F, 0x00, 0x1C, 0x1F, 0x00,
  0x1C, 0x1F, 0x00, 0x1C, 0x1F, 0xF8, 0x1C, 0x1F, 0xF8, 0x1C, 0x1F, 0xF8,
  0x1C, 0x1F, 0xFC, 0x1C, 0x3E, 0x7E, 0x1C, 0x7E, 0x7F, 0x1C, 0xFC, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0x3C,
  0xFF, 0xC0, 0x01, 0xE7, 0xFF, 0x80, 0x07, 0x9F, 0xFF, 0x00, 0x3C, 0xF8,
  0x3C, 0x01, 0xE3, 0xC0, 0xF0, 0x07, 0x8F, 0x01, 0xE0, 0x3C, 0x3C, 0x07,
  0x81, 0xE0, 0xF0, 0x1E, 0x07, 0x03, 0xC0, 0x78, 0x3C, 0x0F, 0x01, 0xE1,
  0xE0, 0x3C, 0x07, 0x8F, 0x00, 0xF0, 0x3C, 0x3C, 0x03, 0xE0, 0xF1, 0xE0,
  0x07, 0xFF, 0xCF, 0x00, 0x1F, 0xFE, 0x3C, 0x00, 0x1F, 0xF1, 0xE0, 0x00,
  0x1E, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE3, 0xFE, 0x00, 0x0F,
  0x1F, 0xFC, 0x00, 0x3C, 0xFF, 0xF8, 0x01, 0xE3, 0xE3, 0xE0, 0x0F, 0x1F,
  0x03, 0xC0, 0x3C, 0x78, 0x0F, 0x01, 0xE1, 0xE0, 0x3C, 0x0F, 0x07, 0x80,
  0xF0, 0x38, 0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0x3C,
  0x78, 0x07, 0x80, 0xF1, 0xE0, 0x0F, 0x07, 0xCF, 0x00, 0x3F, 0x7E, 0x78,
  0x00, 0xFF, 0xF9, 0xE0, 0x01, 0xFF, 0xCF, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x7F, 0xF0, 0xF8,
  0x0F, 0xBE, 0x0F, 0x83, 0xE7, 0xC1, 0xF8, 0x7C, 0xF8, 0x1F, 0x1F, 0x1F,
  0x01, 0xF3, 0xE3, 0xE0, 0x1F, 0xF8, 0x7C, 0x03, 0xFE, 0x0F, 0x80, 0x3F,
  0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0xE0, 0xF8,
  0x01, 0xFC, 0x1F, 0x00, 0x7F, 0xC1, 0xF0, 0x3F, 0xFC, 0x3F, 0xFF, 0xCF,
  0x83, 0xFF, 0xF0, 0xF8, 0x3F, 0xFC, 0x0F, 0x83, 0xFF, 0x01, 0xF8, 0x02,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF,
  0x00, 0x01, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFF,
  0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0xE0, 0x7F, 0xC0, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x06, 0x00, 0xF0, 0x06, 0x78, 0x0F, 0x03, 0xE7, 0xF0, 0xF0, 0xFE, 0xFF,
  0xCE, 0x3F, 0xFF, 0xFE, 0x67, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xF0,
  0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3F, 0x00, 0x78, 0x01, 0xC0, 0x01, 0x00, 0x08, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0xE1, 0xF8, 0x7F, 0x0F, 0xC1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC1, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x3F, 0x3F, 0xDF, 0xEF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E,
  0x0C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7E,
  0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x18, 0x1F, 0xF8,
  0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8,
  0x7E, 0x1F, 0xF8, 0x38, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E,
  0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xBE, 0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0xE0,
  0x3E, 0x00, 0xC0, 0x3E, 0x00, 0x80, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7E, 0x00, 0xFC, 0x7C,
  0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x7C, 0xF8, 0x01, 0xF9, 0xFC, 0x07, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01, 0xF3, 0xE0, 0x03, 0xEF, 0xC0, 0x07,
  0xDF, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0xF0, 0x3E, 0xFF, 0xF8,
  0x7D, 0xFF, 0xF8, 0xFF, 0xFF, 0xF1, 0xFE, 0x07, 0xF3, 0xF8, 0x03, 0xE7,
  0xE0, 0x03, 0xEF, 0x80, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xFC, 0x00, 0xF8, 0xFC, 0x03, 0xF1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x7F, 0xE0,
  0x3E, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0x81, 0xFC, 0x7E, 0x00, 0x7E,
  0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x3E,
  0x7E, 0x00, 0x7E, 0x3F, 0x01, 0xFC, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x3E, 0x00, 0xFC,
  0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0xE7, 0xE0, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0,
  0x1F, 0x81, 0xF8, 0x3E, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x3E,
  0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x7E,
  0x3F, 0x00, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0x30, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xFC, 0x7E, 0x00, 0xFE,
  0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x1C, 0x1F, 0x9F, 0xEF, 0xFF, 0xFB, 0xFD, 0xFE, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x7F, 0xBF, 0xFF, 0xEF, 0xF7, 0xF9,
  0xF8, 0x30, 0x07, 0x03, 0xF8, 0x7F, 0x9F, 0xF3, 0xFE, 0x3F, 0xC7, 0xF8,
  0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x0F,
  0xC3, 0xF8, 0x7E, 0x0F, 0xC1, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0x03, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF0,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC0, 0x1F, 0x81, 0xF0,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x01,
  0xE7, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x0E, 0x0F, 0xF8, 0x03, 0xFC, 0xFF, 0x80, 0xFF,
  0xEF, 0xF8, 0x0F, 0xFE, 0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x1F, 0x01, 0xFF,
  0x81, 0xE0, 0x1F, 0xF8, 0x1E, 0x01, 0xFF, 0x81, 0xE0, 0x1F, 0xF8, 0x1E,
  0x01, 0xFF, 0x81, 0xE0, 0x1F, 0xF8, 0x1E, 0x01, 0xFF, 0x81, 0xE0, 0x1F,
  0xF8, 0x1E, 0x01, 0xFF, 0x81, 0xE0, 0x1F, 0xF8, 0x1E, 0x01, 0xFF, 0x81,
  0xE0, 0x1F, 0xF8, 0x1E, 0x01, 0xFF, 0x81, 0xF0, 0x3F, 0xF8, 0x0F, 0xC7,
  0xFF, 0x80, 0xFF, 0xEF, 0xF8, 0x07, 0xFC, 0xF7, 0x80, 0x1F, 0x8F, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x05, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80,
  0x01, 0xE1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x07,
  0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x1E,
  0x03, 0xE0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3C, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7C, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x9F, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7,
  0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x3E, 0x7C,
  0x00, 0xFC, 0xF8, 0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0x00, 0x7F, 0x3E, 0x00, 0x3F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xFB, 0xE0, 0x1F, 0xE7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF9, 0xF8,
  0x03, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xF0, 0x1F, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0xFF,
  0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF3, 0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0xFF, 0x3F,
  0xFF, 0xF8, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F, 0x03, 0xF9, 0xF8,
  0x03, 0xEF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xF0, 0x1F, 0x8F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0x04, 0x00, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x3F, 0x80, 0xFE, 0x1F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x0C,
  0x00, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00,
  0x0F, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01,
  0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xC1, 0xF8, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x3F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x07, 0xC1, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x3E,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x7F,
  0xFE, 0x00, 0x77, 0xEF, 0x00, 0xF7, 0xEF, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF7, 0x81, 0xEF, 0xF3, 0xC3, 0xCF,
  0xF3, 0xC3, 0xCF, 0xF3, 0xC3, 0xCF, 0xF1, 0xE7, 0x8F, 0xF1, 0xE7, 0x8F,
  0xF1, 0xE7, 0x8F, 0xF0, 0xE7, 0x1F, 0xF0, 0xFF, 0x1F, 0xF0, 0xFF, 0x1F,
  0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0x7F, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x1F, 0xF7, 0x80,
  0x7F, 0xDE, 0x01, 0xFF, 0x3C, 0x07, 0xFC, 0xF0, 0x1F, 0xF3, 0xC0, 0x7F,
  0xC7, 0x81, 0xFF, 0x1E, 0x07, 0xFC, 0x7C, 0x1F, 0xF0, 0xF0, 0x7F, 0xC3,
  0xC1, 0xFF, 0x0F, 0x87, 0xFC, 0x1E, 0x1F, 0xF0, 0x78, 0x7F, 0xC1, 0xF1,
  0xFF, 0x03, 0xC7, 0xFC, 0x0F, 0x1F, 0xF0, 0x1E, 0x7F, 0xC0, 0x79, 0xFF,
  0x01, 0xE3, 0xFC, 0x03, 0xCF, 0xF0, 0x0F, 0x3F, 0xC0, 0x3E, 0xFF, 0x00,
  0x7B, 0xFC, 0x01, 0xEF, 0xF0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x7F,
  0x07, 0xF9, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xBE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xE7, 0xF0, 0x3F,
  0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00,
  0x08, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x03, 0xFC, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x81, 0xFC, 0x7E, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0x7E, 0x00, 0x7C, 0x3F, 0x01, 0xFC, 0x1F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x2F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xF8,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8,
  0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x01,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F,
  0x81, 0xFC, 0x3E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x01, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x7F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0xF9, 0xF0, 0x03, 0xE7, 0xE0, 0x3F, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0,
  0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x18, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0x7C, 0x00, 0x0F,
  0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x3C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0x78, 0x00, 0x78, 0x1F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1E, 0x00,
  0x07, 0x87, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x1F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x7E, 0x03, 0xDE, 0x03,
  0xF0, 0x1E, 0xF0, 0x1F, 0x80, 0xF7, 0x80, 0xFC, 0x07, 0xBC, 0x07, 0xE0,
  0x3D, 0xF0, 0x3F, 0x03, 0xEF, 0x81, 0xF8, 0x1F, 0x7C, 0x0D, 0xC0, 0xFB,
  0xE0, 0xE7, 0x07, 0x9F, 0x07, 0x38, 0x3C, 0x78, 0x39, 0xC1, 0xE3, 0xC1,
  0xCE, 0x0F, 0x1E, 0x0E, 0x70, 0x78, 0xF0, 0x73, 0x83, 0xC7, 0x83, 0x9C,
  0x1E, 0x3E, 0x1C, 0xE1, 0xF1, 0xF1, 0xC7, 0x0F, 0x0F, 0x8E, 0x1C, 0x78,
  0x3C, 0x70, 0xE3, 0xC1, 0xE3, 0x87, 0x1E, 0x0F, 0x1C, 0x38, 0xF0, 0x78,
  0xE1, 0xC7, 0x83, 0xC7, 0x0E, 0x3C, 0x1E, 0x38, 0x71, 0xE0, 0xF3, 0x83,
  0x9F, 0x07, 0xDC, 0x0C, 0xF0, 0x3E, 0xE0, 0x77, 0x80, 0xF7, 0x03, 0xBC,
  0x07, 0xB8, 0x1D, 0xE0, 0x3D, 0xC0, 0xEF, 0x01, 0xEE, 0x07, 0x78, 0x0F,
  0x70, 0x3B, 0xC0, 0x7F, 0x01, 0xDE, 0x03, 0xF8, 0x0E, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E,
  0x00, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x01, 0xF8,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x78, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xE7, 0x80,
  0x01, 0xE7, 0x80, 0x03, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0xC3, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C,
  0x7C, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F,
  0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC,
  0x1F, 0x80, 0x7E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x01, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0xFF, 0x3F, 0xC7, 0xFF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F,
  0x07, 0xFE, 0x1F, 0x00, 0x30, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x8F, 0xF8,
  0x3E, 0x7F, 0xF8, 0xFB, 0xFF, 0xF3, 0xFF, 0xFF, 0xEF, 0xE0, 0x1F, 0xBF,
  0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x1F, 0xBF, 0xFF, 0xFE, 0xFB, 0xFF, 0xF3,
  0xE7, 0xFF, 0x8F, 0x8F, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC7, 0xE0,
  0x1F, 0x9F, 0x80, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00,
  0x3D, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7E, 0x00, 0x7E, 0x7F, 0x01, 0xF8, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x01, 0xC0, 0x7C, 0x1F, 0xF8, 0xF8, 0x7F, 0xF9,
  0xF1, 0xFF, 0xFB, 0xE7, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xBF, 0x00, 0x3F,
  0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x7E, 0xFC, 0x01, 0xFC, 0xFC, 0x07, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFB,
  0xE1, 0xFF, 0xE7, 0xC0, 0xFF, 0x8F, 0x80, 0x10, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFE, 0x7F, 0x87,
  0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0,
  0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7E, 0x01, 0xF8,
  0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xF1, 0xF1, 0xFF,
  0xE7, 0xCF, 0xFF, 0xDF, 0x7F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xF7, 0xC0, 0x1F, 0xDF, 0xC0, 0xFF, 0x3F,
  0xFF, 0x7C, 0xFF, 0xFD, 0xF0, 0xFF, 0xE7, 0xC0, 0xFE, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x83, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x78, 0x0F, 0x8F,
  0xF8, 0x3E, 0xFF, 0xF8, 0xFB, 0xFF, 0xF3, 0xFF, 0x3F, 0xEF, 0xE0, 0x1F,
  0xBF, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xDF, 0x00,
  0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF0,
  0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x3E, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xFF, 0xF8, 0x01,
  0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3E, 0x07, 0xC0,
  0x1F, 0x03, 0xF0, 0x0F, 0x80, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x81, 0xF0, 0x07, 0xE0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE7, 0xC0, 0x01, 0xFB, 0xE0,
  0x00, 0x7E, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x60, 0x38, 0x7D, 0xFC, 0x7F, 0x3E, 0xFF, 0x7F, 0xDF,
  0xFF, 0xBF, 0xEF, 0xC3, 0xF0, 0xFF, 0xC1, 0xF0, 0x7F, 0xE0, 0x78, 0x1F,
  0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x07, 0x81,
  0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xE0, 0x78,
  0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xFE, 0x07,
  0x81, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3F, 0xE0,
  0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07, 0xFC, 0x0F, 0x03, 0xFE,
  0x07, 0x81, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0, 0x7F, 0xC0, 0xF0, 0x3C,
  0x00, 0x1E, 0x03, 0xE3, 0xFE, 0x0F, 0xBF, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x87, 0xE0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF,
  0x00, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x7F,
  0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x1E, 0x03, 0xE3, 0xFF, 0x0F, 0x9F, 0xFE, 0x3E, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFB, 0xF8, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFB, 0xFC,
  0x07, 0xEF, 0xFF, 0xFF, 0xBE, 0xFF, 0xFC, 0xF9, 0xFF, 0xE3, 0xE3, 0xFE,
  0x0F, 0x81, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xF1, 0xF1, 0xFF, 0xE7,
  0xCF, 0xFF, 0xDF, 0x7F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xFC, 0x01,
  0xFD, 0xF8, 0x0F, 0xF7, 0xFF, 0xFF, 0xCF, 0xFF, 0xDF, 0x1F, 0xFE, 0x7C,
  0x1F, 0xF1, 0xF0, 0x04, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x3C, 0x03, 0xE3, 0xFE, 0x0F,
  0xBF, 0xFE, 0x3E, 0xFF, 0xFC, 0xFF, 0xCF, 0xFB, 0xF8, 0x07, 0xEF, 0xC0,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x80, 0x7F,
  0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xC0, 0x1F, 0x9F, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xFC, 0x01, 0xF9, 0xFF, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF,
  0xE0, 0x00, 0x7F, 0xF0, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0x9F, 0x00, 0x3E, 0x7E, 0x03,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00,
  0x01, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0xC3, 0xE0,
  0x01, 0xF0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1E,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF3, 0xE0, 0x00,
  0x7C, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x1F, 0x80,
  0xFF, 0x81, 0xF8, 0x1E, 0x78, 0x1F, 0x81, 0xE7, 0x81, 0xF8, 0x1E, 0x78,
  0x1B, 0x81, 0xE7, 0x83, 0xB8, 0x1E, 0x78, 0x39, 0xC1, 0xE7, 0x83, 0x9C,
  0x3C, 0x3C, 0x39, 0xC3, 0xC3, 0xC3, 0x9C, 0x3C, 0x3C, 0x31, 0xC3, 0xC3,
  0xC7, 0x1C, 0x3C, 0x3C, 0x70, 0xC3, 0xC3, 0xC7, 0x0E, 0x38, 0x1C, 0x70,
  0xE7, 0x81, 0xE7, 0x0E, 0x78, 0x1E, 0x60, 0xE7, 0x81, 0xE6, 0x0E, 0x78,
  0x1E, 0xE0, 0x67, 0x01, 0xEE, 0x07, 0x70, 0x1E, 0xE0, 0x77, 0x00, 0xEE,
  0x07, 0xF0, 0x0F, 0xE0, 0x7F, 0x00, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x00, 0x0F, 0xDF,
  0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x03, 0xE3,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x8F,
  0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0xC0, 0x7E,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x01, 0xF1,
  0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xDF, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0xC0,
  0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0xFB, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0x8F, 0xF8, 0x03, 0xCF, 0xFE, 0x01, 0xEF, 0xFF, 0x80, 0xF7,
  0xC7, 0xE0, 0x7F, 0xC1, 0xF8, 0x3F, 0xE0, 0x7E, 0x3F, 0xF0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0x7C, 0x01, 0xFF, 0x00, 0x00, 0x3C, 0x00,
};

const GFXglyph JetBrainsMono_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 39, 32, 12, -39 },
  { 40, 16, 16, 32, 8, -39 },
  { 72, 28, 39, 32, 2, -39 },
  { 209, 24, 53, 32, 4, -46 },
  { 368, 30, 39, 32, 1, -39 },
  { 515, 27, 40, 32, 3, -39 },
  { 650, 5, 16, 32, 13, -39 },
  { 660, 16, 51, 32, 10, -45 },
  { 762, 16, 51, 32, 6, -45 },
  { 864, 28, 27, 32, 2, -32 },
  { 959, 25, 25, 32, 3, -30 },
  { 1038, 11, 16, 32, 9, -8 },
  { 1060, 17, 5, 32, 7, -20 },
  { 1071, 9, 9, 32, 11, -8 },
  { 1082, 24, 50, 32, 4, -44 },
  { 1232, 24, 40, 32, 4, -39 },
  { 1352, 24, 39, 32, 5, -39 },
  { 1469, 24, 39, 32, 4, -39 },
  { 1586, 23, 40, 32, 4, -39 },
  { 1701, 23, 39, 32, 4, -39 },
  { 1814, 23, 40, 32, 4, -39 },
  { 1929, 24, 40, 32, 4, -39 },
  { 2049, 24, 39, 32, 4, -39 },
  { 2166, 24, 40, 32, 4, -39 },
  { 2286, 24, 39, 32, 4, -39 },
  { 2403, 9, 31, 32, 11, -30 },
  { 2438, 11, 38, 32, 9, -30 },
  { 2491, 23, 29, 32, 4, -32 },
  { 2575, 23, 17, 32, 4, -26 },
  { 2624, 23, 29, 32, 4, -32 },
  { 2708, 19, 39, 32, 7, -39 },
  { 2801, 28, 49, 32, 2, -39 },
  { 2973, 26, 39, 32, 3, -39 },
  { 3100, 23, 39, 32, 5, -39 },
  { 3213, 22, 40, 32, 5, -39 },
  { 3323, 22, 39, 32, 5, -39 },
  { 3431, 23, 39, 32, 5, -39 },
  { 3544, 23, 39, 32, 5, -39 },
  { 3657, 22, 40, 32, 5, -39 },
  { 3767, 22, 39, 32, 5, -39 },
  { 3875, 20, 39, 32, 6, -39 },
  { 3973, 24, 40, 32, 2, -39 },
  { 4093, 25, 39, 32, 5, -39 },
  { 4215, 22, 39, 32, 6, -39 },
  { 4323, 24, 39, 32, 4, -39 },
  { 4440, 22, 39, 32, 5, -39 },
  { 4548, 22, 40, 32, 5, -39 },
  { 4658, 24, 39, 32, 5, -39 },
  { 4775, 24, 49, 32, 4, -39 },
  { 4922, 24, 39, 32, 5, -39 },
  { 5039, 24, 40, 32, 4, -39 },
  { 5159, 26, 39, 32, 3, -39 },
  { 5286, 22, 40, 32, 5, -39 },
  { 5396, 26, 39, 32, 3, -39 },
  { 5523, 29, 39, 32, 1, -39 },
  { 5665, 28, 39, 32, 2, -39 },
  { 5802, 28, 39, 32, 2, -39 },
  { 5939, 23, 39, 32, 4, -39 },
  { 6052, 13, 50, 32, 11, -44 },
  { 6134, 24, 50, 32, 4, -44 },
  { 6284, 13, 50, 32, 8, -44 },
  { 6366, 24, 21, 32, 4, -39 },
  { 6429, 26, 4, 32, 3, 1 },
  { 6442, 11, 8, 32, 10, -42 },
  { 6453, 24, 31, 32, 3, -30 },
  { 6546, 22, 40, 32, 5, -39 },
  { 6656, 23, 31, 32, 4, -30 },
  { 6746, 23, 40, 32, 4, -39 },
  { 6861, 23, 31, 32, 4, -30 },
  { 6951, 25, 39, 32, 3, -39 },
  { 7073, 22, 40, 32, 5, -30 },
  { 7183, 22, 39, 32, 5, -39 },
  { 7291, 25, 41, 32, 4, -41 },
  { 7420, 20, 51, 32, 4, -41 },
  { 7548, 25, 39, 32, 5, -39 },
  { 7670, 27, 39, 32, 2, -39 },
  { 7802, 25, 30, 32, 3, -30 },
  { 7896, 22, 30, 32, 5, -30 },
  { 7979, 23, 30, 32, 4, -30 },
  { 8066, 22, 40, 32, 5, -30 },
  { 8176, 22, 40, 32, 5, -30 },
  { 8286, 22, 30, 32, 6, -30 },
  { 8369, 23, 30, 32, 5, -30 },
  { 8456, 25, 37, 32, 3, -37 },
  { 8572, 22, 30, 32, 5, -29 },
  { 8655, 26, 29, 32, 3, -29 },
  { 8750, 28, 29, 32, 2, -29 },
  { 8852, 26, 29, 32, 3, -29 },
  { 8947, 26, 39, 32, 3, -29 },
  { 9074, 22, 29, 32, 5, -29 },
  { 9154, 23, 50, 32, 4, -44 },
  { 9298, 4, 50, 32, 14, -44 },
  { 9323, 23, 50, 32, 4, -44 },
  { 9467, 25, 11, 32, 3, -24 },
};

const GFXfont JetBrainsMono_Regular53pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular53pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular53pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _JETBRAINSMONO_REGULAR53PT7B_H_
