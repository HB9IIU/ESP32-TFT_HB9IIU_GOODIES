#ifndef _JETBRAINSMONO_REGULAR15PT7B_H_
#define _JETBRAINSMONO_REGULAR15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x0B, 0x80, 0xDE, 0xF7, 0xBD, 0x80, 0x22, 0x48,
  0x97, 0xF4, 0x48, 0x91, 0x7F, 0x48, 0x92, 0x20, 0x10, 0x21, 0xF2, 0xAD,
  0x7A, 0x1C, 0x1E, 0x16, 0x2E, 0x4E, 0xB7, 0xC2, 0x04, 0x00, 0x71, 0xC8,
  0xA4, 0x92, 0x87, 0x40, 0x40, 0x5C, 0x29, 0x24, 0xA2, 0x71, 0xC0, 0x78,
  0x9B, 0x02, 0x06, 0x1C, 0x24, 0xCE, 0x8D, 0x19, 0xC8, 0xF8, 0x13, 0x6C,
  0x88, 0x88, 0x88, 0x8C, 0x43, 0x10, 0x8C, 0x63, 0x11, 0x11, 0x11, 0x13,
  0x2C, 0x80, 0x10, 0x22, 0x4F, 0xF3, 0x05, 0x13, 0x22, 0x10, 0x23, 0xFF,
  0xF1, 0x02, 0x04, 0x00, 0x76, 0x4C, 0xFF, 0xC0, 0xFC, 0x06, 0x08, 0x30,
  0x40, 0x83, 0x04, 0x18, 0x20, 0x41, 0x82, 0x04, 0x18, 0x00, 0x7C, 0x8B,
  0x1E, 0x3C, 0x7A, 0xF1, 0xE3, 0xC6, 0x89, 0xF0, 0x38, 0xF3, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x33, 0xF8, 0x7D, 0x8B, 0x18, 0x30, 0x41, 0x86,
  0x18, 0x61, 0x83, 0xF8, 0xFC, 0x08, 0x20, 0x83, 0x81, 0x81, 0x83, 0x87,
  0x89, 0xE0, 0x0C, 0x10, 0x41, 0x82, 0x08, 0xF1, 0xFF, 0xFE, 0x0C, 0x18,
  0x7C, 0x81, 0x02, 0x07, 0xC8, 0xA1, 0x83, 0x07, 0x89, 0xF0, 0x18, 0x20,
  0xC1, 0x05, 0x9D, 0xB1, 0xC1, 0x83, 0x8D, 0xF0, 0xFF, 0x87, 0x18, 0x20,
  0xC1, 0x02, 0x0C, 0x10, 0x60, 0x80, 0x7C, 0x8B, 0x1A, 0x26, 0xC7, 0x11,
  0x63, 0xC7, 0x8D, 0xF0, 0x7D, 0x8F, 0x1C, 0x1C, 0x69, 0xCD, 0x04, 0x18,
  0x20, 0xC0, 0xE8, 0x00, 0x3F, 0xE8, 0x00, 0x56, 0xD0, 0x02, 0x18, 0xC6,
  0x0C, 0x06, 0x03, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x81, 0xC0, 0xE0, 0x70,
  0x63, 0x18, 0x40, 0xF0, 0xC2, 0x10, 0xB9, 0x8C, 0x03, 0x18, 0x7D, 0x8E,
  0x0C, 0x19, 0xF2, 0x64, 0xC9, 0x93, 0x3E, 0x06, 0x06, 0x07, 0x00, 0x38,
  0x50, 0xA1, 0x46, 0xC8, 0x91, 0x3E, 0xC7, 0x06, 0x08, 0xF9, 0x8B, 0x1E,
  0x3C, 0x5F, 0xB1, 0xE1, 0xC3, 0x8F, 0xF0, 0x7C, 0x8B, 0x1E, 0x0C, 0x18,
  0x30, 0x60, 0xC6, 0x89, 0xF0, 0xF9, 0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x9B, 0xE0, 0xFF, 0x83, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83,
  0xF8, 0xFF, 0x83, 0x06, 0x0C, 0x1F, 0xB0, 0x60, 0xC1, 0x83, 0x00, 0x7C,
  0x8B, 0x1E, 0x0C, 0x1B, 0xF7, 0xE3, 0xC6, 0x89, 0xF0, 0xC7, 0x8F, 0x1E,
  0x3C, 0x7F, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0xF9, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x3E, 0x3C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x87, 0x37, 0x80, 0xC3,
  0x8F, 0x16, 0x4D, 0x9F, 0x32, 0x66, 0xC5, 0x8F, 0x08, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC7, 0x8E, 0xAD, 0x5A, 0xB2, 0x60,
  0xC1, 0x83, 0x06, 0x08, 0xC7, 0xCF, 0x9F, 0x3D, 0x7A, 0xF5, 0xE7, 0xCF,
  0x9F, 0x18, 0x7C, 0x8B, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x89, 0xF0,
  0xFD, 0x8F, 0x0E, 0x1C, 0x3F, 0xBC, 0x60, 0xC1, 0x83, 0x00, 0x7C, 0x8B,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC6, 0x89, 0xF0, 0x60, 0x40, 0xC0, 0xFD,
  0x8F, 0x0E, 0x1C, 0x7F, 0xB2, 0x64, 0xCD, 0x8B, 0x18, 0x7C, 0x8B, 0x1E,
  0x06, 0x07, 0x81, 0x83, 0x83, 0x8D, 0xF0, 0xFE, 0x20, 0x40, 0x81, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x40, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC6, 0x89, 0xF0, 0x83, 0x87, 0x1A, 0x24, 0x4C, 0x9B, 0x14, 0x28, 0x50,
  0xE0, 0xC9, 0xA4, 0x95, 0x4A, 0xA5, 0x52, 0xA9, 0x54, 0xAA, 0x75, 0x3B,
  0x88, 0x80, 0xC2, 0x89, 0xB1, 0x43, 0x82, 0x0E, 0x14, 0x45, 0x8E, 0x08,
  0x83, 0x8D, 0x13, 0x62, 0x85, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0x0C,
  0x30, 0x41, 0x82, 0x0C, 0x10, 0x41, 0x83, 0xF8, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0xFF, 0xC0, 0x81, 0x81, 0x02, 0x06, 0x04, 0x0C, 0x08, 0x10,
  0x30, 0x20, 0x40, 0xC0, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFF, 0x10,
  0x50, 0xA2, 0x24, 0x58, 0xC0, 0xFF, 0xFC, 0x8C, 0x7D, 0x8C, 0x1B, 0xFC,
  0x70, 0xF1, 0xBF, 0xC1, 0x83, 0x07, 0xEC, 0x78, 0xF1, 0xE3, 0xC7, 0x8B,
  0xF0, 0x7D, 0x8F, 0x06, 0x0C, 0x18, 0xD1, 0xBE, 0x06, 0x0C, 0x1B, 0xFC,
  0x78, 0xF1, 0xE3, 0xC6, 0x8D, 0xF8, 0x7D, 0x8F, 0x1F, 0xFC, 0x18, 0x11,
  0xBE, 0x1E, 0x60, 0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x7F,
  0x8F, 0x1E, 0x3C, 0x78, 0xDF, 0x83, 0x06, 0xF9, 0xE0, 0xC1, 0x83, 0x07,
  0xEC, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x18, 0x10, 0x30, 0x00, 0x07, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x67, 0xF0, 0x08, 0x30, 0x00, 0x7C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0B, 0xEF, 0x00, 0xC1, 0x83, 0x06, 0x3C, 0x59, 0x3E,
  0x6C, 0xCD, 0x8B, 0x18, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x0F, 0xFF, 0x26, 0x4C, 0x99, 0x32, 0x64, 0xC9, 0xFD, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x7D, 0x8F, 0x1E, 0x3C, 0x78, 0xD1, 0x3E,
  0xFD, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0x7E, 0xC1, 0x83, 0x00, 0x7F, 0x8F,
  0x1E, 0x3C, 0x78, 0xD1, 0xBF, 0x06, 0x0C, 0x18, 0xFA, 0x38, 0x60, 0x82,
  0x08, 0x20, 0x7C, 0x8D, 0x03, 0xC0, 0xE0, 0xF1, 0xBE, 0x30, 0x60, 0xC7,
  0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x78, 0xC7, 0x8F, 0x1E, 0x3C, 0x78,
  0xD1, 0x3E, 0x83, 0x8D, 0x12, 0x26, 0xC5, 0x0A, 0x1C, 0x93, 0x56, 0xAD,
  0x5A, 0xBD, 0xDB, 0x22, 0xC6, 0xD8, 0xA0, 0xC3, 0x8D, 0x91, 0x63, 0xC6,
  0x8D, 0x13, 0x62, 0x85, 0x06, 0x08, 0x10, 0x60, 0x80, 0xFC, 0x08, 0x20,
  0x83, 0x0C, 0x30, 0x7F, 0x0E, 0x30, 0x60, 0xC1, 0x83, 0x3C, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0xE0, 0xC0, 0xFF, 0xFC, 0xE0, 0x60, 0xC1, 0x83, 0x06,
  0x07, 0x98, 0x30, 0x60, 0xC1, 0x8E, 0x18, 0x00, 0x63, 0x26, 0x78,
};

const GFXglyph JetBrainsMono_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 5, 9, 2, -11 },
  { 10, 7, 11, 9, 1, -11 },
  { 20, 7, 15, 9, 1, -13 },
  { 34, 9, 11, 9, 0, -11 },
  { 47, 7, 11, 9, 1, -11 },
  { 57, 1, 5, 9, 4, -11 },
  { 58, 4, 15, 9, 3, -13 },
  { 66, 4, 15, 9, 2, -13 },
  { 74, 7, 8, 9, 1, -9 },
  { 81, 7, 7, 9, 1, -8 },
  { 88, 4, 4, 9, 2, -2 },
  { 90, 5, 2, 9, 2, -6 },
  { 92, 3, 2, 9, 3, -2 },
  { 93, 7, 14, 9, 1, -12 },
  { 106, 7, 11, 9, 1, -11 },
  { 116, 7, 11, 9, 1, -11 },
  { 126, 7, 11, 9, 1, -11 },
  { 136, 7, 11, 9, 1, -11 },
  { 146, 7, 11, 9, 1, -11 },
  { 156, 7, 11, 9, 1, -11 },
  { 166, 7, 11, 9, 1, -11 },
  { 176, 7, 11, 9, 1, -11 },
  { 186, 7, 11, 9, 1, -11 },
  { 196, 7, 11, 9, 1, -11 },
  { 206, 3, 8, 9, 3, -8 },
  { 209, 3, 10, 9, 3, -8 },
  { 213, 7, 8, 9, 1, -9 },
  { 220, 7, 4, 9, 1, -7 },
  { 224, 7, 8, 9, 1, -9 },
  { 231, 5, 11, 9, 2, -11 },
  { 238, 7, 14, 9, 1, -11 },
  { 251, 7, 11, 9, 1, -11 },
  { 261, 7, 11, 9, 1, -11 },
  { 271, 7, 11, 9, 1, -11 },
  { 281, 7, 11, 9, 1, -11 },
  { 291, 7, 11, 9, 1, -11 },
  { 301, 7, 11, 9, 1, -11 },
  { 311, 7, 11, 9, 1, -11 },
  { 321, 7, 11, 9, 1, -11 },
  { 331, 5, 11, 9, 2, -11 },
  { 338, 6, 11, 9, 1, -11 },
  { 347, 7, 11, 9, 1, -11 },
  { 357, 6, 11, 9, 2, -11 },
  { 366, 7, 11, 9, 1, -11 },
  { 376, 7, 11, 9, 1, -11 },
  { 386, 7, 11, 9, 1, -11 },
  { 396, 7, 11, 9, 1, -11 },
  { 406, 7, 14, 9, 1, -11 },
  { 419, 7, 11, 9, 1, -11 },
  { 429, 7, 11, 9, 1, -11 },
  { 439, 7, 11, 9, 1, -11 },
  { 449, 7, 11, 9, 1, -11 },
  { 459, 7, 11, 9, 1, -11 },
  { 469, 9, 11, 9, 0, -11 },
  { 482, 7, 11, 9, 1, -11 },
  { 492, 7, 11, 9, 1, -11 },
  { 502, 7, 11, 9, 1, -11 },
  { 512, 4, 14, 9, 3, -12 },
  { 519, 7, 14, 9, 1, -12 },
  { 532, 4, 14, 9, 2, -12 },
  { 539, 7, 6, 9, 1, -11 },
  { 545, 7, 2, 9, 1, 0 },
  { 547, 3, 2, 9, 3, -12 },
  { 548, 7, 8, 9, 1, -8 },
  { 555, 7, 11, 9, 1, -11 },
  { 565, 7, 8, 9, 1, -8 },
  { 572, 7, 11, 9, 1, -11 },
  { 582, 7, 8, 9, 1, -8 },
  { 589, 7, 11, 9, 1, -11 },
  { 599, 7, 11, 9, 1, -8 },
  { 609, 7, 11, 9, 1, -11 },
  { 619, 7, 12, 9, 1, -12 },
  { 630, 6, 15, 9, 1, -12 },
  { 642, 7, 11, 9, 1, -11 },
  { 652, 8, 11, 9, 0, -11 },
  { 663, 7, 8, 9, 1, -8 },
  { 670, 7, 8, 9, 1, -8 },
  { 677, 7, 8, 9, 1, -8 },
  { 684, 7, 11, 9, 1, -8 },
  { 694, 7, 11, 9, 1, -8 },
  { 704, 6, 8, 9, 2, -8 },
  { 710, 7, 8, 9, 1, -8 },
  { 717, 7, 11, 9, 1, -11 },
  { 727, 7, 8, 9, 1, -8 },
  { 734, 7, 8, 9, 1, -8 },
  { 741, 7, 8, 9, 1, -8 },
  { 748, 7, 8, 9, 1, -8 },
  { 755, 7, 11, 9, 1, -8 },
  { 765, 7, 8, 9, 1, -8 },
  { 772, 7, 14, 9, 1, -12 },
  { 785, 1, 14, 9, 4, -12 },
  { 787, 7, 14, 9, 1, -12 },
  { 800, 7, 3, 9, 1, -7 },
};

const GFXfont JetBrainsMono_Regular15pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular15pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _JETBRAINSMONO_REGULAR15PT7B_H_
