#ifndef _JETBRAINSMONO_REGULAR31PT7B_H_
#define _JETBRAINSMONO_REGULAR31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x31, 0x8C, 0x00,
  0x00, 0xCF, 0x7F, 0xC0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x0F,
  0x87, 0xC3, 0xE1, 0xC0, 0x03, 0x06, 0x01, 0x83, 0x01, 0xC3, 0x80, 0xC1,
  0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0xFF, 0xFF, 0x7F, 0xFF, 0x86,
  0x0C, 0x03, 0x06, 0x01, 0x83, 0x01, 0xC1, 0x80, 0xE1, 0xC0, 0x60, 0xC1,
  0xFF, 0xFC, 0xFF, 0xFE, 0x0C, 0x18, 0x0E, 0x0C, 0x06, 0x0E, 0x03, 0x06,
  0x01, 0x83, 0x00, 0xC1, 0x80, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00, 0x40,
  0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x4F, 0x71, 0x1D, 0xC4, 0x77, 0x10,
  0x1C, 0x40, 0x79, 0x00, 0xF4, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x05,
  0xE0, 0x11, 0xC0, 0x47, 0x01, 0x0F, 0x84, 0x3E, 0x11, 0xDC, 0x47, 0x7D,
  0x78, 0xFF, 0xE1, 0xFE, 0x00, 0x40, 0x01, 0x00, 0x04, 0x00, 0x10, 0x00,
  0x1E, 0x00, 0xCF, 0xC0, 0x67, 0x38, 0x39, 0x86, 0x0C, 0xE1, 0x86, 0x38,
  0x63, 0x86, 0x18, 0xC1, 0x86, 0x60, 0x7F, 0xB8, 0x0F, 0xCC, 0x00, 0x86,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x67, 0xC0, 0x3B, 0xF8, 0x0C, 0xC7,
  0x06, 0x70, 0xC3, 0x9C, 0x31, 0xC7, 0x0C, 0x60, 0xC3, 0x30, 0x31, 0xDC,
  0x0F, 0xEE, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0xE0, 0x3D, 0xF0, 0x70, 0x70,
  0x70, 0x70, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0xE7, 0x0E, 0xE3, 0x8C, 0xE3, 0x9C, 0xE1, 0xF8,
  0xE0, 0xF8, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0xF8, 0xF1, 0xDC, 0x7F, 0x9C,
  0x3F, 0x0F, 0xFF, 0xFF, 0xFE, 0xD8, 0x01, 0x83, 0xC3, 0xE3, 0xC3, 0x83,
  0xC1, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1E, 0x07,
  0xC1, 0xF0, 0x38, 0x04, 0x80, 0x70, 0x3E, 0x07, 0x81, 0xE0, 0x70, 0x1C,
  0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x38, 0x1C, 0x1E, 0x0E, 0x0E, 0x1E, 0x1E, 0x0E,
  0x04, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C,
  0x13, 0x8C, 0x3B, 0xF6, 0x7E, 0xFD, 0xFC, 0x07, 0xF0, 0x00, 0xE0, 0x01,
  0xD8, 0x00, 0xCE, 0x00, 0xE3, 0x80, 0xE1, 0xC0, 0xF0, 0x70, 0x10, 0x10,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x00, 0x1E, 0x78, 0xF1, 0xC7, 0x8E, 0x1C, 0x38,
  0xE1, 0xC0, 0xFF, 0xFF, 0xF0, 0x77, 0xFF, 0xFF, 0x00, 0x00, 0x1C, 0x00,
  0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x7F, 0xC3, 0xEF, 0x9C, 0x0E, 0x70, 0x1D, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x39, 0xF9, 0xE7, 0xE3, 0x9F, 0x84,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x01, 0xDC, 0x0F, 0x78,
  0x78, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x1E, 0xE0,
  0xF3, 0x83, 0x0E, 0x08, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xC0,
  0x7F, 0xC3, 0xFF, 0x9C, 0x0E, 0x70, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x7F, 0xFD, 0xFF,
  0xF7, 0xFF, 0xC0, 0x7F, 0xF9, 0xFF, 0xE7, 0xFF, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x7E, 0x01,
  0xDC, 0x0E, 0x78, 0x78, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x01, 0xC1, 0xCE, 0x07, 0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE7, 0xC7, 0xFF, 0x3F, 0xFD, 0xE0, 0xEE, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x0F, 0x3F,
  0xF0, 0x7F, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xEF, 0x87, 0xFF, 0x1F, 0x1E,
  0x70, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01,
  0xDC, 0x0F, 0x7C, 0x78, 0xFF, 0xC0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x6E, 0x01, 0xDC, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0x70,
  0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x0E, 0x38, 0x38, 0xF1, 0xC0, 0xFE, 0x01,
  0xF0, 0x1F, 0xF0, 0xE1, 0xE7, 0x03, 0x9C, 0x07, 0x60, 0x1F, 0x80, 0x76,
  0x01, 0xDC, 0x07, 0x78, 0x78, 0xFF, 0xC1, 0xFE, 0x00, 0x07, 0xC0, 0x7F,
  0xC3, 0xFF, 0x9E, 0x0F, 0x70, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x77, 0x01, 0xDE, 0x0F, 0x3F, 0xF8, 0x7E, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0xF7, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xF0, 0x3C, 0x7C, 0xF9, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xE7, 0x8F, 0x1C, 0x38, 0xF1, 0xC3, 0x86, 0x1C, 0x00, 0x00, 0x18, 0x03,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x18, 0x00, 0xE0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x07, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x78, 0x0F, 0xC1, 0xF8, 0x3F, 0x07,
  0xE0, 0x7C, 0x03, 0x80, 0x10, 0x00, 0xF8, 0x1F, 0xE3, 0xFF, 0x01, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x0F, 0x0F, 0xE1, 0xF0,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x00, 0x00, 0x0C, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0x03, 0xF0, 0x0F, 0xFC, 0x1E, 0x1E, 0x38, 0x0E, 0x70, 0x07,
  0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0xFB, 0xE1, 0xFF, 0xE1, 0xC7,
  0xE1, 0x83, 0xE3, 0x83, 0xE3, 0x83, 0xE3, 0x83, 0xE3, 0x83, 0xE3, 0x83,
  0xE3, 0x83, 0xE1, 0x87, 0xE1, 0xFF, 0xE0, 0xFB, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0xEC, 0x01, 0xDC, 0x03,
  0x38, 0x06, 0x70, 0x1C, 0x60, 0x38, 0xE0, 0x61, 0xC0, 0xC3, 0x83, 0x83,
  0x07, 0x07, 0x0C, 0x0E, 0x3F, 0xFC, 0x7F, 0xF8, 0xE0, 0x39, 0xC0, 0x77,
  0x00, 0xEE, 0x00, 0xDC, 0x01, 0xF8, 0x03, 0x80, 0xFE, 0x07, 0xFF, 0x3F,
  0xFD, 0xC0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x37, 0x07,
  0xBF, 0xF9, 0xFF, 0xCE, 0x1F, 0x70, 0x3F, 0x80, 0xFC, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF, 0x7F, 0xF3, 0xFF, 0x00, 0x0F, 0x81,
  0xFF, 0x1F, 0xFD, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x01, 0xF8, 0x0F, 0xC0, 0xF7, 0x8F, 0x3F, 0xF0, 0x7F, 0x00,
  0xFE, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xEE, 0x3F, 0x7F, 0xF3,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xEE, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xE0,
  0xEE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC7, 0xFE, 0x3F, 0xF1, 0xFF, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0xF7, 0x8F, 0x3F, 0xF0, 0x7F, 0x00, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0xE0, 0x0F, 0x80, 0x77, 0x01, 0xDC, 0x07, 0x7C, 0x78, 0xFF, 0xC0,
  0xFE, 0x00, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0x73, 0x83,
  0x8E, 0x0E, 0x38, 0x70, 0xE1, 0xC3, 0x8E, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF,
  0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x78, 0xE0, 0xE3, 0x83, 0xCE, 0x07, 0x38,
  0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x01, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x1F, 0xC0,
  0xFF, 0x83, 0xF6, 0x0F, 0xD8, 0x7F, 0xF1, 0xBE, 0xC6, 0xFB, 0x3B, 0xEE,
  0xCF, 0x9B, 0x3E, 0x6C, 0xF9, 0xE3, 0xE3, 0x8F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xC0, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xF0, 0x7D, 0x83, 0xEC, 0x1F,
  0x70, 0xF9, 0x87, 0xCC, 0x3E, 0x71, 0xF1, 0x8F, 0x8C, 0x7C, 0x73, 0xE1,
  0x9F, 0x0E, 0xF8, 0x77, 0xC1, 0xBE, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x0F,
  0xE0, 0x3F, 0x01, 0xE0, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xE0, 0xEE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xE7, 0x8F, 0x3F, 0xF0, 0x7F, 0x00, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x38,
  0x1E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x03, 0xBF, 0xFE, 0xFF, 0xE3, 0xFE, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07,
  0xC0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0E, 0x70, 0x1D, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x77, 0x01, 0xDC, 0x0F, 0x7C, 0x78,
  0xFF, 0xC0, 0xFE, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0xFF, 0x03, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B, 0x80,
  0x6E, 0x01, 0xF8, 0x07, 0xE0, 0x3B, 0x80, 0xEE, 0x07, 0xBF, 0xFC, 0xFF,
  0xC3, 0x8E, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE3, 0x83, 0x8E, 0x07, 0x38,
  0x1C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF,
  0x9E, 0x0F, 0x70, 0x1D, 0xC0, 0x77, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0F, 0x80, 0x3E, 0x01, 0xDC, 0x07, 0x78, 0x78, 0xFF, 0xE1, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xE7, 0x8F, 0x3F, 0xF0, 0x7F, 0x00, 0xC0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xE6, 0x01, 0xCE, 0x03, 0x9C, 0x06, 0x38,
  0x1C, 0x30, 0x38, 0x70, 0x70, 0xE0, 0xC1, 0xC3, 0x81, 0x87, 0x03, 0x8E,
  0x07, 0x18, 0x0E, 0x70, 0x0C, 0xE0, 0x1D, 0xC0, 0x3B, 0x00, 0x76, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0xC1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70,
  0xFC, 0x38, 0x6E, 0x34, 0x37, 0x1A, 0x1B, 0x8D, 0x8C, 0xC6, 0xC6, 0x63,
  0x67, 0x31, 0xB3, 0x98, 0x99, 0xCE, 0x4C, 0xE7, 0x66, 0x63, 0xB1, 0x31,
  0xD8, 0x98, 0x6C, 0x6C, 0x36, 0x36, 0x1B, 0x1F, 0x0D, 0x0F, 0x86, 0x87,
  0xC3, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0x70, 0x70, 0x07, 0x70, 0x0E, 0x38,
  0x0E, 0x38, 0x1C, 0x1C, 0x1C, 0x1E, 0x38, 0x0E, 0x38, 0x07, 0x70, 0x07,
  0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07,
  0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x38,
  0x0E, 0x70, 0x0F, 0xF0, 0x07, 0xE0, 0x03, 0xB8, 0x03, 0x9C, 0x01, 0xC6,
  0x01, 0xC3, 0x80, 0xE0, 0xC0, 0xE0, 0x70, 0x70, 0x18, 0x70, 0x0E, 0x38,
  0x07, 0x38, 0x01, 0xDC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF,
  0xFF, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0xFF, 0xFF, 0xF8, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x7C, 0x01,
  0xB0, 0x0E, 0xE0, 0x31, 0x81, 0xC6, 0x06, 0x1C, 0x38, 0x30, 0xC0, 0xE7,
  0x01, 0xB8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xE1, 0xC3, 0x87, 0x0F, 0xE0,
  0xFF, 0xC3, 0x87, 0x9C, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC7, 0xFF,
  0x7F, 0xFD, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x07,
  0xDF, 0xF7, 0x3F, 0x9C, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xBF, 0x1F, 0xFE, 0xF8, 0xF7, 0x03, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0xFF, 0x8F, 0x7F, 0xFB, 0xBF, 0x00, 0x1F, 0xC3, 0xFF, 0x1E, 0x3D, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x7E, 0x03, 0xF0, 0x1D, 0xE3, 0xCF, 0xFC, 0x1F, 0xC0, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xFC, 0xEF, 0xF7, 0xF0,
  0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0x0F, 0xBF, 0xDC, 0xFC, 0xE0,
  0x1F, 0xC3, 0xFF, 0x1C, 0x3D, 0xC0, 0x6E, 0x03, 0xE0, 0x1F, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x1D, 0xC1,
  0xCF, 0xFE, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xFC, 0x1F, 0xF8, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x3F, 0x3B, 0xFD, 0xFC, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x07, 0xBF, 0xFC, 0xFE,
  0xE3, 0xE7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE3, 0xFF, 0x1F, 0xF0,
  0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xBF, 0x1F, 0xFE, 0xF0, 0xF7, 0x03, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x60, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x38, 0x0F, 0x7F,
  0xCF, 0xF1, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x01, 0xF8, 0x0E, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x38,
  0x70, 0xE3, 0xC3, 0xFE, 0x0F, 0xF8, 0x38, 0xE0, 0xE1, 0xC3, 0x87, 0x8E,
  0x0E, 0x38, 0x1C, 0xE0, 0x7B, 0x80, 0xEE, 0x01, 0xC0, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xFE, 0x79, 0xFF, 0xFB, 0x8E,
  0x37, 0x18, 0x7E, 0x30, 0xFC, 0x61, 0xF8, 0xC3, 0xF1, 0x87, 0xE3, 0x0F,
  0xC6, 0x1F, 0x8C, 0x3F, 0x18, 0x7E, 0x30, 0xFC, 0x61, 0xF8, 0xC3, 0xF1,
  0x87, 0xE3, 0x0E, 0xEF, 0xC7, 0xFF, 0xBE, 0x3D, 0xC0, 0xFE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x38, 0x1F, 0xC3, 0xFF, 0x1E, 0x3D,
  0xC0, 0xEE, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x3D, 0xE3, 0xCF, 0xFC, 0x1F, 0xC0, 0xEF,
  0xC7, 0xFF, 0xBE, 0x3D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0xE3, 0xDF,
  0xFE, 0xEF, 0xC7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x00, 0x3F, 0x3B, 0xFD, 0xFC, 0x3F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F,
  0xC3, 0xEF, 0xF7, 0x3F, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0xE7, 0xE3, 0xBF, 0xCF, 0x87, 0xBC, 0x0E, 0xE0, 0x1B,
  0x80, 0x7E, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x3F, 0xE3, 0xFF,
  0x9C, 0x3D, 0xC0, 0x7E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xF0, 0x3F, 0xF0,
  0x1F, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xF0, 0x1F, 0xC1, 0xEF, 0xFE, 0x3F,
  0xE0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x03, 0xFF, 0xFF,
  0xFF, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0xFF,
  0x07, 0xFC, 0x07, 0xF0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x39, 0xE3, 0xCF, 0xFC, 0x1F, 0xC0, 0xE0, 0x0F, 0xC0, 0x19,
  0x80, 0x73, 0x80, 0xE7, 0x01, 0x86, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x18,
  0x70, 0x38, 0xE0, 0x71, 0x80, 0x67, 0x00, 0xEE, 0x01, 0xD8, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0x80, 0xE1, 0xC3, 0xF0, 0xE1, 0xB8, 0x70, 0xCC, 0x78,
  0x66, 0x34, 0x73, 0x1B, 0x39, 0x8D, 0x98, 0xE4, 0xCC, 0x72, 0x66, 0x1B,
  0x33, 0x0D, 0x89, 0x86, 0xC5, 0xC3, 0x63, 0xC1, 0xA1, 0xE0, 0xF0, 0xF0,
  0x38, 0x78, 0x1C, 0x1C, 0x00, 0xF0, 0x1E, 0xE0, 0x78, 0xE0, 0xE1, 0xC3,
  0x81, 0xC7, 0x01, 0xDC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x80,
  0x3B, 0x80, 0xE7, 0x01, 0xC7, 0x07, 0x0F, 0x1C, 0x0E, 0x38, 0x0E, 0xE0,
  0x1E, 0xE0, 0x0F, 0xC0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x83, 0x87, 0x07,
  0x0E, 0x0C, 0x0E, 0x38, 0x1C, 0x70, 0x38, 0xC0, 0x3B, 0x80, 0x77, 0x00,
  0x6C, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0xFF, 0xF7, 0xFF,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x38, 0x0F, 0xC0, 0xFE, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x07, 0x83,
  0xF8, 0x1F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xF0, 0x0F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE0, 0x07, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0xC0, 0x0F,
  0xE0, 0xFF, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x01, 0xF8, 0x0F, 0x80, 0x00,
  0x3C, 0x0E, 0xFE, 0x1F, 0x9C, 0x3F, 0x1C, 0x6E, 0x1F, 0xDC, 0x1F, 0x00,
};

const GFXglyph JetBrainsMono_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 9, 10, 19, 5, -23 },
  { 28, 17, 23, 19, 1, -23 },
  { 77, 14, 31, 19, 2, -27 },
  { 132, 18, 23, 19, 0, -23 },
  { 184, 16, 23, 19, 2, -23 },
  { 230, 3, 10, 19, 8, -23 },
  { 234, 9, 30, 19, 6, -26 },
  { 268, 9, 30, 19, 4, -26 },
  { 302, 17, 16, 19, 1, -19 },
  { 336, 15, 15, 19, 2, -18 },
  { 365, 7, 10, 19, 5, -5 },
  { 374, 10, 2, 19, 4, -11 },
  { 377, 5, 5, 19, 7, -5 },
  { 381, 14, 29, 19, 2, -26 },
  { 432, 14, 23, 19, 2, -23 },
  { 473, 14, 23, 19, 3, -23 },
  { 514, 14, 23, 19, 2, -23 },
  { 555, 14, 23, 19, 2, -23 },
  { 596, 14, 23, 19, 2, -23 },
  { 637, 13, 23, 19, 3, -23 },
  { 675, 14, 23, 19, 2, -23 },
  { 716, 15, 23, 19, 2, -23 },
  { 760, 14, 23, 19, 2, -23 },
  { 801, 14, 23, 19, 2, -23 },
  { 842, 5, 17, 19, 7, -17 },
  { 853, 7, 22, 19, 5, -17 },
  { 873, 13, 16, 19, 3, -18 },
  { 899, 13, 10, 19, 3, -15 },
  { 916, 13, 16, 19, 3, -18 },
  { 942, 11, 23, 19, 4, -23 },
  { 974, 16, 29, 19, 1, -23 },
  { 1032, 15, 23, 19, 2, -23 },
  { 1076, 13, 23, 19, 3, -23 },
  { 1114, 13, 23, 19, 3, -23 },
  { 1152, 13, 23, 19, 3, -23 },
  { 1190, 13, 23, 19, 3, -23 },
  { 1228, 13, 23, 19, 3, -23 },
  { 1266, 13, 23, 19, 3, -23 },
  { 1304, 13, 23, 19, 3, -23 },
  { 1342, 12, 23, 19, 3, -23 },
  { 1377, 14, 23, 19, 1, -23 },
  { 1418, 14, 23, 19, 3, -23 },
  { 1459, 13, 23, 19, 4, -23 },
  { 1497, 14, 23, 19, 2, -23 },
  { 1538, 13, 23, 19, 3, -23 },
  { 1576, 13, 23, 19, 3, -23 },
  { 1614, 14, 23, 19, 3, -23 },
  { 1655, 14, 29, 19, 2, -23 },
  { 1706, 14, 23, 19, 3, -23 },
  { 1747, 14, 23, 19, 2, -23 },
  { 1788, 15, 23, 19, 2, -23 },
  { 1832, 13, 23, 19, 3, -23 },
  { 1870, 15, 23, 19, 2, -23 },
  { 1914, 17, 23, 19, 1, -23 },
  { 1963, 16, 23, 19, 1, -23 },
  { 2009, 17, 23, 19, 1, -23 },
  { 2058, 13, 23, 19, 3, -23 },
  { 2096, 8, 29, 19, 6, -26 },
  { 2125, 14, 29, 19, 2, -26 },
  { 2176, 7, 29, 19, 5, -26 },
  { 2202, 14, 12, 19, 2, -23 },
  { 2223, 15, 2, 19, 2, 1 },
  { 2227, 6, 4, 19, 6, -24 },
  { 2230, 14, 17, 19, 2, -17 },
  { 2260, 13, 23, 19, 3, -23 },
  { 2298, 13, 17, 19, 3, -17 },
  { 2326, 13, 23, 19, 3, -23 },
  { 2364, 13, 17, 19, 3, -17 },
  { 2392, 15, 23, 19, 2, -23 },
  { 2436, 13, 23, 19, 3, -17 },
  { 2474, 13, 23, 19, 3, -23 },
  { 2512, 14, 24, 19, 3, -24 },
  { 2554, 11, 30, 19, 3, -24 },
  { 2596, 14, 23, 19, 3, -23 },
  { 2637, 16, 23, 19, 1, -23 },
  { 2683, 15, 17, 19, 2, -17 },
  { 2715, 13, 17, 19, 3, -17 },
  { 2743, 13, 17, 19, 3, -17 },
  { 2771, 13, 23, 19, 3, -17 },
  { 2809, 13, 23, 19, 3, -17 },
  { 2847, 14, 17, 19, 3, -17 },
  { 2877, 13, 17, 19, 3, -17 },
  { 2905, 14, 22, 19, 2, -22 },
  { 2944, 13, 17, 19, 3, -17 },
  { 2972, 15, 17, 19, 2, -17 },
  { 3004, 17, 17, 19, 1, -17 },
  { 3041, 15, 17, 19, 2, -17 },
  { 3073, 15, 23, 19, 2, -17 },
  { 3117, 13, 17, 19, 3, -17 },
  { 3145, 13, 29, 19, 3, -26 },
  { 3193, 3, 29, 19, 8, -26 },
  { 3204, 13, 29, 19, 3, -26 },
  { 3252, 15, 6, 19, 2, -14 },
};

const GFXfont JetBrainsMono_Regular31pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular31pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular31pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _JETBRAINSMONO_REGULAR31PT7B_H_
