#ifndef _JETBRAINSMONO_REGULAR19PT7B_H_
#define _JETBRAINSMONO_REGULAR19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xD2, 0x48, 0x0F, 0xC0, 0xCF, 0x3C, 0xF2, 0xCB, 0x20,
  0x11, 0x84, 0x61, 0x10, 0x44, 0xFF, 0xC8, 0x42, 0x30, 0x88, 0x22, 0x3F,
  0xE6, 0x21, 0x18, 0x46, 0x11, 0x00, 0x08, 0x04, 0x02, 0x07, 0xC7, 0xF3,
  0x4D, 0x26, 0xD0, 0x68, 0x1E, 0x03, 0xC1, 0x70, 0x9E, 0x4D, 0x26, 0xF6,
  0x3E, 0x04, 0x02, 0x01, 0x00, 0x78, 0x79, 0x0B, 0x33, 0x66, 0xCC, 0xD0,
  0xF4, 0x01, 0x80, 0x20, 0x0B, 0xC3, 0x44, 0x48, 0x91, 0x16, 0x37, 0x83,
  0x80, 0x3C, 0x1D, 0x86, 0x31, 0x80, 0x60, 0x0C, 0x07, 0x03, 0x63, 0xCD,
  0xB1, 0x4C, 0x73, 0x1C, 0xEF, 0x9F, 0x30, 0xFE, 0xA0, 0x09, 0xD8, 0x8C,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x63, 0x0C, 0x38, 0xC0, 0xC3, 0x83, 0x06,
  0x08, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x8E, 0x73, 0x00, 0x0C,
  0x03, 0x00, 0xC2, 0x22, 0xEB, 0xCF, 0x81, 0xC0, 0xD8, 0x33, 0x18, 0xC0,
  0x0C, 0x06, 0x03, 0x01, 0x8F, 0xF8, 0x60, 0x30, 0x18, 0x0C, 0x00, 0x37,
  0x66, 0x4C, 0xFC, 0x7F, 0x80, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0xC0, 0x60,
  0x60, 0x00, 0x7C, 0xEE, 0xC3, 0x83, 0x83, 0x83, 0x9B, 0x9B, 0x83, 0x83,
  0x83, 0xC3, 0xE6, 0x7C, 0x38, 0x78, 0xD8, 0x98, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3E, 0x3B, 0x90, 0x78, 0x30, 0x18,
  0x08, 0x0C, 0x0C, 0x0C, 0x0E, 0x0E, 0x0E, 0x07, 0xFB, 0xFC, 0x7F, 0x3F,
  0x80, 0xC0, 0xC0, 0xC0, 0xE0, 0x7C, 0x06, 0x01, 0x80, 0xF0, 0x68, 0x36,
  0x31, 0xF0, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x63, 0xC3, 0x83, 0xFF,
  0xFF, 0x03, 0x03, 0x03, 0xFE, 0xFE, 0xC0, 0xC0, 0xC0, 0xFC, 0xE6, 0xC3,
  0x03, 0x03, 0x03, 0x83, 0xE6, 0x7C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x01,
  0x61, 0xFC, 0xC3, 0xC1, 0xE0, 0xF0, 0x68, 0x37, 0x31, 0xF0, 0xFF, 0xFF,
  0x83, 0x83, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x18, 0x18, 0x10, 0x30, 0x30,
  0x7C, 0xEE, 0xC3, 0x83, 0xC2, 0x66, 0x3C, 0x7C, 0xC6, 0x83, 0x83, 0x83,
  0xE6, 0x7C, 0x3E, 0x3B, 0x98, 0x78, 0x3C, 0x1E, 0x0D, 0x86, 0xFE, 0x1B,
  0x03, 0x01, 0x81, 0x81, 0x80, 0xC0, 0x5F, 0x80, 0x00, 0x5F, 0x80, 0x37,
  0x70, 0x00, 0x00, 0x37, 0x66, 0x4C, 0x03, 0x0E, 0x38, 0xE0, 0x80, 0xE0,
  0x78, 0x1E, 0x07, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x07, 0x1C, 0x70, 0xC0, 0x80, 0xF3, 0xE0, 0xC1, 0x04,
  0x31, 0xDE, 0x61, 0x80, 0x00, 0xE1, 0x80, 0x3E, 0x1C, 0xEC, 0x0B, 0x03,
  0x80, 0xE3, 0xF8, 0x8E, 0x23, 0x88, 0xE2, 0x38, 0x8E, 0x33, 0x87, 0xF0,
  0x0C, 0x01, 0x80, 0x3E, 0x00, 0x1C, 0x0E, 0x05, 0x02, 0xC3, 0x61, 0x90,
  0xCC, 0x46, 0x63, 0x3F, 0x98, 0x68, 0x3C, 0x1E, 0x04, 0xFC, 0xFE, 0x83,
  0x83, 0x83, 0x86, 0xFC, 0xFE, 0x83, 0x83, 0x83, 0x83, 0xFE, 0xFC, 0x7C,
  0xFE, 0xC3, 0x83, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x83, 0xC3, 0xE6,
  0x7C, 0xF8, 0xFE, 0x86, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x82, 0xFE, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x80, 0x80, 0xFE,
  0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7C, 0xFE, 0xC3, 0x83, 0x80,
  0x80, 0x80, 0x9F, 0x83, 0x83, 0x83, 0xC3, 0xE6, 0x7C, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0xFF, 0xFF, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xFF,
  0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xCF, 0xFF, 0xC0,
  0x1F, 0x1F, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0x01, 0xC1, 0xC3,
  0x67, 0x3E, 0x83, 0x41, 0xA1, 0x90, 0xC8, 0xC4, 0x63, 0xE1, 0xF0, 0x8C,
  0x46, 0x21, 0x90, 0xC8, 0x34, 0x1C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE1, 0xF1, 0xF8, 0xBE,
  0x5D, 0x6E, 0xAF, 0x77, 0x9B, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0C,
  0xC3, 0xC3, 0xE3, 0xA3, 0xB3, 0xB3, 0x93, 0x9B, 0x9B, 0x8B, 0x8F, 0x87,
  0x87, 0x87, 0x7C, 0xEE, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0xC3, 0xE6, 0x7C, 0xFC, 0xFF, 0x83, 0x81, 0x81, 0x83, 0x87, 0xFE,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x7C, 0xEE, 0xC3, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xE6, 0x7C, 0x0C, 0x06, 0x07, 0xFC,
  0xFE, 0x83, 0x83, 0x83, 0x83, 0x86, 0xFC, 0x8C, 0x8C, 0x86, 0x86, 0x83,
  0x83, 0x3E, 0x3B, 0x98, 0x68, 0x36, 0x03, 0x00, 0xF0, 0x1E, 0x03, 0x80,
  0xF0, 0x68, 0x37, 0x31, 0xF0, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xE6, 0x7C, 0xC0,
  0xE0, 0xD0, 0x6C, 0x36, 0x13, 0x18, 0x8C, 0x66, 0x32, 0x1B, 0x05, 0x83,
  0xC1, 0xC0, 0xE0, 0xC6, 0x68, 0xCD, 0x19, 0xA5, 0x36, 0xA4, 0xD4, 0x9A,
  0x93, 0x52, 0x69, 0xC5, 0x38, 0xA7, 0x1C, 0xE3, 0x18, 0x63, 0x00, 0xC1,
  0x98, 0x66, 0x30, 0xCC, 0x36, 0x07, 0x01, 0xC0, 0x70, 0x1E, 0x0D, 0x83,
  0x31, 0x8C, 0x41, 0xB0, 0x70, 0xC0, 0xF0, 0x66, 0x19, 0x8C, 0x33, 0x0D,
  0x81, 0x60, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF,
  0xFF, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x30, 0x60, 0x40, 0xC0, 0xFF,
  0xFF, 0xFF, 0xF1, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7,
  0xC0, 0xC0, 0x30, 0x18, 0x04, 0x03, 0x01, 0x80, 0x60, 0x30, 0x08, 0x06,
  0x03, 0x00, 0x80, 0x60, 0x30, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xC0, 0x18, 0x38,
  0x2C, 0x64, 0x44, 0xC6, 0xC2, 0x83, 0xFF, 0xFF, 0xC0, 0xE2, 0x30, 0x0C,
  0x1F, 0x98, 0x40, 0x30, 0x19, 0xFD, 0x87, 0x83, 0xC1, 0xB1, 0xDF, 0x60,
  0x80, 0x80, 0x80, 0x98, 0xBE, 0xC6, 0xC3, 0x83, 0x83, 0x83, 0x83, 0xC3,
  0xA6, 0xBC, 0x18, 0x7E, 0xC3, 0x83, 0x80, 0x80, 0x80, 0x80, 0xC3, 0xE6,
  0x7C, 0x03, 0x03, 0x03, 0x33, 0xFF, 0xC7, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xC3, 0xE7, 0x7B, 0x38, 0x7E, 0xC2, 0x83, 0x83, 0xFF, 0x80, 0x80, 0xC3,
  0xC6, 0x7C, 0x0F, 0x8F, 0xC6, 0x03, 0x01, 0x87, 0xFC, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x30, 0x7F, 0xC7, 0x83, 0x83, 0x83,
  0x83, 0xC3, 0xC7, 0x7B, 0x03, 0x03, 0x02, 0x7E, 0x80, 0x80, 0x80, 0x98,
  0xBE, 0xC6, 0xC3, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x18, 0x0C,
  0x06, 0x00, 0x00, 0x07, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x87, 0xFF, 0xFE, 0x0C, 0x1C, 0x10, 0x00, 0x1F, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x06, 0x0D, 0xF0, 0xC0, 0x60, 0x30, 0x18, 0x1C,
  0x36, 0x33, 0x31, 0x98, 0xF8, 0x66, 0x33, 0x18, 0xCC, 0x36, 0x1C, 0xF8,
  0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0xF8, 0x7C, 0x13, 0x7F, 0xF2, 0x39, 0x1C, 0x8E, 0x47, 0x23, 0x91,
  0xC8, 0xE4, 0x72, 0x20, 0x18, 0xBE, 0xC6, 0xC3, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0x18, 0x7E, 0xC6, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3,
  0xE6, 0x7C, 0x18, 0xBE, 0xC7, 0xC3, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xA6,
  0xBC, 0x80, 0x80, 0x80, 0x30, 0x7F, 0xC7, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xC3, 0xE7, 0x7B, 0x03, 0x03, 0x03, 0x1C, 0xFE, 0xC3, 0xC3, 0xC3, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x38, 0x7E, 0xC3, 0xC0, 0xC0, 0x7C, 0x0F,
  0x03, 0x83, 0xC7, 0x7E, 0x18, 0x0C, 0x06, 0x1F, 0xF1, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0xF0, 0xF8, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0xC3, 0xE6, 0x7C, 0xC1, 0xA0, 0xD8, 0x4C, 0x62, 0x31, 0x90,
  0xD8, 0x2C, 0x1C, 0x0E, 0x00, 0x8C, 0xE3, 0x2D, 0x4B, 0x52, 0xD4, 0x95,
  0x65, 0x39, 0x4C, 0x63, 0x18, 0xC0, 0xE1, 0x91, 0x8D, 0x83, 0xC0, 0xC0,
  0xE0, 0xD8, 0x66, 0x63, 0x60, 0xC0, 0xC1, 0xB0, 0xD8, 0xC4, 0x63, 0x31,
  0xB0, 0x78, 0x38, 0x0C, 0x06, 0x06, 0x03, 0x03, 0x80, 0xFE, 0x06, 0x0C,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0xFF, 0xFF, 0x07, 0x0F, 0x18, 0x18, 0x18,
  0x08, 0x08, 0x08, 0xF8, 0xF0, 0x18, 0x08, 0x08, 0x08, 0x18, 0x18, 0x0C,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0xF0, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x1F, 0x1F, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x70, 0xE0,
  0x30, 0xBC, 0x73, 0x78, 0xF0,
};

const GFXglyph JetBrainsMono_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 6, 6, 11, 3, -14 },
  { 12, 10, 14, 11, 1, -14 },
  { 30, 9, 20, 11, 1, -17 },
  { 53, 11, 14, 11, 0, -14 },
  { 73, 10, 14, 11, 1, -14 },
  { 91, 2, 6, 11, 5, -14 },
  { 93, 5, 18, 11, 4, -16 },
  { 105, 6, 18, 11, 2, -16 },
  { 119, 10, 10, 11, 1, -12 },
  { 132, 9, 9, 11, 1, -11 },
  { 143, 4, 6, 11, 3, -3 },
  { 146, 6, 1, 11, 3, -7 },
  { 147, 3, 3, 11, 4, -3 },
  { 149, 9, 18, 11, 1, -16 },
  { 170, 8, 14, 11, 2, -14 },
  { 184, 8, 14, 11, 2, -14 },
  { 198, 9, 14, 11, 1, -14 },
  { 214, 9, 14, 11, 1, -14 },
  { 230, 8, 14, 11, 2, -14 },
  { 244, 8, 14, 11, 2, -14 },
  { 258, 9, 14, 11, 1, -14 },
  { 274, 8, 14, 11, 2, -14 },
  { 288, 8, 14, 11, 2, -14 },
  { 302, 9, 14, 11, 1, -14 },
  { 318, 3, 11, 11, 4, -11 },
  { 323, 4, 14, 11, 3, -11 },
  { 330, 8, 10, 11, 2, -11 },
  { 340, 8, 6, 11, 2, -9 },
  { 346, 8, 10, 11, 2, -11 },
  { 356, 6, 14, 11, 3, -14 },
  { 367, 10, 17, 11, 1, -14 },
  { 389, 9, 14, 11, 1, -14 },
  { 405, 8, 14, 11, 2, -14 },
  { 419, 8, 14, 11, 2, -14 },
  { 433, 8, 14, 11, 2, -14 },
  { 447, 8, 14, 11, 2, -14 },
  { 461, 8, 14, 11, 2, -14 },
  { 475, 8, 14, 11, 2, -14 },
  { 489, 8, 14, 11, 2, -14 },
  { 503, 7, 14, 11, 2, -14 },
  { 516, 8, 14, 11, 1, -14 },
  { 530, 9, 14, 11, 2, -14 },
  { 546, 8, 14, 11, 2, -14 },
  { 560, 9, 14, 11, 1, -14 },
  { 576, 8, 14, 11, 2, -14 },
  { 590, 8, 14, 11, 2, -14 },
  { 604, 8, 14, 11, 2, -14 },
  { 618, 8, 17, 11, 2, -14 },
  { 635, 8, 14, 11, 2, -14 },
  { 649, 9, 14, 11, 1, -14 },
  { 665, 9, 14, 11, 1, -14 },
  { 681, 8, 14, 11, 2, -14 },
  { 695, 9, 14, 11, 1, -14 },
  { 711, 11, 14, 11, 0, -14 },
  { 731, 10, 14, 11, 1, -14 },
  { 749, 10, 14, 11, 1, -14 },
  { 767, 8, 14, 11, 2, -14 },
  { 781, 5, 18, 11, 4, -16 },
  { 793, 9, 18, 11, 1, -16 },
  { 814, 5, 18, 11, 3, -16 },
  { 826, 8, 8, 11, 2, -14 },
  { 834, 9, 2, 11, 1, 0 },
  { 837, 4, 3, 11, 3, -15 },
  { 839, 9, 11, 11, 1, -11 },
  { 852, 8, 14, 11, 2, -14 },
  { 866, 8, 11, 11, 2, -11 },
  { 877, 8, 14, 11, 2, -14 },
  { 891, 8, 11, 11, 2, -11 },
  { 902, 9, 14, 11, 1, -14 },
  { 918, 8, 14, 11, 2, -11 },
  { 932, 8, 14, 11, 2, -14 },
  { 946, 9, 15, 11, 2, -15 },
  { 963, 7, 18, 11, 2, -15 },
  { 979, 9, 14, 11, 2, -14 },
  { 995, 9, 14, 11, 1, -14 },
  { 1011, 9, 11, 11, 1, -11 },
  { 1024, 8, 11, 11, 2, -11 },
  { 1035, 8, 11, 11, 2, -11 },
  { 1046, 8, 14, 11, 2, -11 },
  { 1060, 8, 14, 11, 2, -11 },
  { 1074, 8, 11, 11, 2, -11 },
  { 1085, 8, 11, 11, 2, -11 },
  { 1096, 9, 13, 11, 1, -13 },
  { 1111, 8, 10, 11, 2, -10 },
  { 1121, 9, 10, 11, 1, -10 },
  { 1133, 10, 10, 11, 1, -10 },
  { 1146, 9, 10, 11, 1, -10 },
  { 1158, 9, 13, 11, 1, -10 },
  { 1173, 8, 10, 11, 2, -10 },
  { 1183, 8, 18, 11, 2, -16 },
  { 1201, 2, 18, 11, 5, -16 },
  { 1206, 8, 18, 11, 2, -16 },
  { 1224, 9, 4, 11, 1, -9 },
};

const GFXfont JetBrainsMono_Regular19pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular19pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular19pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _JETBRAINSMONO_REGULAR19PT7B_H_
