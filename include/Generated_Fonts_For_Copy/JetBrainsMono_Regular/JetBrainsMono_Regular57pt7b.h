#ifndef _JETBRAINSMONO_REGULAR57PT7B_H_
#define _JETBRAINSMONO_REGULAR57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x18, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7E, 0xF8, 0x1F, 0xFC, 0x0F, 0xFE,
  0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7F, 0xF0, 0x3F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xBE, 0x07, 0xDF, 0x03, 0xEF, 0x80, 0xF7, 0xC0,
  0x7B, 0xE0, 0x3D, 0xF0, 0x1E, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x07, 0x80, 0x07, 0x80, 0x3C, 0x00, 0x1E,
  0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x80,
  0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x0F, 0x80,
  0x07, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0xF0,
  0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x3C, 0x01,
  0xE0, 0x3F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00,
  0x3C, 0x01, 0xE0, 0x00, 0xF0, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80,
  0x3C, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xE3, 0x8F, 0xC3, 0xF0, 0xE1, 0xF8, 0xF8,
  0x38, 0x3E, 0x7E, 0x0E, 0x0F, 0x9F, 0x03, 0x83, 0xE7, 0xC0, 0xE0, 0xFD,
  0xF0, 0x38, 0x00, 0x7E, 0x0E, 0x00, 0x1F, 0x83, 0x80, 0x03, 0xE0, 0xE0,
  0x00, 0xFC, 0x38, 0x00, 0x1F, 0x8E, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0E, 0xFF, 0x00, 0x03, 0x8F,
  0xE0, 0x00, 0xE1, 0xF8, 0x00, 0x38, 0x3F, 0x00, 0x0E, 0x0F, 0xC0, 0x03,
  0x81, 0xF0, 0x00, 0xE0, 0x7F, 0xE0, 0x38, 0x1F, 0xF8, 0x0E, 0x07, 0xFF,
  0x03, 0x81, 0xF7, 0xC0, 0xE0, 0xFD, 0xF8, 0x38, 0x3E, 0x7F, 0x0E, 0x1F,
  0x8F, 0xF3, 0x9F, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x1F,
  0xF8, 0x00, 0x1F, 0x3F, 0xFC, 0x00, 0x1E, 0x7F, 0xFE, 0x00, 0x3C, 0xFC,
  0x3E, 0x00, 0x7C, 0xF8, 0x1E, 0x00, 0x78, 0xF0, 0x1F, 0x00, 0xF0, 0xF0,
  0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x03, 0xC0, 0xF0,
  0x0F, 0x07, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0xF0, 0x1F, 0x0F, 0x00, 0xF0,
  0x1F, 0x1E, 0x00, 0xF8, 0x3E, 0x1E, 0x00, 0x7F, 0xFE, 0x3C, 0x00, 0x7F,
  0xFC, 0x78, 0x00, 0x3F, 0xF8, 0x78, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0x0F, 0xF8, 0x00,
  0x1E, 0x3F, 0xFC, 0x00, 0x3E, 0x3F, 0xFE, 0x00, 0x3C, 0x7C, 0x3F, 0x00,
  0x78, 0x78, 0x1F, 0x00, 0xF8, 0x78, 0x0F, 0x00, 0xF0, 0xF8, 0x0F, 0x01,
  0xE0, 0xF8, 0x0F, 0x03, 0xE0, 0xF8, 0x0F, 0x03, 0xC0, 0xF8, 0x0F, 0x07,
  0x80, 0xF8, 0x0F, 0x0F, 0x00, 0xF8, 0x0F, 0x0F, 0x00, 0x78, 0x0F, 0x1E,
  0x00, 0x7C, 0x1F, 0x3C, 0x00, 0x7F, 0xFE, 0x7C, 0x00, 0x3F, 0xFE, 0x78,
  0x00, 0x1F, 0xFC, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFE, 0x1F,
  0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0,
  0x3F, 0x00, 0x3E, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x7D, 0xF9, 0xF8, 0x07, 0xDF, 0x87, 0xE0, 0x3E, 0xF8, 0x1F,
  0x83, 0xE7, 0xC0, 0x7C, 0x3F, 0x3E, 0x03, 0xF1, 0xF1, 0xF0, 0x0F, 0xDF,
  0x8F, 0x80, 0x3E, 0xF8, 0x7C, 0x01, 0xFF, 0x83, 0xE0, 0x07, 0xFC, 0x1F,
  0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00,
  0x3F, 0xC1, 0xF8, 0x03, 0xFF, 0x07, 0xC0, 0x3F, 0xF8, 0x3F, 0x83, 0xFF,
  0xE1, 0xFF, 0xFF, 0x9F, 0x87, 0xFF, 0xF8, 0x7C, 0x1F, 0xFF, 0x01, 0xF0,
  0x3F, 0xF0, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xBE, 0xFB, 0xEF, 0x9E, 0x78, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0x3C, 0x00, 0x06, 0x80, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x02,
  0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x20, 0x07, 0x80, 0x09,
  0xE0, 0x1E, 0x01, 0xE7, 0xF0, 0x78, 0x3F, 0x9F, 0xF1, 0xE3, 0xFF, 0xFF,
  0xE3, 0x9F, 0xFD, 0xFF, 0xED, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE1, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x01,
  0x80, 0x06, 0x00, 0x02, 0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xF0, 0x7F, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0xFC,
  0x1F, 0xC1, 0xF8, 0x1F, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x1E, 0x0F, 0xE7, 0xF9, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD,
  0xFE, 0x3F, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFC, 0x3F,
  0xC3, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x0F, 0xC1, 0xFF,
  0x87, 0xE0, 0xFF, 0xC3, 0xF8, 0x7F, 0xE1, 0xF8, 0x3F, 0xF0, 0x7C, 0x1F,
  0xF8, 0x08, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x80,
  0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x80, 0x07, 0xF7, 0xE0, 0x07, 0xF9, 0xF8, 0x03, 0xFC,
  0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x03,
  0x00, 0x7E, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0, 0x1F,
  0xC7, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF,
  0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x7F, 0xC0, 0x7D, 0xFF, 0xF0, 0x7D, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xC3, 0xFE, 0x7F, 0x00, 0x7E, 0x7E, 0x00,
  0x3F, 0x7C, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7F, 0x81,
  0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xFF,
  0xC0, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xCF, 0xC0, 0x07,
  0xEF, 0xFE, 0x01, 0xF7, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xE1, 0xFF,
  0x1F, 0xE0, 0x1F, 0xE7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xF0, 0x3F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFE, 0x7F, 0xC3, 0xF8, 0x07, 0xF1,
  0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0xBE, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01,
  0xF1, 0xF8, 0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x81, 0xFC, 0x07, 0xE1,
  0xFC, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x3F, 0x87, 0xF0, 0x3F, 0x00, 0xFC, 0x3F,
  0x00, 0x3F, 0x1F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xF7,
  0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x07,
  0xF3, 0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFF,
  0x0F, 0xE0, 0x1F, 0xC7, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x7C, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x3F, 0x8F, 0xF0, 0x3F, 0xE1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xBE, 0x00, 0x7F, 0x9F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xF8, 0xFE, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0xE7, 0xFB, 0xFF,
  0xFF, 0xDF, 0xF7, 0xF8, 0xFC, 0x04, 0x00, 0x07, 0xC1, 0xFE, 0x1F, 0xF3,
  0xFF, 0x3F, 0xF3, 0xFF, 0x1F, 0xE0, 0xFE, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0xC1,
  0xFC, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xE0, 0x7E, 0x07,
  0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0xC0, 0x03,
  0xFE, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x07,
  0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0x83, 0xFE, 0x00, 0x7F, 0x8F, 0xF0, 0x07,
  0xFE, 0x7F, 0x80, 0x7F, 0xFB, 0xFC, 0x07, 0xE0, 0xFF, 0xE0, 0x3E, 0x03,
  0xFF, 0x01, 0xF0, 0x0F, 0xF8, 0x0F, 0x00, 0x7F, 0xC0, 0x78, 0x03, 0xFE,
  0x03, 0xC0, 0x1F, 0xF0, 0x1E, 0x00, 0xFF, 0x80, 0xF0, 0x07, 0xFC, 0x07,
  0x80, 0x3F, 0xE0, 0x3C, 0x01, 0xFF, 0x01, 0xE0, 0x0F, 0xF8, 0x0F, 0x00,
  0x7F, 0xC0, 0x78, 0x03, 0xFE, 0x03, 0xC0, 0x1F, 0xF0, 0x1F, 0x00, 0xFF,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0xFE, 0xFF, 0x00,
  0x7F, 0xF7, 0xF8, 0x01, 0xFF, 0x3F, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0,
  0xF8, 0x00, 0x1F, 0x07, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C,
  0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC7, 0xC0, 0x0F, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x7C, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0xFE, 0x3F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF1,
  0xF0, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xEF, 0x80, 0x07, 0xF7, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x83, 0xFF, 0x7F, 0xC3, 0xF8, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00,
  0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xF0, 0x07, 0xE1, 0xFE, 0x0F, 0xF0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0x02, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0xFE,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x7E, 0xF8, 0x01, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x83, 0xFF, 0x7F, 0xC3, 0xF8, 0x07, 0xF1, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE1, 0xFC,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0x02, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x07,
  0xE7, 0xE0, 0x07, 0xF1, 0xFC, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0A, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0xCF, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x03, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x3E, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x0F, 0xC0, 0x1F,
  0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x3F,
  0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFC, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xFC, 0x00, 0xF7, 0xFF, 0x00, 0x3F, 0xFD, 0xE0, 0x0F, 0xFF, 0x78,
  0x07, 0xBF, 0xDE, 0x01, 0xEF, 0xF7, 0xC0, 0x7B, 0xFC, 0xF0, 0x3E, 0xFF,
  0x3C, 0x0F, 0x3F, 0xEF, 0x83, 0xCF, 0xF9, 0xE1, 0xF3, 0xFE, 0x78, 0x78,
  0xFF, 0x9F, 0x1E, 0x7F, 0xE3, 0xC7, 0x9F, 0xF8, 0xF3, 0xC7, 0xFE, 0x3E,
  0xF1, 0xFF, 0x87, 0xBC, 0x7F, 0xE1, 0xFE, 0x1F, 0xF8, 0x7F, 0x87, 0xFE,
  0x0F, 0xE1, 0xFF, 0x83, 0xF0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xFB,
  0xC0, 0x1F, 0xFB, 0xE0, 0x1F, 0xFB, 0xE0, 0x1F, 0xF9, 0xE0, 0x1F, 0xF9,
  0xF0, 0x1F, 0xF9, 0xF0, 0x1F, 0xF8, 0xF0, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8,
  0x78, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x3C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x3E, 0x1F, 0xF8, 0x1E, 0x1F, 0xF8, 0x1F, 0x1F, 0xF8,
  0x1F, 0x1F, 0xF8, 0x0F, 0x1F, 0xF8, 0x0F, 0x9F, 0xF8, 0x0F, 0x9F, 0xF8,
  0x07, 0x9F, 0xF8, 0x07, 0xDF, 0xF8, 0x07, 0xDF, 0xF8, 0x03, 0xDF, 0xF8,
  0x03, 0xFF, 0xF8, 0x01, 0xEF, 0xF8, 0x01, 0xEF, 0xF8, 0x01, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00, 0x7E, 0x7C,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xFB, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFB, 0xE0, 0x01, 0xFE, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0xC3, 0xF8, 0x07, 0xF1, 0xF8,
  0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x07, 0xE1,
  0xFC, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x3F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0,
  0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x07,
  0xF3, 0xE0, 0x07, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC,
  0x0F, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xF3, 0xFF, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x3E, 0x7F, 0x00, 0x1F, 0x8F, 0xF0, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x40, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F,
  0x7E, 0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x81, 0xFC, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x03,
  0xE3, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3F,
  0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00,
  0xF8, 0x1F, 0x80, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00,
  0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0,
  0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x78, 0x07, 0xE0, 0x1F, 0x7C,
  0x07, 0xE0, 0x1F, 0x7C, 0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xE0, 0x1E, 0x7C,
  0x07, 0xE0, 0x1E, 0x7C, 0x07, 0xF0, 0x3E, 0x7C, 0x07, 0x70, 0x3E, 0x7C,
  0x07, 0x70, 0x3E, 0x7C, 0x0F, 0x70, 0x3E, 0x3C, 0x0E, 0x70, 0x3E, 0x3C,
  0x0E, 0x70, 0x3C, 0x3E, 0x0E, 0x70, 0x3C, 0x3E, 0x0E, 0x70, 0x3C, 0x3E,
  0x0E, 0x78, 0x3C, 0x3E, 0x0E, 0x78, 0x7C, 0x3E, 0x0E, 0x38, 0x7C, 0x3E,
  0x1E, 0x38, 0x7C, 0x1E, 0x1E, 0x38, 0x7C, 0x1E, 0x1C, 0x38, 0x7C, 0x1E,
  0x1C, 0x38, 0x78, 0x1E, 0x1C, 0x38, 0x78, 0x1F, 0x1C, 0x38, 0x78, 0x1F,
  0x1C, 0x3C, 0x78, 0x1F, 0x1C, 0x3C, 0x78, 0x1F, 0x3C, 0x1C, 0xF8, 0x1F,
  0x3C, 0x1C, 0xF8, 0x0F, 0x38, 0x1C, 0xF8, 0x0F, 0x38, 0x1C, 0xF0, 0x0F,
  0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x0F, 0x38, 0x1C, 0xF0, 0x0F,
  0xB8, 0x1E, 0xF0, 0x0F, 0xF8, 0x1E, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x1F,
  0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0x80,
  0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1F, 0xBE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00,
  0xFC, 0x0F, 0xC0, 0x03, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C,
  0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00,
  0x0F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xF8, 0x0F,
  0x80, 0x07, 0xC0, 0x3F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF8,
  0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF0,
  0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0x78, 0x00, 0xF0,
  0x3E, 0x00, 0xF8, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x7C, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xC7, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFC, 0x03,
  0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFF, 0xDF, 0x80, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xEF, 0xC0, 0x1F, 0xF7, 0xFF, 0xFE,
  0xF9, 0xFF, 0xFF, 0x7C, 0x7F, 0xFE, 0x3E, 0x0F, 0xFE, 0x1F, 0x00, 0x60,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0xF8,
  0x7F, 0xE0, 0xF9, 0xFF, 0xF8, 0xF9, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xFB,
  0x80, 0xFE, 0xFE, 0x00, 0x7E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x3F, 0xFB, 0x00, 0x7E, 0xFB, 0x81, 0xFE, 0xFB, 0xFF, 0xFC, 0xF9,
  0xFF, 0xF8, 0xF8, 0xFF, 0xF0, 0xF8, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC3, 0xF8, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x3E, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x9F, 0x80, 0x1F, 0x87,
  0xF0, 0x3F, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x1F, 0x07, 0xFF, 0x1F, 0x1F, 0xFF, 0x9F, 0x3F, 0xFF,
  0xDF, 0x3F, 0xFF, 0xDF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x81,
  0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x07, 0xFE,
  0x1F, 0x00, 0x30, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xC3, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0x3E, 0x7C, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xFF, 0x1F, 0x0F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0xFF,
  0xDF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0x7C, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7F, 0x7F, 0x00,
  0xFF, 0x3F, 0xF7, 0xDF, 0x3F, 0xFF, 0xDF, 0x1F, 0xFF, 0x9F, 0x07, 0xFF,
  0x1F, 0x01, 0xFC, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x01, 0xFE, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xE0, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x1F,
  0x80, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF, 0xF8, 0xFB, 0xFF, 0xFC, 0xFB, 0xE7,
  0xFC, 0xFB, 0x00, 0xFE, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x0F, 0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x1F, 0x80,
  0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFC, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0x3E, 0x3C,
  0xFE, 0x3F, 0xCF, 0x7F, 0xCF, 0xFB, 0xDF, 0xFF, 0xFF, 0xFC, 0x7F, 0x8F,
  0xFE, 0x0F, 0xC1, 0xFF, 0x81, 0xE0, 0x3F, 0xE0, 0x78, 0x0F, 0xF8, 0x1E,
  0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x3F, 0xE0, 0x78, 0x0F, 0xF8,
  0x1E, 0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x3F, 0xE0, 0x78, 0x0F,
  0xF8, 0x1E, 0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x3F, 0xE0, 0x78,
  0x0F, 0xF8, 0x1E, 0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x3F, 0xE0,
  0x78, 0x0F, 0xF8, 0x1E, 0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0, 0x3F,
  0xE0, 0x78, 0x0F, 0xF8, 0x1E, 0x03, 0xFE, 0x07, 0x80, 0xFF, 0x81, 0xE0,
  0x3F, 0xE0, 0x78, 0x0F, 0x00, 0x1F, 0x80, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF,
  0xF8, 0xFB, 0xFF, 0xFC, 0xFB, 0xFF, 0xFC, 0xFB, 0x00, 0xFE, 0xFE, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0x00, 0xFE, 0x7E, 0x00,
  0x7E, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7E, 0x00,
  0x7E, 0x3F, 0xC1, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0xF8, 0x7F, 0xF0, 0xF9, 0xFF,
  0xF8, 0xF9, 0xFF, 0xFC, 0xFB, 0xFF, 0xFE, 0xFB, 0x80, 0xFE, 0xFE, 0x00,
  0x7E, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFB, 0x00,
  0x7E, 0xFB, 0x81, 0xFE, 0xFB, 0xFF, 0xFC, 0xF9, 0xFF, 0xF8, 0xF8, 0xFF,
  0xF0, 0xF8, 0x7F, 0xE0, 0xF8, 0x06, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xFF, 0x1F, 0x1F, 0xFF, 0x9F, 0x1F, 0xFF, 0xDF, 0x3F, 0xFF,
  0xDF, 0x7F, 0x00, 0xFF, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0x7C, 0x00, 0x7F, 0x7E, 0x00, 0x7F, 0x7F, 0x81, 0xDF, 0x3F, 0xFF,
  0xDF, 0x1F, 0xFF, 0x9F, 0x0F, 0xFF, 0x1F, 0x07, 0xFE, 0x1F, 0x00, 0x30,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0xF8, 0xFF, 0xE0, 0xF9, 0xFF,
  0xF8, 0xFB, 0xFF, 0xFC, 0xFB, 0xE3, 0xFE, 0xFB, 0x00, 0xFE, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE3, 0xF8, 0x03, 0xF9, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0x9F, 0x80, 0x0F, 0xCF, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E,
  0x00, 0x3E, 0x7E, 0x00, 0x7E, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xFC,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x0F, 0x80, 0x01, 0xF0, 0xF8,
  0x00, 0x1F, 0x8F, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x07, 0xC0, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0x80, 0xFC, 0x07, 0xDE,
  0x03, 0xF0, 0x1F, 0x78, 0x0F, 0xC0, 0x79, 0xE0, 0x3F, 0x01, 0xE7, 0xC0,
  0xFE, 0x07, 0x9F, 0x07, 0x38, 0x1E, 0x7C, 0x1C, 0xE0, 0x78, 0xF0, 0x73,
  0x83, 0xE3, 0xC1, 0xCE, 0x0F, 0x0F, 0x07, 0x38, 0x3C, 0x3C, 0x1C, 0xF0,
  0xF0, 0xF8, 0xF1, 0xC3, 0xC3, 0xE3, 0x87, 0x0F, 0x07, 0x8E, 0x1C, 0x3C,
  0x1E, 0x38, 0x71, 0xE0, 0x78, 0xE1, 0xC7, 0x81, 0xE3, 0x87, 0x1E, 0x07,
  0x8E, 0x0E, 0x78, 0x1F, 0x70, 0x39, 0xE0, 0x7D, 0xC0, 0xE7, 0x80, 0xF7,
  0x03, 0x9C, 0x03, 0xDC, 0x0E, 0xF0, 0x0F, 0x70, 0x3B, 0xC0, 0x3D, 0xC0,
  0xFF, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x07, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x0F,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x07,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0xF9, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0x00, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x0F, 0xC0, 0x1F,
  0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x8F,
  0x80, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xFD, 0xF0, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xC0, 0x03, 0xE7, 0xFE, 0x00, 0x7D, 0xFF, 0xE0, 0x0F, 0xBF, 0xFE, 0x01,
  0xFF, 0xCF, 0xE0, 0x3F, 0xF0, 0x7E, 0x07, 0xBE, 0x07, 0xE1, 0xF7, 0xC0,
  0xFF, 0xFE, 0xF8, 0x0F, 0xFF, 0x9F, 0x00, 0xFF, 0xF3, 0xE0, 0x07, 0xF8,
  0x00, 0x00, 0x3C, 0x00,
};

const GFXglyph JetBrainsMono_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 8, 42, 34, 13, -42 },
  { 43, 17, 17, 34, 9, -42 },
  { 80, 30, 42, 34, 2, -42 },
  { 238, 26, 58, 34, 4, -50 },
  { 427, 32, 42, 34, 1, -42 },
  { 595, 29, 43, 34, 3, -42 },
  { 751, 6, 17, 34, 14, -42 },
  { 764, 17, 55, 34, 11, -48 },
  { 881, 17, 55, 34, 7, -48 },
  { 998, 30, 30, 34, 2, -35 },
  { 1111, 27, 27, 34, 4, -32 },
  { 1203, 12, 18, 34, 9, -9 },
  { 1230, 18, 4, 34, 8, -21 },
  { 1239, 10, 10, 34, 12, -9 },
  { 1252, 26, 53, 34, 4, -47 },
  { 1425, 25, 43, 34, 5, -42 },
  { 1560, 26, 42, 34, 5, -42 },
  { 1697, 26, 42, 34, 4, -42 },
  { 1834, 25, 43, 34, 4, -42 },
  { 1969, 24, 42, 34, 5, -42 },
  { 2095, 24, 43, 34, 5, -42 },
  { 2224, 26, 43, 34, 4, -42 },
  { 2364, 26, 42, 34, 5, -42 },
  { 2501, 25, 43, 34, 5, -42 },
  { 2636, 26, 42, 34, 4, -42 },
  { 2773, 10, 33, 34, 12, -32 },
  { 2815, 12, 41, 34, 10, -32 },
  { 2877, 24, 30, 34, 5, -34 },
  { 2967, 24, 18, 34, 5, -28 },
  { 3021, 24, 30, 34, 5, -34 },
  { 3111, 20, 42, 34, 8, -42 },
  { 3216, 29, 52, 34, 3, -42 },
  { 3405, 28, 42, 34, 3, -42 },
  { 3552, 25, 42, 34, 5, -42 },
  { 3684, 25, 43, 34, 5, -42 },
  { 3819, 24, 42, 34, 5, -42 },
  { 3945, 24, 42, 34, 6, -42 },
  { 4071, 25, 42, 34, 5, -42 },
  { 4203, 25, 43, 34, 5, -42 },
  { 4338, 24, 42, 34, 5, -42 },
  { 4464, 22, 42, 34, 6, -42 },
  { 4580, 25, 43, 34, 3, -42 },
  { 4715, 27, 42, 34, 5, -42 },
  { 4857, 24, 42, 34, 7, -42 },
  { 4983, 26, 42, 34, 4, -42 },
  { 5120, 24, 42, 34, 5, -42 },
  { 5246, 24, 43, 34, 5, -42 },
  { 5375, 26, 42, 34, 5, -42 },
  { 5512, 25, 52, 34, 5, -42 },
  { 5675, 26, 42, 34, 5, -42 },
  { 5812, 26, 43, 34, 4, -42 },
  { 5952, 28, 42, 34, 3, -42 },
  { 6099, 24, 43, 34, 5, -42 },
  { 6228, 28, 42, 34, 3, -42 },
  { 6375, 32, 42, 34, 1, -42 },
  { 6543, 30, 42, 34, 2, -42 },
  { 6701, 30, 42, 34, 2, -42 },
  { 6859, 24, 42, 34, 5, -42 },
  { 6985, 14, 53, 34, 12, -47 },
  { 7078, 26, 53, 34, 4, -47 },
  { 7251, 14, 53, 34, 9, -47 },
  { 7344, 25, 23, 34, 5, -42 },
  { 7416, 28, 5, 34, 3, 1 },
  { 7434, 12, 8, 34, 10, -45 },
  { 7446, 25, 33, 34, 4, -32 },
  { 7550, 24, 43, 34, 5, -42 },
  { 7679, 25, 33, 34, 5, -32 },
  { 7783, 24, 43, 34, 5, -42 },
  { 7912, 24, 33, 34, 5, -32 },
  { 8011, 28, 42, 34, 3, -42 },
  { 8158, 24, 42, 34, 5, -32 },
  { 8284, 24, 42, 34, 5, -42 },
  { 8410, 27, 44, 34, 5, -44 },
  { 8559, 21, 54, 34, 5, -44 },
  { 8701, 27, 42, 34, 5, -42 },
  { 8843, 29, 42, 34, 2, -42 },
  { 8996, 26, 32, 34, 4, -32 },
  { 9100, 24, 32, 34, 5, -32 },
  { 9196, 24, 32, 34, 5, -32 },
  { 9292, 24, 42, 34, 5, -32 },
  { 9418, 24, 42, 34, 5, -32 },
  { 9544, 24, 32, 34, 6, -32 },
  { 9640, 25, 32, 34, 5, -32 },
  { 9740, 27, 40, 34, 3, -40 },
  { 9875, 24, 32, 34, 5, -31 },
  { 9971, 28, 31, 34, 3, -31 },
  { 10080, 30, 31, 34, 2, -31 },
  { 10197, 28, 31, 34, 3, -31 },
  { 10306, 28, 41, 34, 3, -31 },
  { 10450, 24, 31, 34, 5, -31 },
  { 10543, 24, 53, 34, 5, -47 },
  { 10702, 5, 53, 34, 15, -47 },
  { 10736, 24, 53, 34, 5, -47 },
  { 10895, 27, 12, 34, 4, -26 },
};

const GFXfont JetBrainsMono_Regular57pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular57pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular57pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _JETBRAINSMONO_REGULAR57PT7B_H_
