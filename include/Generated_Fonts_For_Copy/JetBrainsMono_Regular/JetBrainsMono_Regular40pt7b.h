#ifndef _JETBRAINSMONO_REGULAR40PT7B_H_
#define _JETBRAINSMONO_REGULAR40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x38, 0xC3, 0x0C, 0x00, 0x00, 0x00, 0x33, 0xFF, 0xFF, 0x78, 0xF0,
  0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0,
  0xFF, 0x0F, 0xF0, 0x7E, 0x07, 0x00, 0xC0, 0x70, 0x07, 0x01, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x38, 0x0C,
  0x00, 0xE0, 0x70, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x00,
  0xC0, 0x70, 0x07, 0x01, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0,
  0xE0, 0x06, 0x03, 0x80, 0x38, 0x0C, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF0, 0x38, 0x1C, 0x00, 0xC0, 0x70, 0x07, 0x01, 0x80, 0x1C,
  0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xE0, 0x06, 0x03, 0x80, 0x38, 0x0C,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x38, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF, 0x1F, 0x33, 0xE7,
  0x8C, 0x79, 0xC3, 0x0F, 0x70, 0xC3, 0xDC, 0x30, 0x07, 0x8C, 0x01, 0xE3,
  0x00, 0x7C, 0xC0, 0x0F, 0xB0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x0D, 0xF8, 0x03, 0x1E, 0x00, 0xC3, 0xC0, 0x30, 0xF0,
  0x0C, 0x3F, 0xC3, 0x0F, 0xF0, 0xC3, 0xFC, 0x30, 0xFF, 0x8C, 0x3D, 0xF3,
  0x3E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x3F, 0x80,
  0x1D, 0xFF, 0x00, 0xEF, 0x3C, 0x03, 0xB8, 0x78, 0x1C, 0xE0, 0xE0, 0xE3,
  0x83, 0x83, 0x8E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xE0, 0xE3, 0x83, 0x87,
  0x1C, 0x0F, 0xFC, 0xE0, 0x1F, 0xE7, 0x00, 0x1F, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE3, 0xF0, 0x07, 0x3F, 0xE0,
  0x1C, 0xFF, 0xC0, 0xE7, 0x87, 0x07, 0x1C, 0x1C, 0x1C, 0x70, 0x70, 0xE1,
  0xC1, 0xC7, 0x07, 0x07, 0x1C, 0x1C, 0x1C, 0xE0, 0x78, 0x77, 0x00, 0xFF,
  0xDC, 0x03, 0xFE, 0xE0, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0x80, 0xE0, 0x1E,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x79, 0xE0, 0xF7, 0x87, 0x87, 0x3C, 0x3C, 0x79, 0xE0, 0xF3, 0x8F, 0x03,
  0xFC, 0x78, 0x1F, 0xC3, 0xC0, 0x7E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x87,
  0x80, 0xFC, 0x1E, 0x0F, 0xF0, 0xFF, 0xF3, 0xC3, 0xFF, 0x0F, 0x0F, 0xF0,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0x00, 0x10, 0x07, 0x01, 0xF0,
  0x3F, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E, 0x00, 0xF8, 0x07, 0xC0,
  0x3F, 0x01, 0xF0, 0x07, 0x00, 0x10, 0x80, 0x0E, 0x00, 0xF8, 0x0F, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x7C, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0xC0,
  0xF8, 0x0E, 0x00, 0x80, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x01, 0x01, 0xE0, 0x27, 0x83, 0x07,
  0x9F, 0x8C, 0x7E, 0xFF, 0xB7, 0xFC, 0x7F, 0xFF, 0x80, 0x1F, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0x38, 0x00, 0x3C, 0xF0, 0x01, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x3C, 0x0F, 0x01, 0xE0, 0x3E, 0x01, 0x80, 0x60,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1F, 0x3E, 0x3E, 0x3E, 0x3C,
  0x7C, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x78,
  0xFF, 0x1E, 0x3F, 0xC7, 0x8F, 0xF1, 0xE3, 0xFC, 0x30, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70,
  0x03, 0x9E, 0x01, 0xE7, 0xC0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x01, 0xFB, 0x80, 0xF8, 0xE0,
  0x3C, 0x38, 0x0E, 0x0E, 0x02, 0x03, 0x80, 0x80, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xC0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x3B, 0xC0,
  0x0E, 0xF0, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0x7F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xBE, 0x0F, 0x8F, 0xFF,
  0xC3, 0xFF, 0xC0, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0xF0, 0x3C, 0xF0,
  0x1E, 0xF0, 0x0F, 0x78, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7,
  0xFF, 0xF9, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x9F, 0xC1, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0x83, 0xE7, 0xC0, 0x79, 0xE0, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x39, 0xC0,
  0x0E, 0x78, 0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF7, 0xF0, 0x3F, 0xFE, 0x1F, 0xFF, 0xC7, 0xC0, 0xFB, 0xE0,
  0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x07, 0x9F, 0x03, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F,
  0x9E, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9E, 0x01, 0xE7,
  0x80, 0x78, 0xF0, 0x3C, 0x1E, 0x1E, 0x03, 0xFF, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x1F, 0xFE, 0x0F, 0x87, 0xC7, 0x80, 0x79, 0xE0, 0x1E, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE, 0x01, 0xE7,
  0xC0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x01, 0xE0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x7D, 0xF8, 0x7E, 0x3F, 0xFF, 0x87,
  0xFF, 0xC0, 0x7C, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x33, 0xFF, 0xFF, 0xFD, 0xE0, 0x3F, 0x3F,
  0x3F, 0x3F, 0x3F, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x1F, 0x3E, 0x3E, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70,
  0xF0, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0xC3,
  0xFF, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x7F, 0x07, 0xFC,
  0x0F, 0xF0, 0x1F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0x20, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0,
  0x7C, 0x3C, 0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF7, 0xE0, 0x7F, 0xFE,
  0x0F, 0x0F, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07,
  0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0, 0x7E, 0x0E, 0x07, 0xE0, 0xE0,
  0x7E, 0x0E, 0x07, 0xE0, 0xF0, 0xFE, 0x0F, 0xFB, 0xE0, 0x7F, 0x3E, 0x01,
  0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x07, 0x9E, 0x00, 0x70,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0x70, 0x0E,
  0x07, 0x01, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x38, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x80, 0x1E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0xFF, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9C, 0x07, 0xEE, 0x00, 0xF7,
  0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0x03,
  0xDC, 0x03, 0xCF, 0xFF, 0xC7, 0xFF, 0x83, 0xFF, 0xF1, 0xC0, 0xFC, 0xE0,
  0x0F, 0x70, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x1F, 0xBF, 0xFF, 0x9F, 0xFF,
  0x8F, 0xFF, 0x00, 0x01, 0x80, 0x0F, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF,
  0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0x78, 0x07, 0x9E, 0x07,
  0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF,
  0xFC, 0xE0, 0x3E, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0xE0, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF,
  0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF,
  0xFB, 0xFF, 0xFD, 0xFF, 0xFE, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x01, 0x80, 0x0F,
  0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0x81, 0xF7, 0x80, 0x7B, 0xC0, 0x1D,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xF0, 0x07, 0x78, 0x07, 0x9E, 0x07, 0xCF, 0xFF, 0xC3, 0xFF, 0xC0, 0x7F,
  0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xC0,
  0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0E, 0xF8, 0x07, 0x9F, 0x03, 0xE3, 0xFF, 0xF0, 0x7F, 0xF8,
  0x0F, 0xF8, 0x00, 0xE0, 0x03, 0xF8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x3C,
  0xE0, 0x0F, 0x38, 0x07, 0x8E, 0x01, 0xE3, 0x80, 0xF0, 0xE0, 0x3C, 0x38,
  0x1E, 0x0E, 0x07, 0x83, 0x83, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0x87, 0xC0, 0xE0, 0xF0, 0x38, 0x3E, 0x0E, 0x07, 0x83, 0x81, 0xF0,
  0xE0, 0x3C, 0x38, 0x0F, 0x8E, 0x01, 0xE3, 0x80, 0x3C, 0xE0, 0x0F, 0x38,
  0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0F, 0xE0, 0x03, 0xC0, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x01, 0xFF,
  0xC0, 0xEF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFB, 0x87, 0x7E, 0xE1, 0xDF, 0xB8,
  0x77, 0xE7, 0x19, 0xF9, 0xCE, 0x7E, 0x73, 0x9F, 0x8E, 0xC7, 0xE3, 0xF1,
  0xF8, 0xFC, 0x7E, 0x1F, 0x1F, 0x87, 0x8F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xC0, 0xF8, 0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xEE, 0x07, 0xEE, 0x07, 0xEF, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7,
  0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0xC7, 0xE1, 0xC7, 0xE1, 0xC7, 0xE0,
  0xE7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x77, 0xE0,
  0x3F, 0xE0, 0x3F, 0xE0, 0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0x01,
  0xC0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7F, 0xFE, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xF0, 0x0F, 0x78, 0x1E, 0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xFF,
  0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0x80, 0x7E, 0xE0, 0x07, 0xB8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x1F, 0xE0, 0x07, 0xB8, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF,
  0xF0, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0,
  0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x70,
  0x03, 0x9E, 0x01, 0xE7, 0xC0, 0xF8, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3,
  0x80, 0x7C, 0xE0, 0x0F, 0xB8, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x0F, 0x3F, 0xFF,
  0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0x38, 0x3C, 0x0E, 0x07, 0x83,
  0x81, 0xE0, 0xE0, 0x3C, 0x38, 0x0F, 0x0E, 0x01, 0xE3, 0x80, 0x78, 0xE0,
  0x0F, 0x38, 0x03, 0xCE, 0x00, 0xFB, 0x80, 0x1E, 0xE0, 0x07, 0xC0, 0x01,
  0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xFF, 0xFC, 0x7C, 0x0F, 0x9E, 0x01,
  0xE7, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x01, 0xF7, 0xC0, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x39,
  0xC0, 0x03, 0x9C, 0x00, 0x3D, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0xF0, 0x78, 0x1F, 0xC1, 0xE0,
  0x7F, 0x07, 0x83, 0xFC, 0x1E, 0x0F, 0x70, 0x78, 0x39, 0xC3, 0xF0, 0xE7,
  0x0E, 0xC3, 0x9C, 0x3B, 0x0E, 0x70, 0xCC, 0x39, 0xC3, 0x30, 0xE7, 0x8C,
  0xC3, 0x9E, 0x33, 0x1E, 0x78, 0xCC, 0x78, 0xE7, 0x39, 0xC3, 0x9C, 0xE7,
  0x0E, 0x71, 0x9C, 0x39, 0x86, 0x70, 0xE6, 0x19, 0xC3, 0x98, 0x67, 0x0E,
  0x61, 0x9C, 0x3D, 0x86, 0x70, 0xFE, 0x1B, 0x81, 0xF8, 0x7E, 0x07, 0xE1,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0xF8, 0x00, 0xF7, 0x80, 0x1E, 0x3C, 0x01, 0xC3, 0xC0,
  0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07,
  0x9E, 0x00, 0x79, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0x9E, 0x00, 0x79, 0xE0, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x1E, 0x07,
  0x81, 0xE0, 0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x00,
  0x1F, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0x80, 0x07,
  0x0F, 0x00, 0x3C, 0x1C, 0x00, 0xE0, 0x78, 0x07, 0x80, 0xE0, 0x1C, 0x03,
  0xC0, 0xF0, 0x07, 0x03, 0x80, 0x1E, 0x1E, 0x00, 0x38, 0x70, 0x00, 0xF3,
  0xC0, 0x01, 0xCE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x38, 0x70, 0x1E, 0x0E,
  0x07, 0x03, 0x83, 0xC0, 0xF0, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xEF,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x1E,
  0x07, 0x83, 0xC0, 0xF8, 0x07, 0xFC, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0x81,
  0xF7, 0x80, 0x7B, 0x80, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x83,
  0xFF, 0xCF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xEF, 0xDF, 0x77, 0xFF,
  0xB8, 0xFF, 0x1C, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC7, 0xF0, 0xEF, 0xFC, 0x77, 0xFF,
  0x3E, 0x07, 0xDE, 0x01, 0xEF, 0x00, 0x77, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0E, 0xF0, 0x0F, 0x7C, 0x0F, 0xBB, 0xFF,
  0x9D, 0xFF, 0x8E, 0x3F, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1,
  0xF0, 0x3E, 0x78, 0x07, 0x9C, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x0F, 0x70, 0x03, 0xDE, 0x01, 0xE7, 0xC0, 0xF8,
  0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x1F, 0xC7,
  0x1F, 0xF3, 0x9F, 0xFD, 0xDF, 0x03, 0xEF, 0x00, 0xF7, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0E, 0xE0, 0x0F, 0x78, 0x07,
  0xBE, 0x07, 0xCF, 0xFE, 0xE3, 0xFF, 0x70, 0xFE, 0x38, 0x07, 0xF8, 0x07,
  0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00,
  0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x03, 0xDE,
  0x01, 0xE7, 0xC0, 0x78, 0xFF, 0xFC, 0x1F, 0xFE, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x1F, 0xC7, 0x3F, 0xF7,
  0x7F, 0xF7, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xF7, 0x3F, 0xF7, 0x1F, 0xE7,
  0x02, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F,
  0x3F, 0xFE, 0x3F, 0xFC, 0x3F, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xF8, 0xEF, 0xFC,
  0xEF, 0xFE, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0xFF, 0xF1, 0xFF, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0xE7,
  0xFF, 0x8F, 0xFE, 0x1F, 0xF0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F,
  0xE0, 0x07, 0xB8, 0x03, 0xCE, 0x00, 0xF3, 0x80, 0x78, 0xE0, 0x3C, 0x38,
  0x1F, 0x0E, 0x07, 0x83, 0x83, 0xC0, 0xFF, 0xE0, 0x3F, 0xF8, 0x0F, 0xFE,
  0x03, 0x83, 0xC0, 0xE0, 0x78, 0x38, 0x1E, 0x0E, 0x03, 0xC3, 0x80, 0xF8,
  0xE0, 0x1E, 0x38, 0x03, 0xCE, 0x00, 0xFB, 0x80, 0x1E, 0xE0, 0x03, 0xC0,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xFE, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0x80, 0xEF, 0x9F, 0xBF, 0xF7, 0xEF, 0x3F, 0x7F,
  0x87, 0x87, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0,
  0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30,
  0x7E, 0x0C, 0x1F, 0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x7E, 0x0C, 0x1F,
  0x83, 0x07, 0xE0, 0xC1, 0xF8, 0x30, 0x70, 0xE3, 0xF8, 0xEF, 0xFC, 0xEF,
  0xFE, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x07, 0xF8, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xF0, 0x3E,
  0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3D, 0xC0, 0x0E, 0x70, 0x03, 0x9E, 0x01, 0xE7, 0xC0, 0xF0, 0xFF, 0xFC,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0xE3, 0xF8, 0x77, 0xFE, 0x3B, 0xFF, 0x9F,
  0x03, 0xEF, 0x00, 0xF7, 0x80, 0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0x78, 0x07, 0xBE, 0x07, 0xDD, 0xFF, 0xCE,
  0x7F, 0xC7, 0x1F, 0xC3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xC7, 0x3F, 0xF7, 0x7F,
  0xF7, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x1F, 0x7F, 0xF7, 0x3F,
  0xE7, 0x1F, 0xC7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0xF3, 0xFC, 0x7B, 0xFF, 0x3F, 0xFF, 0xDF,
  0x81, 0xEF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0xF8, 0x1F, 0xFF, 0x1F, 0xFF, 0xDF, 0x01,
  0xEF, 0x00, 0x77, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F,
  0xF0, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xCF, 0xFF, 0xE3, 0xFF,
  0xE0, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0x78, 0x1E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1,
  0xC0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x00, 0xF0, 0xF0,
  0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0x9C,
  0x00, 0x3D, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0xF0, 0x78, 0x3D, 0xC1, 0xE0, 0xE7, 0x07, 0x83, 0x9C, 0x1E, 0x0E,
  0x70, 0x78, 0x39, 0xC3, 0xF0, 0xE7, 0x8C, 0xC3, 0x8E, 0x33, 0x1C, 0x38,
  0xCC, 0x70, 0xE3, 0x31, 0xC3, 0x8C, 0xC7, 0x0E, 0x73, 0x9C, 0x39, 0x8E,
  0x70, 0x76, 0x19, 0x81, 0xD8, 0x6E, 0x07, 0x61, 0xB8, 0x1D, 0x86, 0xE0,
  0x76, 0x1B, 0x81, 0xF0, 0x7E, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C,
  0x0F, 0x00, 0xF8, 0x01, 0xF3, 0xC0, 0x3E, 0x3C, 0x03, 0xC1, 0xE0, 0x78,
  0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x39, 0xC0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0xC0, 0x07, 0x9E, 0x00, 0xF1, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x3E,
  0x07, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x00, 0xF7,
  0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x1E, 0x03, 0x81, 0xE0, 0x78, 0x0E, 0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F,
  0x00, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0x39, 0xE0, 0x03, 0xDC, 0x00, 0x3D,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x3F, 0xF8, 0x0F, 0xF0,
  0x03, 0xFF, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x7F, 0xF0, 0x03, 0xFC, 0x07, 0xFF, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x01, 0xDF, 0xE0, 0x7F, 0xFC, 0x1F, 0x8F, 0x87, 0xE1, 0xF3,
  0xF8, 0x3F, 0xFE, 0x07, 0xFB, 0x80, 0x7C,
};

const GFXglyph JetBrainsMono_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 29, 24, 9, -29 },
  { 23, 12, 12, 24, 6, -29 },
  { 41, 22, 29, 24, 1, -29 },
  { 121, 18, 41, 24, 3, -35 },
  { 214, 22, 29, 24, 1, -29 },
  { 294, 21, 30, 24, 2, -30 },
  { 373, 4, 12, 24, 10, -29 },
  { 379, 12, 39, 24, 7, -34 },
  { 438, 12, 39, 24, 5, -34 },
  { 497, 22, 20, 24, 1, -24 },
  { 552, 18, 19, 24, 3, -23 },
  { 595, 8, 12, 24, 7, -6 },
  { 607, 12, 3, 24, 6, -15 },
  { 612, 6, 6, 24, 9, -6 },
  { 617, 18, 37, 24, 3, -33 },
  { 701, 18, 30, 24, 3, -30 },
  { 769, 18, 29, 24, 4, -29 },
  { 835, 18, 30, 24, 3, -30 },
  { 903, 17, 29, 24, 3, -29 },
  { 965, 17, 29, 24, 3, -29 },
  { 1027, 18, 29, 24, 3, -29 },
  { 1093, 18, 29, 24, 3, -29 },
  { 1159, 18, 29, 24, 3, -29 },
  { 1225, 18, 30, 24, 3, -30 },
  { 1293, 18, 30, 24, 3, -30 },
  { 1361, 6, 22, 24, 9, -22 },
  { 1378, 8, 28, 24, 7, -22 },
  { 1406, 18, 21, 24, 3, -24 },
  { 1454, 18, 13, 24, 3, -20 },
  { 1484, 18, 21, 24, 3, -24 },
  { 1532, 15, 29, 24, 5, -29 },
  { 1587, 20, 37, 24, 2, -30 },
  { 1680, 20, 29, 24, 2, -29 },
  { 1753, 17, 29, 24, 4, -29 },
  { 1815, 17, 30, 24, 4, -30 },
  { 1879, 16, 29, 24, 4, -29 },
  { 1937, 17, 29, 24, 4, -29 },
  { 1999, 17, 29, 24, 4, -29 },
  { 2061, 17, 30, 24, 4, -30 },
  { 2125, 16, 29, 24, 4, -29 },
  { 2183, 16, 29, 24, 4, -29 },
  { 2241, 18, 29, 24, 2, -29 },
  { 2307, 18, 29, 24, 4, -29 },
  { 2373, 16, 29, 24, 5, -29 },
  { 2431, 18, 29, 24, 3, -29 },
  { 2497, 16, 29, 24, 4, -29 },
  { 2555, 16, 30, 24, 4, -30 },
  { 2615, 18, 29, 24, 4, -29 },
  { 2681, 18, 37, 24, 3, -30 },
  { 2765, 18, 29, 24, 4, -29 },
  { 2831, 18, 30, 24, 3, -30 },
  { 2899, 20, 29, 24, 2, -29 },
  { 2972, 16, 29, 24, 4, -29 },
  { 3030, 20, 29, 24, 2, -29 },
  { 3103, 22, 29, 24, 1, -29 },
  { 3183, 20, 29, 24, 2, -29 },
  { 3256, 22, 29, 24, 1, -29 },
  { 3336, 18, 29, 24, 3, -29 },
  { 3402, 10, 37, 24, 8, -33 },
  { 3449, 18, 37, 24, 3, -33 },
  { 3533, 10, 37, 24, 6, -33 },
  { 3580, 18, 15, 24, 3, -29 },
  { 3614, 20, 3, 24, 2, 1 },
  { 3622, 9, 5, 24, 7, -31 },
  { 3628, 17, 22, 24, 3, -22 },
  { 3675, 17, 29, 24, 4, -29 },
  { 3737, 18, 22, 24, 3, -22 },
  { 3787, 17, 29, 24, 3, -29 },
  { 3849, 18, 22, 24, 3, -22 },
  { 3899, 19, 29, 24, 2, -29 },
  { 3968, 16, 29, 24, 4, -22 },
  { 4026, 16, 29, 24, 4, -29 },
  { 4084, 19, 31, 24, 3, -31 },
  { 4158, 15, 38, 24, 3, -31 },
  { 4230, 18, 29, 24, 4, -29 },
  { 4296, 21, 29, 24, 1, -29 },
  { 4373, 18, 22, 24, 3, -22 },
  { 4423, 16, 22, 24, 4, -22 },
  { 4467, 18, 22, 24, 3, -22 },
  { 4517, 17, 29, 24, 4, -22 },
  { 4579, 16, 29, 24, 4, -22 },
  { 4637, 17, 22, 24, 4, -22 },
  { 4684, 17, 22, 24, 4, -22 },
  { 4731, 19, 28, 24, 2, -28 },
  { 4798, 16, 22, 24, 4, -22 },
  { 4842, 20, 22, 24, 2, -22 },
  { 4897, 22, 22, 24, 1, -22 },
  { 4958, 20, 22, 24, 2, -22 },
  { 5013, 20, 29, 24, 2, -22 },
  { 5086, 16, 22, 24, 4, -22 },
  { 5130, 18, 37, 24, 3, -33 },
  { 5214, 4, 37, 24, 10, -33 },
  { 5233, 18, 37, 24, 3, -33 },
  { 5317, 18, 8, 24, 3, -18 },
};

const GFXfont JetBrainsMono_Regular40pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular40pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular40pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _JETBRAINSMONO_REGULAR40PT7B_H_
