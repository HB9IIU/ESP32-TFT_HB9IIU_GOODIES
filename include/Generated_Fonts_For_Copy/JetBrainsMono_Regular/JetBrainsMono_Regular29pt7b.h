#ifndef _JETBRAINSMONO_REGULAR29PT7B_H_
#define _JETBRAINSMONO_REGULAR29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular29pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x66, 0x60, 0x00, 0xFF, 0xE0,
  0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3B, 0x1D, 0x8E, 0xC3, 0x61, 0x80, 0x06,
  0x0C, 0x0C, 0x18, 0x18, 0x70, 0x30, 0xC0, 0xC1, 0x81, 0x83, 0x1F, 0xFF,
  0xBF, 0xFF, 0x0C, 0x30, 0x38, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x1F,
  0xFF, 0xBF, 0xFF, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xC1, 0x81, 0x86,
  0x07, 0x0C, 0x00, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xFE, 0x1F,
  0xF9, 0xCD, 0xCE, 0x67, 0x63, 0x3B, 0x18, 0x1C, 0xC0, 0xE6, 0x03, 0xF0,
  0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x03, 0x78, 0x19, 0xC0, 0xC7, 0xC6, 0x3E,
  0x31, 0xF1, 0x9D, 0xED, 0xE7, 0xFE, 0x1F, 0xC0, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x00, 0x3E, 0x03, 0xBF, 0x81, 0x98, 0xC1, 0x9C, 0x71, 0xCE,
  0x38, 0xC7, 0x1C, 0xC1, 0x8C, 0xC0, 0xFE, 0x60, 0x3E, 0x60, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x31, 0x00, 0x33, 0xF0, 0x1B, 0xFC, 0x19, 0x86, 0x18,
  0xC3, 0x1C, 0x61, 0x8C, 0x30, 0xCC, 0x18, 0xEE, 0x0F, 0xEE, 0x03, 0xE0,
  0x1F, 0x80, 0xFF, 0x87, 0x0E, 0x18, 0x18, 0x60, 0x61, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xE0, 0x39, 0xC7, 0xC7, 0x3B, 0x0E,
  0xEC, 0x1F, 0x30, 0x3C, 0xC0, 0xE3, 0x03, 0xCE, 0x3F, 0xBF, 0xEE, 0x3F,
  0x1C, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0x83, 0xC3, 0xC3, 0x83, 0x81, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x03, 0xC0, 0xE0,
  0xE0, 0x78, 0x1F, 0x03, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30,
  0x38, 0x38, 0x3C, 0x3C, 0x7C, 0x38, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x04, 0x18, 0x3E, 0x33, 0xFF, 0x4F, 0x9F, 0xFC, 0x01, 0x80,
  0x07, 0x80, 0x1B, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x07, 0x06, 0x04, 0x00,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C,
  0xE7, 0x9C, 0x71, 0x8E, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x23, 0xFF,
  0xF7, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x1F, 0xC1,
  0xFF, 0x9C, 0x1C, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x38, 0xF9, 0xC7, 0xCE, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3B, 0x81, 0xDE, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0x1F, 0x01, 0xF8,
  0x1F, 0xC1, 0xCE, 0x0C, 0x70, 0x43, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC1, 0xFF, 0x9C,
  0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0x80, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0F, 0xC0, 0x7F, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0x9C, 0x3C, 0x7F, 0xC1, 0xFC, 0x00, 0x00, 0xF0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC1, 0xDE, 0x0E,
  0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x7F, 0xF3, 0xFF, 0x9C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0xF8, 0x7F, 0xE3, 0xEF, 0x9C, 0x0E, 0xE0,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x3B, 0x01, 0xDE, 0x1C,
  0x7F, 0xC1, 0xFC, 0x00, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x70, 0x07, 0x00, 0x3F, 0xC3, 0xFF, 0x9E, 0x1D, 0xE0, 0x7E,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3B, 0x81, 0xDE, 0x1C, 0x7F,
  0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xB8, 0x0E, 0xE0, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x1F, 0xC1, 0xFF, 0x9C, 0x1C, 0xE0, 0x76, 0x03,
  0xB0, 0x1D, 0xC0, 0xCE, 0x0E, 0x3C, 0xE0, 0x7E, 0x03, 0xF0, 0x7B, 0xC7,
  0x07, 0x30, 0x1F, 0x80, 0xFC, 0x03, 0xE0, 0x3B, 0x01, 0xDE, 0x1C, 0x7F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xFF, 0x9C, 0x1D, 0xC0, 0x7E, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x81, 0xDE, 0x3E, 0x7F, 0xE1, 0xF7,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xE0, 0x00, 0x7F, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xEF,
  0x3D, 0xF7, 0xCF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xE7, 0x9C,
  0x71, 0xCE, 0x38, 0xC0, 0x00, 0x18, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0,
  0x3E, 0x03, 0xC0, 0x1C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0x00, 0x78, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x03, 0x00, 0x00, 0xFE, 0x3F, 0xC0,
  0x78, 0x07, 0x01, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC1, 0xE3, 0xF0, 0xF8,
  0x38, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF0, 0x38, 0x00,
  0x0F, 0xF0, 0x3F, 0xF0, 0xE0, 0x73, 0x80, 0x76, 0x00, 0x6C, 0x00, 0xF8,
  0x01, 0xF0, 0x7B, 0xE1, 0xFF, 0xC7, 0x1F, 0x8C, 0x1F, 0x18, 0x3E, 0x30,
  0x7C, 0x60, 0xF8, 0xC1, 0xF1, 0x83, 0xE3, 0x87, 0xC7, 0xBF, 0x87, 0xDF,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F,
  0x80, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x36, 0x00, 0x6E, 0x01, 0xDC,
  0x03, 0x98, 0x06, 0x30, 0x0C, 0x70, 0x38, 0xE0, 0x70, 0xC0, 0xC1, 0x81,
  0x83, 0x87, 0xFF, 0x0F, 0xFE, 0x18, 0x0E, 0x30, 0x1C, 0xE0, 0x39, 0xC0,
  0x33, 0x80, 0x7E, 0x00, 0xE0, 0xFF, 0x8F, 0xFC, 0xC1, 0xEC, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xC1, 0xEF, 0xFC, 0xFF, 0xCC, 0x0E, 0xC0,
  0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC1, 0xEF, 0xFE, 0xFF,
  0x80, 0x3F, 0x87, 0xFE, 0xF0, 0xEE, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x07, 0xC0, 0x7E, 0x07, 0xF0, 0xE7, 0xFC, 0x3F, 0x80, 0xFF, 0x0F, 0xFC,
  0xC1, 0xEC, 0x0E, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x0E,
  0xC3, 0xEF, 0xFC, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x3F, 0x87, 0xFE,
  0xF0, 0xEE, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC7, 0xFC, 0x7F, 0xC7, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07,
  0xF0, 0xE7, 0xFC, 0x3F, 0x80, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x70, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x7F, 0xFF, 0xFE, 0x03, 0xF8, 0x1F, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x7C, 0x03, 0xE0, 0x1B, 0x81, 0xDE,
  0x1C, 0x7F, 0xE1, 0xFC, 0x00, 0xC0, 0x3E, 0x03, 0xB0, 0x1D, 0x81, 0xCC,
  0x0E, 0x60, 0xE3, 0x07, 0x18, 0x70, 0xC3, 0x87, 0xF8, 0x3F, 0xC1, 0x8E,
  0x0C, 0x38, 0x61, 0xC3, 0x07, 0x18, 0x38, 0xC0, 0xE6, 0x07, 0x30, 0x1D,
  0x80, 0xEC, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x3F, 0x83, 0xFC, 0x1F, 0xB0, 0xFD, 0x8D, 0xEC,
  0x6F, 0x33, 0x79, 0xBB, 0xED, 0x9F, 0x3C, 0xF9, 0xE7, 0xCE, 0x3E, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0x80, 0xE0, 0x7F, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7D, 0x87, 0xD8,
  0x7C, 0xC7, 0xCC, 0x7C, 0xE7, 0xC6, 0x7C, 0x67, 0xC7, 0x7C, 0x37, 0xC3,
  0x7C, 0x3F, 0xC1, 0xFC, 0x1B, 0xC1, 0xFC, 0x0F, 0xC0, 0xF0, 0x3F, 0x87,
  0xFE, 0xF0, 0xEE, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x07, 0xF0, 0xE7, 0xFC, 0x3F, 0x80, 0xFF, 0xC7, 0xFF, 0x30, 0x3D, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x07, 0xBF, 0xF9,
  0xFF, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x9C, 0x1C, 0xE0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0xDE, 0x1C,
  0x7F, 0xC1, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0xFF, 0x87, 0xFF, 0x30, 0x3D, 0x80, 0xEC, 0x03, 0x60, 0x1F, 0x00, 0xD8,
  0x06, 0xC0, 0x76, 0x0F, 0x3F, 0xF9, 0xFF, 0x0C, 0x38, 0x61, 0xC3, 0x07,
  0x18, 0x38, 0xC0, 0xE6, 0x07, 0x30, 0x1D, 0x80, 0xEC, 0x03, 0x80, 0x1F,
  0xE1, 0xFF, 0x9C, 0x1C, 0xE0, 0x76, 0x03, 0xB0, 0x01, 0xC0, 0x0E, 0x00,
  0x3C, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xDE, 0x1E, 0x7F, 0xE1, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x06, 0xF0, 0xE7, 0xFC, 0x3F, 0x80, 0xE0, 0x0E, 0xE0, 0x1D, 0xC0,
  0x33, 0x80, 0xE3, 0x01, 0xC7, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x18, 0x38,
  0x38, 0x60, 0x70, 0xC0, 0xE3, 0x80, 0xC7, 0x01, 0xCC, 0x03, 0x98, 0x07,
  0x70, 0x06, 0xE0, 0x0D, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xC3,
  0x87, 0xC3, 0x86, 0xC3, 0x86, 0xE3, 0xC6, 0xE2, 0xC6, 0xE2, 0xC6, 0xE2,
  0xC6, 0x66, 0xCE, 0x66, 0xCE, 0x66, 0x4E, 0x66, 0x4C, 0x66, 0x4C, 0x74,
  0x6C, 0x74, 0x6C, 0x74, 0x6C, 0x3C, 0x6C, 0x3C, 0x6C, 0x3C, 0x3C, 0x3C,
  0x38, 0x3C, 0x38, 0x3C, 0x38, 0xF0, 0x0E, 0xE0, 0x38, 0xE0, 0x60, 0xC1,
  0xC1, 0xC3, 0x01, 0x8E, 0x03, 0xB8, 0x03, 0x70, 0x07, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xDC, 0x03, 0x9C, 0x0E, 0x38, 0x1C,
  0x38, 0x70, 0x70, 0xC0, 0x73, 0x80, 0xEE, 0x00, 0xE0, 0xE0, 0x0E, 0xE0,
  0x1D, 0xC0, 0x71, 0x80, 0xE3, 0x83, 0x83, 0x07, 0x07, 0x0C, 0x06, 0x38,
  0x0E, 0x60, 0x0D, 0xC0, 0x1F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xFF, 0xF8,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0xFF, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xF8, 0x07, 0x00, 0x3C, 0x03,
  0xE0, 0x1B, 0x81, 0xCC, 0x0C, 0x70, 0xE1, 0x86, 0x0C, 0x30, 0x33, 0x01,
  0xB8, 0x0E, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3, 0x87, 0x1F, 0xC1, 0xFF,
  0x9E, 0x1C, 0xE0, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE7, 0xFF, 0x7F, 0xFF,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3D, 0xFF, 0xE7, 0xF7, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xEF, 0x0E, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7E, 0x07, 0xF0, 0xED, 0xFE, 0xCF, 0xC0, 0x1F, 0xC1, 0xFF, 0x9E, 0x1C,
  0xE0, 0x76, 0x03, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x77, 0x03, 0xBC, 0x38, 0xFF, 0xC3, 0xF8, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x8F, 0x9C, 0xFF, 0xEF, 0x1F, 0x70, 0x3B,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x60,
  0x3B, 0x81, 0xDE, 0x1E, 0x7F, 0xF1, 0xFB, 0x80, 0x1F, 0xC1, 0xFF, 0x1E,
  0x1C, 0xE0, 0x76, 0x03, 0xF0, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x38, 0x00, 0xC0, 0x07, 0x03, 0xB8, 0x38, 0xFF, 0xC3, 0xF8, 0x03, 0xFC,
  0x1F, 0xF0, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F,
  0x77, 0xFF, 0xF1, 0xFE, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7E, 0x0F, 0xF1, 0xF7, 0xF7, 0x3E, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE3, 0xFE, 0x3F, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0xF8, 0xDF, 0xEF, 0x0E, 0xE0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x70, 0x01, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x40, 0x3C, 0x07,
  0x80, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x7B, 0xFE, 0x7F, 0x80, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x1F, 0x01, 0xD8, 0x1C,
  0xC0, 0xE6, 0x0E, 0x30, 0xE1, 0x87, 0x0F, 0xF0, 0x7F, 0x83, 0x0E, 0x18,
  0x38, 0xC1, 0xC6, 0x07, 0x30, 0x3D, 0x80, 0xEC, 0x03, 0x80, 0xFF, 0x01,
  0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0xF0,
  0x0F, 0xE0, 0xDE, 0xF7, 0xF7, 0xF9, 0xC7, 0x86, 0x3C, 0x31, 0xE1, 0x8F,
  0x0C, 0x78, 0x63, 0xC3, 0x1E, 0x18, 0xF0, 0xC7, 0x86, 0x3C, 0x31, 0xE1,
  0x8F, 0x0C, 0x78, 0x63, 0xCF, 0x8D, 0xFE, 0xF0, 0xEE, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0x1F, 0xC1, 0xFF, 0x1E, 0x3C, 0xE0, 0x76, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xC0, 0x77,
  0x03, 0xBC, 0x38, 0xFF, 0x83, 0xF8, 0xCF, 0x8D, 0xFE, 0xF0, 0xEE, 0x07,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0x7F, 0x0E, 0xDF, 0xEC, 0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x3F, 0x77, 0xFF, 0xF1, 0xFE, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7F, 0x0F, 0x7F,
  0xF3, 0xF7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xEF, 0xCF,
  0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3F, 0xC7,
  0xFE, 0xF0, 0xFE, 0x07, 0xE0, 0x0E, 0x00, 0xF8, 0x07, 0xFC, 0x1F, 0xE0,
  0x0F, 0x00, 0x70, 0x07, 0xC0, 0x7E, 0x0F, 0x7F, 0xE3, 0xFC, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xFC, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xFE, 0x07, 0xF0, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xE0, 0x6F, 0x0E, 0x7F, 0xC3, 0xF8, 0xC0, 0x1F, 0x80, 0x6E, 0x03,
  0x98, 0x0E, 0x70, 0x31, 0xC1, 0xC3, 0x07, 0x0E, 0x18, 0x38, 0xE0, 0x63,
  0x81, 0xCC, 0x07, 0x70, 0x0D, 0xC0, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0xC3,
  0x87, 0xC7, 0x0F, 0x8E, 0x1B, 0x14, 0x36, 0x2C, 0x6C, 0x59, 0x99, 0xB3,
  0x33, 0x26, 0x76, 0x4C, 0x6C, 0x98, 0xD1, 0xB1, 0xA3, 0xC3, 0xC7, 0x87,
  0x8F, 0x0F, 0x0E, 0x1E, 0x1C, 0x70, 0x1E, 0x70, 0x38, 0xE0, 0xE0, 0xE3,
  0x80, 0xE7, 0x00, 0xDC, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x3B, 0x80, 0x63, 0x81, 0xC3, 0x87, 0x07, 0x1E, 0x07, 0x78, 0x07, 0xE0,
  0x1F, 0x80, 0xE6, 0x03, 0x9C, 0x0E, 0x70, 0x70, 0xE1, 0xC3, 0x86, 0x06,
  0x38, 0x1C, 0xE0, 0x73, 0x00, 0xDC, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00,
  0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x0F, 0xC0, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x0F, 0xF0, 0x7E, 0x03, 0xFC,
  0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0xC0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x07, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x7F, 0x80, 0xFC, 0x1F, 0xE0, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x01, 0xC0, 0x1E, 0x07,
  0xE0, 0x3E, 0x00, 0x7C, 0x1F, 0xF8, 0x7E, 0x71, 0xB0, 0xEE, 0xC1, 0xFB,
  0x01, 0x80,
};

const GFXglyph JetBrainsMono_Regular29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 21, 17, 7, -21 },
  { 12, 9, 9, 17, 4, -21 },
  { 23, 15, 21, 17, 1, -21 },
  { 63, 13, 29, 17, 2, -25 },
  { 111, 17, 21, 17, 0, -21 },
  { 156, 14, 21, 17, 2, -21 },
  { 193, 3, 9, 17, 7, -21 },
  { 197, 9, 27, 17, 5, -24 },
  { 228, 9, 27, 17, 3, -24 },
  { 259, 15, 15, 17, 1, -18 },
  { 288, 14, 13, 17, 2, -16 },
  { 311, 6, 9, 17, 5, -4 },
  { 318, 9, 3, 17, 4, -11 },
  { 322, 5, 5, 17, 6, -5 },
  { 326, 13, 27, 17, 2, -24 },
  { 370, 13, 21, 17, 2, -21 },
  { 405, 13, 21, 17, 3, -21 },
  { 440, 13, 21, 17, 2, -21 },
  { 475, 13, 21, 17, 2, -21 },
  { 510, 13, 21, 17, 2, -21 },
  { 545, 13, 21, 17, 2, -21 },
  { 580, 13, 21, 17, 2, -21 },
  { 615, 14, 21, 17, 2, -21 },
  { 652, 13, 21, 17, 2, -21 },
  { 687, 13, 21, 17, 2, -21 },
  { 722, 5, 16, 17, 6, -16 },
  { 732, 6, 21, 17, 5, -16 },
  { 748, 13, 15, 17, 2, -17 },
  { 773, 13, 9, 17, 2, -14 },
  { 788, 13, 15, 17, 2, -17 },
  { 813, 10, 21, 17, 4, -21 },
  { 840, 15, 26, 17, 1, -21 },
  { 889, 15, 21, 17, 1, -21 },
  { 929, 12, 21, 17, 3, -21 },
  { 961, 12, 21, 17, 3, -21 },
  { 993, 12, 21, 17, 3, -21 },
  { 1025, 12, 21, 17, 3, -21 },
  { 1057, 12, 21, 17, 3, -21 },
  { 1089, 12, 21, 17, 3, -21 },
  { 1121, 12, 21, 17, 3, -21 },
  { 1153, 11, 21, 17, 3, -21 },
  { 1182, 13, 21, 17, 1, -21 },
  { 1217, 13, 21, 17, 3, -21 },
  { 1252, 13, 21, 17, 3, -21 },
  { 1287, 13, 21, 17, 2, -21 },
  { 1322, 12, 21, 17, 3, -21 },
  { 1354, 12, 21, 17, 3, -21 },
  { 1386, 13, 21, 17, 3, -21 },
  { 1421, 13, 26, 17, 2, -21 },
  { 1464, 13, 21, 17, 3, -21 },
  { 1499, 13, 21, 17, 2, -21 },
  { 1534, 14, 21, 17, 2, -21 },
  { 1571, 12, 21, 17, 3, -21 },
  { 1603, 15, 21, 17, 1, -21 },
  { 1643, 16, 21, 17, 1, -21 },
  { 1685, 15, 21, 17, 1, -21 },
  { 1725, 15, 21, 17, 1, -21 },
  { 1765, 13, 21, 17, 2, -21 },
  { 1800, 7, 27, 17, 6, -24 },
  { 1824, 13, 27, 17, 2, -24 },
  { 1868, 7, 27, 17, 4, -24 },
  { 1892, 13, 11, 17, 2, -21 },
  { 1910, 14, 2, 17, 2, 1 },
  { 1914, 6, 4, 17, 5, -23 },
  { 1917, 13, 16, 17, 2, -16 },
  { 1943, 12, 21, 17, 3, -21 },
  { 1975, 13, 16, 17, 2, -16 },
  { 2001, 13, 21, 17, 2, -21 },
  { 2036, 13, 16, 17, 2, -16 },
  { 2062, 14, 21, 17, 2, -21 },
  { 2099, 12, 21, 17, 3, -16 },
  { 2131, 12, 21, 17, 3, -21 },
  { 2163, 14, 23, 17, 2, -23 },
  { 2204, 11, 28, 17, 2, -23 },
  { 2243, 13, 21, 17, 3, -21 },
  { 2278, 15, 21, 17, 1, -21 },
  { 2318, 13, 16, 17, 2, -16 },
  { 2344, 12, 16, 17, 3, -16 },
  { 2368, 13, 16, 17, 2, -16 },
  { 2394, 12, 21, 17, 3, -16 },
  { 2426, 12, 21, 17, 3, -16 },
  { 2458, 12, 16, 17, 3, -16 },
  { 2482, 12, 16, 17, 3, -16 },
  { 2506, 13, 20, 17, 2, -20 },
  { 2539, 12, 16, 17, 3, -16 },
  { 2563, 14, 16, 17, 2, -16 },
  { 2591, 15, 16, 17, 1, -16 },
  { 2621, 15, 16, 17, 1, -16 },
  { 2651, 14, 21, 17, 2, -16 },
  { 2688, 12, 16, 17, 3, -16 },
  { 2712, 13, 27, 17, 2, -24 },
  { 2756, 3, 27, 17, 7, -24 },
  { 2767, 13, 27, 17, 2, -24 },
  { 2811, 14, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Regular29pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular29pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular29pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _JETBRAINSMONO_REGULAR29PT7B_H_
