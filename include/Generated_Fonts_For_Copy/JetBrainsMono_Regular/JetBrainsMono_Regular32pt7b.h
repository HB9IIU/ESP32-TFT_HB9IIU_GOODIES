#ifndef _JETBRAINSMONO_REGULAR32PT7B_H_
#define _JETBRAINSMONO_REGULAR32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC6, 0x00,
  0x00, 0xEF, 0xFD, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x87,
  0xC3, 0xE1, 0x80, 0x03, 0x07, 0x01, 0x83, 0x01, 0xC1, 0x80, 0xC0, 0xC0,
  0x60, 0xE0, 0x30, 0x61, 0xFF, 0xFE, 0xFF, 0xFF, 0x0E, 0x0C, 0x06, 0x0E,
  0x03, 0x07, 0x01, 0x83, 0x00, 0xC1, 0x80, 0xE0, 0xC0, 0x60, 0x61, 0xFF,
  0xFE, 0xFF, 0xFF, 0x0C, 0x18, 0x0E, 0x0C, 0x07, 0x06, 0x03, 0x07, 0x01,
  0x83, 0x80, 0xC1, 0x80, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x3C, 0x03, 0xFE, 0x0F, 0xFE, 0x1C, 0xDE, 0x71, 0x9C, 0xE3, 0x1D, 0xC6,
  0x3B, 0x8C, 0x07, 0x18, 0x07, 0x30, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x06, 0xF0, 0x0C, 0xE0, 0x18, 0xE0, 0x31, 0xF8, 0x63, 0xF8,
  0xC7, 0x71, 0x9C, 0xFB, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x08, 0x00, 0x27, 0xE0, 0x19, 0xFE, 0x06, 0x30,
  0xC1, 0xC6, 0x18, 0x30, 0xC3, 0x0C, 0x18, 0x63, 0x83, 0x0C, 0x60, 0x61,
  0x98, 0x0F, 0xF7, 0x00, 0xFC, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01,
  0x8C, 0x00, 0x67, 0xE0, 0x1D, 0xFE, 0x03, 0x30, 0xE0, 0xC6, 0x1C, 0x38,
  0xC3, 0x86, 0x18, 0x71, 0x83, 0x0E, 0x70, 0x71, 0x9C, 0x07, 0xF7, 0x00,
  0x7C, 0x07, 0x80, 0x1F, 0xE0, 0x3F, 0xF0, 0x78, 0x70, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0xFF, 0x07, 0xE7, 0x8E, 0xE3, 0x8E, 0xE1, 0xDC, 0xE1, 0xFC, 0xE0,
  0xF8, 0xE0, 0x78, 0xE0, 0x78, 0xE0, 0xFC, 0xF1, 0xFC, 0x7F, 0xCE, 0x3F,
  0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xC0, 0xF0, 0x7C, 0x7C, 0x1C, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0xC0, 0x7C, 0x0F, 0xC0, 0xF0, 0x0C, 0x80, 0x70, 0x3E, 0x0F,
  0x81, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x07,
  0x07, 0x07, 0x8F, 0x8F, 0x87, 0x02, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x03, 0x0E, 0x09, 0xE3, 0x3F, 0xFD, 0x7F,
  0x1F, 0xFE, 0x00, 0xE0, 0x00, 0xD8, 0x00, 0xEE, 0x00, 0xF3, 0x80, 0x71,
  0xC0, 0x78, 0x70, 0x78, 0x3C, 0x08, 0x08, 0x00, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0x1E, 0x78, 0xF1, 0xE3, 0x8F, 0x1C, 0x38, 0x71, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x77, 0xFF, 0xF7, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x3C,
  0x1E, 0xE0, 0x3B, 0x80, 0x6C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x31, 0xF1, 0xC7, 0xC7, 0x9F, 0x1C, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF8, 0x0E, 0xE0, 0x39, 0xE3, 0xE3, 0xFF, 0x07, 0xF0,
  0x0F, 0x80, 0x7E, 0x07, 0xF8, 0x3C, 0xE0, 0xE3, 0x83, 0x0E, 0x08, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0xFF, 0xDF, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFD, 0xFF, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x7E, 0x01, 0xDC,
  0x0F, 0x7C, 0x78, 0xFF, 0xC0, 0xFE, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E,
  0x0E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xEF, 0xE7,
  0xFF, 0xBE, 0x3F, 0xE0, 0x7E, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xF8, 0x0F, 0xC0, 0x77, 0x8F, 0x3F, 0xF8, 0x7F, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x1C, 0x80, 0x77, 0xE1, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xDC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B, 0x80,
  0xE3, 0xC7, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xF0, 0x07, 0xC0, 0x3B, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0xFF, 0x87, 0xFF, 0x1C, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03,
  0xB8, 0x0E, 0x70, 0x39, 0xC1, 0xC3, 0xDE, 0x07, 0xF0, 0x1F, 0xC0, 0xF7,
  0xC7, 0x07, 0xB8, 0x0E, 0xE0, 0x1B, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xE0,
  0x3B, 0xE3, 0xE7, 0xFF, 0x07, 0xF8, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE3,
  0xC1, 0xE7, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x3B, 0x80, 0xE7, 0xC7, 0xC7, 0xFB, 0x83, 0xEE, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x80, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFB, 0xC0, 0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC7, 0x9E, 0x3C, 0x70, 0xE3, 0xC7, 0x0E, 0x38, 0x00,
  0x00, 0x08, 0x01, 0xC0, 0x3E, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x1E,
  0x00, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x07,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x00,
  0x08, 0x03, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x03, 0xE0, 0x1C, 0x00,
  0x80, 0x00, 0xFF, 0x0F, 0xFC, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x0E, 0x03, 0xE1, 0xFC, 0x1F, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xE0, 0x3C,
  0x00, 0x01, 0xE0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x81, 0xE3, 0x80, 0x73,
  0x80, 0x1D, 0x80, 0x0E, 0xC0, 0x07, 0xE0, 0x33, 0xF0, 0x7E, 0xF8, 0x7F,
  0x7C, 0x38, 0x7E, 0x18, 0x3F, 0x0C, 0x1F, 0x86, 0x0F, 0xC3, 0x07, 0xE1,
  0x83, 0xF0, 0xC1, 0xF8, 0x60, 0xFC, 0x38, 0x7E, 0x1F, 0xDF, 0x07, 0xCD,
  0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xFE,
  0x00, 0xFF, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x70, 0x1C,
  0x70, 0x1C, 0x30, 0x18, 0x38, 0x38, 0x38, 0x38, 0x38, 0x3F, 0xF8, 0x3F,
  0xFC, 0x7F, 0xFC, 0x70, 0x1C, 0x70, 0x0C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x07, 0xFF, 0xE3, 0xFF, 0xCE, 0x0F, 0xB8, 0x0E, 0xE0, 0x3B,
  0x80, 0x6E, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x87, 0xCF, 0xFC, 0x3F, 0xFC,
  0xE0, 0x7B, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x0E, 0xFF, 0xFB, 0xFF, 0xCF, 0xFC, 0x00, 0x07, 0x80, 0xFF, 0x87,
  0xFF, 0x1C, 0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x01, 0xF8, 0x0E, 0xF0, 0x39, 0xE3, 0xE3, 0xFF,
  0x07, 0xF0, 0xFF, 0xC7, 0xFF, 0x38, 0x3D, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0xFF, 0xFF,
  0x7F, 0xF3, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xEF, 0xFF, 0xBF,
  0xFE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x1C, 0x1E, 0xE0, 0x3B, 0x80,
  0xEE, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE3,
  0xFF, 0x8F, 0xFE, 0x3F, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x0E, 0xF0, 0x39, 0xE3, 0xE3, 0xFF, 0x07, 0xF0, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xE0, 0xFF, 0xFF,
  0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0xFE, 0x07, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x1D, 0xC0, 0x3B,
  0x80, 0xE3, 0xC7, 0xC7, 0xFF, 0x03, 0xF8, 0x00, 0xE0, 0x1F, 0xC0, 0x7B,
  0x80, 0xE7, 0x03, 0xCE, 0x07, 0x1C, 0x1E, 0x38, 0x38, 0x70, 0xF0, 0xE1,
  0xC1, 0xC7, 0x83, 0xFE, 0x07, 0xFC, 0x0E, 0x3C, 0x1C, 0x38, 0x38, 0x78,
  0x70, 0x70, 0xE0, 0xF1, 0xC0, 0xE3, 0x81, 0xE7, 0x01, 0xCE, 0x03, 0xDC,
  0x03, 0xB8, 0x07, 0x80, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x1F, 0xF0, 0x7F, 0x60, 0xDF,
  0xC1, 0xBF, 0xC7, 0x7D, 0x8F, 0xFB, 0x1B, 0xF7, 0x37, 0xE6, 0xEF, 0xCD,
  0x9F, 0x9F, 0x3F, 0x1E, 0x7E, 0x38, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0x80, 0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xB0, 0x3D, 0x81, 0xFE, 0x0F,
  0xB0, 0x7D, 0xC3, 0xEE, 0x1F, 0x30, 0xF9, 0xC7, 0xCE, 0x3E, 0x31, 0xF1,
  0xCF, 0x8E, 0x7C, 0x33, 0xE1, 0xDF, 0x06, 0xF8, 0x37, 0xC1, 0xFE, 0x07,
  0xF0, 0x3F, 0x81, 0xE0, 0x07, 0x81, 0xFF, 0x1F, 0xFC, 0xE0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7F, 0x03, 0xBC, 0x78, 0xFF, 0xC3, 0xF8, 0xFF, 0xE1, 0xFF, 0xF3, 0x81,
  0xE7, 0x00, 0xEE, 0x01, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1D,
  0xC0, 0x3B, 0x81, 0xF7, 0xFF, 0xCF, 0xFE, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x80, 0xFF, 0x87, 0xFF, 0x3C, 0x1E, 0xE0, 0x3B,
  0x80, 0xEC, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x01,
  0xF8, 0x0E, 0xF0, 0x39, 0xE3, 0xE3, 0xFF, 0x07, 0xF0, 0x01, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0xFF, 0xE3, 0xFF, 0xCE,
  0x07, 0xB8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xEF, 0xFF, 0xBF, 0xFC, 0xFF, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x38,
  0xE0, 0xE3, 0x81, 0xCE, 0x07, 0x38, 0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x01,
  0xC0, 0x03, 0x80, 0x3F, 0xE0, 0xFF, 0xE1, 0xC1, 0xE7, 0x01, 0xCE, 0x01,
  0xDC, 0x03, 0xB8, 0x00, 0x70, 0x00, 0x70, 0x00, 0xFC, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x77, 0x01, 0xCF, 0x87, 0x8F, 0xFE, 0x07, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0,
  0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xE0, 0x77, 0x8F, 0x1F, 0xF8, 0x7F, 0x00, 0xE0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x0E, 0x70, 0x0E, 0x70, 0x1C, 0x70, 0x1C, 0x70, 0x1C, 0x38, 0x1C,
  0x38, 0x38, 0x38, 0x38, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x1C, 0x70,
  0x1C, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0xE1, 0xC1, 0xF0, 0xE0, 0xF8, 0x78,
  0xFC, 0x2C, 0x7E, 0x16, 0x3F, 0x1B, 0x1D, 0x8D, 0x8E, 0xC6, 0xC6, 0x63,
  0x63, 0x39, 0x91, 0x9C, 0xC8, 0xCE, 0x66, 0x67, 0x23, 0x73, 0xB1, 0xB8,
  0xD8, 0xDC, 0x6C, 0x6E, 0x36, 0x36, 0x1B, 0x1B, 0x0D, 0x85, 0x87, 0xC2,
  0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x70, 0x07, 0x9C, 0x07, 0x8E,
  0x03, 0x83, 0x83, 0x81, 0xE1, 0xC0, 0x71, 0xC0, 0x3C, 0xE0, 0x0E, 0xE0,
  0x03, 0xF0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x1D, 0xC0, 0x0E, 0x70, 0x0E, 0x38, 0x0E, 0x0E, 0x07, 0x07, 0x07,
  0x01, 0xC3, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1E, 0xF0, 0x03, 0xB8, 0x03,
  0x9C, 0x01, 0xC7, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x1C,
  0x70, 0x0E, 0x38, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0F,
  0xFF, 0xFF, 0x80, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x3E,
  0x00, 0xD8, 0x07, 0x70, 0x1C, 0xC0, 0x63, 0x83, 0x86, 0x0C, 0x1C, 0x70,
  0x71, 0x80, 0xCE, 0x03, 0xB0, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0xE0,
  0xE0, 0xF0, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0F, 0x70, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x1F, 0xFD, 0xFF, 0xF7, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x1F, 0x7F, 0xFC, 0xFF, 0x70, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x73, 0xE3, 0xBF, 0xDF, 0xFE, 0xF0,
  0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xE0, 0x7F, 0x8F, 0xF7, 0xFB, 0x9F, 0x80,
  0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x3C, 0x1E, 0xE0, 0x3B, 0x80, 0x7E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x1F, 0x80,
  0xEF, 0x03, 0x9E, 0x3E, 0x3F, 0xF0, 0x7F, 0x00, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x8F, 0x9C, 0xFE, 0xEF, 0xFF, 0xF0, 0x7F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0xF7, 0x8F, 0xBF, 0xFC, 0xFE, 0xE0, 0x0F, 0x81,
  0xFF, 0x1F, 0xFD, 0xE0, 0xFE, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0xEF, 0x0F,
  0x3F, 0xF0, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xFC, 0x1E, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x1F, 0x39, 0xFD, 0xDF, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x3D, 0xFF,
  0xE7, 0xF7, 0x0F, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x9F, 0xF8,
  0xFF, 0xC7, 0xF8, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x73,
  0xE3, 0xBF, 0xDF, 0xFE, 0xF0, 0x7F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xE0, 0x03, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x1E, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFE, 0x7F, 0xE7, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x3C, 0xFF, 0x8F,
  0xF0, 0xFC, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x03, 0xF8, 0x07, 0x70, 0x1C, 0xE0, 0x79, 0xC0, 0xE3, 0x83, 0x87,
  0x0E, 0x0E, 0x3C, 0x1F, 0xF0, 0x3F, 0xE0, 0x70, 0xE0, 0xE1, 0xE1, 0xC1,
  0xC3, 0x81, 0xC7, 0x03, 0xCE, 0x03, 0x9C, 0x07, 0xB8, 0x07, 0x80, 0xFF,
  0x80, 0x7F, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xF8, 0x0F, 0xFC, 0x01, 0xFE,
  0xEE, 0x39, 0xFE, 0xFB, 0xDF, 0x7F, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8,
  0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x38,
  0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7, 0xE3, 0x8F, 0xC7, 0x1C, 0xE7, 0xC7,
  0x7F, 0xBF, 0xFD, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xC0, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xE0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0xC0, 0xEF, 0x1E, 0x3F, 0xF0, 0xFE, 0x00, 0xE7, 0xC7,
  0x7F, 0xBF, 0xFD, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0xFF, 0x1F,
  0xEF, 0xF7, 0x3F, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0x1F, 0x39, 0xFD, 0xDF, 0xFF, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0xC1, 0xEF, 0x1F, 0x7F, 0xF9, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0xC7, 0x86, 0xFF, 0x37, 0xFD, 0xE0, 0xFE, 0x03,
  0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xC7, 0xFF, 0xBC, 0x0E, 0xE0, 0x1B, 0x80, 0x0F, 0x00, 0x1F, 0x00,
  0x3F, 0xE0, 0x7F, 0xC0, 0x0F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x7E, 0x03,
  0xBE, 0x1E, 0x7F, 0xF0, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0xC0, 0xEF, 0x1E, 0x3F, 0xE0, 0xFE, 0x00, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3B, 0x80, 0x67, 0x01, 0xCE, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x38,
  0x38, 0x38, 0x60, 0x71, 0xC0, 0xE3, 0x80, 0xE6, 0x01, 0xDC, 0x03, 0xB8,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0xE1, 0xC1, 0xF0, 0xE1, 0xF8, 0x70,
  0xEC, 0x28, 0x76, 0x16, 0x33, 0x1B, 0x19, 0xCD, 0x8C, 0xE6, 0xC6, 0x73,
  0x67, 0x19, 0x93, 0x8C, 0x8D, 0x86, 0xC6, 0xC3, 0x63, 0x61, 0xF1, 0xB0,
  0xF8, 0xD8, 0x3C, 0x3C, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0xE0, 0x0E, 0x70,
  0x1E, 0x78, 0x1C, 0x38, 0x38, 0x1C, 0x70, 0x1E, 0x70, 0x0E, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E, 0xE0, 0x1E, 0x70, 0x1C,
  0x70, 0x38, 0x38, 0x78, 0x1C, 0x70, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x81, 0xC7, 0x03, 0x8E, 0x0E, 0x0E, 0x1C,
  0x1C, 0x70, 0x38, 0xE0, 0x39, 0xC0, 0x77, 0x00, 0x6E, 0x00, 0xFC, 0x01,
  0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x18, 0x07, 0xC0, 0x7E, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC3, 0xFC,
  0x1F, 0x80, 0xFF, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1F, 0x80,
  0x7C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1F, 0xE0, 0x3F, 0x07, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x0F, 0xC0, 0x7C, 0x02, 0x00, 0x00, 0x18, 0x00, 0xFC, 0x1D, 0xFC, 0x3F,
  0x1C, 0x7E, 0x1F, 0xFC, 0x3F, 0xB8, 0x1E, 0x00,
};

const GFXglyph JetBrainsMono_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 23, 19, 7, -23 },
  { 16, 9, 9, 19, 5, -23 },
  { 27, 17, 23, 19, 1, -23 },
  { 76, 15, 32, 19, 2, -28 },
  { 136, 19, 24, 19, 0, -24 },
  { 193, 16, 24, 19, 2, -24 },
  { 241, 3, 9, 19, 8, -23 },
  { 245, 10, 31, 19, 6, -27 },
  { 284, 9, 31, 19, 4, -27 },
  { 319, 17, 17, 19, 1, -20 },
  { 356, 15, 15, 19, 2, -18 },
  { 385, 7, 10, 19, 5, -5 },
  { 394, 11, 3, 19, 4, -12 },
  { 399, 5, 5, 19, 7, -5 },
  { 403, 15, 31, 19, 2, -27 },
  { 462, 14, 24, 19, 3, -24 },
  { 504, 14, 23, 19, 3, -23 },
  { 545, 15, 24, 19, 2, -24 },
  { 590, 14, 23, 19, 2, -23 },
  { 631, 13, 23, 19, 3, -23 },
  { 669, 13, 23, 19, 3, -23 },
  { 707, 15, 23, 19, 2, -23 },
  { 751, 14, 23, 19, 3, -23 },
  { 792, 14, 24, 19, 3, -24 },
  { 834, 15, 24, 19, 2, -24 },
  { 879, 5, 18, 19, 7, -18 },
  { 891, 7, 23, 19, 5, -18 },
  { 912, 13, 17, 19, 3, -19 },
  { 940, 13, 11, 19, 3, -16 },
  { 958, 13, 17, 19, 3, -19 },
  { 986, 12, 23, 19, 4, -23 },
  { 1021, 17, 30, 19, 1, -24 },
  { 1085, 16, 23, 19, 2, -23 },
  { 1131, 14, 23, 19, 3, -23 },
  { 1172, 14, 24, 19, 3, -24 },
  { 1214, 13, 23, 19, 3, -23 },
  { 1252, 14, 23, 19, 3, -23 },
  { 1293, 14, 23, 19, 3, -23 },
  { 1334, 14, 24, 19, 3, -24 },
  { 1376, 13, 23, 19, 3, -23 },
  { 1414, 13, 23, 19, 3, -23 },
  { 1452, 15, 23, 19, 1, -23 },
  { 1496, 15, 23, 19, 3, -23 },
  { 1540, 13, 23, 19, 4, -23 },
  { 1578, 15, 23, 19, 2, -23 },
  { 1622, 13, 23, 19, 3, -23 },
  { 1660, 13, 24, 19, 3, -24 },
  { 1699, 15, 23, 19, 3, -23 },
  { 1743, 14, 30, 19, 3, -24 },
  { 1796, 14, 23, 19, 3, -23 },
  { 1837, 15, 24, 19, 2, -24 },
  { 1882, 15, 23, 19, 2, -23 },
  { 1926, 13, 23, 19, 3, -23 },
  { 1964, 16, 23, 19, 2, -23 },
  { 2010, 17, 23, 19, 1, -23 },
  { 2059, 17, 23, 19, 1, -23 },
  { 2108, 17, 23, 19, 1, -23 },
  { 2157, 13, 23, 19, 3, -23 },
  { 2195, 7, 31, 19, 7, -27 },
  { 2223, 15, 31, 19, 2, -27 },
  { 2282, 8, 31, 19, 5, -27 },
  { 2313, 14, 12, 19, 3, -23 },
  { 2334, 15, 2, 19, 2, 1 },
  { 2338, 7, 4, 19, 6, -25 },
  { 2342, 14, 18, 19, 2, -18 },
  { 2374, 13, 23, 19, 3, -23 },
  { 2412, 14, 18, 19, 3, -18 },
  { 2444, 13, 23, 19, 3, -23 },
  { 2482, 13, 18, 19, 3, -18 },
  { 2512, 15, 23, 19, 2, -23 },
  { 2556, 13, 24, 19, 3, -18 },
  { 2595, 13, 23, 19, 3, -23 },
  { 2633, 15, 25, 19, 3, -25 },
  { 2680, 12, 31, 19, 3, -25 },
  { 2727, 15, 23, 19, 3, -23 },
  { 2771, 17, 23, 19, 1, -23 },
  { 2820, 15, 18, 19, 2, -18 },
  { 2854, 13, 18, 19, 3, -18 },
  { 2884, 13, 18, 19, 3, -18 },
  { 2914, 13, 24, 19, 3, -18 },
  { 2953, 13, 24, 19, 3, -18 },
  { 2992, 13, 18, 19, 4, -18 },
  { 3022, 14, 18, 19, 3, -18 },
  { 3054, 15, 23, 19, 2, -23 },
  { 3098, 13, 18, 19, 3, -18 },
  { 3128, 15, 18, 19, 2, -18 },
  { 3162, 17, 18, 19, 1, -18 },
  { 3201, 16, 18, 19, 2, -18 },
  { 3237, 15, 24, 19, 2, -18 },
  { 3282, 13, 18, 19, 3, -18 },
  { 3312, 13, 31, 19, 3, -27 },
  { 3363, 3, 31, 19, 8, -27 },
  { 3375, 13, 31, 19, 3, -27 },
  { 3426, 15, 7, 19, 2, -15 },
};

const GFXfont JetBrainsMono_Regular32pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular32pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular32pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _JETBRAINSMONO_REGULAR32PT7B_H_
