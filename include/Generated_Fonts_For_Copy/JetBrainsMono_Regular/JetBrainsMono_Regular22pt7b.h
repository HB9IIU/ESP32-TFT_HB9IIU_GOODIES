#ifndef _JETBRAINSMONO_REGULAR22PT7B_H_
#define _JETBRAINSMONO_REGULAR22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF6, 0xDB, 0x49, 0x00, 0xBF, 0xC7, 0x8F, 0x1E, 0x3C, 0x68,
  0xD1, 0x80, 0x08, 0x43, 0x08, 0x63, 0x0C, 0x67, 0xFE, 0xFF, 0xC4, 0x21,
  0x8C, 0x31, 0x86, 0x33, 0xFF, 0xFF, 0xF6, 0x10, 0xC6, 0x18, 0xC2, 0x18,
  0x08, 0x02, 0x00, 0x80, 0xFC, 0x7F, 0xB2, 0x6C, 0x9B, 0x20, 0xE8, 0x1E,
  0x03, 0xE0, 0x3C, 0x0B, 0x82, 0x60, 0x8F, 0x23, 0xC9, 0xBF, 0xE3, 0xF0,
  0x20, 0x08, 0x02, 0x00, 0x7C, 0x1B, 0x61, 0xB1, 0x09, 0x88, 0x8C, 0x4C,
  0x36, 0xC1, 0xF4, 0x00, 0x60, 0x06, 0x00, 0x27, 0x83, 0x66, 0x32, 0x31,
  0x11, 0x98, 0x8D, 0x86, 0xF8, 0x1E, 0x3F, 0x06, 0x71, 0x86, 0x30, 0x06,
  0x00, 0x60, 0x0E, 0x03, 0xC0, 0xEC, 0x78, 0xCF, 0x1B, 0x61, 0xCC, 0x19,
  0x87, 0x9F, 0xF1, 0xE3, 0xFF, 0xF4, 0x90, 0x0E, 0x38, 0xC3, 0x06, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0x60, 0x70,
  0x70, 0x20, 0xC3, 0x83, 0x06, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC7, 0x18, 0xCF, 0x30, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x72, 0x7F,
  0x5E, 0x3E, 0x02, 0x80, 0xD8, 0x39, 0x8E, 0x38, 0x82, 0x00, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xC1, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x76, 0x6E, 0xCC, 0x80, 0xFF, 0xFC, 0xFF, 0x80, 0x01, 0xC0, 0x60, 0x38,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x18,
  0x0C, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0x3E, 0x3B, 0xF0,
  0x78, 0x3C, 0x0E, 0x07, 0x03, 0xB9, 0xDC, 0xE0, 0x70, 0x38, 0x1C, 0x1E,
  0x0D, 0xDE, 0x7C, 0x1C, 0x0F, 0x0E, 0xC3, 0x30, 0x8C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x0F, 0xFF, 0xFF, 0x3E,
  0x1D, 0xCC, 0x1B, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x78, 0x3E, 0x01, 0x80, 0xC0, 0x60, 0x3C, 0x1E, 0x0F, 0xFC,
  0x7C, 0x03, 0x03, 0x03, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xC3, 0xE1, 0xE0,
  0xF0, 0x7F, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xF0, 0x18, 0x0C,
  0x06, 0x63, 0x7D, 0xC7, 0xC1, 0x80, 0xC0, 0x60, 0x3C, 0x1E, 0x0D, 0xFC,
  0x7C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x70, 0x0F, 0xC3, 0xFE,
  0x60, 0xCC, 0x1D, 0x01, 0xE0, 0x36, 0x0E, 0xC1, 0x8F, 0xF0, 0xF8, 0xFF,
  0xFF, 0xFC, 0x0F, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80, 0xC0, 0x3F, 0x3B, 0xF0, 0x78, 0x3C,
  0x1B, 0x0D, 0xDC, 0x3C, 0x3F, 0x31, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0xFE,
  0x7E, 0x1F, 0x07, 0x79, 0x83, 0x30, 0x3C, 0x06, 0xC0, 0xD8, 0x3B, 0x06,
  0x3F, 0xC3, 0xF0, 0x06, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x77, 0x70, 0x00, 0x00, 0x07, 0x76, 0x6C, 0xCC,
  0x00, 0x81, 0xC3, 0xC7, 0x8F, 0x06, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x60, 0x10, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x80, 0x70,
  0x1E, 0x03, 0xC0, 0x78, 0x0C, 0x0E, 0x1E, 0x3C, 0x78, 0x30, 0x10, 0x00,
  0xF8, 0xFE, 0x06, 0x03, 0x03, 0x03, 0x06, 0x1E, 0x3C, 0x30, 0x30, 0x00,
  0x00, 0x20, 0x70, 0x70, 0x1F, 0x86, 0x39, 0x81, 0xE0, 0x3C, 0x03, 0x86,
  0x71, 0xEE, 0x63, 0xCC, 0x39, 0x87, 0x30, 0xE6, 0x1C, 0xC7, 0x8F, 0x70,
  0xEE, 0x00, 0x60, 0x0C, 0x00, 0xFC, 0x07, 0x80, 0x0E, 0x01, 0xC0, 0x2C,
  0x0D, 0x81, 0xB0, 0x36, 0x04, 0x61, 0x8C, 0x31, 0x86, 0x30, 0xFF, 0x3F,
  0xE6, 0x0C, 0xC1, 0xB0, 0x1E, 0x03, 0xFE, 0x3F, 0xCC, 0x1B, 0x06, 0xC1,
  0xB0, 0x6C, 0x33, 0xF8, 0xFF, 0xB0, 0x6C, 0x0F, 0x03, 0xC0, 0xF0, 0x6F,
  0xFB, 0xF8, 0x3F, 0x3F, 0xF0, 0x78, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x1E, 0x0D, 0xFE, 0x7C, 0xFE, 0x7F, 0xB0, 0xF8,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x1F,
  0xFD, 0xFC, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFE, 0xFF, 0xB0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x3F, 0x3F, 0xF0, 0x78, 0x3C, 0x06, 0x03, 0x01,
  0x80, 0xCF, 0xE7, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0xFE, 0x7C, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xFF, 0xFF, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xFF, 0xFF, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x63, 0xFF, 0xFF, 0x0F, 0xC3,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F,
  0x03, 0xC0, 0xF8, 0x77, 0xF8, 0xFC, 0xC0, 0xF0, 0x6C, 0x1B, 0x0C, 0xC3,
  0x31, 0x8C, 0x63, 0xF0, 0xFE, 0x31, 0x8C, 0x73, 0x0C, 0xC3, 0xB0, 0x6C,
  0x1F, 0x03, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0xFF, 0xC1, 0xF8, 0xFE, 0x3E,
  0x8B, 0xB2, 0xED, 0xB9, 0x4F, 0x73, 0xDC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xE1, 0xF0, 0xFC, 0x7E, 0x3D, 0x1E, 0xCF, 0x67,
  0x93, 0xCD, 0xE6, 0xF1, 0x78, 0xFC, 0x7E, 0x17, 0x0F, 0x87, 0x3E, 0x3F,
  0xB0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0D, 0xFC, 0x7C, 0xFF, 0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x0E, 0xFF, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x3E, 0x1D, 0xEC, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0,
  0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x67, 0xF8, 0xF8, 0x06, 0x00, 0xC0, 0x38,
  0x07, 0xFE, 0x3F, 0xEC, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x1B, 0xFE, 0xFF,
  0x31, 0x8C, 0x63, 0x0C, 0xC3, 0x30, 0x6C, 0x1B, 0x07, 0x3F, 0x1D, 0xEC,
  0x1B, 0x06, 0xC0, 0x38, 0x07, 0x00, 0xF8, 0x0F, 0x00, 0xE0, 0x18, 0x03,
  0xC0, 0xF0, 0x6F, 0xF8, 0xFC, 0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0xFC, 0x7C, 0xC0, 0x7C, 0x0D,
  0x83, 0x30, 0x66, 0x0C, 0x61, 0x8C, 0x61, 0x8C, 0x31, 0x83, 0x30, 0x6C,
  0x0D, 0x81, 0xB0, 0x16, 0x03, 0x80, 0x70, 0x86, 0x3C, 0xE2, 0xCE, 0x2C,
  0xA6, 0xCA, 0x6C, 0xA6, 0xCA, 0x6C, 0xB6, 0x4B, 0x65, 0x96, 0x79, 0x47,
  0x14, 0x71, 0x47, 0x1C, 0x71, 0xC7, 0x1C, 0xE0, 0x6C, 0x18, 0xC3, 0x18,
  0xC1, 0xB8, 0x36, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x6C, 0x1C, 0xC3,
  0x18, 0xC1, 0x98, 0x36, 0x03, 0xC0, 0x6C, 0x0D, 0x83, 0x38, 0x63, 0x18,
  0x63, 0x06, 0xC0, 0xD8, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x03, 0xFF, 0xFF, 0xFF, 0xE1, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0xF0, 0xC0, 0x30,
  0x06, 0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x06, 0x00, 0xC0,
  0x30, 0x0E, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x07, 0xFF,
  0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xFF, 0x1C, 0x0E, 0x05, 0x86, 0xC2, 0x33, 0x19, 0x07, 0x83, 0xC0,
  0x80, 0xFF, 0xE0, 0xE3, 0x8E, 0x1F, 0x8E, 0xF6, 0x0C, 0x03, 0x00, 0xCF,
  0xF7, 0x0D, 0x83, 0xC0, 0xD8, 0x37, 0x3C, 0xFB, 0xC0, 0x60, 0x30, 0x18,
  0x0D, 0xF7, 0x9F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1F, 0x0F,
  0xFF, 0xBE, 0x3F, 0x3B, 0xF0, 0x78, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC1,
  0xE0, 0xDF, 0xE7, 0xE0, 0x01, 0x80, 0xC0, 0x60, 0x37, 0xDB, 0xBF, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D, 0xFE, 0x7B, 0x3E, 0x31,
  0xF0, 0x78, 0x3C, 0x1F, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0xDD, 0xE7, 0xE0,
  0x07, 0xE1, 0xFC, 0x30, 0x06, 0x00, 0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x7D, 0xBB,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xBB, 0xCF, 0x60, 0x30,
  0x18, 0x0C, 0xFE, 0x7C, 0xC0, 0x60, 0x30, 0x18, 0x0D, 0xF7, 0x9F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0x0C, 0x07,
  0x00, 0xC0, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x07, 0x07, 0x02, 0x00,
  0x00, 0x7F, 0x7F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x06, 0x06, 0xFC, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xF0,
  0x6C, 0x33, 0x1C, 0xC6, 0x3F, 0x0F, 0xE3, 0x18, 0xC3, 0x30, 0xEC, 0x1B,
  0x03, 0xFC, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0xF8, 0x3F, 0xDD,
  0xDD, 0xDF, 0x11, 0xE2, 0x3C, 0x47, 0x88, 0xF1, 0x1E, 0x23, 0xC4, 0x78,
  0x8F, 0x11, 0xE2, 0x30, 0xDF, 0x79, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x3E, 0x3B, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xDF, 0xC7, 0xC0, 0xDF, 0x79, 0xF0, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xFF, 0xFB, 0xEC, 0x06, 0x03,
  0x01, 0x80, 0x7D, 0xBB, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1,
  0xE0, 0xDF, 0xE7, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0xDF, 0x34, 0xEE, 0x1F,
  0x03, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x7F,
  0x39, 0xF0, 0x78, 0x0E, 0x03, 0xF0, 0x7E, 0x03, 0x01, 0xE0, 0xFF, 0xE7,
  0xE0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFC, 0x1F, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xDF, 0xC7, 0xC0, 0xC0,
  0x6C, 0x19, 0x83, 0x30, 0x63, 0x08, 0x63, 0x0C, 0x60, 0xC8, 0x1B, 0x03,
  0x60, 0x38, 0x07, 0x00, 0xC6, 0x39, 0xC7, 0x29, 0xE5, 0x34, 0xA6, 0x94,
  0x92, 0xD3, 0xCA, 0x71, 0xCE, 0x39, 0xC7, 0x18, 0xC0, 0xE0, 0xEE, 0x18,
  0xC6, 0x0D, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xD8, 0x1B, 0x86, 0x31, 0x83,
  0x70, 0x70, 0xE0, 0x6C, 0x19, 0x83, 0x18, 0x63, 0x18, 0x73, 0x06, 0x60,
  0xD8, 0x0F, 0x01, 0xC0, 0x38, 0x03, 0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0,
  0xFF, 0xFF, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x60, 0x70, 0x3F,
  0xFF, 0xF0, 0x03, 0x83, 0xC3, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x7E, 0x3E, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0x80,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x07, 0xC3, 0xE3, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x0E, 0x1E, 0x00, 0x38, 0x6F, 0x8F, 0x19, 0xE1, 0xE0, 0x10,
};

const GFXglyph JetBrainsMono_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 7, 7, 13, 3, -16 },
  { 14, 11, 16, 13, 1, -16 },
  { 36, 10, 22, 13, 2, -19 },
  { 64, 13, 16, 13, 0, -16 },
  { 90, 11, 16, 13, 1, -16 },
  { 112, 3, 7, 13, 5, -16 },
  { 115, 7, 21, 13, 4, -18 },
  { 134, 6, 21, 13, 3, -18 },
  { 150, 11, 11, 13, 1, -13 },
  { 166, 11, 10, 13, 1, -12 },
  { 180, 4, 7, 13, 4, -3 },
  { 184, 7, 2, 13, 3, -8 },
  { 186, 3, 3, 13, 5, -3 },
  { 188, 10, 20, 13, 2, -18 },
  { 213, 9, 16, 13, 2, -16 },
  { 231, 10, 16, 13, 2, -16 },
  { 251, 10, 16, 13, 2, -16 },
  { 271, 9, 16, 13, 2, -16 },
  { 289, 9, 16, 13, 2, -16 },
  { 307, 9, 16, 13, 2, -16 },
  { 325, 11, 16, 13, 1, -16 },
  { 347, 10, 16, 13, 2, -16 },
  { 367, 9, 16, 13, 2, -16 },
  { 385, 11, 16, 13, 1, -16 },
  { 407, 3, 12, 13, 5, -12 },
  { 412, 4, 16, 13, 4, -12 },
  { 420, 9, 12, 13, 2, -13 },
  { 434, 9, 7, 13, 2, -11 },
  { 442, 9, 12, 13, 2, -13 },
  { 456, 8, 16, 13, 3, -16 },
  { 472, 11, 20, 13, 1, -16 },
  { 500, 11, 16, 13, 1, -16 },
  { 522, 10, 16, 13, 2, -16 },
  { 542, 9, 16, 13, 2, -16 },
  { 560, 9, 16, 13, 2, -16 },
  { 578, 9, 16, 13, 2, -16 },
  { 596, 10, 16, 13, 2, -16 },
  { 616, 9, 16, 13, 2, -16 },
  { 634, 9, 16, 13, 2, -16 },
  { 652, 9, 16, 13, 2, -16 },
  { 670, 10, 16, 13, 1, -16 },
  { 690, 10, 16, 13, 2, -16 },
  { 710, 9, 16, 13, 3, -16 },
  { 728, 10, 16, 13, 2, -16 },
  { 748, 9, 16, 13, 2, -16 },
  { 766, 9, 16, 13, 2, -16 },
  { 784, 10, 16, 13, 2, -16 },
  { 804, 10, 20, 13, 2, -16 },
  { 829, 10, 16, 13, 2, -16 },
  { 849, 10, 16, 13, 2, -16 },
  { 869, 11, 16, 13, 1, -16 },
  { 891, 9, 16, 13, 2, -16 },
  { 909, 11, 16, 13, 1, -16 },
  { 931, 12, 16, 13, 1, -16 },
  { 955, 11, 16, 13, 1, -16 },
  { 977, 11, 16, 13, 1, -16 },
  { 999, 9, 16, 13, 2, -16 },
  { 1017, 5, 20, 13, 5, -18 },
  { 1030, 10, 20, 13, 2, -18 },
  { 1055, 6, 20, 13, 3, -18 },
  { 1070, 9, 9, 13, 2, -16 },
  { 1081, 11, 1, 13, 1, 1 },
  { 1083, 5, 3, 13, 4, -17 },
  { 1085, 10, 12, 13, 1, -12 },
  { 1100, 9, 16, 13, 2, -16 },
  { 1118, 9, 12, 13, 2, -12 },
  { 1132, 9, 16, 13, 2, -16 },
  { 1150, 9, 12, 13, 2, -12 },
  { 1164, 11, 16, 13, 1, -16 },
  { 1186, 9, 16, 13, 2, -12 },
  { 1204, 9, 16, 13, 2, -16 },
  { 1222, 10, 17, 13, 2, -17 },
  { 1244, 8, 21, 13, 2, -17 },
  { 1265, 10, 16, 13, 2, -16 },
  { 1285, 11, 16, 13, 1, -16 },
  { 1307, 11, 12, 13, 1, -12 },
  { 1324, 9, 12, 13, 2, -12 },
  { 1338, 9, 12, 13, 2, -12 },
  { 1352, 9, 16, 13, 2, -12 },
  { 1370, 9, 16, 13, 2, -12 },
  { 1388, 10, 12, 13, 2, -12 },
  { 1403, 9, 12, 13, 2, -12 },
  { 1417, 10, 16, 13, 1, -16 },
  { 1437, 9, 12, 13, 2, -12 },
  { 1451, 11, 12, 13, 1, -12 },
  { 1468, 11, 12, 13, 1, -12 },
  { 1485, 11, 12, 13, 1, -12 },
  { 1502, 11, 16, 13, 1, -12 },
  { 1524, 9, 12, 13, 2, -12 },
  { 1538, 9, 20, 13, 2, -18 },
  { 1561, 2, 20, 13, 6, -18 },
  { 1566, 9, 20, 13, 2, -18 },
  { 1589, 11, 5, 13, 1, -10 },
};

const GFXfont JetBrainsMono_Regular22pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular22pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular22pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _JETBRAINSMONO_REGULAR22PT7B_H_
