#ifndef _JETBRAINSMONO_REGULAR24PT7B_H_
#define _JETBRAINSMONO_REGULAR24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xF7, 0xCF, 0x9F,
  0x3E, 0x3C, 0x78, 0xF1, 0xE3, 0x0C, 0x20, 0x61, 0x03, 0x18, 0x10, 0xC1,
  0x86, 0x3F, 0xFD, 0xFF, 0xE3, 0x18, 0x10, 0xC0, 0x86, 0x0C, 0x30, 0x61,
  0x0F, 0xFF, 0x18, 0xC0, 0x86, 0x0C, 0x30, 0x61, 0x03, 0x08, 0x00, 0x04,
  0x00, 0x80, 0x10, 0x0F, 0x03, 0xF8, 0xEB, 0xB9, 0x36, 0x26, 0xC4, 0x1C,
  0x81, 0xD0, 0x1F, 0x01, 0xF8, 0x0F, 0x81, 0x30, 0x27, 0xC4, 0xF8, 0x9F,
  0x93, 0x3F, 0xE3, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x18, 0x0D, 0xF0, 0x24,
  0x61, 0xB1, 0x8C, 0xC6, 0x23, 0x19, 0x86, 0x6C, 0x1F, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x67, 0x01, 0xBF, 0x0D, 0x8C, 0x66, 0x31, 0x98, 0xCC, 0x63,
  0x60, 0xFF, 0x01, 0xE0, 0x0E, 0x01, 0xFC, 0x0C, 0x70, 0xE1, 0x86, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x3C, 0x03, 0xE1, 0xB9, 0x8D, 0x8E, 0xCC,
  0x3E, 0x60, 0xE3, 0x87, 0x1C, 0x3C, 0x7F, 0x71, 0xF1, 0xC0, 0xFF, 0xFF,
  0x03, 0x0F, 0x1C, 0x38, 0x30, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x30, 0x38, 0x1E, 0x0F, 0x03, 0xC1,
  0xC1, 0xC0, 0xC1, 0xC1, 0x83, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x0E, 0x18, 0x71, 0xC7, 0x1C, 0x20, 0x00, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x0E, 0x63, 0x7D, 0x7C, 0xFF, 0x00, 0xC0, 0x0D, 0x00, 0xCC,
  0x0E, 0x70, 0x61, 0xC1, 0x04, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC1, 0xFF, 0xFF, 0xF8, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x39,
  0xDC, 0xE6, 0x33, 0x18, 0xFF, 0xFF, 0x6F, 0xF7, 0x00, 0xE0, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x00, 0x1E, 0x0F, 0xE7, 0x1F, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xCC, 0xF3, 0xBC, 0x4F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x87,
  0x7F, 0x8F, 0xC0, 0x0E, 0x03, 0xC1, 0xF8, 0x73, 0x0C, 0x61, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0xFF, 0xFF, 0xFC, 0x1E, 0x0F, 0xF1, 0xC7, 0x60, 0x6C, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x7C, 0x1F, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xF0, 0x3C, 0x0F,
  0x87, 0x7F, 0x8F, 0xC0, 0x01, 0x80, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x01,
  0x80, 0xE0, 0x70, 0xD8, 0x3E, 0x0F, 0x03, 0xFF, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x43,
  0xFE, 0xF3, 0xF8, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3C, 0x0F, 0x87, 0x7F,
  0x8F, 0xC0, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0xF8, 0x7F, 0x9C, 0x3B, 0x03, 0x60, 0x7C, 0x07, 0x80, 0xF0, 0x37, 0x0E,
  0x7F, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x6C, 0x0C, 0x03, 0x80,
  0x60, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0x1E, 0x1F, 0xE7, 0x1F, 0x83, 0xC0, 0xF8, 0x36,
  0x1D, 0xCE, 0x1F, 0x0F, 0xC7, 0x1B, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x83,
  0x7F, 0xCF, 0xC0, 0x1E, 0x0F, 0xF1, 0xC7, 0x70, 0x6C, 0x0F, 0x80, 0xF0,
  0x1E, 0x07, 0xE0, 0xCF, 0x78, 0xFF, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80,
  0x60, 0x1C, 0x07, 0x00, 0xFF, 0x70, 0x00, 0x00, 0x00, 0xFF, 0x70, 0x7B,
  0xCE, 0x00, 0x00, 0x00, 0x01, 0xCE, 0xE7, 0x31, 0x9C, 0xC0, 0x00, 0x40,
  0x70, 0x78, 0x78, 0x78, 0x38, 0x0E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3C,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0,
  0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x70, 0x0C, 0x0F, 0x0F, 0x0F, 0x0F,
  0x03, 0x00, 0xE0, 0x7F, 0x3F, 0xC0, 0x60, 0x38, 0x0C, 0x0E, 0x06, 0x07,
  0x1F, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00, 0x60, 0x78, 0x1C, 0x00, 0x07,
  0x83, 0xFE, 0x70, 0x66, 0x03, 0xC0, 0x3C, 0x03, 0xC1, 0x9C, 0x7D, 0xC6,
  0x3C, 0x63, 0xC6, 0x1C, 0x61, 0xC6, 0x1C, 0x63, 0xC6, 0x3C, 0x7D, 0xC1,
  0x8C, 0x00, 0x60, 0x07, 0x00, 0x3E, 0x01, 0xF0, 0x07, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0D, 0x81, 0x98, 0x19, 0x81, 0x98, 0x18, 0xC3, 0x0C, 0x30,
  0xC3, 0x0E, 0x3F, 0xE7, 0x06, 0x60, 0x66, 0x07, 0x60, 0x3E, 0x03, 0xFC,
  0x1F, 0xF3, 0x0F, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x0E, 0xFF, 0x1F,
  0xF3, 0x07, 0x60, 0x6C, 0x07, 0x80, 0xF0, 0x3E, 0x0E, 0xFF, 0xDF, 0xE0,
  0x1E, 0x0F, 0xE7, 0x1F, 0x83, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x3C, 0x0D, 0x87, 0x7F, 0x8F, 0xC0, 0xF8,
  0x3F, 0xCC, 0x7B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xFF, 0xBF, 0x80, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFE, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF, 0xFB, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x1E, 0x0F,
  0xE7, 0x1F, 0x83, 0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x31, 0xFC, 0x7F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0D, 0x87, 0x7F, 0x8F, 0xC0, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xFF, 0xFF, 0xFC, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0xFF, 0xFF, 0xC6, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0xFC, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x80,
  0xF0, 0x3B, 0x06, 0x7F, 0xC7, 0xF0, 0xC0, 0x78, 0x1F, 0x03, 0x60, 0xEC,
  0x19, 0x87, 0x30, 0xC6, 0x38, 0xFE, 0x1F, 0xC3, 0x1C, 0x61, 0x8C, 0x39,
  0x83, 0x30, 0x76, 0x06, 0xC0, 0xF8, 0x0C, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xF0, 0xE0, 0xFC, 0x3E, 0x87, 0xD8, 0xFF,
  0x37, 0xA6, 0xF6, 0xDE, 0xD3, 0xDE, 0x79, 0xCF, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1C, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3,
  0xD0, 0xF6, 0x3D, 0x8F, 0x33, 0xCC, 0xF3, 0x3C, 0x6F, 0x1B, 0xC6, 0xF0,
  0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x70, 0x1E, 0x0F, 0xE7, 0x1F, 0x83, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0D, 0x87, 0x7F, 0x8F, 0xC0, 0xFC, 0x1F, 0xF3, 0x0F, 0x60, 0x7C, 0x07,
  0x80, 0xF0, 0x1E, 0x07, 0xC1, 0xDF, 0xFB, 0xFC, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x1E, 0x07, 0xF1, 0xC7, 0x70, 0x6C,
  0x0D, 0x81, 0xB0, 0x36, 0x06, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0x6C, 0x0D,
  0x81, 0xB0, 0x37, 0x0E, 0x7F, 0x87, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0xFC, 0x1F, 0xF3, 0x0F, 0x60, 0x6C, 0x0F, 0x80, 0xF0, 0x3E, 0x06,
  0xC3, 0xDF, 0xF3, 0xFC, 0x61, 0x8C, 0x31, 0x83, 0x30, 0x66, 0x0E, 0xC0,
  0xD8, 0x1C, 0x0E, 0x07, 0xF1, 0xC7, 0x70, 0x6C, 0x0D, 0x80, 0x38, 0x03,
  0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x00, 0x60, 0x0F, 0x81, 0xF0, 0x3F, 0x06,
  0x7F, 0xC7, 0xE0, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0D, 0x87, 0x7F, 0x8F, 0xC0, 0xC0, 0x3E, 0x03, 0x60, 0x76, 0x06, 0x60,
  0x63, 0x06, 0x30, 0x63, 0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC1, 0x98, 0x19,
  0x80, 0xD8, 0x0D, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0xC6, 0x1E, 0x30, 0xF1,
  0xC7, 0x8E, 0x6C, 0x73, 0x62, 0x9B, 0x34, 0xD9, 0xA6, 0x4D, 0x33, 0x49,
  0x9A, 0x6C, 0xD3, 0x66, 0x9A, 0x3C, 0x71, 0xE3, 0x8F, 0x1C, 0x78, 0xE1,
  0x87, 0x00, 0xE0, 0x36, 0x07, 0x70, 0x63, 0x0C, 0x38, 0xC1, 0x98, 0x0D,
  0x80, 0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF8, 0x19, 0x83, 0x8C, 0x30,
  0xC7, 0x06, 0x60, 0x7E, 0x03, 0xC0, 0x3F, 0x01, 0x98, 0x1C, 0xE0, 0xC3,
  0x0E, 0x1C, 0x60, 0x67, 0x03, 0x30, 0x0D, 0x80, 0x78, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xFF,
  0xFF, 0xF0, 0x0C, 0x07, 0x01, 0x80, 0xC0, 0x30, 0x18, 0x0E, 0x03, 0x01,
  0xC0, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xF0, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0xFF, 0xC0, 0xC0, 0x1C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x38,
  0xFF, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xFF, 0xE0, 0x0C, 0x03, 0x81, 0xE0, 0x6C, 0x33, 0x0C, 0x66, 0x19,
  0x82, 0x40, 0xF0, 0x30, 0xFF, 0xF0, 0xE3, 0x8E, 0x30, 0x3F, 0x9E, 0xFE,
  0x0C, 0x03, 0x00, 0xCF, 0xF7, 0xFF, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0xDF,
  0x7E, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xED, 0xBF, 0x83,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x87, 0xDF, 0xB3,
  0xE0, 0x3F, 0x9F, 0xFE, 0x0F, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x3E, 0x0D, 0xFE, 0x3F, 0x00, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xCF, 0xB7, 0xFF, 0x87, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x87, 0x7F, 0xCF, 0xB0, 0x3F, 0x1C, 0xEE, 0x0F, 0x03, 0xC0, 0xFF,
  0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0E, 0x0D, 0xFF, 0x3F, 0x00, 0x00, 0xF0,
  0x7F, 0x0F, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x3E, 0xDF, 0xFE, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF8, 0x77, 0xFC, 0xFB, 0x00, 0xC0, 0x30, 0x0C, 0xFF, 0x3F, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x37, 0xED, 0xBF, 0x83, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0x04, 0x01,
  0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x1F, 0xFF, 0xFF,
  0x80, 0x01, 0x01, 0xC0, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x77, 0xF3, 0xF0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x81, 0xF0,
  0x36, 0x0C, 0xC3, 0x98, 0x63, 0xF8, 0x7F, 0x0C, 0x71, 0x86, 0x30, 0x66,
  0x0E, 0xC0, 0xD8, 0x0C, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xF0, 0x3F, 0xBF, 0xD9, 0xDF, 0x31, 0xE6,
  0x3C, 0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0xE6, 0x3C,
  0xC6, 0xDF, 0xB6, 0xFE, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0, 0x3F, 0x1F, 0xEE, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFE, 0x3F, 0x00, 0xDF,
  0xB6, 0xFE, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E,
  0x1F, 0x7F, 0xCF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x3E, 0xDF, 0xFE,
  0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3E, 0x1D, 0xFF,
  0x3E, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xDF, 0x3D, 0xEC, 0x1F, 0x03,
  0xC0, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00,
  0x3F, 0x9F, 0xF6, 0x0F, 0x80, 0x60, 0x1F, 0x83, 0xF8, 0x07, 0x00, 0xC0,
  0x3E, 0x0D, 0xFF, 0x3F, 0x80, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x0F, 0xFF,
  0xFF, 0xC3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x3F, 0x07, 0xE0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x36, 0x1D, 0xFE, 0x3F, 0x00, 0xE0, 0x36,
  0x07, 0x60, 0x63, 0x06, 0x30, 0xE3, 0x0C, 0x18, 0xC1, 0x9C, 0x19, 0x80,
  0xD8, 0x0F, 0x80, 0xF0, 0x07, 0x00, 0xC6, 0x1E, 0x39, 0xB1, 0xCD, 0x8E,
  0x64, 0xD3, 0x36, 0x99, 0xA4, 0x8D, 0x24, 0x69, 0xE3, 0x4F, 0x0E, 0x38,
  0x71, 0xC3, 0x0C, 0x00, 0xE0, 0x73, 0x0E, 0x38, 0xC1, 0x98, 0x0F, 0x80,
  0xF0, 0x07, 0x00, 0xF0, 0x1D, 0x81, 0x9C, 0x30, 0xC7, 0x06, 0xE0, 0x70,
  0xE0, 0x76, 0x06, 0x70, 0x63, 0x0E, 0x38, 0xC1, 0x8C, 0x19, 0xC1, 0xD8,
  0x0D, 0x80, 0xF0, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x1C, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60,
  0x38, 0x1C, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0xF0, 0x70, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x8F, 0xC3, 0xE0, 0x0E, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xF0, 0x04,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0, 0x3E, 0x01, 0x80, 0x70, 0x1C,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x07, 0x00, 0xFC, 0x1F, 0x0C, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0xC0, 0x70, 0x38, 0x3E, 0x0C, 0x00, 0x70,
  0x7F, 0x8F, 0x31, 0xE3, 0xEC, 0x3C,
};

const GFXglyph JetBrainsMono_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 18, 14, 5, -18 },
  { 10, 7, 8, 14, 4, -18 },
  { 17, 13, 18, 14, 1, -18 },
  { 47, 11, 24, 14, 2, -21 },
  { 80, 14, 18, 14, 0, -18 },
  { 112, 13, 18, 14, 1, -18 },
  { 142, 2, 8, 14, 6, -18 },
  { 144, 8, 23, 14, 4, -20 },
  { 167, 7, 23, 14, 3, -20 },
  { 188, 13, 13, 14, 1, -15 },
  { 210, 11, 12, 14, 2, -14 },
  { 227, 5, 8, 14, 4, -4 },
  { 232, 8, 2, 14, 3, -9 },
  { 234, 4, 4, 14, 5, -4 },
  { 236, 11, 23, 14, 2, -20 },
  { 268, 10, 18, 14, 2, -18 },
  { 291, 11, 18, 14, 2, -18 },
  { 316, 11, 18, 14, 2, -18 },
  { 341, 10, 18, 14, 2, -18 },
  { 364, 10, 18, 14, 2, -18 },
  { 387, 10, 18, 14, 2, -18 },
  { 410, 11, 18, 14, 2, -18 },
  { 435, 11, 18, 14, 2, -18 },
  { 460, 10, 18, 14, 2, -18 },
  { 483, 11, 18, 14, 2, -18 },
  { 508, 4, 13, 14, 5, -13 },
  { 515, 5, 17, 14, 4, -13 },
  { 526, 10, 12, 14, 2, -14 },
  { 541, 10, 8, 14, 2, -12 },
  { 551, 10, 12, 14, 2, -14 },
  { 566, 9, 18, 14, 3, -18 },
  { 587, 12, 22, 14, 1, -18 },
  { 620, 12, 18, 14, 1, -18 },
  { 647, 11, 18, 14, 2, -18 },
  { 672, 10, 18, 14, 2, -18 },
  { 695, 10, 18, 14, 2, -18 },
  { 718, 10, 18, 14, 2, -18 },
  { 741, 11, 18, 14, 2, -18 },
  { 766, 10, 18, 14, 2, -18 },
  { 789, 10, 18, 14, 2, -18 },
  { 812, 9, 18, 14, 3, -18 },
  { 833, 11, 18, 14, 1, -18 },
  { 858, 11, 18, 14, 2, -18 },
  { 883, 10, 18, 14, 3, -18 },
  { 906, 11, 18, 14, 2, -18 },
  { 931, 10, 18, 14, 2, -18 },
  { 954, 10, 18, 14, 2, -18 },
  { 977, 11, 18, 14, 2, -18 },
  { 1002, 11, 22, 14, 2, -18 },
  { 1033, 11, 18, 14, 2, -18 },
  { 1058, 11, 18, 14, 2, -18 },
  { 1083, 12, 18, 14, 1, -18 },
  { 1110, 10, 18, 14, 2, -18 },
  { 1133, 12, 18, 14, 1, -18 },
  { 1160, 13, 18, 14, 1, -18 },
  { 1190, 12, 18, 14, 1, -18 },
  { 1217, 13, 18, 14, 1, -18 },
  { 1247, 10, 18, 14, 2, -18 },
  { 1270, 6, 23, 14, 5, -20 },
  { 1288, 11, 23, 14, 2, -20 },
  { 1320, 5, 23, 14, 4, -20 },
  { 1335, 10, 10, 14, 2, -18 },
  { 1348, 12, 1, 14, 1, 1 },
  { 1350, 5, 4, 14, 4, -19 },
  { 1353, 10, 13, 14, 2, -13 },
  { 1370, 10, 18, 14, 2, -18 },
  { 1393, 10, 13, 14, 2, -13 },
  { 1410, 10, 18, 14, 2, -18 },
  { 1433, 10, 13, 14, 2, -13 },
  { 1450, 12, 18, 14, 1, -18 },
  { 1477, 10, 17, 14, 2, -13 },
  { 1499, 10, 18, 14, 2, -18 },
  { 1522, 11, 19, 14, 2, -19 },
  { 1549, 9, 23, 14, 2, -19 },
  { 1575, 11, 18, 14, 2, -18 },
  { 1600, 12, 18, 14, 1, -18 },
  { 1627, 11, 13, 14, 2, -13 },
  { 1645, 10, 13, 14, 2, -13 },
  { 1662, 10, 13, 14, 2, -13 },
  { 1679, 10, 17, 14, 2, -13 },
  { 1701, 10, 17, 14, 2, -13 },
  { 1723, 10, 13, 14, 3, -13 },
  { 1740, 10, 13, 14, 2, -13 },
  { 1757, 11, 17, 14, 1, -17 },
  { 1781, 10, 13, 14, 2, -13 },
  { 1798, 12, 13, 14, 1, -13 },
  { 1818, 13, 13, 14, 1, -13 },
  { 1840, 12, 13, 14, 1, -13 },
  { 1860, 12, 17, 14, 1, -13 },
  { 1886, 10, 13, 14, 2, -13 },
  { 1903, 10, 23, 14, 2, -20 },
  { 1932, 2, 23, 14, 6, -20 },
  { 1938, 10, 23, 14, 2, -20 },
  { 1967, 11, 5, 14, 2, -11 },
};

const GFXfont JetBrainsMono_Regular24pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular24pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular24pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _JETBRAINSMONO_REGULAR24PT7B_H_
