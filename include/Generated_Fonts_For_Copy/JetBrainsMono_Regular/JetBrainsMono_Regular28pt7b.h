#ifndef _JETBRAINSMONO_REGULAR28PT7B_H_
#define _JETBRAINSMONO_REGULAR28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x98, 0xC6, 0x30, 0x00, 0x03,
  0xBE, 0xE0, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x37, 0x1B, 0x8D, 0xC6, 0x06,
  0x18, 0x0C, 0x30, 0x18, 0x60, 0x60, 0xC0, 0xC1, 0x8F, 0xFF, 0xDF, 0xFF,
  0x86, 0x18, 0x18, 0x30, 0x30, 0x60, 0x61, 0x80, 0xC3, 0x01, 0x86, 0x1F,
  0xFF, 0x8C, 0x18, 0x18, 0x30, 0x30, 0xC0, 0x61, 0x80, 0xC3, 0x03, 0x06,
  0x00, 0x02, 0x00, 0x10, 0x00, 0x80, 0x0F, 0x01, 0xFE, 0x1F, 0xF9, 0xC9,
  0xCC, 0x46, 0x62, 0x3B, 0x10, 0x1C, 0x80, 0xF4, 0x03, 0xE0, 0x0F, 0xE0,
  0x1F, 0x80, 0x5E, 0x02, 0x30, 0x11, 0xC0, 0x8F, 0xC4, 0x7E, 0x23, 0xB9,
  0x39, 0xFF, 0x83, 0xF8, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x18,
  0x00, 0x7E, 0x03, 0x77, 0x06, 0xE3, 0x0C, 0xE3, 0x0C, 0xE3, 0x18, 0xE3,
  0x30, 0x67, 0x30, 0x7E, 0x60, 0x1C, 0xC0, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x3E, 0x07, 0x7F, 0x06, 0x63, 0x0C, 0x63, 0x1C, 0x63, 0x18, 0x63, 0x30,
  0x63, 0x70, 0x7F, 0xE0, 0x3E, 0x0E, 0x00, 0xFE, 0x07, 0xFC, 0x1C, 0x38,
  0x60, 0xE1, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xF0, 0x0F, 0xC0,
  0x3B, 0x87, 0xC7, 0x3B, 0x0C, 0xCC, 0x3F, 0x30, 0x78, 0xC0, 0xE3, 0x07,
  0x8E, 0x3F, 0x3F, 0xCE, 0x7E, 0x1C, 0xFF, 0xFF, 0xB6, 0x00, 0x81, 0xC3,
  0xE3, 0xC3, 0x81, 0xC1, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x80, 0xE0, 0x78,
  0x1E, 0x07, 0xC0, 0xE0, 0x80, 0x70, 0x3C, 0x07, 0x81, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x01, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xC0, 0x60, 0x70, 0x38, 0x38, 0x38, 0x7C, 0x78, 0x38, 0x00, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x06, 0x30, 0xDF, 0x27, 0xDF, 0x7F,
  0x07, 0xF0, 0x03, 0x80, 0x0D, 0x80, 0x3B, 0x80, 0xE3, 0x83, 0x87, 0x83,
  0x06, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83,
  0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00,
  0x3D, 0xE7, 0x1C, 0x73, 0x8E, 0x30, 0xFF, 0xFF, 0xC0, 0x77, 0xFE, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x38,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x00, 0x07, 0x01, 0xFE, 0x1F, 0x78,
  0xE0, 0xEE, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x39, 0xF9,
  0xCF, 0xCE, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x33, 0x01,
  0x9C, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0xF7, 0x0E, 0x70,
  0x87, 0x08, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0x0F, 0x01, 0xFE, 0x1F, 0xF8, 0xE0, 0xEE, 0x03, 0x70, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x1C, 0x00, 0xFF, 0xF7, 0xFF, 0x80, 0x7F,
  0xF7, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xF8, 0x0F,
  0xC0, 0x1E, 0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x77, 0x0F, 0x7F, 0xE1, 0xF8, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x30, 0x07,
  0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x73, 0x87, 0x70, 0x7E, 0x07, 0xE0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x7F,
  0xF7, 0xFF, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0xFC, 0x7F,
  0xE7, 0x07, 0x60, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x60,
  0x77, 0x07, 0x3F, 0xE1, 0xFC, 0x03, 0xC0, 0x18, 0x01, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x70, 0x7F, 0xE3, 0xEF, 0xBC, 0x1D, 0xC0,
  0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x33, 0x87, 0x8F, 0xF8,
  0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x6E, 0x07, 0x00, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01,
  0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x0F,
  0x01, 0xFE, 0x1F, 0xF8, 0xE0, 0xE6, 0x03, 0x30, 0x19, 0x81, 0xCE, 0x0E,
  0x38, 0xE0, 0xFE, 0x03, 0xE0, 0x7F, 0x87, 0x0E, 0x30, 0x3B, 0x80, 0xDC,
  0x07, 0xE0, 0x3F, 0x01, 0x9C, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0x07, 0x01,
  0xFE, 0x1F, 0xF8, 0xE0, 0xEE, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xE0,
  0x3F, 0x01, 0xDC, 0x1C, 0xFF, 0xE1, 0xF6, 0x00, 0x70, 0x07, 0x00, 0x30,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x67, 0xFF, 0xE2,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xEE, 0x39, 0xF7, 0xDF, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x01, 0x38, 0xE7, 0x9C, 0x71, 0x8E, 0x30, 0x00, 0x10,
  0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x0E, 0x00, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x00, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80,
  0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0x00,
  0x70, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x00, 0xC0, 0x00, 0xFE, 0x3F,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x8F, 0xC3, 0xE0,
  0xC0, 0x30, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0x81, 0xE0, 0x03,
  0xC0, 0x3F, 0xE0, 0xF0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xF8, 0x03,
  0xF0, 0x27, 0xE1, 0xF7, 0xC7, 0x3F, 0x8C, 0x3F, 0x18, 0x7E, 0x30, 0xFC,
  0x61, 0xF8, 0xC3, 0xF1, 0x87, 0xE3, 0x0F, 0xC7, 0x3F, 0x87, 0xDF, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x0F, 0x80,
  0x07, 0x80, 0x1F, 0x00, 0x6C, 0x01, 0xB0, 0x0E, 0xC0, 0x3B, 0x80, 0xCE,
  0x03, 0x18, 0x1C, 0x60, 0x71, 0xC1, 0x87, 0x06, 0x0C, 0x3F, 0xF0, 0xFF,
  0xE3, 0xFF, 0x8C, 0x06, 0x70, 0x1D, 0xC0, 0x76, 0x01, 0xF8, 0x03, 0xFF,
  0x8F, 0xFC, 0xC0, 0xEC, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x6C, 0x0E, 0xFF,
  0xCF, 0xF8, 0xC3, 0xCC, 0x0E, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x6C, 0x1E, 0xFF, 0xCF, 0xF8, 0x07, 0x00, 0xFE, 0x0F, 0xF8, 0xE0, 0xE6,
  0x03, 0x70, 0x1B, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x07, 0x60, 0x33, 0x03, 0x9C, 0x1C,
  0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0x9F, 0xFB, 0x07, 0xE0, 0x7C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0xF8, 0x3B, 0xFE, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xEF, 0xFE, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x00, 0xFE, 0x0F,
  0xF8, 0xE0, 0xE6, 0x03, 0x70, 0x1B, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC7, 0xFE, 0x3F, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x60, 0x33,
  0x03, 0x9C, 0x1C, 0x7F, 0xC1, 0xFC, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0xFF,
  0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC3,
  0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1F, 0x80, 0xFC, 0x07, 0x60, 0x33, 0x83, 0x8F, 0xF8, 0x3F, 0x80,
  0xC0, 0x76, 0x03, 0x30, 0x39, 0x81, 0x8C, 0x1C, 0x60, 0xC3, 0x0E, 0x18,
  0x60, 0xFF, 0x07, 0xF0, 0x3F, 0xC1, 0x86, 0x0C, 0x38, 0x60, 0xC3, 0x07,
  0x18, 0x18, 0xC0, 0xE6, 0x03, 0x30, 0x1D, 0x80, 0x70, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0x83, 0xFC, 0x3F, 0xB1, 0xBD, 0x8D, 0xEC,
  0x6F, 0x36, 0x79, 0xB7, 0xCD, 0xBE, 0x39, 0xF9, 0xCF, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x70,
  0xE0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x87, 0xB0, 0xF6, 0x1E, 0xE3, 0xCC,
  0x79, 0x8F, 0x19, 0xE3, 0x3C, 0x77, 0x86, 0xF0, 0xDE, 0x1F, 0xC1, 0xF8,
  0x3F, 0x07, 0xE0, 0x70, 0x07, 0x03, 0xFC, 0x7F, 0xE7, 0x07, 0x60, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0x60, 0x36, 0x07, 0x70, 0xF3, 0xFE, 0x1F, 0xC0,
  0xFF, 0xCF, 0xFE, 0xC0, 0xFC, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07,
  0xC0, 0x7F, 0xFE, 0xFF, 0xCF, 0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x07, 0x01, 0xFE, 0x1F, 0xF8, 0xE0,
  0xEE, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x33, 0x03, 0x9C,
  0x3C, 0x7F, 0xC1, 0xFC, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x03,
  0xC0, 0xFF, 0x8F, 0xFE, 0xC0, 0xEC, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0xEF, 0xFC, 0xFF, 0x8C, 0x70, 0xC3, 0x8C, 0x38, 0xC1, 0xCC,
  0x1C, 0xC0, 0xEC, 0x0E, 0xC0, 0x7C, 0x07, 0x07, 0x00, 0xFF, 0x0F, 0xFC,
  0xE0, 0xE6, 0x03, 0x30, 0x1D, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xF0, 0x07,
  0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0xE0, 0x07, 0xE0, 0x3F, 0x01,
  0xDC, 0x1C, 0xFF, 0xC1, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0xFC, 0x3D, 0xFF, 0x1F, 0xC0, 0xE0, 0x0D, 0x80, 0x77, 0x01,
  0xDC, 0x06, 0x30, 0x18, 0xC0, 0xE3, 0x83, 0x8E, 0x0C, 0x18, 0x30, 0x61,
  0xC1, 0xC7, 0x07, 0x18, 0x0C, 0x60, 0x33, 0x80, 0xEE, 0x03, 0xB0, 0x06,
  0xC0, 0x1B, 0x00, 0x7C, 0x00, 0xE0, 0xC3, 0x87, 0x87, 0x0F, 0x0A, 0x3F,
  0x14, 0x7E, 0x28, 0xFC, 0xD1, 0xB9, 0xB3, 0x33, 0x66, 0x66, 0xCC, 0xCD,
  0x99, 0x93, 0x33, 0x22, 0x66, 0x45, 0xCF, 0x8B, 0x1F, 0x16, 0x1E, 0x3C,
  0x3C, 0x78, 0x78, 0xF0, 0xE1, 0xE1, 0xC3, 0xC0, 0xF0, 0x1C, 0xE0, 0x30,
  0xE0, 0xE0, 0xC3, 0x81, 0xC7, 0x01, 0x9C, 0x03, 0xB0, 0x03, 0xE0, 0x07,
  0x80, 0x07, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xEE, 0x01, 0x9C, 0x07, 0x1C,
  0x0C, 0x38, 0x38, 0x38, 0x60, 0x71, 0xC0, 0x77, 0x00, 0x70, 0xE0, 0x0E,
  0xE0, 0x39, 0xC0, 0x61, 0x81, 0xC3, 0x83, 0x03, 0x0E, 0x07, 0x18, 0x06,
  0x70, 0x0E, 0xE0, 0x0D, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38,
  0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xFF, 0xFC, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0,
  0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0xFF, 0xFC, 0x07,
  0x00, 0x68, 0x03, 0x60, 0x3B, 0x01, 0x8C, 0x0C, 0x60, 0xC1, 0x86, 0x0C,
  0x60, 0x77, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xE1, 0xC3, 0x87, 0x07,
  0x03, 0xFE, 0x7F, 0xE7, 0x07, 0x60, 0x30, 0x03, 0x00, 0x31, 0xFF, 0x7F,
  0xFE, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x7E, 0x0F, 0x7F, 0xB3, 0xF3, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x61, 0xBF, 0xBF, 0xF7, 0x07, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xFC, 0x1F,
  0x7F, 0x67, 0xC0, 0x07, 0x01, 0xFE, 0x1F, 0xF8, 0xE0, 0xE6, 0x03, 0x70,
  0x1F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x66, 0x03,
  0x38, 0x38, 0xFF, 0x83, 0xF8, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0E,
  0x33, 0xFB, 0x7F, 0xB7, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x77, 0x0F, 0x3F, 0xB1, 0xF3, 0x07,
  0x01, 0xFC, 0x7D, 0xE7, 0x07, 0x60, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x37, 0x07, 0x3F, 0xE1, 0xFC, 0x07,
  0xF8, 0x3F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x03, 0xFF, 0xFF, 0xFF,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x06, 0x03, 0xFB, 0x7F,
  0xB7, 0x07, 0x60, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60,
  0x37, 0x07, 0x78, 0xF3, 0xFB, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x71, 0xFE, 0x1F, 0xC0, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x61, 0xBF,
  0xBE, 0xF7, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0x03, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0xC0, 0x3C, 0x07, 0x80, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0E, 0x07, 0x9F, 0xE3, 0xF8,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x3B, 0x03,
  0x98, 0x18, 0xC1, 0xC6, 0x1C, 0x31, 0xC1, 0xFE, 0x0F, 0xF0, 0x63, 0x83,
  0x0E, 0x18, 0x38, 0xC1, 0xC6, 0x07, 0x30, 0x1D, 0x80, 0xF0, 0xFF, 0x03,
  0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x7F, 0x0C, 0x66, 0xF7,
  0xB9, 0xCF, 0x8E, 0x3C, 0x61, 0xE3, 0x0F, 0x18, 0x78, 0xC3, 0xC6, 0x1E,
  0x30, 0xF1, 0x87, 0x8C, 0x3C, 0x61, 0xE3, 0x0F, 0x18, 0x78, 0xC3, 0x06,
  0x1B, 0xFB, 0xFF, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x07, 0x01, 0xFC,
  0x7F, 0xE7, 0x07, 0x60, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0x60, 0x77, 0x0F, 0x3F, 0xE1, 0xFC, 0x06, 0x1B, 0xFB,
  0xFF, 0xF0, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3E, 0x0F, 0xC1, 0xF7, 0xF6, 0x7C, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x0E, 0x03, 0xFB, 0x7F, 0xB7, 0x07, 0x60, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0x60, 0x77, 0x0F, 0x3F,
  0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x0E,
  0xFC, 0xFF, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x0E, 0x07,
  0xFC, 0xFF, 0xEE, 0x06, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0xF0, 0x3F, 0xC0,
  0x1E, 0x00, 0x60, 0x07, 0xC0, 0x7E, 0x0E, 0xFF, 0xE3, 0xF8, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x7F, 0xFF, 0xFF, 0xE1, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x78, 0x01, 0xFC, 0x07, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x7E,
  0x1E, 0xFF, 0x8F, 0xE0, 0xC0, 0x3F, 0x01, 0xD8, 0x0C, 0xC0, 0xE7, 0x07,
  0x18, 0x30, 0xC3, 0x87, 0x1C, 0x18, 0xC0, 0xC6, 0x07, 0x70, 0x1B, 0x00,
  0xD8, 0x07, 0xC0, 0x1C, 0x00, 0xC3, 0x87, 0x87, 0x1F, 0x8E, 0x33, 0x14,
  0x66, 0x68, 0xCC, 0xD9, 0x99, 0xB3, 0x32, 0x66, 0x64, 0xD8, 0x68, 0xB0,
  0xF1, 0x61, 0xE2, 0xC3, 0xC7, 0x87, 0x0F, 0x0E, 0x1C, 0x00, 0x70, 0x1C,
  0xE0, 0xE1, 0xC7, 0x07, 0x18, 0x0E, 0xE0, 0x1F, 0x00, 0x78, 0x00, 0xE0,
  0x07, 0xC0, 0x3B, 0x81, 0xCE, 0x07, 0x1C, 0x38, 0x39, 0xC0, 0xEF, 0x01,
  0xC0, 0xE0, 0x3F, 0x01, 0xD8, 0x0C, 0xE0, 0xE7, 0x06, 0x1C, 0x70, 0xE3,
  0x83, 0x18, 0x1D, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0xFF, 0xFF,
  0xFC, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x0C, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x1F, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x70, 0xFE, 0x0F, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x0F, 0xC0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0xFC, 0x0F, 0x80, 0x38,
  0x1B, 0xE0, 0xFB, 0x87, 0x8E, 0x7C, 0x3F, 0x60, 0xF0,
};

const GFXglyph JetBrainsMono_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 20, 17, 6, -20 },
  { 14, 9, 8, 17, 4, -20 },
  { 23, 15, 20, 17, 1, -20 },
  { 61, 13, 28, 17, 2, -24 },
  { 107, 16, 21, 17, 0, -21 },
  { 149, 14, 21, 17, 2, -21 },
  { 186, 3, 8, 17, 7, -20 },
  { 189, 9, 27, 17, 5, -24 },
  { 220, 9, 27, 17, 3, -24 },
  { 251, 15, 14, 17, 1, -17 },
  { 278, 13, 13, 17, 2, -16 },
  { 300, 6, 8, 17, 5, -4 },
  { 306, 9, 2, 17, 4, -10 },
  { 309, 5, 4, 17, 6, -4 },
  { 312, 13, 26, 17, 2, -23 },
  { 355, 13, 21, 17, 2, -21 },
  { 390, 12, 20, 17, 3, -20 },
  { 420, 13, 21, 17, 2, -21 },
  { 455, 12, 20, 17, 2, -20 },
  { 485, 12, 20, 17, 2, -20 },
  { 515, 12, 20, 17, 2, -20 },
  { 545, 13, 20, 17, 2, -20 },
  { 578, 13, 20, 17, 2, -20 },
  { 611, 13, 21, 17, 2, -21 },
  { 646, 13, 21, 17, 2, -21 },
  { 681, 5, 16, 17, 6, -16 },
  { 691, 6, 20, 17, 5, -16 },
  { 706, 12, 15, 17, 2, -17 },
  { 729, 12, 9, 17, 2, -14 },
  { 743, 12, 15, 17, 2, -17 },
  { 766, 10, 20, 17, 4, -20 },
  { 791, 15, 26, 17, 1, -21 },
  { 840, 14, 20, 17, 1, -20 },
  { 875, 12, 20, 17, 3, -20 },
  { 905, 13, 21, 17, 2, -21 },
  { 940, 11, 20, 17, 3, -20 },
  { 968, 12, 20, 17, 3, -20 },
  { 998, 12, 20, 17, 3, -20 },
  { 1028, 13, 21, 17, 2, -21 },
  { 1063, 11, 20, 17, 3, -20 },
  { 1091, 11, 20, 17, 3, -20 },
  { 1119, 13, 20, 17, 1, -20 },
  { 1152, 13, 20, 17, 3, -20 },
  { 1185, 12, 20, 17, 3, -20 },
  { 1215, 13, 20, 17, 2, -20 },
  { 1248, 11, 20, 17, 3, -20 },
  { 1276, 12, 21, 17, 2, -21 },
  { 1308, 12, 20, 17, 3, -20 },
  { 1338, 13, 26, 17, 2, -21 },
  { 1381, 12, 20, 17, 3, -20 },
  { 1411, 13, 21, 17, 2, -21 },
  { 1446, 13, 20, 17, 2, -20 },
  { 1479, 11, 20, 17, 3, -20 },
  { 1507, 14, 20, 17, 1, -20 },
  { 1542, 15, 20, 17, 1, -20 },
  { 1580, 15, 20, 17, 1, -20 },
  { 1618, 15, 20, 17, 1, -20 },
  { 1656, 12, 20, 17, 2, -20 },
  { 1686, 7, 26, 17, 6, -23 },
  { 1709, 13, 26, 17, 2, -23 },
  { 1752, 7, 26, 17, 4, -23 },
  { 1775, 13, 10, 17, 2, -20 },
  { 1792, 13, 2, 17, 2, 1 },
  { 1796, 6, 4, 17, 5, -22 },
  { 1799, 12, 16, 17, 2, -16 },
  { 1823, 11, 20, 17, 3, -20 },
  { 1851, 13, 16, 17, 2, -16 },
  { 1877, 12, 20, 17, 2, -20 },
  { 1907, 12, 16, 17, 2, -16 },
  { 1931, 13, 20, 17, 2, -20 },
  { 1964, 12, 21, 17, 2, -16 },
  { 1996, 11, 20, 17, 3, -20 },
  { 2024, 14, 22, 17, 2, -22 },
  { 2063, 11, 27, 17, 2, -22 },
  { 2101, 13, 20, 17, 3, -20 },
  { 2134, 14, 20, 17, 1, -20 },
  { 2169, 13, 16, 17, 2, -16 },
  { 2195, 11, 16, 17, 3, -16 },
  { 2217, 12, 16, 17, 2, -16 },
  { 2241, 11, 21, 17, 3, -16 },
  { 2270, 12, 21, 17, 2, -16 },
  { 2302, 12, 16, 17, 3, -16 },
  { 2326, 12, 16, 17, 3, -16 },
  { 2350, 13, 20, 17, 2, -20 },
  { 2383, 11, 15, 17, 3, -15 },
  { 2404, 13, 15, 17, 2, -15 },
  { 2429, 15, 15, 17, 1, -15 },
  { 2458, 14, 15, 17, 1, -15 },
  { 2485, 13, 20, 17, 2, -15 },
  { 2518, 11, 15, 17, 3, -15 },
  { 2539, 12, 26, 17, 2, -23 },
  { 2578, 3, 26, 17, 7, -23 },
  { 2588, 12, 26, 17, 2, -23 },
  { 2627, 13, 6, 17, 2, -13 },
};

const GFXfont JetBrainsMono_Regular28pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular28pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular28pt7bGlyphs,
  0x20, 0x7E, 37
};

#endif // _JETBRAINSMONO_REGULAR28PT7B_H_
