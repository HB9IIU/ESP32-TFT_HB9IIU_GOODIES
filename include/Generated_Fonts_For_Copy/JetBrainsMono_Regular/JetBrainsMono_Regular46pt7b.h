#ifndef _JETBRAINSMONO_REGULAR46PT7B_H_
#define _JETBRAINSMONO_REGULAR46PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x87, 0x0E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x7E, 0xF8, 0xF0, 0x7F, 0xC1, 0xFF, 0x07,
  0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0,
  0xEF, 0x03, 0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xE0, 0x00, 0xE0, 0x1C, 0x00,
  0xE0, 0x3C, 0x00, 0xE0, 0x38, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x38, 0x01,
  0xC0, 0x38, 0x01, 0xC0, 0x78, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x70, 0x03,
  0xC0, 0x70, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x03,
  0x80, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x01, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0F, 0x01, 0xC0, 0x0E,
  0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x1E,
  0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0x1C, 0x07, 0x80, 0x1C,
  0x07, 0x00, 0x3C, 0x07, 0x00, 0x3C, 0x07, 0x00, 0x38, 0x07, 0x00, 0x38,
  0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60,
  0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0x8C, 0x7C, 0x78, 0x61, 0xE7, 0xC3, 0x0F,
  0xBC, 0x18, 0x3D, 0xE0, 0xC1, 0xEF, 0x06, 0x00, 0x7C, 0x30, 0x01, 0xE1,
  0x80, 0x0F, 0x8C, 0x00, 0x7E, 0x60, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0C,
  0x7C, 0x00, 0x61, 0xF0, 0x03, 0x0F, 0x80, 0x18, 0x3C, 0x00, 0xC1, 0xFE,
  0x06, 0x0F, 0xF8, 0x30, 0x7B, 0xC1, 0x83, 0xDE, 0x0C, 0x3E, 0xF8, 0x63,
  0xE3, 0xFB, 0x7F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00,
  0x00, 0x18, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0xF0, 0x00, 0xE7, 0xFE, 0x00,
  0x7B, 0xE7, 0xC0, 0x3C, 0xF0, 0x70, 0x0E, 0x38, 0x1C, 0x07, 0x8E, 0x07,
  0x83, 0xC3, 0x81, 0xE0, 0xE0, 0xE0, 0x78, 0x70, 0x38, 0x1E, 0x3C, 0x0E,
  0x07, 0x0E, 0x03, 0xC1, 0xC7, 0x00, 0xFF, 0xF3, 0xC0, 0x1F, 0xF8, 0xE0,
  0x03, 0xFC, 0x70, 0x00, 0x0C, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE3, 0xF8, 0x00, 0x71, 0xFF, 0x00,
  0x3C, 0xFF, 0xE0, 0x1E, 0x7C, 0x78, 0x07, 0x1E, 0x0F, 0x03, 0xC7, 0x83,
  0xC1, 0xE1, 0xC0, 0xF0, 0x70, 0x70, 0x3C, 0x3C, 0x1C, 0x0F, 0x1E, 0x07,
  0x03, 0xC7, 0x01, 0xE0, 0xF3, 0x80, 0x78, 0x79, 0xE0, 0x0F, 0xFE, 0x70,
  0x01, 0xFF, 0x38, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0x78, 0x1F,
  0x00, 0xF0, 0x3E, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0, 0x7F, 0xE7, 0xC0,
  0xF7, 0x87, 0xC3, 0xEF, 0x07, 0x87, 0x9E, 0x0F, 0x9F, 0x3C, 0x0F, 0xBC,
  0x78, 0x0F, 0xF0, 0xF0, 0x0F, 0xE1, 0xE0, 0x1F, 0x83, 0xC0, 0x1F, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0xFE, 0x1F, 0x03, 0xFE, 0x3F, 0x1F, 0xBE, 0x3F,
  0xFE, 0x3C, 0x3F, 0xF8, 0x7C, 0x3F, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDE, 0xE7, 0x38, 0x00, 0x08, 0x01, 0xC0, 0x3E, 0x03, 0xF0,
  0x7F, 0x87, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF8,
  0x0F, 0xC0, 0x3E, 0x00, 0x70, 0x00, 0x80, 0x80, 0x03, 0xC0, 0x0F, 0xC0,
  0x3F, 0x80, 0x7F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0xFF, 0x03, 0xF8, 0x0F, 0x80, 0x38, 0x00,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x40, 0x3C, 0x02, 0x70,
  0x38, 0x1E, 0xFE, 0x38, 0x7E, 0xFF, 0x19, 0xFF, 0xFF, 0xDB, 0xFE, 0x1F,
  0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xEF, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F,
  0x83, 0xE0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x06, 0x00, 0xE0, 0x02,
  0x00, 0x40, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x8F, 0xC7, 0xC7, 0xE3, 0xE1, 0xF0, 0xF8, 0xF8,
  0x7C, 0x3C, 0x1E, 0x1E, 0x0F, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x7C, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7C, 0x07, 0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x60, 0xFF, 0x1F, 0x0F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F,
  0xF1, 0xF0, 0xFF, 0x0E, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x03, 0xF7, 0x80, 0x3F, 0x3C, 0x03, 0xF1, 0xE0, 0x1E, 0x0F,
  0x00, 0xE0, 0x78, 0x06, 0x03, 0xC0, 0x20, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xE0, 0x3E, 0x3E,
  0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3,
  0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7,
  0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x3F, 0x8F, 0xE1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x3E, 0x01, 0xEF, 0x80, 0x3D,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0xFE, 0x07, 0xBF,
  0xF0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0x78,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x00, 0x1E,
  0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x9F, 0x00, 0x7B, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xF0, 0x1F, 0x9F, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1E, 0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x9F, 0x00, 0xF8, 0xFE, 0x3F,
  0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x7C, 0x07, 0xC7, 0x80, 0x3E, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x3E, 0x7C, 0x03, 0xC3,
  0xE0, 0xF8, 0x1F, 0x9F, 0x00, 0x7F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0xE0,
  0x1F, 0xBF, 0x03, 0xE0, 0xFC, 0x7C, 0x03, 0xC7, 0x80, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x01, 0xEF, 0xC0, 0x3E, 0x7F, 0x0F, 0xE3, 0xFF, 0xFC, 0x1F,
  0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC3, 0xE0, 0x3F, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x7E, 0x01,
  0xF9, 0xF8, 0x3F, 0x87, 0xFF, 0xFC, 0x1F, 0xFB, 0xC0, 0x7F, 0xBE, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x7E,
  0xFE, 0xFF, 0xFF, 0xFE, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0xFE, 0xFF, 0xFF, 0xFE, 0x7E,
  0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xCF, 0xE1, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xC1, 0xF0, 0x7C,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xFE, 0x1F, 0xFF, 0x80, 0x1F, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x0F, 0xFE, 0x07, 0xFE, 0x03, 0xFC,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0xC1, 0xF8, 0x1F, 0x00, 0x7C,
  0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xCF,
  0xF0, 0x1F, 0xEF, 0xF0, 0x3F, 0xF7, 0xF0, 0x7C, 0x1F, 0xF0, 0x78, 0x0F,
  0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F,
  0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F,
  0xF0, 0x78, 0x0F, 0xF0, 0x78, 0x0F, 0xF0, 0x7C, 0x1F, 0xF0, 0x3F, 0x7F,
  0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0xF3, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x1E, 0x00, 0x1E,
  0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0xC0,
  0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xF8, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x01, 0xE3,
  0xC0, 0x03, 0xCF, 0x80, 0x07, 0x9E, 0x00, 0x0F, 0x3C, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0xF0, 0x00, 0x3C, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x3C, 0xF0, 0x1F, 0xCF, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0xF0, 0x1F, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xEF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3F, 0x9F, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x1F, 0xCF, 0x00, 0x7C, 0xF0, 0x03,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xE7, 0x80, 0x3E, 0xF8, 0x01, 0xEF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3F, 0x0F, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x03, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xE7, 0x80,
  0x1F, 0x3E, 0x00, 0xF8, 0xFE, 0x3F, 0x83, 0xFF, 0xF8, 0x0F, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C,
  0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x01,
  0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x0F, 0x07, 0xC0, 0x3F, 0xFF, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x0F, 0x07, 0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x83,
  0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xE3, 0xC0,
  0x07, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0, 0x01,
  0xF0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x7F, 0xDC, 0x03,
  0xFE, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xDC, 0x0E, 0xFE, 0xE0, 0xF7, 0xF7,
  0x87, 0xBF, 0xBC, 0x39, 0xFC, 0xE1, 0xCF, 0xE7, 0x1E, 0x7F, 0x3C, 0xE7,
  0xF8, 0xE7, 0x3F, 0xC7, 0x79, 0xFE, 0x3F, 0x8F, 0xF0, 0xFC, 0x7F, 0x87,
  0xE3, 0xFC, 0x3E, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xC0, 0xFC, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0,
  0x7F, 0xB8, 0x0F, 0xF7, 0x81, 0xFE, 0xF0, 0x3F, 0xCE, 0x07, 0xF9, 0xE0,
  0xFF, 0x3C, 0x1F, 0xE3, 0x83, 0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF0, 0xE1,
  0xFE, 0x1E, 0x3F, 0xC3, 0xC7, 0xF8, 0x38, 0xFF, 0x07, 0x9F, 0xE0, 0xF3,
  0xFC, 0x0F, 0x3F, 0x81, 0xE7, 0xF0, 0x1C, 0xFE, 0x03, 0xDF, 0xC0, 0x7B,
  0xF8, 0x07, 0x7F, 0x00, 0xFF, 0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7E, 0x07, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xEF, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0xC0, 0x3E, 0x3F, 0x1F, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0x00, 0x7F, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x7F, 0x78, 0x00, 0xFB, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3E,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x07,
  0xEF, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x01,
  0xE7, 0xC0, 0x3E, 0x7F, 0x1F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0x7E, 0x78, 0x01,
  0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x7C, 0x1E, 0x03, 0xE0,
  0xF0, 0x0F, 0x87, 0x80, 0x7C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x00,
  0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0xF0, 0x00, 0xF7,
  0x80, 0x07, 0xC0, 0x01, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC3, 0xE0, 0x3F, 0x1E, 0x00, 0x79, 0xF0, 0x03, 0xEF, 0x00, 0x0F,
  0x78, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0xBE, 0x00, 0xF8, 0xFE, 0x1F,
  0xC3, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0xCF, 0xC3, 0xF1, 0xFF, 0xFC, 0x1F,
  0xFF, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x01, 0xF7, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F,
  0x1E, 0x00, 0x3C, 0x3E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0,
  0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07,
  0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3,
  0xC0, 0x03, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x78,
  0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0xF0, 0x1E, 0x03, 0xF8, 0x0F, 0x01,
  0xFC, 0x0F, 0x81, 0xEE, 0x07, 0xC0, 0xF7, 0x83, 0xF0, 0x7B, 0xC1, 0xF8,
  0x3D, 0xE0, 0xFC, 0x1E, 0xF0, 0x6E, 0x0F, 0x78, 0x37, 0x07, 0xBC, 0x19,
  0x83, 0x9E, 0x1C, 0xC1, 0xCF, 0x0E, 0x61, 0xE3, 0x87, 0x30, 0xF1, 0xC3,
  0x9C, 0x78, 0xF1, 0xCE, 0x3C, 0x78, 0xC7, 0x1E, 0x3C, 0x63, 0x8F, 0x1E,
  0x31, 0xC7, 0x0F, 0x38, 0x63, 0x87, 0x9C, 0x31, 0xC3, 0xCE, 0x18, 0xE0,
  0xE7, 0x0C, 0xF0, 0x73, 0x87, 0x78, 0x39, 0xC3, 0xBC, 0x1E, 0xC1, 0xDE,
  0x0F, 0x60, 0xEF, 0x07, 0xF0, 0x77, 0x03, 0xF8, 0x1B, 0x81, 0xFC, 0x0D,
  0xC0, 0xFE, 0x06, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0xC0, 0x7E, 0x00, 0xF8, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x3C, 0x3E, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x03,
  0xC7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03,
  0xE7, 0x80, 0x03, 0xC7, 0xC0, 0x07, 0xC3, 0xC0, 0x07, 0x83, 0xE0, 0x0F,
  0x81, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x3E, 0x00, 0x78, 0x3C,
  0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0xF8, 0x1F,
  0x00, 0xF0, 0x0F, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07,
  0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x39, 0xC0, 0x07, 0x9E, 0x00, 0x71, 0xE0,
  0x0F, 0x0E, 0x00, 0xE0, 0xF0, 0x1E, 0x07, 0x01, 0xC0, 0x78, 0x3C, 0x03,
  0x83, 0xC0, 0x3C, 0x78, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x01, 0xEF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xC1, 0xFF, 0xFE, 0x3F, 0x03, 0xF3, 0xC0, 0x1F, 0x7C,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x3F, 0xFF, 0x1F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0x00, 0xF7, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0x7C, 0x07, 0xF7, 0xFF, 0xFF, 0x3F, 0xFE, 0xF0, 0xFF,
  0x8F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x0F,
  0x1F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC, 0xF6, 0x07, 0xEF, 0xC0, 0x3E,
  0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8,
  0x01, 0xEF, 0xC0, 0x3E, 0xF7, 0x0F, 0xCF, 0x7F, 0xFC, 0xF3, 0xFF, 0x8F,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7E, 0x07, 0xE7, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7F, 0x0F, 0xC3,
  0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x03, 0xC1, 0xE1, 0xFF, 0x3C, 0xFF, 0xF7, 0x9F, 0xFF, 0xF7,
  0xE0, 0x7E, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x83, 0xF9, 0xFF, 0xEF, 0x1F,
  0xFD, 0xE1, 0xFE, 0x3C, 0x01, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x7E, 0x07, 0xC7, 0x80, 0x3E, 0xF8, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x01, 0xE7, 0xC0, 0x3E, 0x7E,
  0x07, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x3C,
  0x7F, 0xF7, 0x9F, 0xFF, 0xF7, 0xE0, 0x7E, 0xF8, 0x07, 0xFE, 0x00, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0xBE, 0x03, 0xF7, 0xF1, 0xFE, 0x7F, 0xFB, 0xC7,
  0xFF, 0x78, 0x7F, 0x8F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x83, 0xFF, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x78, 0x1E, 0x3F, 0xE3, 0xCF, 0xFE, 0x7B, 0xFF, 0xEF, 0x60, 0x7F, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x7C, 0xFF, 0xFC, 0x7F, 0xFC, 0x3F, 0xFC, 0x1F,
  0xF8, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xF8,
  0x03, 0xE3, 0xE0, 0x1F, 0x0F, 0x80, 0x78, 0x3E, 0x03, 0xE0, 0xF8, 0x1F,
  0x03, 0xE0, 0x78, 0x0F, 0x83, 0xE0, 0x3F, 0xFF, 0x00, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F,
  0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xF0,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x03, 0x81, 0xC3, 0xDF, 0x9F, 0xCF,
  0xFF, 0x7F, 0xBF, 0x7F, 0xBE, 0xF0, 0x78, 0x7B, 0xC1, 0xE0, 0xEF, 0x07,
  0x03, 0xFC, 0x1C, 0x0F, 0xF0, 0x70, 0x3F, 0xC1, 0xC0, 0xFF, 0x07, 0x03,
  0xFC, 0x1C, 0x0F, 0xF0, 0x70, 0x3F, 0xC1, 0xC0, 0xFF, 0x07, 0x03, 0xFC,
  0x1C, 0x0F, 0xF0, 0x70, 0x3F, 0xC1, 0xC0, 0xFF, 0x07, 0x03, 0xFC, 0x1C,
  0x0F, 0xF0, 0x70, 0x3F, 0xC1, 0xC0, 0xFF, 0x07, 0x03, 0xFC, 0x1C, 0x0F,
  0xF0, 0x70, 0x3F, 0xC1, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x3F, 0xE3, 0xCF,
  0xFE, 0x7B, 0xFF, 0xEF, 0x60, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0x3E, 0xF8,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF8, 0x01,
  0xE7, 0xC0, 0x3E, 0x7F, 0x9F, 0xC3, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0x3C, 0x0F, 0x1F, 0xF0, 0xF3, 0xFF, 0x8F, 0x7F, 0xFC, 0xF6,
  0x07, 0xEF, 0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0xC0, 0x3E, 0xF7, 0x0F, 0xCF, 0x7F,
  0xFC, 0xF3, 0xFF, 0x8F, 0x1F, 0xE0, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF, 0x3C, 0x7F, 0xF7, 0x9F, 0xFF, 0xF7,
  0xE0, 0x7E, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3E, 0xF8, 0x07, 0xDF, 0x83, 0xF9, 0xFF, 0xEF, 0x1F,
  0xFD, 0xE1, 0xFE, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x78, 0x0F, 0x3F, 0xF0, 0xF7, 0xFF, 0x8F, 0x7F, 0xFC, 0xFE, 0x07, 0xCF,
  0xC0, 0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xFC, 0x7E, 0x03, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFF,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1F, 0x7E,
  0x07, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07, 0xFE, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0xC0, 0x3E, 0x7E,
  0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xEF, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0xF1, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x78, 0x3E, 0x01, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x1E, 0x00,
  0xF8, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0xE0, 0x3C, 0x0F, 0xF0, 0x3C, 0x0F,
  0xF0, 0x7C, 0x0F, 0xF0, 0x7C, 0x0E, 0xF0, 0x7E, 0x0E, 0x70, 0x6E, 0x0E,
  0x70, 0x6E, 0x1E, 0x70, 0x6E, 0x1E, 0x78, 0xE6, 0x1E, 0x78, 0xE6, 0x1C,
  0x78, 0xE6, 0x1C, 0x78, 0xC7, 0x1C, 0x38, 0xC7, 0x1C, 0x38, 0xC7, 0x3C,
  0x39, 0xC3, 0x3C, 0x3D, 0xC3, 0x38, 0x3D, 0xC3, 0x38, 0x3D, 0x83, 0xB8,
  0x1D, 0x83, 0xB8, 0x1D, 0x83, 0xB8, 0x1D, 0x81, 0xF8, 0x1F, 0x81, 0xF0,
  0x1F, 0x81, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x01, 0xF0, 0x7C, 0x00, 0x7E,
  0x7C, 0x00, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1F, 0x00,
  0xF0, 0x7C, 0x00, 0xF0, 0xF0, 0x01, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x87,
  0x80, 0x1E, 0x0F, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x1F, 0x03, 0xC0, 0x1F,
  0x0F, 0x80, 0x1F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x7F,
  0xE0, 0x01, 0xE7, 0x80, 0x07, 0x9F, 0x00, 0x3E, 0x7C, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xE0, 0x7C, 0x0F,
  0x00, 0xF0, 0x3C, 0x03, 0xE1, 0xF0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00,
  0x7C, 0xF8, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0xFF, 0xF0,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x3C, 0xFF, 0x00, 0xF7, 0xFE, 0x03, 0xFF, 0xFC,
  0x0F, 0xF0, 0xF8, 0x3F, 0xC1, 0xF1, 0xEF, 0x03, 0xFF, 0xBC, 0x07, 0xFC,
  0xF0, 0x0F, 0xE0, 0x00, 0x04, 0x00,
};

const GFXglyph JetBrainsMono_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 34, 28, 10, -34 },
  { 31, 14, 14, 28, 7, -34 },
  { 56, 24, 34, 28, 2, -34 },
  { 158, 21, 46, 28, 3, -40 },
  { 279, 26, 34, 28, 1, -34 },
  { 390, 23, 34, 28, 3, -34 },
  { 488, 5, 14, 28, 11, -34 },
  { 497, 13, 45, 28, 9, -39 },
  { 571, 14, 45, 28, 5, -39 },
  { 650, 24, 24, 28, 2, -28 },
  { 722, 22, 22, 28, 3, -26 },
  { 783, 9, 14, 28, 8, -7 },
  { 799, 15, 4, 28, 6, -17 },
  { 807, 8, 7, 28, 10, -7 },
  { 814, 21, 43, 28, 3, -38 },
  { 927, 20, 34, 28, 4, -34 },
  { 1012, 21, 34, 28, 4, -34 },
  { 1102, 21, 34, 28, 3, -34 },
  { 1192, 20, 34, 28, 3, -34 },
  { 1277, 19, 34, 28, 4, -34 },
  { 1358, 20, 34, 28, 4, -34 },
  { 1443, 21, 34, 28, 3, -34 },
  { 1533, 21, 34, 28, 4, -34 },
  { 1623, 20, 34, 28, 4, -34 },
  { 1708, 21, 34, 28, 3, -34 },
  { 1798, 8, 26, 28, 10, -26 },
  { 1824, 10, 33, 28, 8, -26 },
  { 1866, 20, 24, 28, 4, -27 },
  { 1926, 20, 15, 28, 4, -23 },
  { 1964, 20, 24, 28, 4, -27 },
  { 2024, 17, 34, 28, 6, -34 },
  { 2097, 24, 42, 28, 2, -34 },
  { 2223, 23, 34, 28, 2, -34 },
  { 2321, 20, 34, 28, 4, -34 },
  { 2406, 20, 34, 28, 4, -34 },
  { 2491, 20, 34, 28, 4, -34 },
  { 2576, 19, 34, 28, 5, -34 },
  { 2657, 20, 34, 28, 4, -34 },
  { 2742, 20, 34, 28, 4, -34 },
  { 2827, 19, 34, 28, 4, -34 },
  { 2908, 18, 34, 28, 5, -34 },
  { 2985, 21, 34, 28, 2, -34 },
  { 3075, 22, 34, 28, 4, -34 },
  { 3169, 20, 34, 28, 5, -34 },
  { 3254, 21, 34, 28, 3, -34 },
  { 3344, 19, 34, 28, 4, -34 },
  { 3425, 20, 34, 28, 4, -34 },
  { 3510, 21, 34, 28, 4, -34 },
  { 3600, 20, 42, 28, 4, -34 },
  { 3705, 21, 34, 28, 4, -34 },
  { 3795, 21, 34, 28, 3, -34 },
  { 3885, 22, 34, 28, 3, -34 },
  { 3979, 19, 34, 28, 4, -34 },
  { 4060, 23, 34, 28, 2, -34 },
  { 4158, 25, 34, 28, 1, -34 },
  { 4265, 24, 34, 28, 2, -34 },
  { 4367, 24, 34, 28, 2, -34 },
  { 4469, 20, 34, 28, 4, -34 },
  { 4554, 12, 43, 28, 9, -38 },
  { 4619, 21, 43, 28, 3, -38 },
  { 4732, 11, 43, 28, 7, -38 },
  { 4792, 20, 18, 28, 4, -34 },
  { 4837, 22, 4, 28, 3, 1 },
  { 4848, 10, 6, 28, 8, -36 },
  { 4856, 20, 26, 28, 3, -26 },
  { 4921, 20, 34, 28, 4, -34 },
  { 5006, 20, 26, 28, 4, -26 },
  { 5071, 19, 34, 28, 4, -34 },
  { 5152, 20, 26, 28, 4, -26 },
  { 5217, 22, 34, 28, 3, -34 },
  { 5311, 19, 34, 28, 4, -26 },
  { 5392, 19, 34, 28, 4, -34 },
  { 5473, 22, 36, 28, 4, -36 },
  { 5572, 17, 44, 28, 4, -36 },
  { 5666, 22, 34, 28, 4, -34 },
  { 5760, 24, 34, 28, 1, -34 },
  { 5862, 22, 26, 28, 3, -26 },
  { 5934, 19, 26, 28, 4, -26 },
  { 5996, 20, 26, 28, 4, -26 },
  { 6061, 20, 34, 28, 4, -26 },
  { 6146, 19, 34, 28, 4, -26 },
  { 6227, 20, 26, 28, 5, -26 },
  { 6292, 20, 26, 28, 4, -26 },
  { 6357, 21, 32, 28, 3, -32 },
  { 6441, 19, 25, 28, 4, -25 },
  { 6501, 22, 25, 28, 3, -25 },
  { 6570, 24, 25, 28, 2, -25 },
  { 6645, 23, 25, 28, 2, -25 },
  { 6717, 22, 33, 28, 3, -25 },
  { 6808, 19, 25, 28, 4, -25 },
  { 6868, 20, 43, 28, 4, -38 },
  { 6976, 4, 43, 28, 12, -38 },
  { 6998, 20, 43, 28, 4, -38 },
  { 7106, 22, 10, 28, 3, -21 },
};

const GFXfont JetBrainsMono_Regular46pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular46pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular46pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _JETBRAINSMONO_REGULAR46PT7B_H_
