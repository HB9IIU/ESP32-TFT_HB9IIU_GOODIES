#ifndef _JETBRAINSMONO_REGULAR45PT7B_H_
#define _JETBRAINSMONO_REGULAR45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular45pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xC7, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xDF, 0xFF, 0xFF, 0x7C, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x07,
  0x80, 0xE0, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70,
  0x1C, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x70, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x78, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x78,
  0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x3C, 0x1F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFE, 0x1C, 0x03, 0x80, 0x38, 0x0F, 0x00, 0x70, 0x1C, 0x00, 0xE0,
  0x38, 0x01, 0xC0, 0x70, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x07,
  0x80, 0x38, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xBF, 0x0F, 0x9C, 0x78, 0x78, 0xE1, 0xE7,
  0x87, 0x0F, 0x3C, 0x38, 0x79, 0xE1, 0xC0, 0x0F, 0x0E, 0x00, 0x7C, 0x70,
  0x01, 0xE3, 0x80, 0x0F, 0x9C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0x9F,
  0x00, 0x1C, 0x7C, 0x00, 0xE1, 0xE0, 0x07, 0x0F, 0x80, 0x38, 0x3F, 0xC1,
  0xC1, 0xFE, 0x0E, 0x0F, 0xF8, 0x70, 0xFB, 0xC3, 0x87, 0x9F, 0x1C, 0x7C,
  0x7E, 0xEF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xBF, 0xE0, 0x03, 0x9F, 0xF8, 0x03,
  0xDE, 0x1E, 0x01, 0xCE, 0x07, 0x01, 0xC7, 0x03, 0x81, 0xE3, 0x81, 0xC0,
  0xE1, 0xC0, 0xE0, 0xE0, 0xE0, 0x70, 0xF0, 0x70, 0x38, 0x70, 0x38, 0x1C,
  0x70, 0x1E, 0x1E, 0x78, 0x07, 0xFE, 0x38, 0x01, 0xFE, 0x38, 0x00, 0x7E,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x1E, 0x00, 0x0E, 0x3F, 0xC0, 0x0F, 0x3F, 0xF0, 0x0F, 0x3E, 0x7C,
  0x07, 0x1C, 0x0E, 0x07, 0x0E, 0x07, 0x07, 0x87, 0x03, 0x83, 0x83, 0x81,
  0xC3, 0x81, 0xC0, 0xE3, 0xC0, 0xE0, 0x71, 0xC0, 0x70, 0x39, 0xC0, 0x3C,
  0x3D, 0xE0, 0x0F, 0xFC, 0xE0, 0x07, 0xFE, 0xE0, 0x00, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFC, 0x7E, 0x01, 0xE0,
  0x3C, 0x07, 0xC0, 0x7C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0xF9, 0xE0, 0x3D, 0xE3, 0xE0, 0xF7, 0xC3, 0xE1, 0xEF, 0x83, 0xC7, 0x9F,
  0x03, 0xDF, 0x3E, 0x07, 0xFC, 0x7C, 0x07, 0xF0, 0xF8, 0x07, 0xE1, 0xF0,
  0x07, 0x83, 0xE0, 0x0F, 0x83, 0xC0, 0x3F, 0x07, 0x80, 0xFF, 0x0F, 0xC7,
  0xFF, 0x0F, 0xFF, 0x9F, 0x0F, 0xFE, 0x1E, 0x0F, 0xF0, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x77, 0x00, 0x04, 0x00, 0xF0, 0x0F, 0xC0, 0x7F,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x01, 0xC0, 0x80, 0x03, 0xC0,
  0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0xF8,
  0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xE0, 0x0E, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x18, 0x0E, 0x03, 0x7C, 0x1C, 0x1F,
  0xFE, 0x38, 0xFF, 0xFF, 0x77, 0xFC, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xF7, 0x80, 0x03,
  0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x3E, 0x0F, 0x80, 0x78, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xC0, 0x1C, 0x00, 0x80, 0x20, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x0F, 0xC3, 0xE1, 0xF8, 0x7E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x3C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7D, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0x8F, 0xE7, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x38, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x3E, 0x3F, 0xC3,
  0x87, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xF7, 0x80,
  0x3C, 0xFC, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x3F, 0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x78, 0x0F,
  0xC7, 0x80, 0xF8, 0x78, 0x0F, 0x07, 0x80, 0xC0, 0x78, 0x08, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0xC7, 0xC0, 0x3E, 0x3C,
  0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x7C,
  0x03, 0xE3, 0xF0, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0xF9,
  0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x18, 0x07,
  0xBF, 0xE0, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7C, 0x03, 0xCF,
  0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x01, 0xF7, 0x80, 0x3C, 0xFC, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x7F, 0x80, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0x07, 0xE3, 0xE0,
  0x0F, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xDE, 0x00,
  0x3C, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x1F, 0xC7, 0xF0, 0x7F, 0xFF, 0x01,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F,
  0x8F, 0xE7, 0xC0, 0x7C, 0xF0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x78, 0x3E,
  0x3E, 0x03, 0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xE0, 0xFC,
  0x7E, 0x3E, 0x03, 0xE7, 0x80, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80,
  0x3E, 0xFC, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0x1F, 0xC7, 0xE0, 0x3F,
  0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x7D,
  0xE0, 0x03, 0xCF, 0x80, 0x3E, 0x3E, 0x03, 0xF1, 0xFF, 0xFF, 0x07, 0xFF,
  0xF8, 0x0F, 0xF7, 0x80, 0x08, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0xEF, 0x84, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xEF, 0xFF, 0xFF, 0xFF, 0x7C,
  0x1F, 0x1F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xF1, 0xF1,
  0xF8, 0xF8, 0x7C, 0x3C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0x83, 0xC1, 0xE0,
  0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03,
  0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF0,
  0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x38,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x01, 0xFC,
  0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x00, 0x01, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFC, 0x07, 0xC3, 0xE0, 0x07,
  0xC7, 0x80, 0x07, 0x9E, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x3C, 0x7F, 0x01, 0xFE, 0xFE,
  0x07, 0xFD, 0xFC, 0x1F, 0x0F, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x1F, 0xE0,
  0xE0, 0x1F, 0xC1, 0xC0, 0x3F, 0x83, 0x80, 0x7F, 0x07, 0x00, 0xFE, 0x0E,
  0x01, 0xFC, 0x1C, 0x03, 0xF8, 0x38, 0x07, 0xF0, 0x70, 0x1F, 0xE0, 0xF0,
  0x3F, 0xC1, 0xE0, 0x7F, 0x83, 0xF3, 0xFF, 0x03, 0xFE, 0xFE, 0x03, 0xF9,
  0xFC, 0x00, 0xC0, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x3D,
  0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8F,
  0x00, 0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x38, 0x38, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0,
  0x01, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0x9E, 0x00,
  0x0F, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x3E, 0xF0, 0x03, 0xCF, 0x00, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xEF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x07, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF,
  0xFE, 0x3F, 0xCF, 0xE7, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01,
  0xF7, 0xC0, 0x3C, 0xFE, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC,
  0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x00,
  0xFD, 0xE0, 0x0F, 0xBC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xEF, 0x00, 0xFD, 0xFF, 0xFF,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF0, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xCF, 0xE7,
  0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x7F, 0xFE, 0x0F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x3F, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xF7, 0xC0, 0x3C, 0xFE,
  0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80,
  0x1F, 0x7C, 0x03, 0xE3, 0xF0, 0xFE, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x07,
  0xFE, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xCF, 0x00, 0x3E, 0x78, 0x01, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0,
  0x0F, 0x07, 0x80, 0xF8, 0x3C, 0x07, 0x81, 0xE0, 0x7C, 0x0F, 0x03, 0xC0,
  0x78, 0x3E, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x03,
  0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01,
  0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xDE,
  0x00, 0x1E, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xDC, 0x07, 0xFE, 0xE0,
  0x3B, 0xF7, 0x01, 0xDF, 0xFC, 0x1E, 0xFE, 0xE0, 0xEF, 0xF7, 0x07, 0x7F,
  0xBC, 0x7B, 0xFC, 0xE3, 0x9F, 0xE7, 0x1C, 0xFF, 0x3D, 0xE7, 0xF8, 0xEE,
  0x3F, 0xC7, 0x71, 0xFE, 0x3F, 0x8F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC,
  0x3E, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x78, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFF, 0x00,
  0xFF, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x0F, 0xF7, 0x01,
  0xFE, 0xF0, 0x3F, 0xCE, 0x07, 0xF9, 0xE0, 0xFF, 0x3C, 0x1F, 0xE3, 0x83,
  0xFC, 0x78, 0x7F, 0x8F, 0x0F, 0xF0, 0xE1, 0xFE, 0x1E, 0x3F, 0xC3, 0xC7,
  0xF8, 0x38, 0xFF, 0x07, 0x9F, 0xE0, 0xF3, 0xFC, 0x0E, 0x7F, 0x81, 0xEF,
  0xF0, 0x1D, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xE0, 0x07, 0xFC,
  0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xDF, 0xE7, 0xC0, 0x7D, 0xF0, 0x07,
  0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xFC, 0x01, 0xF7, 0xC0, 0x7C, 0xFE, 0x3F, 0x8F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xC0, 0x03, 0xDE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xDE, 0x00, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xC0, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF,
  0xF0, 0x3F, 0xFF, 0x87, 0xF1, 0xFC, 0x7C, 0x07, 0xCF, 0x80, 0x3E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00,
  0x1E, 0xF0, 0x01, 0xEF, 0x80, 0x3E, 0x7C, 0x07, 0xC7, 0xF0, 0xFC, 0x3F,
  0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x8F, 0x00, 0x7E, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00,
  0x1F, 0x78, 0x00, 0xF3, 0xC0, 0x0F, 0x9F, 0xFF, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F,
  0x03, 0xC0, 0x7C, 0x1E, 0x03, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x7C, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07,
  0x9E, 0x00, 0x3E, 0xF0, 0x00, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0x1F, 0xC3, 0xE0, 0x1F, 0x1E, 0x00, 0x79, 0xE0, 0x03,
  0xCF, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x3E, 0xF0, 0x01, 0xE7, 0xC0, 0x1F, 0x1F, 0x83,
  0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xFC, 0x01, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFC, 0x00, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0xC0, 0x01, 0xE7, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x3E, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0,
  0x07, 0x81, 0xF0, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80,
  0xF0, 0x0F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x7C, 0x38, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0,
  0x01, 0xC7, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00,
  0x0E, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x7C, 0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0x03, 0xFC, 0x0F, 0x81, 0xEE,
  0x07, 0xC0, 0xE7, 0x03, 0x60, 0x73, 0xC1, 0xB0, 0x39, 0xE0, 0xD8, 0x3C,
  0xF0, 0x6E, 0x1E, 0x78, 0x77, 0x0F, 0x3C, 0x3B, 0x87, 0x9E, 0x1D, 0xC3,
  0xCF, 0x0E, 0xE1, 0xE3, 0x86, 0x30, 0xE1, 0xC3, 0x18, 0x70, 0xE1, 0x8C,
  0x38, 0x78, 0xC6, 0x1C, 0x3C, 0xE3, 0x9E, 0x1E, 0x71, 0xCF, 0x0F, 0x38,
  0xE7, 0x87, 0x9C, 0x73, 0xC3, 0xCE, 0x19, 0xC0, 0xE6, 0x0C, 0xE0, 0x73,
  0x06, 0x70, 0x39, 0x83, 0x38, 0x1D, 0xC1, 0xDC, 0x0F, 0xE0, 0xFE, 0x07,
  0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC, 0x1F, 0xC0, 0xFC, 0x07, 0xC0,
  0x3E, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x78, 0xF0, 0x01, 0xE1, 0xF0, 0x07, 0xC1, 0xE0, 0x0F,
  0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0,
  0x0F, 0x8F, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x83, 0xC0, 0x1E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xE0, 0x0F, 0x87, 0x80, 0x0F,
  0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE3, 0xC0, 0x07, 0x87,
  0x80, 0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x1E,
  0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78,
  0xF0, 0x00, 0xFB, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x0F, 0x78, 0x01, 0xC7, 0x00, 0x78, 0xF0, 0x0E, 0x0E, 0x03,
  0xC1, 0xE0, 0x70, 0x1C, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x9E,
  0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xFC, 0x00, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3,
  0xF8, 0xFE, 0x3E, 0x03, 0xE7, 0xC0, 0x1F, 0x78, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xF7, 0xC0, 0x7F, 0x7F,
  0xFE, 0xF3, 0xFF, 0xCF, 0x0F, 0xF8, 0xF0, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7B, 0xCF, 0xEF,
  0xC0, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC,
  0x01, 0xFF, 0xC0, 0x3D, 0xFC, 0x1F, 0xBD, 0xFF, 0xE7, 0x9F, 0xF8, 0xF1,
  0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFE, 0x3F, 0xDF, 0xE7,
  0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0xFC,
  0x01, 0xF7, 0xC0, 0x3E, 0xFE, 0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07,
  0xFC, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x07, 0xF1, 0xE3,
  0xFF, 0x3C, 0xFF, 0xF7, 0xBF, 0x9E, 0xF7, 0xC0, 0x7F, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xF7, 0x80, 0x7E, 0xFC,
  0x1B, 0xCF, 0xFF, 0x78, 0xFF, 0xCF, 0x0F, 0xF1, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0x0F, 0xE7, 0xC0, 0x7D, 0xF0, 0x07, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0xF7, 0x80, 0x3E, 0xFC,
  0x0F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xF1, 0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0xBF, 0x9E, 0xF7, 0xC0, 0x7F,
  0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x1F, 0xBF, 0x07, 0xF3,
  0xFF, 0xDE, 0x3F, 0xF3, 0xC3, 0xFC, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFE, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF1, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF, 0xFE, 0x7B, 0x8F, 0xEF,
  0xC0, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x80,
  0x3F, 0xFC, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7,
  0xFF, 0xF3, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF1, 0xFF, 0xF8, 0xFF,
  0xF8, 0x7F, 0xF8, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x79, 0xE0,
  0x07, 0xCF, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x03, 0xE0,
  0xF0, 0x3E, 0x07, 0x81, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0x80, 0x7F, 0xFE, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x07,
  0x80, 0xF8, 0x3C, 0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x7C, 0x78, 0x01,
  0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3E, 0xF0, 0x00, 0xF8, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xF7, 0xC3, 0xE7, 0xFF, 0x3F, 0xBF, 0xFF, 0xFD, 0xF1, 0xF1, 0xFF, 0x07,
  0x07, 0xF8, 0x38, 0x3F, 0xC1, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x7F,
  0x83, 0x83, 0xFC, 0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x38,
  0x3F, 0xC1, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x7F, 0x83, 0x83, 0xFC,
  0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x38, 0x3F, 0xC1, 0xC1,
  0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x78, 0xF1, 0xFC, 0x1E, 0x7F, 0xE3, 0xDF,
  0xFE, 0x7B, 0xCF, 0xEF, 0xC0, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF,
  0xFE, 0x3F, 0xDF, 0xE7, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xF7, 0xC0, 0x7C, 0xFE, 0x3F, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF0, 0xFE, 0x1E, 0x7F, 0xE3, 0xDF,
  0xFE, 0x7B, 0xCF, 0xEF, 0xC0, 0x7D, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x3D, 0xEC, 0x1F, 0xBD, 0xFF,
  0xE7, 0x9F, 0xF8, 0xF1, 0xFE, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0xF1, 0xE3, 0xFF, 0x3C, 0xFF, 0xF7, 0xBF, 0x9E, 0xF7, 0xC0,
  0x7F, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01,
  0xF7, 0xC0, 0x7E, 0xFC, 0x1B, 0xCF, 0xFF, 0x78, 0xFF, 0xCF, 0x0F, 0xF1,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0xF1, 0xFC, 0x1E, 0x7F,
  0xE3, 0xDF, 0xFE, 0x7F, 0x8F, 0xEF, 0xC0, 0x7D, 0xF0, 0x07, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x03, 0xFF,
  0xE0, 0xFF, 0xFF, 0x3F, 0xCF, 0xE7, 0xC0, 0x3E, 0xF0, 0x03, 0xDE, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0xFC, 0x0F,
  0xDF, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x01, 0xE7, 0xC0, 0x7C, 0xFC, 0x1F,
  0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x79, 0xE0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x0F, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78,
  0x01, 0xE0, 0xF0, 0x01, 0xE1, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00,
  0x07, 0x9C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x38, 0x0F, 0xC0,
  0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x83, 0xE0, 0x7F, 0x06, 0xC1, 0xFE, 0x0D,
  0x83, 0xDC, 0x1B, 0x07, 0x38, 0x77, 0x0E, 0x70, 0xEE, 0x1C, 0xE1, 0xDC,
  0x39, 0xE3, 0x18, 0xF3, 0xC6, 0x31, 0xE3, 0x8C, 0x63, 0x87, 0x38, 0xE7,
  0x0E, 0x71, 0xCE, 0x1C, 0xE3, 0x9C, 0x39, 0x83, 0x38, 0x7B, 0x06, 0xF0,
  0xF6, 0x0D, 0xC0, 0xEC, 0x1B, 0x81, 0xF8, 0x3F, 0x03, 0xF0, 0x7E, 0x07,
  0xC0, 0xFC, 0x0F, 0x80, 0xF8, 0x1F, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x78,
  0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF0, 0x1E, 0x01, 0xF0,
  0x7C, 0x01, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xEF, 0x80, 0x03, 0xDE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x80, 0x0F, 0x8F, 0x80,
  0x1E, 0x0F, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x1E, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x79, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xE0, 0x07, 0x83, 0xC0,
  0x1F, 0x07, 0x80, 0x3C, 0x0F, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0xF8,
  0x00, 0xF1, 0xE0, 0x01, 0xF3, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB,
  0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x3F, 0xE0, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x80, 0x7B, 0xFF, 0x03, 0xDF,
  0xF8, 0x1F, 0xE3, 0xE0, 0xFF, 0x07, 0x87, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF,
  0xDE, 0x03, 0xFC, 0xF0, 0x07, 0x80,
};

const GFXglyph JetBrainsMono_Regular45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 33, 27, 10, -33 },
  { 30, 13, 14, 27, 7, -33 },
  { 53, 23, 33, 27, 2, -33 },
  { 148, 21, 45, 27, 3, -39 },
  { 267, 25, 33, 27, 1, -33 },
  { 371, 23, 33, 27, 2, -33 },
  { 466, 4, 14, 27, 11, -33 },
  { 473, 14, 43, 27, 8, -38 },
  { 549, 14, 43, 27, 5, -38 },
  { 625, 23, 23, 27, 2, -27 },
  { 692, 21, 21, 27, 3, -25 },
  { 748, 10, 14, 27, 7, -7 },
  { 766, 15, 4, 27, 6, -17 },
  { 774, 7, 7, 27, 10, -7 },
  { 781, 21, 42, 27, 3, -37 },
  { 892, 19, 33, 27, 4, -33 },
  { 971, 20, 33, 27, 4, -33 },
  { 1054, 21, 33, 27, 3, -33 },
  { 1141, 20, 33, 27, 3, -33 },
  { 1224, 19, 33, 27, 4, -33 },
  { 1303, 19, 33, 27, 4, -33 },
  { 1382, 21, 33, 27, 3, -33 },
  { 1469, 20, 33, 27, 4, -33 },
  { 1552, 19, 33, 27, 4, -33 },
  { 1631, 21, 33, 27, 3, -33 },
  { 1718, 7, 25, 27, 10, -25 },
  { 1740, 9, 32, 27, 8, -25 },
  { 1776, 19, 24, 27, 4, -27 },
  { 1833, 19, 14, 27, 4, -22 },
  { 1867, 19, 24, 27, 4, -27 },
  { 1924, 16, 33, 27, 6, -33 },
  { 1990, 23, 41, 27, 2, -33 },
  { 2108, 23, 33, 27, 2, -33 },
  { 2203, 20, 33, 27, 4, -33 },
  { 2286, 19, 33, 27, 4, -33 },
  { 2365, 19, 33, 27, 4, -33 },
  { 2444, 19, 33, 27, 4, -33 },
  { 2523, 20, 33, 27, 4, -33 },
  { 2606, 19, 33, 27, 4, -33 },
  { 2685, 19, 33, 27, 4, -33 },
  { 2764, 17, 33, 27, 5, -33 },
  { 2835, 20, 33, 27, 2, -33 },
  { 2918, 21, 33, 27, 4, -33 },
  { 3005, 19, 33, 27, 5, -33 },
  { 3084, 21, 33, 27, 3, -33 },
  { 3171, 19, 33, 27, 4, -33 },
  { 3250, 19, 33, 27, 4, -33 },
  { 3329, 21, 33, 27, 4, -33 },
  { 3416, 20, 41, 27, 4, -33 },
  { 3519, 21, 33, 27, 4, -33 },
  { 3606, 21, 33, 27, 3, -33 },
  { 3693, 23, 33, 27, 2, -33 },
  { 3788, 19, 33, 27, 4, -33 },
  { 3867, 23, 33, 27, 2, -33 },
  { 3962, 25, 33, 27, 1, -33 },
  { 4066, 23, 33, 27, 2, -33 },
  { 4161, 23, 33, 27, 2, -33 },
  { 4256, 19, 33, 27, 4, -33 },
  { 4335, 11, 42, 27, 9, -37 },
  { 4393, 21, 42, 27, 3, -37 },
  { 4504, 11, 42, 27, 7, -37 },
  { 4562, 19, 18, 27, 4, -33 },
  { 4605, 21, 4, 27, 3, 1 },
  { 4616, 10, 6, 27, 8, -35 },
  { 4624, 20, 25, 27, 3, -25 },
  { 4687, 19, 33, 27, 4, -33 },
  { 4766, 19, 25, 27, 4, -25 },
  { 4826, 19, 33, 27, 4, -33 },
  { 4905, 19, 25, 27, 4, -25 },
  { 4965, 21, 33, 27, 3, -33 },
  { 5052, 19, 33, 27, 4, -25 },
  { 5131, 19, 33, 27, 4, -33 },
  { 5210, 21, 35, 27, 4, -35 },
  { 5302, 17, 43, 27, 4, -35 },
  { 5394, 21, 33, 27, 4, -33 },
  { 5481, 24, 33, 27, 1, -33 },
  { 5580, 21, 25, 27, 3, -25 },
  { 5646, 19, 25, 27, 4, -25 },
  { 5706, 19, 25, 27, 4, -25 },
  { 5766, 19, 33, 27, 4, -25 },
  { 5845, 19, 33, 27, 4, -25 },
  { 5924, 19, 25, 27, 5, -25 },
  { 5984, 19, 25, 27, 4, -25 },
  { 6044, 21, 32, 27, 2, -32 },
  { 6128, 19, 25, 27, 4, -25 },
  { 6188, 23, 25, 27, 2, -25 },
  { 6260, 23, 25, 27, 2, -25 },
  { 6332, 23, 25, 27, 2, -25 },
  { 6404, 23, 33, 27, 2, -25 },
  { 6499, 19, 25, 27, 4, -25 },
  { 6559, 19, 42, 27, 4, -37 },
  { 6659, 5, 42, 27, 11, -37 },
  { 6686, 19, 42, 27, 4, -37 },
  { 6786, 21, 9, 27, 3, -20 },
};

const GFXfont JetBrainsMono_Regular45pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular45pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular45pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _JETBRAINSMONO_REGULAR45PT7B_H_
