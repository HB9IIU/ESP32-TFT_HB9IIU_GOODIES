#ifndef _JETBRAINSMONO_REGULAR44PT7B_H_
#define _JETBRAINSMONO_REGULAR44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xF1, 0xE3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x00, 0x00, 0x00,
  0x03, 0xEF, 0xDF, 0xFF, 0x3E, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1D, 0xC0,
  0xEE, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0,
  0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x78, 0x0E, 0x00, 0xE0, 0x3C, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF0, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0xE0, 0x0F, 0x01, 0xC0, 0x1C, 0x07, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x1C,
  0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x01, 0xE0, 0x38, 0x03,
  0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xF7, 0x7E,
  0x3C, 0x71, 0xE7, 0x87, 0x1E, 0x78, 0x70, 0xF7, 0x87, 0x0F, 0x78, 0x70,
  0x07, 0x87, 0x00, 0x7C, 0x70, 0x03, 0xC7, 0x00, 0x3F, 0x70, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x77, 0xE0, 0x07, 0x3E, 0x00, 0x71, 0xF0, 0x07, 0x0F, 0x00, 0x70, 0xF0,
  0x07, 0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x0F, 0x78, 0x70, 0xF7, 0xC7, 0x1E,
  0x3F, 0x77, 0xE3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x3F, 0x80, 0x07, 0xBF, 0xF0, 0x07, 0xBF, 0xF8, 0x03, 0x9E, 0x1E,
  0x03, 0x8E, 0x07, 0x03, 0xC7, 0x03, 0x81, 0xC3, 0x81, 0xC1, 0xC1, 0xC0,
  0xE1, 0xE0, 0xE0, 0x70, 0xE0, 0x70, 0x38, 0xE0, 0x3C, 0x3C, 0xF0, 0x1F,
  0xFC, 0x70, 0x07, 0xFE, 0x70, 0x01, 0xFC, 0x78, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x10, 0x00, 0x1C, 0x7F,
  0x00, 0x1C, 0x7F, 0xC0, 0x1E, 0x7D, 0xF0, 0x0E, 0x38, 0x38, 0x0E, 0x3C,
  0x1E, 0x0F, 0x1E, 0x0F, 0x07, 0x0F, 0x07, 0x87, 0x07, 0x83, 0xC7, 0x83,
  0xC1, 0xE3, 0x80, 0xE0, 0xF3, 0x80, 0x70, 0x73, 0xC0, 0x3F, 0xF9, 0xC0,
  0x0F, 0xF9, 0xC0, 0x03, 0xF8, 0x00, 0x60, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xFC, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x00,
  0xF0, 0x1E, 0x01, 0xE0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xE0, 0x7D, 0xE3, 0xC0, 0xF7,
  0xC3, 0xC3, 0xCF, 0x07, 0xC7, 0x9E, 0x07, 0xDE, 0x3C, 0x07, 0xBC, 0x78,
  0x07, 0xF0, 0xF0, 0x0F, 0xE1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0xC0,
  0x3F, 0x07, 0x80, 0xFF, 0x0F, 0x87, 0xFE, 0x0F, 0xFF, 0x9E, 0x1F, 0xFE,
  0x3E, 0x0F, 0xF0, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x08, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0x7E, 0x07, 0xC0, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0xC0, 0x07, 0x80, 0x3F,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xE0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC3, 0xFC, 0x1F,
  0x80, 0xF8, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x10, 0x1E,
  0x01, 0x78, 0x1C, 0x1E, 0xFC, 0x38, 0xFD, 0xFE, 0x67, 0xFD, 0xFF, 0xDF,
  0xE0, 0x7F, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3B, 0x80,
  0x00, 0xE7, 0x80, 0x03, 0xCF, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1F, 0x00,
  0x78, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xC0, 0x38, 0x01, 0x00, 0x20, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC7, 0xE1, 0xF8,
  0x7C, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x70,
  0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x79, 0xFB, 0xFF, 0xFF,
  0xFF, 0xDF, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xC0, 0xF9,
  0xF0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x38, 0x7F,
  0x0F, 0x8F, 0xE1, 0xF1, 0xFC, 0x3E, 0x3F, 0x87, 0x87, 0xF0, 0x20, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xEF, 0x80, 0x7C, 0xFC, 0x1F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80,
  0x0F, 0xF8, 0x03, 0xF7, 0x80, 0x7E, 0x78, 0x0F, 0xC7, 0x80, 0xF0, 0x78,
  0x0E, 0x07, 0x80, 0xC0, 0x78, 0x08, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3E, 0x07, 0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF0, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x07, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBE, 0x01, 0xF3, 0xE0, 0xFC, 0x7F,
  0xFF, 0x07, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x03, 0xE0, 0x3C, 0xF0, 0x0F, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0xFE, 0x0F, 0x7F,
  0xF1, 0xEF, 0xFF, 0x3F, 0xCF, 0xE7, 0xE0, 0x3E, 0xF8, 0x03, 0xDE, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x03,
  0xE7, 0xE0, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x7E, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0xF9, 0xFE, 0x7C, 0x03, 0xE7, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0x78, 0x01, 0xF7, 0xC0, 0x3E, 0x3F, 0x07, 0xE1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x03, 0xCE,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7,
  0xC0, 0xF8, 0xF0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE,
  0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0x78, 0x7C, 0x1E, 0x07,
  0xEF, 0x80, 0x7F, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0xFC, 0x3E,
  0x07, 0xC7, 0x80, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x80, 0x7C, 0xFC,
  0x1F, 0x9F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x20, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE7, 0xC0, 0x3E,
  0x78, 0x01, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80,
  0x1F, 0x7E, 0x03, 0xE3, 0xFD, 0xFE, 0x1F, 0xFF, 0xE0, 0xFF, 0xBC, 0x03,
  0xE7, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x31, 0xFB, 0xFF, 0xFF,
  0xFF, 0x9E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xEF, 0xDF, 0xFF, 0xFF, 0x7C, 0x06, 0x07, 0xE1, 0xFC, 0xFF, 0x1F,
  0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x3E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C,
  0x3E, 0x0F, 0x83, 0xC0, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00,
  0x70, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x03, 0xC0, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x1C, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x70, 0x00, 0x3E,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x20, 0x00, 0x00,
  0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x1F, 0x00, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x80, 0xFF, 0xFF, 0x81, 0xF0, 0x0F, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x70, 0x00, 0x1D, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x01, 0xFD, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0xBB, 0xF8,
  0x3C, 0x1F, 0xF0, 0x70, 0x1F, 0xE0, 0xE0, 0x3F, 0xC1, 0xC0, 0x7F, 0x83,
  0x80, 0xFF, 0x07, 0x01, 0xFE, 0x0E, 0x03, 0xFC, 0x1C, 0x07, 0xF8, 0x38,
  0x0F, 0xF0, 0x70, 0x1F, 0xE0, 0xE0, 0x3F, 0xC1, 0xE0, 0xFF, 0x83, 0xE3,
  0xFF, 0x03, 0xFE, 0xFE, 0x03, 0xF9, 0xFC, 0x00, 0xC0, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xB8, 0x00, 0x1C, 0xF0, 0x00, 0x73, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x1E, 0x0E, 0x00, 0x78, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03,
  0xC0, 0x3C, 0x07, 0x00, 0xF0, 0x1E, 0x07, 0x80, 0x78, 0x1F, 0xFF, 0xE0,
  0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0,
  0x01, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF,
  0xFE, 0x78, 0x1F, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00,
  0x79, 0xE0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFF, 0x9E, 0x01,
  0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x03,
  0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC7, 0xFF, 0xC0, 0x00, 0x60,
  0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF0, 0x0F,
  0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x0F, 0xFC, 0x01, 0xE7, 0x80, 0x7C, 0xFC, 0x1F, 0x0F, 0xFF, 0xE0,
  0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC,
  0x78, 0x3F, 0xCF, 0x00, 0xF9, 0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78, 0x07, 0xCF,
  0xFF, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF,
  0xFF, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F, 0xFC,
  0x1F, 0xFF, 0xC7, 0xE0, 0xF8, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x1F, 0xFF,
  0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xE7,
  0x80, 0x7C, 0xFC, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x7E, 0x0F, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x7F, 0xE0, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79,
  0xE0, 0x07, 0x8F, 0x00, 0x7C, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01,
  0xE0, 0xF0, 0x1F, 0x07, 0x80, 0xF0, 0x3C, 0x0F, 0x81, 0xE0, 0x78, 0x0F,
  0x07, 0xC0, 0x78, 0x3C, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0xFF, 0xF8,
  0x07, 0x83, 0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x78, 0x0F, 0x03, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x7C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C,
  0x3C, 0x01, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xC0,
  0x07, 0xDE, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0xEE, 0x07, 0xFE, 0xE0, 0x77, 0xEF,
  0x07, 0x7F, 0x70, 0x77, 0xF7, 0x0E, 0x7F, 0x78, 0xE7, 0xF3, 0x8E, 0x7F,
  0x39, 0xC7, 0xF3, 0xDC, 0x7F, 0x1D, 0xCF, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F,
  0xF0, 0xF8, 0xFF, 0x0F, 0x8F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x07, 0xFE, 0x01, 0xFB, 0x80, 0x7F, 0xF0, 0x1F, 0xFC, 0x07, 0xF7, 0x01,
  0xFD, 0xE0, 0x7F, 0x38, 0x1F, 0xCE, 0x07, 0xF3, 0xC1, 0xFC, 0x70, 0x7F,
  0x1C, 0x1F, 0xC7, 0x87, 0xF0, 0xE1, 0xFC, 0x3C, 0x7F, 0x0F, 0x1F, 0xC1,
  0xC7, 0xF0, 0x79, 0xFC, 0x1E, 0x7F, 0x03, 0x9F, 0xC0, 0xF7, 0xF0, 0x3D,
  0xFC, 0x07, 0x7F, 0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0x00, 0x60, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F,
  0xFF, 0xC7, 0xE0, 0xF8, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1E, 0xF0,
  0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0x80,
  0x7C, 0xFC, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0x01, 0xFC, 0xF0, 0x03, 0xEF,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x07,
  0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xF8, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x80,
  0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF9, 0xF0, 0x0F, 0xBC, 0x00, 0xF7,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x01, 0xEF, 0x80, 0x7C, 0xFC, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0x03, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x3E, 0xF0, 0x0F, 0xCF, 0xFF,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3E,
  0xF0, 0x01, 0xEF, 0x00, 0x1F, 0x00, 0x70, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xE7, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xE3, 0xF0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x7E,
  0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xF0, 0x3F, 0xF0, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC1,
  0xE0, 0x0E, 0x07, 0x80, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x38,
  0x01, 0xE1, 0xE0, 0x03, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0x70, 0x00,
  0xF3, 0xC0, 0x01, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xE0, 0x00, 0x7B,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0xF0, 0x3C, 0x07, 0xF0, 0x3E, 0x07, 0xF0, 0x3E, 0x0F, 0x70, 0x3E, 0x0F,
  0x70, 0x3E, 0x0F, 0x70, 0x36, 0x0F, 0x78, 0x76, 0x0F, 0x78, 0x76, 0x0E,
  0x78, 0x76, 0x0E, 0x78, 0x76, 0x0E, 0x78, 0x67, 0x0E, 0x78, 0x67, 0x1E,
  0x38, 0x67, 0x1E, 0x38, 0x67, 0x1E, 0x38, 0xE3, 0x1E, 0x38, 0xE3, 0x1C,
  0x3C, 0xE3, 0x1C, 0x3C, 0xE3, 0x1C, 0x3C, 0xC3, 0x1C, 0x3C, 0xC3, 0x9C,
  0x3C, 0xC3, 0x9C, 0x1C, 0xC3, 0xBC, 0x1D, 0xC3, 0xBC, 0x1D, 0xC1, 0xBC,
  0x1D, 0xC1, 0xB8, 0x1D, 0xC1, 0xB8, 0x1F, 0x81, 0xB8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x81, 0xF8,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF0, 0xF0, 0x03, 0xE1, 0xF0, 0x07, 0x81,
  0xE0, 0x1F, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x07, 0xC1, 0xE0, 0x07,
  0x87, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0xF0,
  0x00, 0x79, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0,
  0x3E, 0x03, 0xC0, 0x78, 0x07, 0xC1, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x8F,
  0x80, 0x0F, 0x1E, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80,
  0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x79, 0xE0,
  0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x0E, 0x78, 0x03, 0xC7,
  0x00, 0x70, 0xF0, 0x1E, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x3C, 0x1E, 0x03,
  0x83, 0x80, 0x78, 0xF0, 0x07, 0x1C, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x3C, 0x0F,
  0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0xE0, 0x7E, 0xF8, 0x03, 0xDE, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x87, 0xFF, 0xF3, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0xF8, 0x0D, 0xDF, 0xFF, 0xB9,
  0xFF, 0xE7, 0x0F, 0xF8, 0xE0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x81, 0x80,
  0xF3, 0xFE, 0x1E, 0xFF, 0xE3, 0xDF, 0xFE, 0x7F, 0x07, 0xEF, 0x80, 0x7D,
  0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0x7C, 0x03, 0xEF,
  0xE0, 0xFD, 0xEF, 0xFF, 0x3D, 0xFF, 0xC7, 0x8F, 0xF0, 0x01, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xC0, 0xFD, 0xF0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x07, 0xFC, 0x01, 0xE7, 0x80, 0x7C, 0xFC,
  0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x0E, 0x0F, 0x1F, 0xF3, 0xCF, 0xFE, 0xF7, 0xFF, 0xFD, 0xF0, 0x3F,
  0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x1F,
  0x7E, 0x0F, 0xCF, 0xFF, 0xF3, 0xFF, 0xBC, 0x3F, 0xCF, 0x00, 0xE0, 0x01,
  0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xC0, 0xF9, 0xF0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x0E, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xF7, 0x80, 0x3C, 0xF8,
  0x1F, 0x8F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xF8,
  0x03, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x03,
  0xFC, 0xF3, 0xFF, 0xBD, 0xFF, 0xFF, 0x7C, 0x0F, 0xFE, 0x01, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE,
  0x00, 0xF7, 0x80, 0x7D, 0xF8, 0x3F, 0x3F, 0xFF, 0xCF, 0xFE, 0xF0, 0xFF,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC7, 0xFF, 0xE1, 0xFF, 0xF8, 0x7F, 0xFC, 0x1F, 0xFC, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0xF3, 0xFE, 0x3D, 0xFF, 0xCF, 0x7F,
  0xFB, 0xF0, 0x3F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x7F,
  0xFE, 0x7F, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xFF,
  0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01,
  0xF7, 0x80, 0x0F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x78,
  0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x07, 0xC0, 0xF0, 0x3C, 0x07, 0x83, 0xE0,
  0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x78, 0x3E, 0x03, 0xC0,
  0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1F, 0x07, 0x80, 0x78, 0x3C, 0x03, 0xE1,
  0xE0, 0x0F, 0x8F, 0x00, 0x3C, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF,
  0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x01, 0x01, 0x07,
  0x3E, 0x3F, 0x3B, 0xFB, 0xFD, 0xD3, 0xDB, 0xEF, 0x0F, 0x0F, 0x78, 0x78,
  0x3B, 0xC1, 0xC1, 0xDE, 0x0E, 0x0F, 0xF0, 0x70, 0x7F, 0x83, 0x83, 0xFC,
  0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x38, 0x3F, 0xC1, 0xC1,
  0xFE, 0x0E, 0x0F, 0xF0, 0x70, 0x7F, 0x83, 0x83, 0xFC, 0x1C, 0x1F, 0xE0,
  0xE0, 0xFF, 0x07, 0x07, 0xF8, 0x38, 0x3F, 0xC1, 0xC1, 0xFE, 0x0E, 0x0F,
  0xF0, 0x70, 0x78, 0x00, 0x70, 0x3C, 0xFF, 0x8F, 0x7F, 0xF3, 0xDF, 0xFE,
  0xFE, 0x0F, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xC0,
  0x00, 0x40, 0x01, 0xFF, 0x80, 0x7F, 0xFC, 0x1F, 0xFF, 0xC7, 0xE0, 0xF9,
  0xF0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0x78, 0x01, 0xE7,
  0x80, 0x7C, 0xFC, 0x3F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0x30, 0x1E, 0x7F, 0xC3, 0xDF, 0xFC, 0x7B, 0xFF, 0xCF, 0xE0, 0xFD,
  0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xFC, 0x01, 0xEF,
  0x80, 0x7D, 0xFC, 0x1F, 0xBD, 0xFF, 0xE7, 0x9F, 0xF8, 0xF1, 0xFE, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x03, 0xFC, 0xF3,
  0xFF, 0xBD, 0xFF, 0xFF, 0x7C, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x07, 0xDF, 0x83, 0xF3, 0xFF, 0xFC, 0xFF,
  0xEF, 0x0F, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x1E, 0x7F, 0xC3, 0xDF, 0xFC, 0x7F, 0xFF, 0xCF, 0xC0, 0xF9, 0xF0, 0x0F,
  0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0,
  0x01, 0xFF, 0xC0, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xC0, 0x7C, 0xF0, 0x07,
  0x9E, 0x00, 0x0B, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x3E,
  0xF8, 0x0F, 0x9F, 0xFF, 0xF1, 0xFF, 0xFC, 0x0F, 0xFE, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xC0, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x80, 0x3D, 0xE0, 0x1F, 0x7E, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0,
  0x1F, 0xF0, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0x8F, 0x00,
  0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x78,
  0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0xF0, 0x07,
  0x83, 0xC0, 0x1E, 0x0E, 0x00, 0x78, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xC7,
  0x00, 0x0F, 0x3C, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xE0, 0x78, 0x1F, 0xC0,
  0xF0, 0x3F, 0x81, 0xF0, 0x77, 0x83, 0xE0, 0xEF, 0x07, 0xC1, 0xDE, 0x1D,
  0x83, 0x9C, 0x3B, 0x07, 0x38, 0x66, 0x1E, 0x70, 0xCC, 0x38, 0xE1, 0x9C,
  0x71, 0xE3, 0x38, 0xE3, 0xCE, 0x31, 0xC3, 0x9C, 0x63, 0x87, 0x38, 0xCF,
  0x0E, 0x61, 0x9C, 0x1C, 0xC3, 0xB8, 0x39, 0x87, 0x70, 0x7B, 0x0E, 0xE0,
  0x7E, 0x0D, 0xC0, 0xFC, 0x1B, 0x81, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x7C, 0x00, 0x7C, 0xF0, 0x03, 0xE1, 0xE0,
  0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x03, 0xE0, 0x1E, 0x1F, 0x00, 0x7C, 0x78,
  0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0xF3,
  0xC0, 0x07, 0xC7, 0x80, 0x1E, 0x1F, 0x00, 0xF0, 0x3C, 0x07, 0xC0, 0x78,
  0x1E, 0x01, 0xF0, 0xF0, 0x03, 0xC7, 0xC0, 0x07, 0xBE, 0x00, 0x1F, 0xF8,
  0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x00,
  0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0xC7, 0x80, 0x0F,
  0x1E, 0x00, 0x3C, 0x78, 0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xB8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x07, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x7F, 0xF8, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x1F, 0xE0, 0x00,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x7B, 0xFE, 0x03, 0xDF, 0xF8, 0x1F, 0xF3, 0xE0,
  0xFF, 0x0F, 0x07, 0x78, 0x3E, 0x7B, 0xC0, 0xFF, 0xDE, 0x03, 0xFC, 0xF0,
  0x0F, 0x80,
};

const GFXglyph JetBrainsMono_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 32, 26, 10, -32 },
  { 29, 13, 13, 26, 7, -32 },
  { 51, 23, 32, 26, 2, -32 },
  { 143, 20, 44, 26, 3, -38 },
  { 253, 25, 32, 26, 1, -32 },
  { 353, 23, 33, 26, 2, -33 },
  { 448, 4, 13, 26, 11, -32 },
  { 455, 13, 42, 26, 8, -37 },
  { 524, 13, 42, 26, 5, -37 },
  { 593, 23, 23, 26, 2, -27 },
  { 660, 21, 21, 26, 3, -25 },
  { 716, 10, 14, 26, 7, -7 },
  { 734, 14, 3, 26, 6, -16 },
  { 740, 7, 7, 26, 10, -7 },
  { 747, 20, 42, 26, 3, -37 },
  { 852, 19, 33, 26, 4, -33 },
  { 931, 20, 32, 26, 4, -32 },
  { 1011, 20, 33, 26, 3, -33 },
  { 1094, 19, 32, 26, 3, -32 },
  { 1170, 18, 32, 26, 4, -32 },
  { 1242, 19, 32, 26, 4, -32 },
  { 1318, 20, 32, 26, 3, -32 },
  { 1398, 20, 32, 26, 4, -32 },
  { 1478, 19, 33, 26, 4, -33 },
  { 1557, 20, 33, 26, 3, -33 },
  { 1640, 7, 25, 26, 10, -25 },
  { 1662, 10, 32, 26, 7, -25 },
  { 1702, 19, 23, 26, 4, -26 },
  { 1757, 19, 15, 26, 4, -22 },
  { 1793, 19, 23, 26, 4, -26 },
  { 1848, 16, 32, 26, 6, -32 },
  { 1912, 23, 41, 26, 2, -33 },
  { 2030, 22, 32, 26, 2, -32 },
  { 2118, 19, 32, 26, 4, -32 },
  { 2194, 19, 33, 26, 4, -33 },
  { 2273, 19, 32, 26, 4, -32 },
  { 2349, 19, 32, 26, 4, -32 },
  { 2425, 19, 32, 26, 4, -32 },
  { 2501, 19, 33, 26, 4, -33 },
  { 2580, 18, 32, 26, 4, -32 },
  { 2652, 17, 32, 26, 5, -32 },
  { 2720, 20, 32, 26, 2, -32 },
  { 2800, 21, 32, 26, 4, -32 },
  { 2884, 19, 32, 26, 5, -32 },
  { 2960, 20, 32, 26, 3, -32 },
  { 3040, 18, 32, 26, 4, -32 },
  { 3112, 19, 33, 26, 4, -33 },
  { 3191, 20, 32, 26, 4, -32 },
  { 3271, 19, 41, 26, 4, -33 },
  { 3369, 20, 32, 26, 4, -32 },
  { 3449, 20, 33, 26, 3, -33 },
  { 3532, 22, 32, 26, 2, -32 },
  { 3620, 18, 32, 26, 4, -32 },
  { 3692, 22, 32, 26, 2, -32 },
  { 3780, 24, 32, 26, 1, -32 },
  { 3876, 23, 32, 26, 2, -32 },
  { 3968, 23, 32, 26, 2, -32 },
  { 4060, 19, 32, 26, 4, -32 },
  { 4136, 11, 42, 26, 9, -37 },
  { 4194, 20, 42, 26, 3, -37 },
  { 4299, 10, 42, 26, 7, -37 },
  { 4352, 19, 17, 26, 4, -32 },
  { 4393, 21, 3, 26, 3, 1 },
  { 4401, 9, 7, 26, 8, -35 },
  { 4409, 19, 25, 26, 3, -25 },
  { 4469, 19, 32, 26, 4, -32 },
  { 4545, 19, 25, 26, 4, -25 },
  { 4605, 18, 32, 26, 4, -32 },
  { 4677, 19, 25, 26, 4, -25 },
  { 4737, 21, 32, 26, 3, -32 },
  { 4821, 18, 33, 26, 4, -25 },
  { 4896, 18, 32, 26, 4, -32 },
  { 4968, 20, 34, 26, 4, -34 },
  { 5053, 16, 42, 26, 4, -34 },
  { 5137, 21, 32, 26, 4, -32 },
  { 5221, 23, 32, 26, 1, -32 },
  { 5313, 21, 25, 26, 3, -25 },
  { 5379, 18, 25, 26, 4, -25 },
  { 5436, 19, 25, 26, 4, -25 },
  { 5496, 19, 33, 26, 4, -25 },
  { 5575, 18, 33, 26, 4, -25 },
  { 5650, 19, 25, 26, 5, -25 },
  { 5710, 19, 25, 26, 4, -25 },
  { 5770, 21, 31, 26, 2, -31 },
  { 5852, 18, 24, 26, 4, -24 },
  { 5906, 22, 24, 26, 2, -24 },
  { 5972, 23, 24, 26, 2, -24 },
  { 6041, 22, 24, 26, 2, -24 },
  { 6107, 22, 32, 26, 2, -24 },
  { 6195, 18, 24, 26, 4, -24 },
  { 6249, 19, 42, 26, 4, -37 },
  { 6349, 4, 42, 26, 11, -37 },
  { 6370, 19, 42, 26, 4, -37 },
  { 6470, 21, 9, 26, 3, -20 },
};

const GFXfont JetBrainsMono_Regular44pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular44pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular44pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _JETBRAINSMONO_REGULAR44PT7B_H_
