#ifndef _JETBRAINSMONO_REGULAR6PT7B_H_
#define _JETBRAINSMONO_REGULAR6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x7F, 0xD0, 0x5D, 0x3A, 0x80, 0xFA, 0x5A, 0xEA, 0xF0,
  0x80, 0x6A, 0x90, 0xFC, 0x55, 0x80, 0x5C, 0xC0, 0xC0, 0x80, 0x25, 0x25,
  0x00, 0xFE, 0xB0, 0xAB, 0xE5, 0x70, 0x6C, 0xF0, 0x6F, 0x90, 0xF7, 0x4E,
  0xB0, 0xE5, 0x20, 0xEE, 0xB0, 0xF5, 0xA0, 0xA0, 0xB0, 0x69, 0xF0, 0x96,
  0xDA, 0xFF, 0xDC, 0x4D, 0xD0, 0xFF, 0xEB, 0xFF, 0xFB, 0xFA, 0xEF, 0xFF,
  0xEB, 0x64, 0xF0, 0xEF, 0xAB, 0xBE, 0xD0, 0xFF, 0xFF, 0xFA, 0xF6, 0xB2,
  0xFF, 0xE8, 0xF0, 0xE9, 0x20, 0xFF, 0xAD, 0xA0, 0xFF, 0xD0, 0xE9, 0xD0,
  0xA9, 0x20, 0xEB, 0xEA, 0xB0, 0x89, 0x12, 0x40, 0xFC, 0x54, 0xE0, 0x80,
  0xFF, 0x80, 0xBF, 0xEC, 0x7F, 0xEC, 0x7D, 0x20, 0xFF, 0xBF, 0x8A, 0xC0,
  0x65, 0x70, 0xBB, 0xC9, 0x30, 0xFF, 0x80, 0xFC, 0xFC, 0xFE, 0xFD, 0xE8,
  0xFC, 0xE9, 0x30, 0xFC, 0xAD, 0x00, 0xFE, 0x80, 0xEA, 0x80, 0xAD, 0x20,
  0xEC, 0x69, 0x90, 0xFC, 0xAE, 0xA0, 0x74,
};

const GFXglyph JetBrainsMono_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 1, 4, 4, 1, -4 },
  { 2, 2, 1, 4, 1, -4 },
  { 3, 3, 4, 4, 0, -4 },
  { 5, 3, 6, 4, 0, -5 },
  { 8, 4, 4, 4, 0, -4 },
  { 10, 3, 4, 4, 0, -4 },
  { 12, 1, 1, 4, 1, -4 },
  { 13, 2, 6, 4, 1, -5 },
  { 15, 1, 6, 4, 1, -5 },
  { 16, 3, 3, 4, 0, -4 },
  { 18, 3, 2, 4, 0, -3 },
  { 19, 1, 2, 4, 1, -1 },
  { 20, 2, 1, 4, 1, -2 },
  { 21, 1, 1, 4, 1, -1 },
  { 22, 3, 6, 4, 0, -5 },
  { 25, 3, 4, 4, 0, -4 },
  { 27, 2, 4, 4, 1, -4 },
  { 28, 3, 4, 4, 0, -4 },
  { 30, 3, 4, 4, 0, -4 },
  { 32, 3, 4, 4, 0, -4 },
  { 34, 2, 4, 4, 1, -4 },
  { 35, 3, 4, 4, 0, -4 },
  { 37, 3, 4, 4, 0, -4 },
  { 39, 3, 4, 4, 0, -4 },
  { 41, 3, 4, 4, 0, -4 },
  { 43, 1, 3, 4, 1, -3 },
  { 44, 1, 4, 4, 1, -3 },
  { 45, 2, 4, 4, 1, -4 },
  { 46, 2, 2, 4, 1, -3 },
  { 47, 2, 4, 4, 1, -4 },
  { 48, 2, 4, 4, 1, -4 },
  { 49, 3, 5, 4, 0, -4 },
  { 51, 3, 4, 4, 0, -4 },
  { 53, 2, 4, 4, 1, -4 },
  { 54, 2, 4, 4, 1, -4 },
  { 55, 2, 4, 4, 1, -4 },
  { 56, 2, 4, 4, 1, -4 },
  { 57, 2, 4, 4, 1, -4 },
  { 58, 2, 4, 4, 1, -4 },
  { 59, 2, 4, 4, 1, -4 },
  { 60, 2, 4, 4, 1, -4 },
  { 61, 3, 4, 4, 0, -4 },
  { 63, 2, 4, 4, 1, -4 },
  { 64, 2, 4, 4, 1, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 2, 4, 4, 1, -4 },
  { 68, 2, 4, 4, 1, -4 },
  { 69, 2, 4, 4, 1, -4 },
  { 70, 3, 5, 4, 0, -4 },
  { 72, 2, 4, 4, 1, -4 },
  { 73, 3, 4, 4, 0, -4 },
  { 75, 3, 4, 4, 0, -4 },
  { 77, 2, 4, 4, 1, -4 },
  { 78, 3, 4, 4, 0, -4 },
  { 80, 3, 4, 4, 0, -4 },
  { 82, 3, 4, 4, 0, -4 },
  { 84, 3, 4, 4, 0, -4 },
  { 86, 2, 4, 4, 1, -4 },
  { 87, 2, 6, 4, 1, -5 },
  { 89, 3, 6, 4, 0, -5 },
  { 92, 1, 6, 4, 1, -5 },
  { 93, 3, 2, 4, 0, -4 },
  { 94, 3, 1, 4, 0, 0 },
  { 95, 1, 1, 4, 1, -5 },
  { 96, 3, 3, 4, 0, -3 },
  { 98, 2, 4, 4, 1, -4 },
  { 99, 2, 3, 4, 1, -3 },
  { 100, 2, 4, 4, 1, -4 },
  { 101, 2, 3, 4, 1, -3 },
  { 102, 3, 4, 4, 0, -4 },
  { 104, 2, 4, 4, 1, -3 },
  { 105, 2, 4, 4, 1, -4 },
  { 106, 2, 5, 4, 1, -5 },
  { 108, 2, 6, 4, 1, -5 },
  { 110, 2, 4, 4, 1, -4 },
  { 111, 3, 4, 4, 0, -4 },
  { 113, 3, 3, 4, 0, -3 },
  { 115, 2, 3, 4, 1, -3 },
  { 116, 2, 3, 4, 1, -3 },
  { 117, 2, 4, 4, 1, -3 },
  { 118, 2, 4, 4, 1, -3 },
  { 119, 2, 3, 4, 1, -3 },
  { 120, 2, 3, 4, 1, -3 },
  { 121, 3, 4, 4, 0, -4 },
  { 123, 2, 3, 4, 1, -3 },
  { 124, 3, 3, 4, 0, -3 },
  { 126, 3, 3, 4, 0, -3 },
  { 128, 3, 3, 4, 0, -3 },
  { 130, 3, 4, 4, 0, -3 },
  { 132, 2, 3, 4, 1, -3 },
  { 133, 2, 6, 4, 1, -5 },
  { 135, 1, 6, 4, 1, -5 },
  { 136, 2, 6, 4, 1, -5 },
  { 138, 3, 2, 4, 0, -3 },
};

const GFXfont JetBrainsMono_Regular6pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular6pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _JETBRAINSMONO_REGULAR6PT7B_H_
