#ifndef _JETBRAINSMONO_REGULAR8PT7B_H_
#define _JETBRAINSMONO_REGULAR8PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 8pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular8pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB6, 0x80, 0x52, 0x9E, 0xAF, 0x30, 0x5F, 0xE7, 0xFA, 0xCD,
  0xB8, 0x66, 0xCC, 0x62, 0x91, 0x79, 0x3C, 0xE0, 0x2A, 0x49, 0x11, 0x95,
  0x56, 0x27, 0xC8, 0xA0, 0x4B, 0xA0, 0x60, 0xE0, 0x80, 0x24, 0xA5, 0x24,
  0xF6, 0xFB, 0xC0, 0x59, 0x25, 0xC0, 0xF4, 0xA9, 0xC0, 0xE9, 0x1B, 0xC0,
  0x2A, 0x5E, 0x40, 0xF3, 0x93, 0xC0, 0x4B, 0x5B, 0xC0, 0xF4, 0xA5, 0x80,
  0xF6, 0xFB, 0xC0, 0xF6, 0xF5, 0x80, 0x90, 0x41, 0x80, 0x2A, 0x30, 0xE3,
  0x80, 0x88, 0xE0, 0xC4, 0xA1, 0x80, 0x79, 0xBB, 0xBA, 0x60, 0x26, 0x55,
  0x79, 0xF7, 0xDB, 0xC0, 0xF6, 0x4B, 0xC0, 0xD6, 0xDB, 0xC0, 0xF3, 0xC9,
  0xC0, 0xF2, 0x79, 0x00, 0xF6, 0x7B, 0xC0, 0xB7, 0xDB, 0x40, 0xE9, 0x25,
  0xC0, 0x31, 0x11, 0x97, 0xB7, 0x6B, 0x40, 0x92, 0x49, 0xC0, 0xB7, 0xDB,
  0x40, 0xB7, 0xFB, 0x40, 0xF6, 0xDB, 0xC0, 0xF6, 0xE9, 0x00, 0xF6, 0xDB,
  0xC8, 0xF6, 0xEB, 0x40, 0xF6, 0x3B, 0xC0, 0xF2, 0x22, 0x22, 0xB6, 0xDB,
  0xC0, 0x95, 0x55, 0x62, 0xAD, 0x7D, 0xE5, 0x28, 0x95, 0x22, 0x59, 0x9A,
  0x94, 0x42, 0x10, 0xE5, 0x29, 0xC0, 0xEA, 0xAB, 0x92, 0x24, 0x89, 0xD5,
  0x57, 0x56, 0x80, 0xF0, 0xC0, 0xFE, 0xF0, 0x9A, 0xDB, 0xC0, 0xF2, 0x70,
  0x2E, 0xDB, 0xC0, 0xFE, 0x70, 0x32, 0xF2, 0x22, 0xF6, 0xFE, 0x9A, 0xDB,
  0x40, 0x51, 0x25, 0xC0, 0x38, 0x92, 0x70, 0x92, 0xEB, 0x40, 0xC2, 0x22,
  0x23, 0xFF, 0xF0, 0xF6, 0xD0, 0xF6, 0xF0, 0xF6, 0xF8, 0xF6, 0xF2, 0xF2,
  0x40, 0xF8, 0xF0, 0x2F, 0x22, 0x23, 0xB6, 0xF0, 0xD5, 0x52, 0xAF, 0x94,
  0xA0, 0xD2, 0x6D, 0xD5, 0x62, 0x60, 0xEA, 0x70, 0x29, 0x2C, 0x91, 0xFF,
  0x89, 0x26, 0x94, 0xBC,
};

const GFXglyph JetBrainsMono_Regular8pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 3, 5, 1, -6 },
  { 4, 5, 6, 5, 0, -6 },
  { 8, 3, 8, 5, 1, -7 },
  { 11, 5, 6, 5, 0, -6 },
  { 15, 5, 6, 5, 0, -6 },
  { 19, 1, 3, 5, 2, -6 },
  { 20, 3, 8, 5, 1, -7 },
  { 23, 2, 8, 5, 1, -7 },
  { 25, 5, 4, 5, 0, -5 },
  { 28, 3, 4, 5, 1, -5 },
  { 30, 2, 2, 5, 1, -1 },
  { 31, 3, 1, 5, 1, -3 },
  { 32, 1, 1, 5, 2, -1 },
  { 33, 3, 8, 5, 1, -7 },
  { 36, 3, 6, 5, 1, -6 },
  { 39, 3, 6, 5, 1, -6 },
  { 42, 3, 6, 5, 1, -6 },
  { 45, 3, 6, 5, 1, -6 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 3, 6, 5, 1, -6 },
  { 54, 3, 6, 5, 1, -6 },
  { 57, 3, 6, 5, 1, -6 },
  { 60, 3, 6, 5, 1, -6 },
  { 63, 3, 6, 5, 1, -6 },
  { 66, 1, 4, 5, 2, -4 },
  { 67, 2, 5, 5, 1, -4 },
  { 69, 3, 4, 5, 1, -5 },
  { 71, 3, 3, 5, 1, -4 },
  { 73, 3, 4, 5, 1, -5 },
  { 75, 3, 6, 5, 1, -6 },
  { 78, 4, 7, 5, 0, -6 },
  { 82, 4, 6, 5, 0, -6 },
  { 85, 3, 6, 5, 1, -6 },
  { 88, 3, 6, 5, 1, -6 },
  { 91, 3, 6, 5, 1, -6 },
  { 94, 3, 6, 5, 1, -6 },
  { 97, 3, 6, 5, 1, -6 },
  { 100, 3, 6, 5, 1, -6 },
  { 103, 3, 6, 5, 1, -6 },
  { 106, 3, 6, 5, 1, -6 },
  { 109, 4, 6, 5, 0, -6 },
  { 112, 3, 6, 5, 1, -6 },
  { 115, 3, 6, 5, 1, -6 },
  { 118, 3, 6, 5, 1, -6 },
  { 121, 3, 6, 5, 1, -6 },
  { 124, 3, 6, 5, 1, -6 },
  { 127, 3, 6, 5, 1, -6 },
  { 130, 3, 7, 5, 1, -6 },
  { 133, 3, 6, 5, 1, -6 },
  { 136, 3, 6, 5, 1, -6 },
  { 139, 4, 6, 5, 0, -6 },
  { 142, 3, 6, 5, 1, -6 },
  { 145, 4, 6, 5, 0, -6 },
  { 148, 5, 6, 5, 0, -6 },
  { 152, 4, 6, 5, 0, -6 },
  { 155, 5, 6, 5, 0, -6 },
  { 159, 3, 6, 5, 1, -6 },
  { 162, 2, 8, 5, 2, -7 },
  { 164, 3, 8, 5, 1, -7 },
  { 167, 2, 8, 5, 1, -7 },
  { 169, 3, 3, 5, 1, -6 },
  { 171, 4, 1, 5, 0, 0 },
  { 172, 2, 1, 5, 1, -6 },
  { 173, 3, 4, 5, 1, -4 },
  { 175, 3, 6, 5, 1, -6 },
  { 178, 3, 4, 5, 1, -4 },
  { 180, 3, 6, 5, 1, -6 },
  { 183, 3, 4, 5, 1, -4 },
  { 185, 4, 6, 5, 0, -6 },
  { 188, 3, 5, 5, 1, -4 },
  { 190, 3, 6, 5, 1, -6 },
  { 193, 3, 6, 5, 1, -6 },
  { 196, 3, 7, 5, 1, -6 },
  { 199, 3, 6, 5, 1, -6 },
  { 202, 4, 6, 5, 0, -6 },
  { 205, 3, 4, 5, 1, -4 },
  { 207, 3, 4, 5, 1, -4 },
  { 209, 3, 4, 5, 1, -4 },
  { 211, 3, 5, 5, 1, -4 },
  { 213, 3, 5, 5, 1, -4 },
  { 215, 3, 4, 5, 1, -4 },
  { 217, 3, 4, 5, 1, -4 },
  { 219, 4, 6, 5, 0, -6 },
  { 222, 3, 4, 5, 1, -4 },
  { 224, 4, 4, 5, 0, -4 },
  { 226, 5, 4, 5, 0, -4 },
  { 229, 4, 4, 5, 0, -4 },
  { 231, 4, 5, 5, 0, -4 },
  { 234, 3, 4, 5, 1, -4 },
  { 236, 3, 8, 5, 1, -7 },
  { 239, 1, 8, 5, 2, -7 },
  { 240, 3, 8, 5, 1, -7 },
  { 243, 3, 2, 5, 1, -4 },
};

const GFXfont JetBrainsMono_Regular8pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular8pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular8pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _JETBRAINSMONO_REGULAR8PT7B_H_
