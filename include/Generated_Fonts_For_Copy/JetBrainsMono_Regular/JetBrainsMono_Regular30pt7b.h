#ifndef _JETBRAINSMONO_REGULAR30PT7B_H_
#define _JETBRAINSMONO_REGULAR30PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xF7, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x0F, 0xFF,
  0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x61, 0x98, 0x66, 0x19, 0x86, 0x61, 0x80,
  0x07, 0x0E, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x0C, 0x06, 0x1C,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0C, 0x18, 0x0C, 0x18, 0x0C, 0x38, 0x1C, 0x30,
  0x18, 0x30, 0x18, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x38, 0x70, 0x30, 0x60,
  0x30, 0x60, 0x30, 0x60, 0x30, 0x60, 0x70, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x0F, 0xE0, 0xFF, 0xC3, 0xB7, 0x9C, 0xCE, 0x73, 0x19,
  0x8C, 0x77, 0x30, 0x1C, 0xC0, 0x7B, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC,
  0x03, 0xF8, 0x0C, 0xE0, 0x31, 0xC0, 0xC7, 0xE3, 0x1F, 0x8C, 0x77, 0x33,
  0x9E, 0xDE, 0x3F, 0xF0, 0x7F, 0x80, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x3E, 0x01, 0xDF, 0xC0, 0xE6, 0x38, 0x33, 0x86, 0x18, 0xE1, 0x8E,
  0x38, 0x63, 0x06, 0x19, 0x81, 0x8E, 0xE0, 0x7F, 0x30, 0x0F, 0x98, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x01, 0x9E, 0x00, 0xCF, 0xE0, 0x37, 0x18, 0x19,
  0x86, 0x0C, 0x61, 0xC7, 0x18, 0x71, 0x86, 0x1C, 0xC1, 0xC6, 0x70, 0x3F,
  0xB8, 0x07, 0xC0, 0x1F, 0x80, 0x7F, 0xC1, 0xE3, 0x83, 0x83, 0x87, 0x07,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x78, 0x01, 0xF8, 0x07,
  0x70, 0x7E, 0x71, 0xD8, 0x73, 0xB0, 0x7E, 0x60, 0xF8, 0xC0, 0xF1, 0x80,
  0xE3, 0x83, 0xC7, 0x0F, 0xC7, 0xF9, 0xC7, 0xE1, 0xC0, 0xFF, 0xFF, 0xDB,
  0x60, 0x03, 0x83, 0xC7, 0xC7, 0x83, 0x83, 0x83, 0x81, 0xC0, 0xE0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x3C, 0x0F, 0x03, 0xE0, 0x70, 0x08, 0xE0, 0x78,
  0x1F, 0x03, 0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x1C,
  0x0E, 0x1E, 0x1E, 0x3E, 0x1C, 0x08, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x61, 0x86, 0xF9, 0x9F, 0xFF, 0xFF, 0x1F, 0xF8, 0x01,
  0x80, 0x03, 0xC0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x38, 0x3C, 0x3C, 0x18,
  0x18, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x0F,
  0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x3C, 0xF3, 0x8E, 0x79, 0xC7, 0x18, 0xE3, 0x00, 0xFF, 0xFF,
  0xF0, 0x6F, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00,
  0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E,
  0x60, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x8C, 0x7E, 0x79,
  0xF9, 0xE7, 0xE3, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0x80,
  0x67, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0x00, 0xF8, 0x1E,
  0xC1, 0xE6, 0x0E, 0x30, 0x41, 0x82, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x0F, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0xFF, 0xC7,
  0x87, 0x1C, 0x0E, 0xE0, 0x3B, 0x80, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0x7F, 0xFD, 0xFF, 0xF0, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0x80, 0x7F, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0xE0, 0x1F, 0x01, 0xDC, 0x0E, 0xF0, 0xE3, 0xFF, 0x0F, 0xE0, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xE1, 0xCE, 0x0E, 0xE0, 0x77, 0x03, 0xF0, 0x1F, 0x80, 0xFF,
  0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xEF,
  0xCF, 0xFE, 0xF0, 0xFE, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x3C, 0x03, 0xE0, 0x7F, 0x0F, 0x7F, 0xE3, 0xF8, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x80,
  0xFF, 0xC7, 0xFF, 0x9C, 0x0E, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xE0, 0x03, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0x70, 0x39, 0x80,
  0xE7, 0x03, 0x9C, 0x0E, 0x38, 0x70, 0x7F, 0x80, 0xFC, 0x07, 0xF8, 0x3C,
  0xF1, 0xC0, 0xE6, 0x03, 0xB8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9E,
  0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0xC7, 0x87, 0x9C, 0x0E,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03,
  0x9F, 0xFE, 0x3F, 0xB0, 0x39, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0x6F, 0xFF, 0x60, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x18, 0x79, 0xF9, 0xE1, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC7, 0x8F, 0x1C, 0x78, 0xE1, 0xC3, 0x0E, 0x1C,
  0x00, 0x00, 0x10, 0x03, 0x00, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x0E,
  0x00, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x70,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0x00, 0x30, 0x0F, 0x03, 0xE1, 0xF8, 0x7E, 0x0F,
  0x80, 0xE0, 0x08, 0x00, 0xFE, 0x1F, 0xE3, 0xFE, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xC0, 0x38, 0xFE, 0x1F, 0x83, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x07, 0xC0, 0x78, 0x00, 0x07,
  0xF0, 0x1F, 0xFC, 0x3C, 0x1C, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0,
  0x07, 0xE0, 0x27, 0xE1, 0xFB, 0xE1, 0xCF, 0xE3, 0x87, 0xE3, 0x87, 0xE3,
  0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE1,
  0xFB, 0xE0, 0xFB, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x70, 0x0C,
  0x30, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x18, 0x3F, 0xFC, 0x3F,
  0xFC, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0xE0,
  0x07, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0x80, 0xEC, 0x07, 0x60, 0x1B, 0x00,
  0xD8, 0x0E, 0xC0, 0x77, 0xFF, 0x3F, 0xE1, 0xFF, 0xCC, 0x07, 0x60, 0x1B,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1D, 0x83, 0xEF, 0xFE, 0x7F,
  0xC0, 0x1F, 0x83, 0xFF, 0x1E, 0x3D, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x3F, 0x01, 0xB8, 0x1C, 0xE1, 0xE7, 0xFE, 0x0F,
  0xE0, 0xFF, 0x0F, 0xFC, 0xFF, 0xEC, 0x0F, 0xC0, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xFC, 0x3E, 0xFF, 0xCF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xFF, 0xBF, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x3F, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x1F, 0x83,
  0xFF, 0x1E, 0x3D, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x8F, 0xFC, 0x7F, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3F, 0x01, 0xB8, 0x1C, 0xE1, 0xE7, 0xFE, 0x0F, 0xE0, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xFF, 0xFF, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x77,
  0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F, 0x80, 0xC0, 0x3F, 0x00, 0xEC, 0x07,
  0x30, 0x1C, 0xC0, 0xE3, 0x03, 0x8C, 0x1C, 0x30, 0x70, 0xC3, 0x83, 0xFE,
  0x0F, 0xF0, 0x3F, 0xE0, 0xC3, 0x83, 0x0F, 0x0C, 0x1C, 0x30, 0x78, 0xC0,
  0xE3, 0x03, 0xCC, 0x07, 0x30, 0x1E, 0xC0, 0x3B, 0x00, 0xF0, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0xF0, 0x3F,
  0xC0, 0xFF, 0x87, 0xF6, 0x1B, 0xD8, 0x6F, 0x71, 0xBE, 0xCD, 0xFB, 0x37,
  0xEE, 0xDF, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x70, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x83, 0xF8, 0x3D, 0x83, 0xDC, 0x3C,
  0xC3, 0xCC, 0x3C, 0xE3, 0xC6, 0x3C, 0x63, 0xC7, 0x3C, 0x33, 0xC3, 0x3C,
  0x3B, 0xC1, 0xBC, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0x1F, 0x87,
  0xFE, 0x70, 0xEE, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E,
  0x07, 0xE0, 0x7F, 0x0F, 0x7F, 0xE3, 0xF8, 0xFF, 0x83, 0xFF, 0x8F, 0xFF,
  0x30, 0x1E, 0xC0, 0x3B, 0x00, 0x6C, 0x01, 0xF0, 0x06, 0xC0, 0x3B, 0x00,
  0xEC, 0x1F, 0x3F, 0xF8, 0xFF, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x0F, 0xC0,
  0xFF, 0xC7, 0x87, 0x9C, 0x0E, 0x60, 0x1B, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1D, 0x80, 0x67, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0xFF, 0x87,
  0xFF, 0x3F, 0xFD, 0x80, 0xEC, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x03, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8, 0x61, 0xC3, 0x07, 0x18, 0x38,
  0xC0, 0xE6, 0x07, 0x30, 0x1D, 0x80, 0xEC, 0x03, 0xE0, 0x1C, 0x0F, 0xE0,
  0xFF, 0xC3, 0x87, 0x9C, 0x0E, 0x70, 0x19, 0x80, 0x77, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9E, 0x1E, 0x3F, 0xF0, 0x7F,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0xE0, 0x7F, 0x0E, 0x7F, 0xE3,
  0xFC, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x30, 0x0C, 0x38,
  0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x1C, 0x38, 0x1C,
  0x38, 0x0C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xC1, 0xC3, 0xC3,
  0xC3, 0xE3, 0xC3, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0xC7, 0xE3, 0x47, 0x62,
  0x46, 0x62, 0x46, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x76, 0x6E, 0x76,
  0x6E, 0x76, 0x6E, 0x34, 0x2C, 0x34, 0x2C, 0x3C, 0x2C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x70, 0x0E, 0x70, 0x0E, 0x38, 0x1C, 0x38,
  0x1C, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x07, 0x60, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x0E,
  0x70, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0xE0,
  0x0F, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x18,
  0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x07, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x06, 0x00,
  0xE0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03,
  0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0xFF, 0xFF, 0x03, 0x00, 0x1E, 0x00, 0x78, 0x03, 0xB0, 0x0C, 0xC0,
  0x73, 0x81, 0x86, 0x0E, 0x1C, 0x30, 0x31, 0xC0, 0xE6, 0x01, 0xB8, 0x07,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0x07, 0x80, 0xFF,
  0x0F, 0xFC, 0xE0, 0x77, 0x03, 0x80, 0x0C, 0x00, 0x60, 0xFF, 0x3F, 0xFB,
  0xC0, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0xC1, 0x6F, 0xFB, 0x3F,
  0x98, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x78, 0xCF, 0xED,
  0xFE, 0xD0, 0x7E, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3E, 0x03, 0xE0, 0x7D, 0x0F, 0xDF, 0xEC, 0xFC, 0x0F, 0x01,
  0xFE, 0x1F, 0xF9, 0xC0, 0xEE, 0x03, 0x60, 0x1F, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x1C, 0x03, 0x70, 0x3B, 0xC3, 0xCF, 0xFC,
  0x1F, 0xC0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x31, 0xE3, 0x7F,
  0xB7, 0xFB, 0xE0, 0xBE, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xE0, 0x7F, 0x0B, 0x7F, 0xB3, 0xF3, 0x0F,
  0x03, 0xFC, 0x7F, 0xEE, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x07, 0xF0, 0xF7, 0xFE, 0x1F,
  0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0xC1, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x0E, 0x37, 0xFB, 0x7F, 0xBE, 0x0B, 0xE0, 0x7C,
  0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7E, 0x07, 0xE0, 0x77,
  0x9B, 0x7F, 0xB1, 0xE3, 0x00, 0x30, 0x03, 0x00, 0x70, 0x07, 0x3F, 0xE3,
  0xFC, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x78, 0xDF, 0xED,
  0xFE, 0xE0, 0x7E, 0x07, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x07, 0x00,
  0x3E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x7C, 0x07, 0x00, 0x40, 0x00, 0x00, 0x3F,
  0xF7, 0xFE, 0xFF, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0xF3, 0xFC, 0x7F, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x7E, 0x03, 0xB8, 0x1C, 0xE0, 0xF3, 0x83, 0x8E,
  0x1C, 0x38, 0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xF8, 0x38, 0xE0, 0xE1, 0xC3,
  0x83, 0x8E, 0x0E, 0x38, 0x1C, 0xE0, 0x3B, 0x80, 0xF0, 0xFF, 0x00, 0xFF,
  0x00, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0xC0, 0x01, 0xFF, 0x00, 0xFF, 0xCC, 0x73, 0x7F, 0xEE, 0x79, 0xF8, 0xC7,
  0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30,
  0xF0, 0xC3, 0xC3, 0x0F, 0x0C, 0x3C, 0x30, 0xF0, 0xC3, 0xC3, 0x0C, 0xC7,
  0x8D, 0xFE, 0xDF, 0xEF, 0x07, 0xE0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x30, 0x0F, 0x03, 0xFC, 0x7F, 0xEE, 0x07, 0xE0, 0x7C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07, 0xF0, 0xF7,
  0xFE, 0x1F, 0x80, 0xC7, 0x8D, 0xFE, 0xDF, 0xED, 0x07, 0xE0, 0x7E, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x07,
  0xD0, 0xFD, 0xFE, 0xCF, 0xCC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x1E, 0x37, 0xFB, 0x7F, 0xBE, 0x0B, 0xE0, 0x7C, 0x07, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x7E, 0x07, 0xF0, 0xB7, 0xFB,
  0x3F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0xE7, 0x87, 0x7F,
  0x3F, 0xFD, 0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x00, 0x0F, 0x83, 0xFF, 0x1F, 0xFD, 0xC0, 0xEE, 0x00, 0x70, 0x03, 0xC0,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xF0, 0x1B,
  0xC1, 0xCF, 0xFE, 0x3F, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x78, 0x01, 0xFE, 0x03, 0xF8, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x7E, 0x07, 0x70, 0xE7, 0xFE, 0x1F, 0x80, 0xC0, 0x0F, 0x80, 0x7E,
  0x01, 0xD8, 0x06, 0x70, 0x39, 0xC0, 0xE3, 0x03, 0x0E, 0x1C, 0x38, 0x70,
  0x61, 0x81, 0xCE, 0x07, 0x38, 0x0C, 0xC0, 0x3F, 0x00, 0xFC, 0x01, 0xE0,
  0x07, 0x80, 0xC1, 0x83, 0xE1, 0x83, 0xE3, 0xC7, 0x63, 0xC6, 0x63, 0xC6,
  0x63, 0xC6, 0x62, 0x46, 0x62, 0x46, 0x76, 0x6E, 0x76, 0x6C, 0x36, 0x6C,
  0x36, 0x6C, 0x34, 0x2C, 0x34, 0x2C, 0x3C, 0x2C, 0x3C, 0x38, 0x1C, 0x38,
  0x70, 0x0E, 0x38, 0x1E, 0x38, 0x1C, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70,
  0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70,
  0x0E, 0x70, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0xF0, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x70, 0x38, 0xE0, 0xE3, 0x87, 0x0E, 0x1C,
  0x1C, 0x60, 0x73, 0x80, 0xCE, 0x03, 0xB0, 0x0F, 0xC0, 0x1F, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x1F, 0x03, 0xF0, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0x80, 0x30, 0x07, 0x0F, 0xE0,
  0xFE, 0x00, 0xF0, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x38, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0x7F, 0x07, 0xF0, 0xF0, 0x0C, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0xFC, 0x0F, 0x00, 0x18, 0x1D,
  0xF8, 0x7F, 0xF1, 0xF8, 0xE7, 0xE3, 0xFF, 0x87, 0xE0, 0x02, 0x00,
};

const GFXglyph JetBrainsMono_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 22, 18, 7, -22 },
  { 12, 10, 9, 18, 4, -22 },
  { 24, 16, 22, 18, 1, -22 },
  { 68, 14, 30, 18, 2, -26 },
  { 121, 18, 22, 18, 0, -22 },
  { 171, 15, 22, 18, 2, -22 },
  { 213, 3, 9, 18, 7, -22 },
  { 217, 9, 29, 18, 6, -25 },
  { 250, 9, 29, 18, 3, -25 },
  { 283, 16, 15, 18, 1, -18 },
  { 313, 14, 14, 18, 2, -17 },
  { 338, 6, 10, 18, 5, -5 },
  { 346, 10, 2, 18, 4, -11 },
  { 349, 4, 5, 18, 7, -5 },
  { 352, 14, 28, 18, 2, -25 },
  { 401, 14, 22, 18, 2, -22 },
  { 440, 13, 22, 18, 3, -22 },
  { 476, 14, 22, 18, 2, -22 },
  { 515, 13, 22, 18, 2, -22 },
  { 551, 13, 22, 18, 2, -22 },
  { 587, 12, 22, 18, 3, -22 },
  { 620, 14, 22, 18, 2, -22 },
  { 659, 14, 22, 18, 2, -22 },
  { 698, 14, 22, 18, 2, -22 },
  { 737, 14, 22, 18, 2, -22 },
  { 776, 4, 17, 18, 7, -17 },
  { 785, 7, 22, 18, 5, -17 },
  { 805, 12, 16, 18, 3, -18 },
  { 829, 12, 10, 18, 3, -15 },
  { 844, 12, 16, 18, 3, -18 },
  { 868, 11, 22, 18, 4, -22 },
  { 899, 16, 27, 18, 1, -22 },
  { 953, 16, 22, 18, 1, -22 },
  { 997, 13, 22, 18, 3, -22 },
  { 1033, 13, 22, 18, 3, -22 },
  { 1069, 12, 22, 18, 3, -22 },
  { 1102, 13, 22, 18, 3, -22 },
  { 1138, 13, 22, 18, 3, -22 },
  { 1174, 13, 22, 18, 3, -22 },
  { 1210, 12, 22, 18, 3, -22 },
  { 1243, 12, 22, 18, 3, -22 },
  { 1276, 14, 22, 18, 1, -22 },
  { 1315, 14, 22, 18, 3, -22 },
  { 1354, 13, 22, 18, 3, -22 },
  { 1390, 14, 22, 18, 2, -22 },
  { 1429, 12, 22, 18, 3, -22 },
  { 1462, 12, 22, 18, 3, -22 },
  { 1495, 14, 22, 18, 3, -22 },
  { 1534, 14, 27, 18, 2, -22 },
  { 1582, 13, 22, 18, 3, -22 },
  { 1618, 14, 22, 18, 2, -22 },
  { 1657, 14, 22, 18, 2, -22 },
  { 1696, 12, 22, 18, 3, -22 },
  { 1729, 16, 22, 18, 1, -22 },
  { 1773, 16, 22, 18, 1, -22 },
  { 1817, 16, 22, 18, 1, -22 },
  { 1861, 16, 22, 18, 1, -22 },
  { 1905, 12, 22, 18, 3, -22 },
  { 1938, 8, 28, 18, 6, -25 },
  { 1966, 14, 28, 18, 2, -25 },
  { 2015, 8, 28, 18, 4, -25 },
  { 2043, 14, 12, 18, 2, -22 },
  { 2064, 14, 2, 18, 2, 1 },
  { 2068, 7, 5, 18, 5, -24 },
  { 2073, 13, 17, 18, 2, -17 },
  { 2101, 12, 22, 18, 3, -22 },
  { 2134, 13, 17, 18, 3, -17 },
  { 2162, 12, 22, 18, 3, -22 },
  { 2195, 12, 17, 18, 3, -17 },
  { 2221, 14, 22, 18, 2, -22 },
  { 2260, 12, 22, 18, 3, -17 },
  { 2293, 12, 22, 18, 3, -22 },
  { 2326, 14, 23, 18, 3, -23 },
  { 2367, 11, 28, 18, 3, -23 },
  { 2406, 14, 22, 18, 3, -22 },
  { 2445, 16, 22, 18, 1, -22 },
  { 2489, 14, 17, 18, 2, -17 },
  { 2519, 12, 17, 18, 3, -17 },
  { 2545, 12, 17, 18, 3, -17 },
  { 2571, 12, 22, 18, 3, -17 },
  { 2604, 12, 22, 18, 3, -17 },
  { 2637, 13, 17, 18, 3, -17 },
  { 2665, 13, 17, 18, 3, -17 },
  { 2693, 14, 21, 18, 2, -21 },
  { 2730, 12, 17, 18, 3, -17 },
  { 2756, 14, 17, 18, 2, -17 },
  { 2786, 16, 17, 18, 1, -17 },
  { 2820, 16, 17, 18, 1, -17 },
  { 2854, 14, 22, 18, 2, -17 },
  { 2893, 12, 17, 18, 3, -17 },
  { 2919, 12, 28, 18, 3, -25 },
  { 2961, 2, 28, 18, 8, -25 },
  { 2968, 12, 28, 18, 3, -25 },
  { 3010, 14, 7, 18, 2, -14 },
};

const GFXfont JetBrainsMono_Regular30pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular30pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular30pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _JETBRAINSMONO_REGULAR30PT7B_H_
