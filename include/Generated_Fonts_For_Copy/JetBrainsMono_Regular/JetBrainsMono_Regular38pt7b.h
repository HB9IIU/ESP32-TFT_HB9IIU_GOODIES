#ifndef _JETBRAINSMONO_REGULAR38PT7B_H_
#define _JETBRAINSMONO_REGULAR38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xE1, 0xFC, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x70,
  0x01, 0xC0, 0xE0, 0x1C, 0x0C, 0x01, 0xC0, 0xC0, 0x18, 0x1C, 0x03, 0x81,
  0xC0, 0x38, 0x1C, 0x03, 0x81, 0x80, 0x38, 0x18, 0x3F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x07, 0x03, 0x80, 0x70, 0x38, 0x07, 0x03, 0x00, 0x60, 0x30, 0x06,
  0x07, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0x0C, 0x0E, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xC0, 0xC0,
  0x18, 0x0C, 0x01, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x7F,
  0xF0, 0x7F, 0xFC, 0x7D, 0xDF, 0x3C, 0xE7, 0x9C, 0x71, 0xEE, 0x38, 0xFF,
  0x1C, 0x03, 0x8E, 0x01, 0xE7, 0x00, 0xF3, 0x80, 0x3F, 0xC0, 0x1F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x0E, 0xF8, 0x07, 0x3C, 0x03,
  0x8F, 0x01, 0xC7, 0x80, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0xFF, 0x1C, 0x7B,
  0xCE, 0x79, 0xFF, 0xF8, 0x7F, 0xFC, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3B, 0xFC, 0x01,
  0xBF, 0xF0, 0x1D, 0xC3, 0x81, 0xCC, 0x1C, 0x0C, 0x60, 0xE0, 0xE3, 0x07,
  0x0E, 0x18, 0x38, 0x60, 0xC1, 0xC7, 0x07, 0x0E, 0x70, 0x3F, 0xE7, 0x00,
  0xFF, 0x38, 0x01, 0xE3, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C,
  0x20, 0x01, 0xCF, 0xE0, 0x0E, 0xFF, 0x80, 0xE7, 0x1E, 0x0E, 0x38, 0x70,
  0x61, 0x83, 0x87, 0x0C, 0x1C, 0x70, 0x60, 0xE3, 0x03, 0x07, 0x38, 0x1C,
  0x3B, 0x80, 0xF7, 0xD8, 0x03, 0xFD, 0xC0, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xC1, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0xEF, 0x1C,
  0x1E, 0xF1, 0xE1, 0xCF, 0x0F, 0x3C, 0xF0, 0x7F, 0x8F, 0x03, 0xF0, 0xF0,
  0x3F, 0x0F, 0x01, 0xE0, 0xF0, 0x1F, 0x0F, 0x03, 0xF0, 0xF0, 0x7F, 0x87,
  0xFF, 0xBC, 0x3F, 0xF1, 0xC1, 0xFC, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0x77,
  0x77, 0x00, 0x20, 0x1C, 0x0F, 0x83, 0xF0, 0xF8, 0x3C, 0x0F, 0x01, 0xE0,
  0x78, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x1E,
  0x01, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC,
  0x0F, 0x80, 0x70, 0x02, 0xC0, 0x0F, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0xF8, 0x3F, 0x0F, 0xE0, 0xF8, 0x0F, 0x00, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x04, 0x07, 0x02, 0x78, 0x70, 0xF7, 0xE6, 0x3F, 0xFF, 0xAF, 0xF0, 0xFF,
  0xF8, 0x00, 0x70, 0x00, 0x0F, 0x80, 0x01, 0xDC, 0x00, 0x3D, 0xE0, 0x07,
  0x8E, 0x00, 0x78, 0xF0, 0x0F, 0x07, 0x81, 0xE0, 0x3C, 0x06, 0x03, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1F, 0x1F, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0xFB, 0xF7, 0xFF,
  0xCF, 0x80, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F,
  0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x1C, 0x7F, 0x1F,
  0x3F, 0x8F, 0x9F, 0xC3, 0x8F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1E, 0xE0, 0x1E, 0x78, 0x1F,
  0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFB, 0x80, 0x7C, 0xE0, 0x3E, 0x38, 0x0E, 0x0E, 0x03, 0x03,
  0x80, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xCF, 0x00, 0xF7, 0x80, 0x3B, 0x80,
  0x1D, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0xF8, 0x07, 0xFC,
  0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1E,
  0x7F, 0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x07, 0x3C, 0x07, 0x78, 0x07,
  0x78, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x7F, 0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xCE, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0xFE, 0x0E, 0xFF, 0x87, 0xFF, 0xE3, 0xE0, 0xF9, 0xE0, 0x3C, 0xE0, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3F, 0xC0, 0x1C, 0xE0, 0x1E, 0x78, 0x1F, 0x1F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0xBF, 0x07, 0xFF, 0xE3, 0xFF, 0xFB, 0xE0, 0x3D, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0xC0, 0x1F, 0xE0, 0x1E, 0x78, 0x1F, 0x1F, 0xFF, 0x07, 0xFF, 0x01,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xC7, 0x80,
  0xF3, 0x80, 0x39, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x07, 0x3C, 0x07, 0x8F,
  0x07, 0x83, 0xC7, 0x80, 0xFF, 0x80, 0x3F, 0x00, 0x3F, 0xE0, 0x3C, 0xF8,
  0x3C, 0x1E, 0x3C, 0x07, 0xBC, 0x01, 0xDE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0E, 0x78, 0x0F, 0x3F, 0xFF, 0x0F, 0xFF, 0x01,
  0xFF, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xEF, 0x80,
  0xF7, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x79, 0xF8, 0xFC, 0x7F, 0xFE,
  0x1F, 0xFE, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0x7D, 0xFB, 0xFF, 0xE7, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7D, 0xFB, 0xFF, 0xE7, 0xC0, 0x1F, 0x1F, 0x8F,
  0xE7, 0xE1, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x1F, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE0, 0xE0, 0xF0,
  0x78, 0x38, 0x3C, 0x00, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x38, 0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x80, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xC0, 0x00, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x18, 0x00, 0x08,
  0x00, 0x00, 0xFE, 0x03, 0xFF, 0x0F, 0xFE, 0x01, 0xFC, 0x00, 0xF8, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0xF8, 0x7F, 0xC1, 0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1E, 0x01,
  0xE7, 0x80, 0x1C, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x81, 0xFB, 0xF0, 0x7F, 0xBE, 0x0E, 0x1F, 0xC3, 0x81,
  0xF8, 0x70, 0x3F, 0x0E, 0x07, 0xE1, 0xC0, 0xFC, 0x38, 0x1F, 0x87, 0x03,
  0xF0, 0xE0, 0x7E, 0x1C, 0x0F, 0xC3, 0x81, 0xF8, 0x78, 0x3F, 0x07, 0xFB,
  0xE0, 0x7F, 0x7C, 0x07, 0x8F, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x3C, 0x70, 0x07, 0x0F, 0x00, 0xE0, 0xE0, 0x1C, 0x1C,
  0x07, 0x83, 0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x70, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x1E,
  0x70, 0x01, 0xCE, 0x00, 0x3B, 0xC0, 0x07, 0xF8, 0x00, 0xF0, 0xFF, 0x80,
  0xFF, 0xF0, 0xFF, 0xFC, 0xE0, 0xFC, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x3C, 0xFF, 0xF8,
  0xFF, 0xF0, 0xFF, 0xFC, 0xE0, 0x3E, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x3E,
  0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0x83, 0xE7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x1C, 0xF0, 0x1E, 0x7C, 0x1F, 0x1F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC,
  0xF0, 0x7E, 0xF0, 0x1F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0x83, 0xE7, 0x80, 0xF3, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC3, 0xFF, 0xE1, 0xFF, 0xF0, 0xFF, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xC0, 0x1C, 0xF0, 0x1E, 0x7C, 0x1F, 0x1F,
  0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x70, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x1E, 0x78, 0x1F, 0x3F, 0xFF, 0x0F,
  0xFF, 0x01, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0,
  0x3C, 0xF0, 0x0F, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xFF, 0xF0, 0x3F, 0xF8, 0x0F,
  0xFE, 0x03, 0xC3, 0xC0, 0xF0, 0x70, 0x3C, 0x1E, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xF0, 0x1C, 0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3C, 0xF0, 0x07,
  0xBC, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFB, 0x03, 0xBD,
  0xC1, 0xFF, 0xE0, 0xFF, 0xB0, 0xEF, 0xDC, 0x77, 0xEE, 0x3B, 0xF3, 0x19,
  0xF9, 0xDC, 0xFC, 0xEE, 0x7E, 0x36, 0x3F, 0x1F, 0x1F, 0x8F, 0x8F, 0xC3,
  0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x70, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x07, 0xFC,
  0x07, 0xEE, 0x07, 0xFE, 0x07, 0xF7, 0x07, 0xF7, 0x07, 0xF7, 0x07, 0xF3,
  0x87, 0xF3, 0x87, 0xF3, 0x87, 0xF1, 0xC7, 0xF1, 0xC7, 0xF1, 0xC7, 0xF0,
  0xE7, 0xF0, 0xE7, 0xF0, 0xE7, 0xF0, 0x77, 0xF0, 0x77, 0xF0, 0x7F, 0xF0,
  0x3F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0x07,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFE, 0x7C, 0x1E, 0x78, 0x0F, 0x70, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x7C,
  0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xFF, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xF3, 0xC0, 0xFC, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x07,
  0xBC, 0x1F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xFF, 0xC0, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF0,
  0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80, 0x3B, 0xC0,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xE0,
  0x1E, 0x78, 0x1F, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFF, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F,
  0xBC, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xEF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F, 0x3F, 0xFF, 0xCF, 0xFF, 0xC3, 0xFF,
  0xE0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xF0, 0xF0, 0x3C,
  0x3C, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x1F, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83,
  0xE7, 0x80, 0xF3, 0x80, 0x3D, 0xC0, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0, 0x1F, 0xF0,
  0x01, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0x78, 0x0F, 0x3F, 0xFF, 0x0F,
  0xFF, 0x81, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x0F, 0x78,
  0x1F, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF8, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x3C, 0xF0, 0x07, 0x8E, 0x00, 0xE1,
  0xC0, 0x1C, 0x38, 0x07, 0x87, 0x80, 0xF0, 0x70, 0x1C, 0x0E, 0x03, 0x81,
  0xC0, 0xF0, 0x3C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x70, 0x0E, 0x1E, 0x01,
  0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x0F, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0xE0, 0x70, 0x3F, 0x03, 0x81, 0xF8, 0x3E, 0x1F, 0xE1, 0xB0,
  0xEF, 0x0D, 0x87, 0x38, 0x6C, 0x39, 0xC3, 0x61, 0xCE, 0x1B, 0x0E, 0x70,
  0xD8, 0x73, 0x86, 0xC3, 0x9C, 0x76, 0x1C, 0xE3, 0x38, 0xE7, 0x18, 0xCE,
  0x3C, 0xC6, 0x70, 0xE6, 0x33, 0x87, 0x31, 0x9C, 0x39, 0x8C, 0xE1, 0xCC,
  0x67, 0x0E, 0xE3, 0x38, 0x76, 0x19, 0xC3, 0xB0, 0xEC, 0x1D, 0x83, 0xE0,
  0x6C, 0x1F, 0x03, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8, 0x3E, 0x07, 0xC1,
  0xF0, 0x3E, 0x0F, 0x80, 0xF0, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x1E,
  0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0x80, 0x78, 0xF0, 0x0F,
  0x1C, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0xF7, 0x00, 0x1C,
  0xF0, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xF0, 0xF0,
  0x00, 0x77, 0x00, 0x0F, 0x78, 0x00, 0xE3, 0x80, 0x1E, 0x3C, 0x01, 0xC1,
  0xC0, 0x3C, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0x07, 0x80, 0x70, 0x70,
  0x07, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0xDE, 0x00, 0x1D, 0xC0, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x7F, 0xFF,
  0xFF, 0xF0, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x71,
  0x80, 0x38, 0xE0, 0x1C, 0x70, 0x1C, 0x1C, 0x0E, 0x0E, 0x0E, 0x03, 0x87,
  0x01, 0xC7, 0x00, 0x73, 0x80, 0x3B, 0x80, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x78, 0x3C, 0x1C, 0x1F, 0x03, 0xFC, 0x07,
  0xFF, 0x07, 0xFF, 0xC7, 0x81, 0xF3, 0x80, 0x79, 0xC0, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x87, 0xFF, 0xCF, 0xFF, 0xEF, 0xC0, 0x77, 0x80,
  0x3B, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70, 0x07, 0xBC, 0x07, 0xDF,
  0x8F, 0xE7, 0xFF, 0x71, 0xFF, 0x38, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE7, 0xF0, 0xF7,
  0xFC, 0x7F, 0xFF, 0x3F, 0x07, 0xDF, 0x01, 0xEF, 0x00, 0x77, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1D, 0xF0, 0x1E, 0xFC, 0x1F, 0x7F,
  0xFF, 0x3D, 0xFF, 0x1E, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xFE, 0x0F, 0xFF,
  0x8F, 0x83, 0xE7, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x1F, 0xE0, 0x0F, 0x78, 0x07, 0x3E, 0x07, 0x8F, 0xFF, 0x83, 0xFF,
  0x80, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x0F, 0xC7, 0x3F, 0xF7, 0x3F, 0xF7, 0x78,
  0x1F, 0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0x70, 0x0F, 0x78, 0x1F, 0x7F, 0xF7, 0x3F, 0xF7, 0x0F, 0xE7, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x01, 0xE7, 0x00, 0xF7, 0x80, 0x3B,
  0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0x70, 0x07, 0x3C,
  0x07, 0x8F, 0xFF, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xFC, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F,
  0xE7, 0x3F, 0xF7, 0x3F, 0xF7, 0x7C, 0x1F, 0x78, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0x70, 0x0F, 0x78, 0x0F, 0x7E, 0x7F, 0x3F, 0xF7, 0x1F,
  0xE7, 0x07, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x1F, 0x1F, 0xFE, 0x1F, 0xFC, 0x1F, 0xF0, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF3, 0xF8, 0xF7,
  0xFC, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x10, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x0F, 0xCF, 0xFE,
  0x3F, 0xF0, 0xFF, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0xE0, 0x0F, 0x70,
  0x0F, 0x38, 0x07, 0x9C, 0x07, 0x8E, 0x07, 0x87, 0x03, 0xC3, 0x83, 0xC1,
  0xC3, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF8, 0x1C, 0x1E, 0x0E, 0x0F,
  0x07, 0x03, 0xC3, 0x80, 0xF1, 0xC0, 0x78, 0xE0, 0x1E, 0x70, 0x07, 0xB8,
  0x03, 0xDC, 0x00, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xEF, 0x1F, 0x7F, 0xDF, 0xBC, 0xE9, 0xFC, 0x38, 0x7E, 0x1C,
  0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8,
  0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87,
  0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x1C, 0x38, 0xF3,
  0xF8, 0xF7, 0xFC, 0xFF, 0xFE, 0xFC, 0x1F, 0xF8, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F,
  0x83, 0xE7, 0x80, 0xF7, 0x80, 0x3B, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0E, 0x70, 0x0F, 0x3E, 0x0F, 0x8F, 0xFF, 0x83, 0xFF, 0x80,
  0xFF, 0x00, 0xF3, 0xF8, 0x7B, 0xFE, 0x3F, 0xFF, 0x9F, 0x83, 0xEF, 0x80,
  0xF7, 0x80, 0x3B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0E,
  0xF8, 0x0F, 0x7E, 0x0F, 0xBF, 0xFF, 0x9E, 0xFF, 0xCF, 0x3F, 0x87, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0xC7, 0x3F, 0xF7, 0x3F, 0xF7, 0x7C, 0x1F, 0x78, 0x0F,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x0F,
  0x78, 0x1F, 0x3F, 0xF7, 0x3F, 0xF7, 0x0F, 0xE7, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0xF3, 0xF8,
  0xF7, 0xFC, 0xFF, 0xFE, 0xF8, 0x1E, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x0F, 0xFF, 0xCF, 0x01,
  0xE7, 0x80, 0x7B, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0xF0, 0x07, 0xBC, 0x07, 0x9F, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF,
  0xC0, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xE0,
  0x07, 0xF8, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x0F,
  0x7C, 0x1E, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0xF0, 0xF0, 0x01, 0xEE, 0x00,
  0x39, 0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0x80, 0x38, 0x70, 0x0F, 0x0F, 0x01,
  0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0xC1, 0xE0, 0x38, 0x38, 0x07, 0x07,
  0x00, 0xF1, 0xE0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x3D, 0xE0, 0x03, 0xB8,
  0x00, 0x77, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0xE0, 0x70,
  0x37, 0x07, 0x07, 0x70, 0xF0, 0x77, 0x0F, 0x87, 0x70, 0xD8, 0x77, 0x0D,
  0x87, 0x70, 0xD8, 0x63, 0x0D, 0x8E, 0x39, 0x98, 0xE3, 0x99, 0xCE, 0x39,
  0x8C, 0xE3, 0x98, 0xCE, 0x39, 0x8C, 0xC3, 0x98, 0xCC, 0x19, 0x8D, 0xC1,
  0xF0, 0xDC, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xF0, 0x78,
  0x0F, 0x07, 0x80, 0xF8, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x0F, 0x07,
  0x81, 0xE0, 0xE0, 0x1E, 0x3C, 0x01, 0xEF, 0x00, 0x3D, 0xC0, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x0F, 0x78,
  0x03, 0xC7, 0x00, 0x78, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x1E,
  0x3C, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F,
  0x3C, 0x01, 0xC3, 0xC0, 0x78, 0x78, 0x0F, 0x07, 0x01, 0xC0, 0xF0, 0x78,
  0x1E, 0x0F, 0x01, 0xC1, 0xC0, 0x3C, 0x78, 0x03, 0x8E, 0x00, 0x79, 0xC0,
  0x0F, 0x78, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x1F, 0xC0, 0x1F,
  0xE0, 0x1F, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x7F, 0xE0, 0x3F, 0xC0, 0x1F, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xC0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x3C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0x80, 0x00, 0x1F, 0x01, 0xDF, 0xF0, 0x77, 0xFC,
  0x1D, 0xC7, 0x87, 0xF0, 0xFB, 0xFC, 0x1F, 0xFF, 0x03, 0xF8, 0x00, 0x10,
};

const GFXglyph JetBrainsMono_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 5, 28, 23, 9, -28 },
  { 19, 11, 12, 23, 6, -28 },
  { 36, 20, 28, 23, 1, -28 },
  { 106, 17, 38, 23, 3, -33 },
  { 187, 21, 28, 23, 1, -28 },
  { 261, 20, 28, 23, 2, -28 },
  { 331, 4, 12, 23, 9, -28 },
  { 337, 11, 37, 23, 7, -32 },
  { 388, 12, 37, 23, 4, -32 },
  { 444, 20, 19, 23, 1, -23 },
  { 492, 18, 17, 23, 2, -21 },
  { 531, 8, 12, 23, 6, -6 },
  { 543, 12, 3, 23, 5, -14 },
  { 548, 7, 6, 23, 8, -6 },
  { 554, 17, 36, 23, 3, -32 },
  { 631, 17, 28, 23, 3, -28 },
  { 691, 18, 28, 23, 3, -28 },
  { 754, 17, 28, 23, 3, -28 },
  { 814, 16, 28, 23, 3, -28 },
  { 870, 16, 28, 23, 3, -28 },
  { 926, 17, 28, 23, 3, -28 },
  { 986, 17, 28, 23, 3, -28 },
  { 1046, 17, 28, 23, 3, -28 },
  { 1106, 17, 28, 23, 3, -28 },
  { 1166, 17, 28, 23, 3, -28 },
  { 1226, 7, 21, 23, 8, -21 },
  { 1245, 9, 27, 23, 6, -21 },
  { 1276, 17, 21, 23, 3, -23 },
  { 1321, 17, 13, 23, 3, -19 },
  { 1349, 17, 21, 23, 3, -23 },
  { 1394, 14, 28, 23, 5, -28 },
  { 1443, 19, 35, 23, 2, -28 },
  { 1527, 19, 28, 23, 2, -28 },
  { 1594, 16, 28, 23, 4, -28 },
  { 1650, 17, 28, 23, 3, -28 },
  { 1710, 16, 28, 23, 3, -28 },
  { 1766, 16, 28, 23, 4, -28 },
  { 1822, 16, 28, 23, 4, -28 },
  { 1878, 17, 28, 23, 3, -28 },
  { 1938, 15, 28, 23, 4, -28 },
  { 1991, 15, 28, 23, 4, -28 },
  { 2044, 17, 28, 23, 2, -28 },
  { 2104, 18, 28, 23, 3, -28 },
  { 2167, 16, 28, 23, 4, -28 },
  { 2223, 17, 28, 23, 3, -28 },
  { 2283, 16, 28, 23, 3, -28 },
  { 2339, 16, 28, 23, 3, -28 },
  { 2395, 18, 28, 23, 3, -28 },
  { 2458, 17, 35, 23, 3, -28 },
  { 2533, 18, 28, 23, 3, -28 },
  { 2596, 17, 28, 23, 3, -28 },
  { 2656, 19, 28, 23, 2, -28 },
  { 2723, 16, 28, 23, 3, -28 },
  { 2779, 19, 28, 23, 2, -28 },
  { 2846, 21, 28, 23, 1, -28 },
  { 2920, 19, 28, 23, 2, -28 },
  { 2987, 20, 28, 23, 1, -28 },
  { 3057, 17, 28, 23, 3, -28 },
  { 3117, 9, 36, 23, 8, -32 },
  { 3158, 17, 36, 23, 3, -32 },
  { 3235, 9, 36, 23, 6, -32 },
  { 3276, 17, 15, 23, 3, -28 },
  { 3308, 19, 3, 23, 2, 1 },
  { 3316, 8, 5, 23, 7, -30 },
  { 3321, 17, 21, 23, 2, -21 },
  { 3366, 17, 28, 23, 3, -28 },
  { 3426, 17, 21, 23, 3, -21 },
  { 3471, 16, 28, 23, 3, -28 },
  { 3527, 17, 21, 23, 3, -21 },
  { 3572, 18, 28, 23, 2, -28 },
  { 3635, 16, 28, 23, 3, -21 },
  { 3691, 16, 28, 23, 3, -28 },
  { 3747, 18, 30, 23, 3, -30 },
  { 3815, 14, 37, 23, 3, -30 },
  { 3880, 17, 28, 23, 4, -28 },
  { 3940, 20, 28, 23, 1, -28 },
  { 4010, 17, 21, 23, 3, -21 },
  { 4055, 16, 21, 23, 3, -21 },
  { 4097, 17, 21, 23, 3, -21 },
  { 4142, 17, 28, 23, 3, -21 },
  { 4202, 16, 28, 23, 3, -21 },
  { 4258, 16, 21, 23, 4, -21 },
  { 4300, 17, 21, 23, 3, -21 },
  { 4345, 18, 27, 23, 2, -27 },
  { 4406, 16, 21, 23, 3, -21 },
  { 4448, 19, 21, 23, 2, -21 },
  { 4498, 20, 21, 23, 1, -21 },
  { 4551, 19, 21, 23, 2, -21 },
  { 4601, 19, 28, 23, 2, -21 },
  { 4668, 16, 21, 23, 3, -21 },
  { 4710, 17, 36, 23, 3, -32 },
  { 4787, 3, 36, 23, 10, -32 },
  { 4801, 17, 36, 23, 3, -32 },
  { 4878, 18, 8, 23, 2, -17 },
};

const GFXfont JetBrainsMono_Regular38pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular38pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular38pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _JETBRAINSMONO_REGULAR38PT7B_H_
