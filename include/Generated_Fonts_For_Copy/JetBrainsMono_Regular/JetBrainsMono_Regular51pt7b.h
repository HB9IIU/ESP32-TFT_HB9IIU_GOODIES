#ifndef _JETBRAINSMONO_REGULAR51PT7B_H_
#define _JETBRAINSMONO_REGULAR51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C,
  0x1C, 0x1C, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x7F, 0x7F, 0xFF,
  0x7F, 0x7E, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFE, 0x0F, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81,
  0xFF, 0x03, 0xFE, 0x03, 0xBC, 0x07, 0x00, 0x00, 0x78, 0x07, 0x00, 0x0E,
  0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0,
  0x01, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0xF0, 0x01, 0xE0,
  0x1E, 0x00, 0x3C, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01,
  0xC0, 0x03, 0xC0, 0x38, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xC0, 0x1C,
  0x07, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0x70, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xF1, 0xC7, 0xC7, 0xC3,
  0x87, 0xCF, 0x87, 0x0F, 0x9E, 0x0E, 0x0F, 0x3C, 0x1C, 0x1E, 0x78, 0x38,
  0x00, 0xF0, 0x70, 0x01, 0xF0, 0xE0, 0x03, 0xE1, 0xC0, 0x03, 0xE3, 0x80,
  0x07, 0xF7, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x03, 0x9F, 0x80,
  0x07, 0x1F, 0x80, 0x0E, 0x1F, 0x00, 0x1C, 0x1F, 0x00, 0x38, 0x3E, 0x00,
  0x70, 0x7F, 0xC0, 0xE0, 0xFF, 0x81, 0xC1, 0xFF, 0x83, 0x83, 0xFF, 0x07,
  0x07, 0x9F, 0x0E, 0x1F, 0x3F, 0x1C, 0x7E, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x79, 0xFF, 0x80, 0x07, 0x9F, 0xFE,
  0x00, 0x79, 0xF0, 0xF8, 0x03, 0x8F, 0x03, 0xC0, 0x3C, 0x78, 0x1E, 0x03,
  0xC3, 0xC0, 0xF0, 0x1C, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1E, 0x07,
  0x81, 0xE1, 0xE0, 0x3C, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0xF0, 0x0F, 0x87,
  0xCF, 0x00, 0x3F, 0xFC, 0x78, 0x01, 0xFF, 0xC7, 0x80, 0x03, 0xFC, 0x78,
  0x00, 0x02, 0x03, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1E, 0x3F, 0xE0, 0x00,
  0xE3, 0xFF, 0x80, 0x0F, 0x3F, 0xFE, 0x00, 0xF1, 0xE0, 0xF0, 0x07, 0x0F,
  0x03, 0xC0, 0x78, 0x70, 0x1E, 0x07, 0x83, 0x80, 0xF0, 0x38, 0x1C, 0x07,
  0x83, 0xC0, 0xE0, 0x3C, 0x3C, 0x07, 0x01, 0xE3, 0xC0, 0x38, 0x0F, 0x1E,
  0x01, 0xE0, 0xF9, 0xE0, 0x0F, 0x8F, 0x9E, 0x00, 0x3F, 0xFC, 0xF0, 0x00,
  0xFF, 0xCF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0x87, 0xF0, 0x0F, 0xC0,
  0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFC,
  0xF8, 0x0F, 0xBE, 0x1F, 0x03, 0xEF, 0x83, 0xE1, 0xF3, 0xC0, 0xF8, 0x78,
  0xF0, 0x1F, 0x3E, 0x3C, 0x03, 0xEF, 0x0F, 0x00, 0xFF, 0xC3, 0xC0, 0x1F,
  0xE0, 0xF0, 0x03, 0xF8, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x03, 0xE0,
  0x0F, 0xE0, 0xF8, 0x07, 0xFC, 0x3F, 0x03, 0xFF, 0x87, 0xFF, 0xFB, 0xE1,
  0xFF, 0xFC, 0x7C, 0x3F, 0xFE, 0x0F, 0x83, 0xFE, 0x03, 0xE0, 0x08, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x7B, 0xC0, 0x00,
  0x01, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x1F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x03, 0xF8,
  0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x3E, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x0F,
  0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x03, 0x00, 0xF0, 0x04,
  0x78, 0x1E, 0x07, 0xDF, 0xE1, 0xC3, 0xFB, 0xFE, 0x39, 0xFF, 0xFF, 0xF6,
  0x7F, 0xE1, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xC7,
  0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x03,
  0xF0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0x00, 0x3C, 0x00, 0x60, 0x02,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xE1, 0xFC, 0x3F, 0x07, 0xE1, 0xF8, 0x3F, 0x07, 0xE0, 0xF8,
  0x3F, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x3F, 0xBF, 0xDF, 0xEF,
  0xFF, 0xF9, 0xFC, 0xFC, 0x08, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83,
  0xFC, 0x7F, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0xF8,
  0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x38,
  0x3F, 0xF0, 0xF8, 0x7F, 0xE3, 0xF0, 0xFF, 0xC7, 0xE1, 0xFF, 0x8F, 0xC3,
  0xFF, 0x0F, 0x87, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xDF,
  0x00, 0x07, 0xBE, 0x00, 0x0F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0xFC, 0x7C,
  0x03, 0xF0, 0xFF, 0x3F, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xF3, 0xC0, 0x1F, 0xC7, 0x80, 0x3F, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0xE0, 0x3C, 0x01, 0x80, 0x78, 0x02, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xFC, 0xFF, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBF, 0x00, 0x3E, 0x7E, 0x01,
  0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x7C, 0x7C, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x7C, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x7F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF3, 0xFE, 0x07,
  0xDF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xFC, 0x07, 0xE7, 0xE0,
  0x0F, 0xDF, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00,
  0x3E, 0x7E, 0x01, 0xF8, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x9F, 0xC0, 0x1F, 0x7F, 0xF0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x3F, 0x80, 0xFC, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x80, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFC,
  0x7F, 0x07, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x78, 0x00,
  0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x0F, 0xC1, 0xF0, 0x0F, 0xEF, 0xC0,
  0x0F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xFC, 0x03,
  0xF0, 0xFC, 0x0F, 0xC0, 0x7C, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0xF0,
  0x00, 0xFB, 0xE0, 0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x03,
  0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0,
  0x00, 0x04, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xE3, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x3E, 0x3F, 0x00,
  0x7E, 0x3F, 0x81, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0x7C, 0x07, 0xFE,
  0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x08, 0x3F,
  0x3F, 0xDF, 0xEF, 0xFF, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8,
  0xFE, 0xFF, 0x7F, 0xFF, 0xDF, 0xE7, 0xE0, 0x40, 0x07, 0x03, 0xF0, 0xFF,
  0x1F, 0xF3, 0xFE, 0x7F, 0x87, 0xF0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x87, 0xF0, 0xFC, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x70, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x3F, 0x03, 0xFF, 0xC0, 0xFF, 0xE0, 0x3F, 0xF0, 0x0F, 0xF0,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x0F, 0x3C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x03, 0xC3,
  0xFC, 0x01, 0xFE, 0x7F, 0x80, 0x7F, 0xEF, 0xF0, 0x1F, 0xFD, 0xFE, 0x03,
  0xC0, 0xFF, 0xC0, 0xF8, 0x0F, 0xF8, 0x1E, 0x01, 0xFF, 0x03, 0xC0, 0x3F,
  0xE0, 0x78, 0x07, 0xFC, 0x0F, 0x00, 0xFF, 0x81, 0xE0, 0x1F, 0xF0, 0x3C,
  0x03, 0xFE, 0x07, 0x80, 0x7F, 0xC0, 0xF0, 0x0F, 0xF8, 0x1E, 0x01, 0xFF,
  0x03, 0xC0, 0x3F, 0xE0, 0x7C, 0x07, 0xFC, 0x07, 0x80, 0xFF, 0x80, 0xF8,
  0x7F, 0xF0, 0x1F, 0xFD, 0xFE, 0x01, 0xFF, 0xBF, 0xC0, 0x0F, 0xC7, 0xBC,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBC, 0x00, 0x07,
  0xDE, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0xF8, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x0F, 0x00,
  0x1F, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x78,
  0x03, 0xE0, 0x3C, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03,
  0xC0, 0x7C, 0x01, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xC0, 0x07, 0xC3, 0xC0, 0x03, 0xE3, 0xE0,
  0x00, 0xF1, 0xF0, 0x00, 0x78, 0xF8, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x7C,
  0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF8,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0,
  0x07, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00,
  0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xFB,
  0xC0, 0x07, 0xCF, 0x00, 0x3F, 0x3C, 0x07, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x03, 0xF3, 0xC0, 0x03,
  0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xBC, 0x00, 0x7E, 0xF0, 0x07, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xF8, 0xFC, 0x07, 0xE7, 0xC0,
  0x0F, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00,
  0xFC, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x00, 0x7E, 0x78, 0x01, 0xFB, 0xC0, 0x07,
  0xDE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x07, 0xDE, 0x00, 0x7E, 0xF0, 0x0F, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F, 0xEF, 0xF8, 0xFC, 0x07,
  0xE7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1F,
  0x7E, 0x00, 0xFC, 0xFC, 0x07, 0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDF, 0x00, 0x0F,
  0xBF, 0x00, 0x3E, 0x3F, 0x00, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0x00, 0x00, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0xF0, 0x07, 0xC0, 0xF0, 0x0F, 0xC0, 0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00,
  0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0xF0, 0x3E, 0x00,
  0xF0, 0x1F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x80,
  0xF0, 0x07, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x03, 0xE0,
  0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xF0,
  0x07, 0x7E, 0xE0, 0x1E, 0xFD, 0xE0, 0x3F, 0xFB, 0xC0, 0x77, 0xF3, 0x81,
  0xEF, 0xF7, 0x83, 0xDF, 0xEF, 0x07, 0x3F, 0xCE, 0x1E, 0x7F, 0x9E, 0x3C,
  0xFF, 0x3C, 0x71, 0xFE, 0x38, 0xE3, 0xFC, 0x7B, 0xC7, 0xF8, 0xF7, 0x0F,
  0xF0, 0xEE, 0x3F, 0xE1, 0xFC, 0x7F, 0xC3, 0xF8, 0xFF, 0x83, 0xE1, 0xFF,
  0x07, 0xC3, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF7, 0x80,
  0x7F, 0xBC, 0x03, 0xFD, 0xF0, 0x1F, 0xE7, 0x80, 0xFF, 0x3C, 0x07, 0xF8,
  0xF0, 0x3F, 0xC7, 0x81, 0xFE, 0x3C, 0x0F, 0xF0, 0xF0, 0x7F, 0x87, 0x83,
  0xFC, 0x3C, 0x1F, 0xE0, 0xF0, 0xFF, 0x07, 0x87, 0xF8, 0x3C, 0x3F, 0xC0,
  0xF1, 0xFE, 0x07, 0x8F, 0xF0, 0x3E, 0x7F, 0x80, 0xF3, 0xFC, 0x07, 0x9F,
  0xE0, 0x1E, 0xFF, 0x00, 0xF7, 0xF8, 0x07, 0xBF, 0xC0, 0x1F, 0xFE, 0x00,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xEF, 0xF0, 0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xE0,
  0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7E, 0x00, 0xF8, 0xFC, 0x07,
  0xE3, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFE, 0x00,
  0x01, 0x00, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x78,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0xFD, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0x80, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFC, 0xFF, 0x8F, 0xC0, 0x3F, 0x1F, 0x00, 0x3F, 0x3E, 0x00,
  0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xDF, 0x00, 0x07, 0xBE, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0xFC, 0x7E, 0x03, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFC,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x00, 0x3F, 0x9E, 0x00, 0x1F, 0x3C,
  0x00, 0x3F, 0x78, 0x00, 0x3E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0,
  0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00,
  0x3F, 0x78, 0x00, 0x7C, 0xF0, 0x03, 0xF9, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1E, 0x07, 0xC0, 0x3C, 0x07, 0xC0,
  0x78, 0x0F, 0x80, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x1F, 0x07,
  0x80, 0x3E, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x7C, 0x3C, 0x00, 0xFC, 0x78,
  0x00, 0xF8, 0xF0, 0x01, 0xF9, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xF7, 0x80,
  0x03, 0xEF, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFC, 0x7F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1E, 0xFC, 0x00, 0x7C, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0C, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3E, 0x7E, 0x03, 0xF3, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x10, 0x00, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0x80,
  0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xE0, 0x1E, 0x01, 0xF0,
  0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0xFF, 0x80, 0xF8,
  0x0F, 0x78, 0x0F, 0x80, 0xF7, 0x80, 0xF8, 0x0F, 0x78, 0x1D, 0x80, 0xF7,
  0x81, 0xD8, 0x0F, 0x78, 0x1D, 0xC1, 0xF7, 0x81, 0xDC, 0x1E, 0x7C, 0x1D,
  0xC1, 0xE7, 0xC1, 0xDC, 0x1E, 0x3C, 0x1D, 0xC1, 0xE3, 0xC1, 0x9C, 0x1E,
  0x3C, 0x39, 0xC1, 0xE3, 0xC3, 0x8C, 0x1E, 0x3C, 0x38, 0xC1, 0xE3, 0xC3,
  0x8E, 0x3C, 0x3C, 0x38, 0xE3, 0xC3, 0xC3, 0x8E, 0x3C, 0x3E, 0x38, 0xE3,
  0xC1, 0xE3, 0x0E, 0x3C, 0x1E, 0x70, 0xE3, 0xC1, 0xE7, 0x0E, 0x3C, 0x1E,
  0x70, 0x63, 0xC1, 0xE7, 0x07, 0x3C, 0x1E, 0x70, 0x73, 0x81, 0xE7, 0x07,
  0x78, 0x1E, 0x70, 0x77, 0x81, 0xE7, 0x07, 0x78, 0x0F, 0xE0, 0x77, 0x80,
  0xFE, 0x07, 0x78, 0x0F, 0xE0, 0x77, 0x80, 0xFE, 0x03, 0x78, 0x0F, 0xE0,
  0x3F, 0x00, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0xF0,
  0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0xBE, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0x9F,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xC3, 0xE0,
  0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x3D,
  0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x83, 0x80, 0x0F, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x1E,
  0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x00, 0xF9,
  0xE0, 0x00, 0xF7, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xC0, 0xF8, 0x0F,
  0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x00, 0x08, 0x00, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xC1, 0xFF, 0x7F, 0xC3, 0xE0, 0x1F, 0x8F, 0x80,
  0x1F, 0x9F, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0x7F, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE,
  0x00, 0x3F, 0x7C, 0x00, 0xDE, 0xFE, 0x07, 0xBC, 0xFF, 0xFE, 0x78, 0xFF,
  0xF8, 0xF0, 0x7F, 0xE1, 0xE0, 0x0C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x08, 0x07, 0x87, 0xF8, 0x3C, 0xFF,
  0xF1, 0xEF, 0xFF, 0xCF, 0x7D, 0xFF, 0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03, 0xF7, 0xBE,
  0xFF, 0xBD, 0xFF, 0xF9, 0xE7, 0xFF, 0x8F, 0x0F, 0xF0, 0x00, 0x0C, 0x00,
  0x00, 0x10, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0xFC, 0x07, 0xE7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x78, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x3D, 0xE0, 0x00,
  0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x3F, 0x3F, 0x01, 0xF8, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0xC0, 0x7C,
  0x1F, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xEF, 0xFD, 0xF8,
  0x07, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x3F, 0x7E, 0x01, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF, 0xF7, 0xC3,
  0xFF, 0x9F, 0x07, 0xFC, 0x7C, 0x01, 0x80, 0x00, 0x00, 0x18, 0x00, 0x0F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0xC7, 0xF0, 0xF8, 0x07,
  0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xDF,
  0x00, 0x1F, 0x3E, 0x00, 0xF8, 0xFF, 0x1F, 0xE1, 0xFF, 0xFF, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0x80, 0x00, 0x40, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x40,
  0x00, 0x1F, 0xF1, 0xF0, 0xFF, 0xF7, 0xC7, 0xFF, 0xDF, 0x3F, 0xEF, 0xFC,
  0xF8, 0x07, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF7,
  0x80, 0x07, 0xDF, 0x00, 0x1F, 0x7C, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xF0,
  0x3F, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0x7C, 0x3F, 0xF9, 0xF0, 0x3F, 0xC7,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0x83, 0xFF,
  0xFC, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x18, 0x07, 0x8F, 0xF8, 0x3C, 0xFF, 0xF1,
  0xEF, 0xFF, 0xCF, 0x78, 0xFF, 0x7F, 0x01, 0xFB, 0xF0, 0x07, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x03, 0xF9, 0xFF, 0xFE, 0x3F, 0xFF,
  0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xF7, 0x80, 0x07, 0xCF, 0x00, 0x1F, 0x9E, 0x00, 0x3E, 0x3C, 0x00,
  0xF8, 0x78, 0x03, 0xF0, 0xF0, 0x07, 0xC1, 0xE0, 0x1F, 0x03, 0xC0, 0x7E,
  0x07, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7E, 0x07,
  0x80, 0x7C, 0x0F, 0x00, 0xFC, 0x1E, 0x00, 0xFC, 0x3C, 0x00, 0xF8, 0x78,
  0x01, 0xF8, 0xF0, 0x01, 0xF1, 0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xF7, 0x80,
  0x03, 0xEF, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xC0, 0x20, 0xF3, 0xF0, 0xFC,
  0xF7, 0xF9, 0xFE, 0xF7, 0xFF, 0xFE, 0xFC, 0x7E, 0x1F, 0xF8, 0x3E, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F,
  0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0x00, 0x18, 0x07,
  0x8F, 0xF8, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0x7D, 0xFF, 0x7F, 0x01,
  0xFB, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00,
  0x0F, 0x80, 0x03, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3F, 0x01, 0xF9, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0xDE, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x0F, 0x8F, 0xC0, 0x7E, 0x3F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x08, 0x07, 0x87, 0xFC,
  0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0x7D, 0xFF, 0x7F, 0x01, 0xFB, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x3F, 0xFE, 0x03,
  0xF7, 0xBE, 0xFF, 0xBD, 0xFF, 0xF9, 0xE7, 0xFF, 0x8F, 0x0F, 0xF0, 0x78,
  0x04, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x1F, 0xF1, 0xF0, 0xFF, 0xE7, 0xC7, 0xFF, 0xDF, 0x3F, 0xEF,
  0xFD, 0xF8, 0x07, 0xF7, 0xC0, 0x0F, 0xDF, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xF7,
  0xC0, 0x07, 0xDF, 0x00, 0x3F, 0x3F, 0x01, 0xFC, 0xFF, 0xFF, 0xF1, 0xFF,
  0xF7, 0xC3, 0xFF, 0x9F, 0x07, 0xFC, 0x7C, 0x01, 0x81, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x30, 0x07, 0x8F,
  0xF8, 0x3C, 0xFF, 0xF1, 0xEF, 0xFF, 0xCF, 0x78, 0xFF, 0x7F, 0x01, 0xFB,
  0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03, 0xFC, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC,
  0x7C, 0x01, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xC0,
  0x01, 0xEF, 0x80, 0x0F, 0xBF, 0x00, 0x7E, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFE, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xCF, 0xC0, 0x7E, 0x7F, 0xFF, 0xE1,
  0xFF, 0xFE, 0x07, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0x9E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7,
  0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x78,
  0x1E, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x1E, 0x01, 0xE0, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x1F, 0x01, 0xFE, 0x03, 0xE0, 0x3F, 0xC0, 0x7C,
  0x07, 0x78, 0x0F, 0x81, 0xE7, 0x83, 0xF0, 0x3C, 0xF0, 0x76, 0x07, 0x9E,
  0x0E, 0xE0, 0xF3, 0xC1, 0xDC, 0x1E, 0x78, 0x3B, 0x83, 0x8F, 0x06, 0x70,
  0x71, 0xE1, 0xCE, 0x1E, 0x1C, 0x38, 0xC3, 0xC3, 0xC7, 0x18, 0x78, 0x78,
  0xE3, 0x8F, 0x0F, 0x1C, 0x71, 0xC1, 0xE3, 0x0E, 0x38, 0x3C, 0x61, 0xC7,
  0x03, 0x9C, 0x39, 0xE0, 0x73, 0x83, 0x3C, 0x0F, 0x70, 0x77, 0x81, 0xEE,
  0x0E, 0xE0, 0x3D, 0x81, 0xDC, 0x07, 0xB0, 0x3B, 0x80, 0x7E, 0x07, 0xF0,
  0x0F, 0xC0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xC0,
  0x3E, 0x00, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x83,
  0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x1F,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0x80,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x0F, 0x07, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x00,
  0xF9, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0xFF, 0xF8,
  0x03, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0xFF,
  0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xC0,
  0x0F, 0x3F, 0xF0, 0x0F, 0x7F, 0xF8, 0x0F, 0x7F, 0xFC, 0x0F, 0x78, 0x7C,
  0x0F, 0xF8, 0x3E, 0x1F, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFE, 0xF8, 0x07,
  0xFC, 0xF8, 0x03, 0xF8,
};

const GFXglyph JetBrainsMono_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 37, 31, 11, -37 },
  { 38, 15, 15, 31, 8, -37 },
  { 67, 27, 37, 31, 2, -37 },
  { 192, 23, 51, 31, 4, -44 },
  { 339, 29, 37, 31, 1, -37 },
  { 474, 26, 39, 31, 3, -38 },
  { 601, 5, 15, 31, 13, -37 },
  { 611, 16, 49, 31, 9, -43 },
  { 709, 15, 49, 31, 6, -43 },
  { 801, 27, 26, 31, 2, -31 },
  { 889, 24, 24, 31, 3, -29 },
  { 961, 11, 16, 31, 8, -8 },
  { 983, 16, 4, 31, 7, -19 },
  { 991, 9, 9, 31, 11, -8 },
  { 1002, 23, 48, 31, 4, -42 },
  { 1140, 23, 39, 31, 4, -38 },
  { 1253, 23, 37, 31, 5, -37 },
  { 1360, 23, 38, 31, 4, -38 },
  { 1470, 22, 38, 31, 4, -37 },
  { 1575, 22, 37, 31, 4, -37 },
  { 1677, 22, 38, 31, 4, -37 },
  { 1782, 24, 38, 31, 3, -37 },
  { 1896, 23, 37, 31, 4, -37 },
  { 2003, 23, 39, 31, 4, -38 },
  { 2116, 24, 38, 31, 3, -38 },
  { 2230, 9, 30, 31, 11, -29 },
  { 2264, 11, 37, 31, 9, -29 },
  { 2315, 22, 27, 31, 4, -30 },
  { 2390, 22, 16, 31, 4, -25 },
  { 2434, 22, 27, 31, 4, -30 },
  { 2509, 18, 37, 31, 7, -37 },
  { 2593, 27, 47, 31, 2, -38 },
  { 2752, 25, 37, 31, 3, -37 },
  { 2868, 22, 37, 31, 5, -37 },
  { 2970, 22, 39, 31, 4, -38 },
  { 3078, 21, 37, 31, 5, -37 },
  { 3176, 22, 37, 31, 5, -37 },
  { 3278, 22, 37, 31, 5, -37 },
  { 3380, 22, 39, 31, 4, -38 },
  { 3488, 21, 37, 31, 5, -37 },
  { 3586, 20, 37, 31, 5, -37 },
  { 3679, 23, 38, 31, 2, -37 },
  { 3789, 24, 37, 31, 5, -37 },
  { 3900, 21, 37, 31, 6, -37 },
  { 3998, 23, 37, 31, 4, -37 },
  { 4105, 21, 37, 31, 5, -37 },
  { 4203, 22, 39, 31, 4, -38 },
  { 4311, 23, 37, 31, 5, -37 },
  { 4418, 23, 47, 31, 4, -38 },
  { 4554, 23, 37, 31, 5, -37 },
  { 4661, 23, 39, 31, 4, -38 },
  { 4774, 25, 37, 31, 3, -37 },
  { 4890, 21, 38, 31, 5, -37 },
  { 4990, 25, 37, 31, 3, -37 },
  { 5106, 28, 37, 31, 1, -37 },
  { 5236, 27, 37, 31, 2, -37 },
  { 5361, 27, 37, 31, 2, -37 },
  { 5486, 22, 37, 31, 4, -37 },
  { 5588, 13, 48, 31, 10, -42 },
  { 5666, 23, 48, 31, 4, -42 },
  { 5804, 12, 48, 31, 8, -42 },
  { 5876, 23, 20, 31, 4, -37 },
  { 5934, 25, 4, 31, 3, 1 },
  { 5947, 11, 7, 31, 9, -40 },
  { 5957, 23, 30, 31, 3, -29 },
  { 6044, 21, 38, 31, 5, -37 },
  { 6144, 22, 30, 31, 4, -29 },
  { 6227, 22, 38, 31, 4, -37 },
  { 6332, 22, 30, 31, 4, -29 },
  { 6415, 24, 37, 31, 3, -37 },
  { 6526, 22, 38, 31, 4, -29 },
  { 6631, 21, 37, 31, 5, -37 },
  { 6729, 24, 40, 31, 4, -40 },
  { 6849, 19, 49, 31, 4, -40 },
  { 6966, 23, 37, 31, 5, -37 },
  { 7073, 26, 37, 31, 2, -37 },
  { 7194, 24, 29, 31, 3, -29 },
  { 7281, 21, 29, 31, 5, -29 },
  { 7358, 22, 28, 31, 4, -28 },
  { 7435, 21, 38, 31, 5, -29 },
  { 7535, 22, 38, 31, 4, -29 },
  { 7640, 21, 29, 31, 6, -29 },
  { 7717, 22, 28, 31, 5, -28 },
  { 7794, 24, 36, 31, 3, -36 },
  { 7902, 21, 29, 31, 5, -28 },
  { 7979, 25, 28, 31, 3, -28 },
  { 8067, 27, 28, 31, 2, -28 },
  { 8162, 25, 28, 31, 3, -28 },
  { 8250, 25, 37, 31, 3, -28 },
  { 8366, 21, 28, 31, 5, -28 },
  { 8440, 22, 48, 31, 4, -42 },
  { 8572, 5, 48, 31, 13, -42 },
  { 8602, 22, 48, 31, 4, -42 },
  { 8734, 24, 10, 31, 3, -23 },
};

const GFXfont JetBrainsMono_Regular51pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular51pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular51pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _JETBRAINSMONO_REGULAR51PT7B_H_
