#ifndef _JETBRAINSMONO_REGULAR42PT7B_H_
#define _JETBRAINSMONO_REGULAR42PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: JetBrainsMono-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t JetBrainsMono_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0xF1, 0xE3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x00, 0x00, 0x00, 0x00,
  0xF3, 0xFF, 0xEF, 0xDF, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFF,
  0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0x70, 0x7B, 0x83, 0xDC, 0x1E, 0xE0,
  0xF7, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x81, 0xC0,
  0x06, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x1C,
  0x07, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x70, 0x03, 0x80,
  0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C,
  0x0F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x07, 0x01, 0x80,
  0x0E, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x70, 0x03, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xED, 0xF0, 0xF1, 0x8F, 0x3C,
  0x31, 0xE7, 0x86, 0x1E, 0xF0, 0xC3, 0xDE, 0x18, 0x03, 0xC3, 0x00, 0x78,
  0x60, 0x0F, 0x8C, 0x00, 0xF9, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFC, 0x00, 0x67, 0xC0, 0x0C, 0x7C, 0x01,
  0x87, 0x80, 0x30, 0xF0, 0x06, 0x1F, 0xE0, 0xC3, 0xFC, 0x18, 0x7F, 0x83,
  0x0F, 0x78, 0x63, 0xCF, 0xCC, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x7F,
  0xC0, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x1F, 0x00, 0x0F, 0x7F, 0xC0, 0x0E, 0x7F, 0xC0,
  0x1C, 0xF1, 0xE0, 0x38, 0xE0, 0xE0, 0x38, 0xE0, 0xE0, 0x70, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1, 0xC0, 0xE0, 0xE3, 0x80, 0xE0, 0xE3,
  0x80, 0xFF, 0xE7, 0x00, 0x7F, 0xCE, 0x00, 0x3F, 0x8E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x71, 0xF0, 0x00, 0xE3,
  0xFC, 0x01, 0xE7, 0xFE, 0x01, 0xCF, 0x1E, 0x03, 0x8E, 0x0E, 0x07, 0x8E,
  0x0F, 0x07, 0x0E, 0x0F, 0x0E, 0x0E, 0x0F, 0x1C, 0x0E, 0x0F, 0x1C, 0x0E,
  0x0E, 0x38, 0x0F, 0x0E, 0x70, 0x07, 0xFE, 0x70, 0x07, 0xFC, 0xE0, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xF0, 0x07, 0xC7, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF8, 0x01, 0x79, 0xE0, 0x7B,
  0xE3, 0xC1, 0xEF, 0x07, 0x8F, 0x3C, 0x1E, 0x3C, 0xF0, 0x3D, 0xE3, 0xC0,
  0x7F, 0x0F, 0x01, 0xFC, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x3F,
  0x07, 0x81, 0xFE, 0x1F, 0x0F, 0xF8, 0x7F, 0xFC, 0xF0, 0xFF, 0xE1, 0xE0,
  0xFE, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x70, 0x00, 0x30,
  0x0F, 0x03, 0xF0, 0x7F, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x3F, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0,
  0x7C, 0x0F, 0x83, 0xF0, 0xFE, 0x0F, 0xC0, 0xF0, 0x0C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x08, 0x0E, 0x01, 0x3C, 0x1C, 0x1E, 0x7E, 0x38, 0xFD,
  0xFF, 0x37, 0xFC, 0x7F, 0x5F, 0xE0, 0x3F, 0xFE, 0x00, 0x03, 0x80, 0x00,
  0x0D, 0x80, 0x00, 0x3B, 0x80, 0x00, 0xF3, 0x80, 0x03, 0xC7, 0x80, 0x0F,
  0x8F, 0x80, 0x1E, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0xF0, 0x1E, 0x00, 0x40,
  0x10, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1F, 0x8F, 0x87, 0xC7, 0xC3, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x3C, 0x3C, 0x1E, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x10, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0x87, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0x9C, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE1, 0xC3, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF1, 0xF1, 0xFE, 0x1C,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x0F, 0x1F, 0x07,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x1F, 0xF8, 0x07, 0xEF, 0x01, 0xF1, 0xE0, 0x3C, 0x3C,
  0x07, 0x07, 0x80, 0x80, 0xF0, 0x10, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF0, 0x07,
  0xBC, 0x00, 0xF7, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8,
  0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF9, 0xFF, 0xFE, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80,
  0x7D, 0xF8, 0x3E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03,
  0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xBF, 0xFF,
  0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0xE0, 0xF7,
  0xFE, 0x3F, 0xFF, 0xCF, 0xE1, 0xF3, 0xE0, 0x3E, 0xF0, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xE0, 0x03, 0xBC, 0x01, 0xEF, 0x00, 0x79, 0xF0, 0x7C, 0x7F,
  0xFF, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xEF,
  0xC0, 0x7B, 0xFE, 0x1F, 0xFF, 0xE3, 0xF0, 0x7E, 0x7C, 0x03, 0xDF, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x0F, 0x1F, 0x07,
  0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF0, 0x07,
  0x9E, 0x00, 0xF3, 0xC0, 0x0E, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x0F,
  0x1E, 0x03, 0xC1, 0xE0, 0xF0, 0x1F, 0x7C, 0x01, 0xFF, 0x00, 0x1F, 0xE0,
  0x0F, 0xFE, 0x03, 0xE3, 0xE0, 0xF0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x1C,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEF, 0x00, 0x3D,
  0xE0, 0x0F, 0x3F, 0x07, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0x8F, 0xC7, 0xC0, 0x7C,
  0xF0, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0xFB,
  0xE0, 0x3E, 0x3F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xDE, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x10, 0xFB, 0xFF, 0xFF, 0xEF, 0xCE, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xFF, 0xFF, 0xFF, 0xBE, 0x04,
  0x0F, 0x8F, 0xE7, 0xF3, 0xF8, 0xFC, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE3, 0xE1, 0xF0, 0xF0,
  0xF8, 0x7C, 0x3C, 0x3E, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC0, 0x00, 0x00,
  0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xFE, 0x01,
  0xFF, 0x83, 0xFF, 0xC7, 0xFF, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F,
  0x80, 0x7E, 0x0F, 0xF8, 0x1F, 0xE0, 0x3F, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0xFF, 0xFE, 0x07, 0xC0, 0x78, 0x3C, 0x00, 0xF1, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0x80, 0x00,
  0xEE, 0x00, 0x03, 0xF8, 0x0F, 0xEF, 0xE0, 0x7F, 0xFF, 0x81, 0xE3, 0xFE,
  0x0F, 0x03, 0xF8, 0x3C, 0x0F, 0xE0, 0xE0, 0x3F, 0x83, 0x80, 0xFE, 0x0E,
  0x03, 0xF8, 0x38, 0x0F, 0xE0, 0xE0, 0x3F, 0x83, 0x80, 0xFE, 0x0E, 0x03,
  0xF8, 0x3C, 0x0F, 0xE0, 0xF0, 0x3F, 0x81, 0xE1, 0xFE, 0x07, 0xFD, 0xF8,
  0x0F, 0xE7, 0xE0, 0x06, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xCE, 0x00, 0x1C, 0x78, 0x01,
  0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0x70, 0x03, 0x83, 0xC0, 0x3C, 0x1E,
  0x01, 0xE0, 0xF0, 0x0F, 0x03, 0x80, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x3C,
  0x07, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0x80, 0x3C,
  0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80,
  0x07, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F,
  0x3F, 0xFF, 0x8F, 0xFF, 0xC3, 0xFF, 0xF8, 0xFF, 0xFF, 0x3C, 0x03, 0xEF,
  0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC1, 0xFE, 0xFF, 0xFF,
  0x3F, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xF1,
  0xFC, 0xFC, 0x78, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xEF, 0x80, 0x79, 0xF0, 0x7E, 0x3F, 0xFF, 0x07, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0x80, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xFF, 0xF8,
  0xF0, 0x1F, 0x3C, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xBC,
  0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3B, 0xC0, 0x0E, 0xF0, 0x07, 0xBC,
  0x01, 0xEF, 0x00, 0xF3, 0xC1, 0xFC, 0xFF, 0xFE, 0x3F, 0xFF, 0x0F, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0xFF, 0xFF, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xF0, 0x07,
  0xFF, 0x03, 0xFF, 0xF1, 0xFC, 0xFC, 0x78, 0x0F, 0xBC, 0x01, 0xEF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x83, 0xFF, 0xE0, 0xFF, 0xF8,
  0x3F, 0xFE, 0x0F, 0xFF, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xEF, 0x80, 0x79, 0xF0, 0x7E,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE0, 0x1F, 0xFC,
  0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x79, 0xE0, 0x0F, 0x3F,
  0x07, 0xC3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xF0, 0x01, 0xEF,
  0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF0,
  0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0x80, 0xF0, 0x78, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xFF, 0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0x78, 0x0F, 0x07, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F,
  0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3E,
  0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x1F, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xDC, 0x1F, 0xFB,
  0x83, 0xBF, 0x70, 0x77, 0xE7, 0x0E, 0xFC, 0xE3, 0x9F, 0x9C, 0x73, 0xF9,
  0xCE, 0x7F, 0x3B, 0x8F, 0xE7, 0x71, 0xFC, 0x7E, 0x7F, 0x8F, 0x8F, 0xF1,
  0xF1, 0xFE, 0x1E, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x78, 0xF8,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F,
  0xB8, 0x0F, 0xDC, 0x07, 0xEF, 0x03, 0xF3, 0x81, 0xF9, 0xC0, 0xFC, 0xF0,
  0x7E, 0x38, 0x3F, 0x1E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1, 0xE3, 0xF0,
  0x71, 0xF8, 0x38, 0xFC, 0x1E, 0x7E, 0x07, 0x3F, 0x03, 0x9F, 0x81, 0xEF,
  0xC0, 0x77, 0xE0, 0x3B, 0xF0, 0x1F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x3E, 0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xE1,
  0xFC, 0xFC, 0x78, 0x0F, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xE0,
  0x03, 0xB8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0E, 0xF0,
  0x07, 0xBC, 0x01, 0xEF, 0x80, 0xF9, 0xF0, 0x7C, 0x3F, 0xFF, 0x0F, 0xFF,
  0x80, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF,
  0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xBC, 0x03, 0xF7, 0xFF, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0x83, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC,
  0x1F, 0x8F, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0x70, 0x01, 0xEF, 0x00, 0x79, 0xF0, 0x0F, 0x1F, 0x07, 0xE3,
  0xFF, 0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0x00, 0xF9, 0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xDE,
  0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x0F, 0x3C,
  0x0F, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x03, 0xC1, 0xE0, 0x78,
  0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0,
  0x1F, 0x1E, 0x01, 0xE3, 0xC0, 0x3E, 0x78, 0x03, 0xCF, 0x00, 0x7D, 0xE0,
  0x07, 0xBC, 0x00, 0xF8, 0x03, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x1F,
  0x8F, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x0F, 0x3F, 0x03, 0xE3, 0xFF,
  0xF8, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFE,
  0x03, 0xEF, 0x83, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F,
  0x07, 0x80, 0x70, 0x3C, 0x03, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C,
  0x0E, 0x01, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0x38, 0x3C, 0x01, 0xE1, 0xC0,
  0x0F, 0x0E, 0x00, 0x78, 0xF0, 0x01, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x79,
  0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x0F, 0xE0,
  0x78, 0x1F, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xF7, 0x07, 0xC1, 0xEE, 0x0D,
  0x83, 0xDC, 0x1B, 0x07, 0x38, 0x36, 0x0E, 0x70, 0x6E, 0x1C, 0xF0, 0xDC,
  0x39, 0xE3, 0xB8, 0x73, 0xC7, 0x30, 0xE7, 0x8E, 0x63, 0xC7, 0x18, 0xC7,
  0x8E, 0x31, 0x8F, 0x1C, 0x63, 0x1C, 0x38, 0xC7, 0x38, 0x71, 0x8E, 0x70,
  0xF7, 0x1C, 0xE1, 0xEE, 0x39, 0xC3, 0xDC, 0x33, 0x87, 0xB0, 0x6F, 0x07,
  0x60, 0xDE, 0x0E, 0xC1, 0xB8, 0x1D, 0x83, 0x70, 0x3B, 0x07, 0xE0, 0x76,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x03, 0xF0, 0x3E, 0x03, 0xC0,
  0x7C, 0x00, 0xF8, 0x00, 0x79, 0xE0, 0x03, 0xC7, 0xC0, 0x0F, 0x0F, 0x00,
  0x78, 0x3E, 0x01, 0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0,
  0x07, 0x87, 0x00, 0x1E, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xCF, 0x00,
  0x1E, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xE0, 0x03,
  0xEF, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x79, 0xE0, 0x00,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x3C,
  0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00,
  0x1E, 0x1C, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xFC, 0x00, 0x3B, 0x80, 0x0F, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xF0, 0x0E,
  0x0E, 0x01, 0xC1, 0xE0, 0x78, 0x1C, 0x0E, 0x03, 0x83, 0xC0, 0x38, 0x70,
  0x07, 0x1E, 0x00, 0xF3, 0x80, 0x0E, 0xF0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x78, 0x3C, 0x3E, 0x1E, 0x0F, 0x00,
  0x60, 0x01, 0xFF, 0x81, 0xFF, 0xF0, 0xFF, 0xFE, 0x3E, 0x07, 0xDE, 0x00,
  0xF7, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x7F, 0xFF, 0x3F, 0xFF, 0xDF, 0x80, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x0F, 0xDF, 0xFF,
  0x73, 0xFF, 0x9C, 0x7F, 0xC7, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0x80, 0xF3,
  0xFC, 0x3D, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x3E, 0xF8, 0x07, 0xBC, 0x01,
  0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xEF, 0x80, 0x7B, 0xF0, 0x7E, 0xFF, 0xFF, 0x3D, 0xFF,
  0x8F, 0x3F, 0xC0, 0x00, 0x80, 0x03, 0xFF, 0x03, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7C, 0x0F, 0xBE, 0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xE0, 0x1E,
  0x7C, 0x1F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x02, 0x07, 0x1F, 0xE3, 0x9F, 0xF9, 0xDF, 0xFE, 0xFF, 0x83, 0x7F, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x83, 0x77, 0xFF, 0xB9, 0xFF,
  0x9C, 0x7F, 0x8E, 0x00, 0x80, 0x03, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFC,
  0x78, 0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x1E,
  0x7C, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x0F, 0xE0,
  0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01,
  0x00, 0x0F, 0xF1, 0xCF, 0xFC, 0xEF, 0xFF, 0x77, 0xC1, 0xBF, 0xC0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xFC,
  0x07, 0xDF, 0x06, 0xEF, 0xFF, 0x73, 0xFF, 0x38, 0xFF, 0x1C, 0x0C, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF1, 0xFF,
  0xF0, 0xFF, 0xF8, 0x7F, 0xF0, 0x3F, 0x80, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x80,
  0xF3, 0xFC, 0x7B, 0xFF, 0x3F, 0xFF, 0xDF, 0x81, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x0E, 0x00, 0xC0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x7C,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x9F, 0xFE, 0x3F, 0xF8, 0x7F, 0xE0, 0xFE,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xFE, 0x00,
  0x7B, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF1, 0xE0, 0x3C, 0x3C, 0x0F,
  0x87, 0x81, 0xE0, 0xF0, 0x78, 0x1F, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xF8,
  0x0F, 0xFF, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xF0, 0xF0, 0x1E,
  0x1E, 0x03, 0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x7D, 0xE0, 0x07,
  0xBC, 0x00, 0x78, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0x02, 0x1D, 0xF9, 0xFB, 0xBF, 0x7F,
  0x7D, 0xFD, 0xFF, 0x0F, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07,
  0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F,
  0xC1, 0xC1, 0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F,
  0x83, 0x83, 0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC1, 0xC1, 0xF8, 0x38, 0x3F,
  0x07, 0x07, 0x00, 0x40, 0x79, 0xFE, 0x3D, 0xFF, 0x9F, 0xFF, 0xEF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x0F, 0xF8, 0x0F, 0xFF, 0x87, 0xFF, 0xF1,
  0xF0, 0x7C, 0xF8, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3B, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xBC, 0x01, 0xEF, 0x80, 0x79,
  0xF0, 0x7C, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x20, 0x3C,
  0xFF, 0x0F, 0x7F, 0xE3, 0xFF, 0xFC, 0xFC, 0x0F, 0xBE, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7B, 0xE0, 0x1E, 0xFC, 0x1F, 0xBF, 0xFF, 0xCF, 0x7F,
  0xE3, 0xCF, 0xF0, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0x00, 0x0F,
  0xF1, 0xCF, 0xFC, 0xEF, 0xFF, 0x77, 0xC1, 0xBF, 0xC0, 0x7F, 0xC0, 0x1F,
  0xE0, 0x0F, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFF, 0x01, 0xF7, 0xC1, 0xBB, 0xFF, 0xDC, 0xFF, 0xCE, 0x3F, 0xC7,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x40, 0x71, 0xFE, 0x39, 0xFF, 0x9D,
  0xFF, 0xEF, 0xC0, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0xC7, 0xFF, 0xF1, 0xE0, 0x3E, 0xF0, 0x07, 0xBC, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x03,
  0xFF, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x3E, 0x7F, 0xFF, 0x8F, 0xFF, 0xC0, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFE, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xEF, 0x83, 0xE3, 0xFF, 0xF0,
  0xFF, 0xE0, 0x3F, 0xE0, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0x9E, 0x00, 0x3C,
  0x70, 0x01, 0xE3, 0xC0, 0x0E, 0x1E, 0x00, 0xF0, 0x70, 0x07, 0x83, 0xC0,
  0x38, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xE0, 0x1E, 0x0F, 0x00,
  0x70, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x3C, 0x00, 0x71, 0xE0, 0x03, 0xCE,
  0x00, 0x1E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x3C, 0x1E, 0xE0, 0x78, 0x39, 0xC1,
  0xF0, 0x73, 0x83, 0x60, 0xE7, 0x06, 0xC1, 0xCF, 0x0D, 0x83, 0x8E, 0x1B,
  0x07, 0x1C, 0x37, 0x1C, 0x38, 0xEE, 0x38, 0x71, 0xCC, 0x70, 0xE3, 0x18,
  0xE1, 0xC6, 0x31, 0xC3, 0xCC, 0x63, 0x83, 0x98, 0xE6, 0x07, 0x31, 0xDC,
  0x0E, 0xE1, 0xB8, 0x1D, 0x83, 0x70, 0x3B, 0x06, 0xE0, 0x76, 0x0D, 0xC0,
  0x7C, 0x1B, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xC0, 0x78, 0x00,
  0x78, 0x00, 0xF9, 0xE0, 0x0F, 0x8F, 0x80, 0x78, 0x3C, 0x07, 0x80, 0xF0,
  0x7C, 0x07, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x0F, 0x78, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x80, 0x78, 0x3C, 0x07,
  0xC0, 0xF0, 0x7C, 0x07, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0x7B, 0xE0, 0x03,
  0xE0, 0xF8, 0x00, 0x7B, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0x78, 0x01, 0xE3,
  0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x0F, 0x03,
  0xC0, 0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x01,
  0xE7, 0x80, 0x0F, 0x38, 0x00, 0x7B, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3F,
  0xF8, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xC0,
  0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0xC0, 0xFF, 0xF0, 0x3C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xC0,
  0x03, 0x80, 0x00, 0x3F, 0x00, 0xEF, 0xF0, 0x1F, 0xFF, 0x03, 0xF8, 0xF0,
  0x7E, 0x0F, 0x0F, 0xC0, 0xFF, 0xF8, 0x1F, 0xF7, 0x00, 0xFC, 0x00, 0x06,
  0x00,
};

const GFXglyph JetBrainsMono_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 13, 13, 25, 6, -31 },
  { 51, 23, 31, 25, 1, -31 },
  { 141, 19, 43, 25, 3, -37 },
  { 244, 24, 31, 25, 1, -31 },
  { 337, 22, 31, 25, 2, -31 },
  { 423, 4, 13, 25, 10, -31 },
  { 430, 12, 40, 25, 8, -35 },
  { 490, 12, 40, 25, 5, -35 },
  { 550, 23, 22, 25, 1, -26 },
  { 614, 19, 20, 25, 3, -24 },
  { 662, 9, 13, 25, 7, -6 },
  { 677, 13, 4, 25, 6, -16 },
  { 684, 7, 7, 25, 9, -7 },
  { 691, 19, 40, 25, 3, -35 },
  { 786, 19, 31, 25, 3, -31 },
  { 860, 19, 31, 25, 4, -31 },
  { 934, 19, 31, 25, 3, -31 },
  { 1008, 18, 31, 25, 3, -31 },
  { 1078, 18, 31, 25, 3, -31 },
  { 1148, 18, 31, 25, 4, -31 },
  { 1218, 19, 31, 25, 3, -31 },
  { 1292, 19, 31, 25, 3, -31 },
  { 1366, 19, 31, 25, 3, -31 },
  { 1440, 19, 31, 25, 3, -31 },
  { 1514, 7, 24, 25, 9, -24 },
  { 1535, 9, 31, 25, 7, -24 },
  { 1570, 18, 22, 25, 4, -25 },
  { 1620, 18, 14, 25, 4, -21 },
  { 1652, 18, 22, 25, 4, -25 },
  { 1702, 15, 31, 25, 6, -31 },
  { 1761, 22, 39, 25, 2, -31 },
  { 1869, 21, 31, 25, 2, -31 },
  { 1951, 18, 31, 25, 4, -31 },
  { 2021, 18, 31, 25, 4, -31 },
  { 2091, 18, 31, 25, 4, -31 },
  { 2161, 18, 31, 25, 4, -31 },
  { 2231, 18, 31, 25, 4, -31 },
  { 2301, 18, 31, 25, 4, -31 },
  { 2371, 17, 31, 25, 4, -31 },
  { 2437, 17, 31, 25, 4, -31 },
  { 2503, 19, 31, 25, 2, -31 },
  { 2577, 20, 31, 25, 4, -31 },
  { 2655, 17, 31, 25, 5, -31 },
  { 2721, 19, 31, 25, 3, -31 },
  { 2795, 17, 31, 25, 4, -31 },
  { 2861, 18, 31, 25, 4, -31 },
  { 2931, 19, 31, 25, 4, -31 },
  { 3005, 19, 39, 25, 3, -31 },
  { 3098, 19, 31, 25, 4, -31 },
  { 3172, 19, 31, 25, 3, -31 },
  { 3246, 21, 31, 25, 2, -31 },
  { 3328, 17, 31, 25, 4, -31 },
  { 3394, 21, 31, 25, 2, -31 },
  { 3476, 23, 31, 25, 1, -31 },
  { 3566, 22, 31, 25, 2, -31 },
  { 3652, 23, 31, 25, 1, -31 },
  { 3742, 18, 31, 25, 4, -31 },
  { 3812, 10, 40, 25, 9, -35 },
  { 3862, 19, 40, 25, 3, -35 },
  { 3957, 11, 40, 25, 6, -35 },
  { 4012, 19, 17, 25, 3, -31 },
  { 4053, 20, 3, 25, 3, 1 },
  { 4061, 8, 6, 25, 8, -33 },
  { 4067, 18, 24, 25, 3, -24 },
  { 4121, 18, 31, 25, 4, -31 },
  { 4191, 18, 24, 25, 4, -24 },
  { 4245, 17, 31, 25, 4, -31 },
  { 4311, 18, 24, 25, 4, -24 },
  { 4365, 19, 31, 25, 3, -31 },
  { 4439, 17, 32, 25, 4, -24 },
  { 4507, 17, 31, 25, 4, -31 },
  { 4573, 19, 33, 25, 4, -33 },
  { 4652, 15, 41, 25, 4, -33 },
  { 4729, 19, 31, 25, 4, -31 },
  { 4803, 22, 31, 25, 1, -31 },
  { 4889, 19, 24, 25, 3, -24 },
  { 4946, 17, 24, 25, 4, -24 },
  { 4997, 18, 23, 25, 4, -23 },
  { 5049, 18, 32, 25, 4, -24 },
  { 5121, 17, 32, 25, 4, -24 },
  { 5189, 17, 24, 25, 5, -24 },
  { 5240, 18, 23, 25, 4, -23 },
  { 5292, 20, 30, 25, 2, -30 },
  { 5367, 17, 23, 25, 4, -23 },
  { 5416, 21, 23, 25, 2, -23 },
  { 5477, 23, 23, 25, 1, -23 },
  { 5544, 21, 23, 25, 2, -23 },
  { 5605, 21, 31, 25, 2, -23 },
  { 5687, 17, 23, 25, 4, -23 },
  { 5736, 18, 40, 25, 4, -35 },
  { 5826, 3, 40, 25, 11, -35 },
  { 5841, 18, 40, 25, 4, -35 },
  { 5931, 19, 9, 25, 3, -19 },
};

const GFXfont JetBrainsMono_Regular42pt7b PROGMEM = {
  (uint8_t  *)JetBrainsMono_Regular42pt7bBitmaps,
  (GFXglyph *)JetBrainsMono_Regular42pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _JETBRAINSMONO_REGULAR42PT7B_H_
