#ifndef _NOTOSANS_CONDENSED_LIGHT43PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light43pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0x06, 0xFF, 0xE0, 0xC3, 0xE1, 0xF0, 0xF8, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x01, 0x81, 0x80, 0x18, 0x10, 0x01,
  0x83, 0x00, 0x18, 0x30, 0x01, 0x83, 0x00, 0x30, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x30, 0x60,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x0C,
  0x00, 0x60, 0xC0, 0x06, 0x0C, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xC0,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0x80, 0x0C, 0x18, 0x00, 0xC1, 0x80, 0x08,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x30, 0x00,
  0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x1F, 0xFC, 0x3D, 0x7E,
  0x71, 0x04, 0xE1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00, 0xC1, 0x00,
  0xC1, 0x00, 0xE1, 0x00, 0x71, 0x00, 0x3D, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF0, 0x01, 0x3C, 0x01, 0x1E, 0x01, 0x06, 0x01, 0x06, 0x01, 0x07,
  0x01, 0x07, 0x01, 0x07, 0x01, 0x06, 0x01, 0x0E, 0xC1, 0x1C, 0xFF, 0xF8,
  0x7F, 0xF0, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00, 0x01, 0x00,
  0x1E, 0x00, 0x30, 0x1F, 0x80, 0x30, 0x18, 0x60, 0x18, 0x0C, 0x30, 0x18,
  0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x06, 0x01, 0x81, 0x83,
  0x00, 0xC0, 0xC3, 0x00, 0x60, 0x61, 0x80, 0x30, 0x30, 0xC0, 0x18, 0x18,
  0xC0, 0x0C, 0x0C, 0x63, 0xC6, 0x06, 0x63, 0xF3, 0x03, 0x33, 0x9C, 0xC3,
  0x19, 0x86, 0x61, 0x98, 0xC1, 0x9F, 0x8C, 0xC0, 0xC7, 0x8C, 0x60, 0x60,
  0x06, 0x30, 0x30, 0x03, 0x18, 0x18, 0x03, 0x0C, 0x0C, 0x01, 0x86, 0x06,
  0x01, 0x83, 0x03, 0x00, 0xC1, 0x81, 0x80, 0x60, 0xC0, 0xC0, 0x60, 0x60,
  0x60, 0x30, 0x18, 0x60, 0x30, 0x0C, 0x30, 0x18, 0x03, 0xF0, 0x1C, 0x00,
  0xF8, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x1C, 0x30, 0x01, 0x83, 0x80, 0x38,
  0x18, 0x03, 0x01, 0x80, 0x30, 0x18, 0x03, 0x81, 0x80, 0x38, 0x38, 0x01,
  0x83, 0x00, 0x1C, 0x30, 0x00, 0xC6, 0x00, 0x0E, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x00, 0x00, 0xF8, 0x00, 0x3D, 0xC0, 0x03, 0x0C, 0x06, 0x70, 0xE0,
  0xEE, 0x07, 0x0C, 0xC0, 0x30, 0xCC, 0x03, 0x8C, 0xC0, 0x1D, 0xCC, 0x00,
  0xF8, 0xC0, 0x07, 0x8C, 0x00, 0x70, 0xE0, 0x0F, 0x8E, 0x01, 0xD8, 0x70,
  0x39, 0xC3, 0xFF, 0x0E, 0x1F, 0xE0, 0x70, 0xFF, 0xFF, 0xFC, 0x03, 0x07,
  0x06, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0xE0,
  0xE0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60,
  0x60, 0x60, 0x70, 0x30, 0x30, 0x38, 0x18, 0x1C, 0x0C, 0x06, 0x07, 0x03,
  0xE0, 0x38, 0x0C, 0x03, 0x01, 0x80, 0x60, 0x30, 0x1C, 0x06, 0x03, 0x01,
  0xC0, 0x60, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x38, 0x18,
  0x0C, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x03, 0x8C, 0x3F, 0xF7, 0xCF, 0xFC, 0x03, 0x80, 0x1E,
  0x00, 0xCC, 0x07, 0x18, 0x38, 0x70, 0xC0, 0xC1, 0x02, 0x00, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x33, 0x77, 0x76, 0x6E, 0xCC, 0x80, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFF, 0xF0, 0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x03, 0x00, 0x30,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06,
  0x00, 0x70, 0x03, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x1C, 0x38, 0x38,
  0x1C, 0x30, 0x0C, 0x70, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0E, 0x30, 0x0C, 0x38,
  0x1C, 0x1C, 0x38, 0x1F, 0xF0, 0x07, 0xE0, 0x01, 0x81, 0xC1, 0xE1, 0xF1,
  0xDB, 0xCF, 0x86, 0x83, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x0F, 0xE0, 0x3F, 0xF0, 0xF0, 0x78,
  0x60, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xE0, 0xFF, 0xE3,
  0xC0, 0xE6, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xEC, 0x03, 0xDF, 0xFF, 0x1F, 0xF8, 0x00, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0C, 0xC0, 0x03,
  0x30, 0x01, 0x8C, 0x00, 0xE3, 0x00, 0x30, 0xC0, 0x1C, 0x30, 0x06, 0x0C,
  0x03, 0x83, 0x00, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x03, 0x03,
  0x00, 0xC1, 0x80, 0x30, 0xE0, 0x0C, 0x30, 0x03, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x00, 0x00, 0xC0, 0x3F, 0xFC, 0x3F, 0xFC, 0x30, 0x00, 0x30,
  0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x61, 0x00, 0x7F, 0xF0, 0x7F, 0xF8, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x06, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x1C, 0xC0, 0x38, 0xFF, 0xF0, 0x7F, 0xE0, 0x01, 0xFC, 0x07, 0xFC, 0x0F,
  0x04, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE3, 0xF0, 0xEF, 0xF8, 0xFC,
  0x1C, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x07, 0x70, 0x06, 0x70,
  0x0E, 0x38, 0x0E, 0x1C, 0x1C, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x07,
  0xE0, 0x1F, 0xF8, 0x38, 0x3C, 0x70, 0x0C, 0x60, 0x0E, 0x60, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x1C,
  0x38, 0x0F, 0xF0, 0x07, 0xC0, 0x07, 0xE0, 0x1E, 0x70, 0x38, 0x38, 0x70,
  0x1C, 0x60, 0x0E, 0xE0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x06, 0x60, 0x0E, 0x78, 0x1C, 0x3F, 0xF8, 0x0F,
  0xF0, 0x0F, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xDC, 0x01,
  0xB8, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x03, 0xB8, 0x0F, 0x78, 0x36, 0x7F, 0xEC, 0x7F,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x0F, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x73, 0x9E, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x67, 0x39, 0xCC,
  0x67, 0x31, 0x88, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3E, 0x00,
  0xF8, 0x00, 0xE0, 0x00, 0x80, 0x00, 0x3F, 0x8F, 0xFC, 0xE0, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x1E, 0x07, 0x80, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x03, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x30, 0x60, 0x00, 0x0E, 0x30, 0x00, 0x01, 0x8C, 0x07,
  0xF8, 0x67, 0x03, 0xFC, 0x0D, 0x81, 0xC3, 0x03, 0x60, 0xE0, 0xC0, 0xD8,
  0x30, 0x30, 0x3E, 0x0C, 0x0C, 0x0F, 0x07, 0x03, 0x03, 0xC1, 0x80, 0xC0,
  0xF0, 0x60, 0x30, 0x3C, 0x18, 0x0C, 0x0F, 0x06, 0x03, 0x03, 0xC1, 0x80,
  0xC0, 0xF0, 0x30, 0x70, 0x7E, 0x0C, 0x14, 0x19, 0x83, 0x8D, 0x8E, 0x60,
  0x7F, 0x7F, 0x18, 0x0F, 0x8F, 0x87, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00,
  0x40, 0x07, 0x80, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xD8, 0x00,
  0x19, 0x80, 0x01, 0x98, 0x00, 0x19, 0xC0, 0x03, 0x8C, 0x00, 0x30, 0xC0,
  0x03, 0x0C, 0x00, 0x30, 0xE0, 0x07, 0x06, 0x00, 0x60, 0x60, 0x06, 0x07,
  0x00, 0xE0, 0x30, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0x81, 0xFF,
  0xF8, 0x18, 0x01, 0x81, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0C, 0x30,
  0x00, 0xC3, 0x00, 0x0E, 0x70, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x30, 0xFF, 0x00, 0xFF, 0xF0, 0xC1, 0xF8, 0xC0,
  0x1C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0,
  0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xE0, 0xFF,
  0xF0, 0xC0, 0x3C, 0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0,
  0x1E, 0xC0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0xFF, 0xF0,
  0x78, 0x18, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x80,
  0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0xFF, 0x80, 0x3F, 0xFC, 0x0C, 0x3F, 0x83,
  0x00, 0xF0, 0xC0, 0x0E, 0x30, 0x01, 0xCC, 0x00, 0x73, 0x00, 0x0E, 0xC0,
  0x03, 0xB0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x06, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0xEC, 0x00, 0x3B, 0x00, 0x0E, 0xC0,
  0x07, 0x30, 0x01, 0xCC, 0x00, 0xE3, 0x00, 0x70, 0xC0, 0xF8, 0x3F, 0xFC,
  0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0xFF, 0xDF, 0xFE, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFE, 0xFF, 0xF6, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x0F, 0xFF, 0x81, 0xF0, 0x3C, 0x1E, 0x00, 0x21, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x18,
  0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x0E, 0xC0,
  0x00, 0x76, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xE6, 0x00, 0x07,
  0x38, 0x00, 0x39, 0xC0, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x70, 0x78,
  0x03, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0x80, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x06, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x81, 0xC0, 0xE0,
  0x6C, 0xF7, 0xF1, 0xF0, 0xC0, 0x07, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x18,
  0xC0, 0x38, 0xC0, 0x70, 0xC0, 0x60, 0xC0, 0xE0, 0xC1, 0xC0, 0xC1, 0x80,
  0xC3, 0x80, 0xC7, 0x00, 0xC6, 0x00, 0xCE, 0x00, 0xDE, 0x00, 0xDE, 0x00,
  0xF7, 0x00, 0xE3, 0x80, 0xC3, 0x80, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0,
  0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1C,
  0xC0, 0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x1B, 0xD8, 0x00, 0x1B, 0xD8, 0x00, 0x3B, 0xDC, 0x00, 0x33,
  0xCC, 0x00, 0x33, 0xCC, 0x00, 0x73, 0xCE, 0x00, 0x63, 0xC6, 0x00, 0x63,
  0xC6, 0x00, 0x63, 0xC7, 0x00, 0xC3, 0xC3, 0x00, 0xC3, 0xC3, 0x00, 0xC3,
  0xC3, 0x81, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0xC3, 0x03,
  0xC0, 0xC3, 0x03, 0xC0, 0xC3, 0x03, 0xC0, 0xE6, 0x03, 0xC0, 0x66, 0x03,
  0xC0, 0x66, 0x03, 0xC0, 0x7E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x18, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0x80, 0x0F, 0x70, 0x03,
  0xCC, 0x00, 0xF3, 0x80, 0x3C, 0x70, 0x0F, 0x1C, 0x03, 0xC3, 0x80, 0xF0,
  0xE0, 0x3C, 0x1C, 0x0F, 0x07, 0x03, 0xC0, 0xE0, 0xF0, 0x38, 0x3C, 0x07,
  0x0F, 0x01, 0xC3, 0xC0, 0x38, 0xF0, 0x0E, 0x3C, 0x01, 0xCF, 0x00, 0x73,
  0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1C, 0x01, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0xF0, 0x3C,
  0x07, 0x80, 0x70, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x07, 0x1C,
  0x00, 0x0C, 0x70, 0x00, 0x39, 0x80, 0x00, 0xE6, 0x00, 0x01, 0x98, 0x00,
  0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x01, 0x98, 0x00, 0x06, 0x60,
  0x00, 0x19, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x30, 0x00,
  0x30, 0xE0, 0x01, 0xC1, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0F, 0x03, 0xC0,
  0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x01, 0xFF, 0xC3, 0x1F, 0xC6,
  0x01, 0xCC, 0x01, 0xD8, 0x03, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x36, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0xB0, 0x0E, 0x60, 0x3C,
  0xFF, 0xF1, 0xFF, 0x83, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0,
  0x3C, 0x07, 0x80, 0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x00, 0x07,
  0x1C, 0x00, 0x0C, 0x70, 0x00, 0x39, 0x80, 0x00, 0xE6, 0x00, 0x01, 0x98,
  0x00, 0x06, 0xE0, 0x00, 0x1B, 0x80, 0x00, 0x6E, 0x00, 0x01, 0xB8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x6E, 0x00, 0x01, 0x98, 0x00, 0x06,
  0x60, 0x00, 0x19, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x30,
  0x00, 0x30, 0xE0, 0x01, 0xC1, 0x80, 0x0E, 0x07, 0x00, 0x38, 0x0F, 0x03,
  0xC0, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x60, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0xFF, 0x00, 0xFF, 0xE0, 0xC7, 0xF0, 0xC0, 0x38, 0xC0, 0x1C,
  0xC0, 0x0C, 0xC0, 0x0C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0C,
  0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x38, 0xC3, 0xF0, 0xFF, 0xC0,
  0xFF, 0x80, 0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70,
  0xC0, 0x30, 0xC0, 0x38, 0xC0, 0x18, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x07, 0x07, 0xF8, 0x3F, 0xFC, 0xF0, 0x73, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xEC, 0x03, 0x9F, 0xFE,
  0x1F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00,
  0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0x60, 0x01, 0xD8, 0x00, 0x77, 0x00, 0x18, 0xE0, 0x0E,
  0x3C, 0x07, 0x07, 0xFF, 0x80, 0x7F, 0xC0, 0xE0, 0x00, 0x7E, 0x00, 0x06,
  0x60, 0x00, 0x66, 0x00, 0x0E, 0x70, 0x00, 0xC7, 0x00, 0x0C, 0x30, 0x01,
  0xC3, 0x00, 0x1C, 0x38, 0x01, 0x81, 0x80, 0x18, 0x18, 0x03, 0x81, 0x80,
  0x38, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0x00, 0xE0, 0x60, 0x0E,
  0x06, 0x00, 0x60, 0xE0, 0x06, 0x0E, 0x00, 0x70, 0xC0, 0x03, 0x0C, 0x00,
  0x31, 0xC0, 0x03, 0x1C, 0x00, 0x39, 0x80, 0x01, 0x98, 0x00, 0x1B, 0x80,
  0x01, 0xB0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x60, 0x01, 0x80, 0x07, 0x60, 0x03, 0xC0,
  0x06, 0x70, 0x03, 0xC0, 0x06, 0x70, 0x03, 0xC0, 0x0E, 0x30, 0x03, 0xC0,
  0x0E, 0x30, 0x07, 0xE0, 0x0C, 0x38, 0x06, 0x60, 0x0C, 0x38, 0x06, 0x60,
  0x1C, 0x18, 0x06, 0x60, 0x1C, 0x18, 0x06, 0x60, 0x18, 0x18, 0x0E, 0x30,
  0x18, 0x1C, 0x0C, 0x30, 0x38, 0x1C, 0x0C, 0x30, 0x38, 0x0C, 0x0C, 0x30,
  0x38, 0x0C, 0x1C, 0x38, 0x30, 0x0E, 0x18, 0x18, 0x30, 0x0E, 0x18, 0x18,
  0x70, 0x06, 0x18, 0x18, 0x70, 0x06, 0x18, 0x1C, 0x60, 0x06, 0x38, 0x0C,
  0x60, 0x07, 0x30, 0x0C, 0xE0, 0x07, 0x30, 0x0C, 0xE0, 0x03, 0x30, 0x0C,
  0xC0, 0x03, 0x70, 0x0E, 0xC0, 0x03, 0x60, 0x06, 0xC0, 0x03, 0xE0, 0x07,
  0xC0, 0x01, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x03,
  0x80, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xCC, 0x00, 0xE3, 0x80, 0x30,
  0x60, 0x1C, 0x1C, 0x07, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x38, 0x30, 0x06,
  0x1C, 0x01, 0xC6, 0x00, 0x33, 0x80, 0x0E, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3B, 0x00,
  0x0C, 0xE0, 0x07, 0x18, 0x01, 0x87, 0x00, 0xE0, 0xC0, 0x30, 0x30, 0x1C,
  0x0E, 0x06, 0x01, 0x83, 0x80, 0x70, 0xC0, 0x0C, 0x70, 0x03, 0x9C, 0x00,
  0x6E, 0x00, 0x1C, 0xE0, 0x01, 0xF8, 0x00, 0x66, 0x00, 0x39, 0xC0, 0x0C,
  0x30, 0x07, 0x0E, 0x01, 0x83, 0x80, 0x60, 0x60, 0x38, 0x1C, 0x0C, 0x03,
  0x07, 0x00, 0xE1, 0x80, 0x38, 0x60, 0x06, 0x38, 0x01, 0xCC, 0x00, 0x37,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0F, 0xFF, 0xFC, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00,
  0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0xFF, 0xFF, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x30, 0x00, 0xCC, 0x00, 0x61, 0x80,
  0x18, 0x60, 0x0C, 0x0C, 0x03, 0x03, 0x01, 0x80, 0x60, 0x60, 0x18, 0x38,
  0x03, 0x0C, 0x00, 0xC7, 0x00, 0x39, 0x80, 0x06, 0xE0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1, 0xC1, 0xC1, 0x81, 0x81, 0x80, 0x1F,
  0xE1, 0xFF, 0xC3, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0xFF, 0xCF, 0xE7, 0x78, 0x1F, 0x80, 0x7E,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF8, 0x0B, 0xE0, 0x6D,
  0xFF, 0x33, 0xF8, 0xC0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE7, 0xF0, 0xCF, 0xF8, 0xD8, 0x1C, 0xD0, 0x0E, 0xF0, 0x0E, 0xE0, 0x06,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06,
  0xF0, 0x0E, 0xD0, 0x0E, 0xD8, 0x1C, 0xCF, 0xF8, 0xC7, 0xF0, 0x07, 0xF8,
  0x7F, 0xC7, 0x02, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x60, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0xC0, 0x8F, 0xFC, 0x3F, 0xE0,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x0F, 0xE3, 0x1F, 0xF3,
  0x3C, 0x1B, 0x30, 0x0B, 0x70, 0x0F, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x70, 0x0B,
  0x38, 0x1B, 0x1F, 0xF3, 0x0F, 0xE3, 0x07, 0xE0, 0x3F, 0xE0, 0xE0, 0xE1,
  0x80, 0xE7, 0x00, 0xCC, 0x01, 0xD8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x43, 0xFF, 0x81,
  0xFE, 0x00, 0x01, 0xF0, 0x7F, 0x07, 0x10, 0xE0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3F, 0xCF, 0xFC, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xE3, 0x1F, 0xF3, 0x38, 0x1B, 0x30, 0x0B,
  0x70, 0x0F, 0x60, 0x07, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F, 0x70, 0x0B, 0x38, 0x1B, 0x1F, 0xF3,
  0x0F, 0xE3, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x0E, 0x60, 0x1C, 0x7F, 0xF8, 0x3F, 0xF0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x9F, 0xC6, 0x7F, 0xCD, 0xC3, 0xDA, 0x03,
  0xBC, 0x03, 0x70, 0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0E,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x0E, 0x1C, 0x38, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0x87, 0x7E, 0xF8,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x01, 0xF8, 0x0E, 0xE0, 0x73, 0x81,
  0x8E, 0x0C, 0x38, 0x70, 0xE3, 0x83, 0x0C, 0x0C, 0x70, 0x33, 0x80, 0xCF,
  0x03, 0x6C, 0x0F, 0x38, 0x38, 0x60, 0xE1, 0xC3, 0x83, 0x0E, 0x0E, 0x38,
  0x18, 0xE0, 0x73, 0x80, 0xCE, 0x03, 0xB8, 0x06, 0xE0, 0x1C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC7,
  0xE0, 0xFC, 0x67, 0xF8, 0xFF, 0x36, 0x0E, 0xC1, 0xDA, 0x03, 0x40, 0x6F,
  0x01, 0xE0, 0x3F, 0x00, 0xE0, 0x1F, 0x80, 0x70, 0x0F, 0xC0, 0x38, 0x03,
  0xE0, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0xF8, 0x07, 0x00, 0x7C, 0x03, 0x80,
  0x3E, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x0F, 0x80, 0x70, 0x07, 0xC0, 0x38,
  0x03, 0xE0, 0x1C, 0x01, 0xF0, 0x0E, 0x00, 0xF8, 0x07, 0x00, 0x7C, 0x03,
  0x80, 0x3E, 0x01, 0xC0, 0x1F, 0x00, 0xE0, 0x0F, 0x80, 0x70, 0x06, 0xC7,
  0xF1, 0x9F, 0xF3, 0x60, 0x76, 0x80, 0xEF, 0x00, 0xDC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0x80, 0x07, 0xF0, 0x1F, 0xF8, 0x3C,
  0x1C, 0x30, 0x0E, 0x70, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x07, 0x70, 0x06, 0x30, 0x0E, 0x38,
  0x1C, 0x1F, 0xF8, 0x0F, 0xF0, 0xC7, 0xF0, 0xCF, 0xF8, 0xDC, 0x1C, 0xD0,
  0x0E, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x06, 0xF0, 0x0E, 0xD0, 0x0E, 0xD8, 0x1C, 0xEF,
  0xF8, 0xE7, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x0F,
  0xE3, 0x1F, 0xF3, 0x3C, 0x1B, 0x30, 0x0B, 0x70, 0x0F, 0x60, 0x07, 0x60,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70,
  0x0F, 0x70, 0x0B, 0x38, 0x1B, 0x1F, 0xF3, 0x0F, 0xE3, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0xC7, 0xF3, 0xFD, 0xC3, 0x60, 0xD0, 0x3C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0x1F, 0xE7,
  0xFF, 0x70, 0x2E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xF0, 0x07,
  0x80, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x07, 0x80, 0xEF, 0xFE, 0x7F, 0x80, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x1F, 0xFF, 0xFC, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xFC, 0x3F, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x7B, 0x00, 0xF7, 0x06, 0xE7,
  0xFC, 0xC7, 0xF1, 0x80, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x06, 0x70, 0x06,
  0x70, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0C, 0x30, 0x0E, 0x70, 0x06, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0xE0, 0x0E, 0x01, 0xD8, 0x03, 0x80, 0x76, 0x01, 0xE0, 0x19,
  0xC0, 0x78, 0x06, 0x70, 0x1B, 0x01, 0x8C, 0x06, 0xC0, 0xE3, 0x03, 0xB0,
  0x30, 0xE0, 0xCC, 0x0C, 0x38, 0x33, 0x83, 0x06, 0x0C, 0x61, 0xC1, 0x87,
  0x18, 0x60, 0x61, 0x86, 0x18, 0x1C, 0x61, 0xC6, 0x03, 0x18, 0x33, 0x80,
  0xCE, 0x0C, 0xC0, 0x33, 0x03, 0x30, 0x0E, 0xC0, 0xCC, 0x01, 0xB0, 0x1B,
  0x00, 0x6C, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xE0,
  0x0E, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x71, 0x81,
  0xC3, 0x83, 0x03, 0x0E, 0x03, 0x18, 0x07, 0x70, 0x06, 0xC0, 0x0F, 0x80,
  0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xD8, 0x03, 0xB8, 0x06, 0x30, 0x1C,
  0x70, 0x30, 0x60, 0xE0, 0xE1, 0x80, 0xC7, 0x01, 0xCC, 0x01, 0xB8, 0x03,
  0x80, 0xE0, 0x03, 0x60, 0x07, 0x70, 0x06, 0x70, 0x06, 0x30, 0x06, 0x30,
  0x0E, 0x38, 0x0C, 0x18, 0x0C, 0x18, 0x1C, 0x1C, 0x18, 0x0C, 0x18, 0x0C,
  0x18, 0x0C, 0x38, 0x0E, 0x30, 0x06, 0x30, 0x06, 0x70, 0x06, 0x60, 0x03,
  0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7F, 0xF7, 0xFF, 0x00, 0x70,
  0x06, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00,
  0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x07,
  0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x60, 0x7C, 0x1E, 0x03, 0x80,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x0C, 0x03, 0x83, 0xC0, 0x78, 0x03, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0xC0, 0x3E, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x0F,
  0x80, 0x3C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x38, 0x01, 0xF0, 0x1F, 0x03, 0x80, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xE0, 0x0C, 0x03, 0xC0, 0xF8, 0x0E, 0x00, 0x7F, 0x01, 0xFF, 0xC3, 0x81,
  0xFF, 0x80, 0x7C,
};

const GFXglyph NotoSans_Condensed_Light43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 31, 10, 3, -31 },
  { 17, 9, 11, 15, 3, -31 },
  { 30, 20, 31, 22, 1, -31 },
  { 108, 16, 36, 20, 2, -33 },
  { 180, 25, 31, 29, 2, -31 },
  { 277, 20, 31, 22, 2, -31 },
  { 355, 2, 11, 8, 3, -31 },
  { 358, 8, 38, 12, 2, -31 },
  { 396, 9, 38, 12, 1, -31 },
  { 439, 14, 15, 18, 2, -33 },
  { 466, 16, 20, 20, 2, -25 },
  { 506, 4, 11, 9, 2, -5 },
  { 512, 10, 3, 12, 1, -13 },
  { 516, 3, 4, 9, 3, -4 },
  { 518, 13, 31, 15, 1, -31 },
  { 569, 16, 31, 20, 2, -31 },
  { 631, 9, 31, 20, 3, -31 },
  { 666, 16, 31, 20, 2, -31 },
  { 728, 15, 31, 20, 2, -31 },
  { 787, 18, 31, 20, 1, -31 },
  { 857, 16, 31, 20, 2, -31 },
  { 919, 16, 31, 20, 2, -31 },
  { 981, 16, 31, 20, 2, -31 },
  { 1043, 16, 31, 20, 2, -31 },
  { 1105, 15, 31, 20, 2, -31 },
  { 1164, 3, 23, 9, 3, -23 },
  { 1173, 5, 29, 9, 2, -23 },
  { 1192, 16, 19, 20, 2, -25 },
  { 1230, 16, 11, 20, 2, -21 },
  { 1252, 16, 19, 20, 2, -25 },
  { 1290, 12, 31, 14, 1, -31 },
  { 1337, 26, 35, 30, 2, -31 },
  { 1451, 20, 31, 20, 0, -31 },
  { 1529, 16, 31, 22, 4, -31 },
  { 1591, 18, 31, 21, 2, -31 },
  { 1661, 18, 31, 24, 4, -31 },
  { 1731, 13, 31, 19, 4, -31 },
  { 1782, 13, 31, 18, 4, -31 },
  { 1833, 21, 31, 25, 2, -31 },
  { 1915, 17, 31, 25, 4, -31 },
  { 1981, 8, 31, 12, 2, -31 },
  { 2012, 9, 39, 9, -3, -31 },
  { 2056, 16, 31, 20, 4, -31 },
  { 2118, 13, 31, 17, 4, -31 },
  { 2169, 24, 31, 32, 4, -31 },
  { 2262, 18, 31, 26, 4, -31 },
  { 2332, 22, 31, 26, 2, -31 },
  { 2418, 15, 31, 20, 4, -31 },
  { 2477, 22, 38, 26, 2, -31 },
  { 2582, 16, 31, 21, 4, -31 },
  { 2644, 15, 31, 19, 2, -31 },
  { 2703, 17, 31, 18, 0, -31 },
  { 2769, 18, 31, 24, 3, -31 },
  { 2839, 20, 31, 20, 0, -31 },
  { 2917, 32, 31, 32, 0, -31 },
  { 3041, 18, 31, 18, 0, -31 },
  { 3111, 18, 31, 18, 0, -31 },
  { 3181, 16, 31, 18, 1, -31 },
  { 3243, 9, 38, 13, 3, -31 },
  { 3286, 13, 31, 15, 1, -31 },
  { 3337, 9, 38, 13, 1, -31 },
  { 3380, 18, 17, 20, 1, -31 },
  { 3419, 18, 2, 18, 0, 4 },
  { 3424, 7, 7, 11, 2, -33 },
  { 3431, 14, 23, 19, 2, -23 },
  { 3472, 16, 33, 21, 3, -33 },
  { 3538, 13, 23, 16, 2, -23 },
  { 3576, 16, 33, 21, 2, -33 },
  { 3642, 15, 23, 19, 2, -23 },
  { 3686, 12, 33, 11, 0, -33 },
  { 3736, 16, 33, 21, 2, -23 },
  { 3802, 15, 33, 21, 3, -33 },
  { 3864, 3, 31, 9, 3, -31 },
  { 3876, 7, 41, 9, -1, -31 },
  { 3912, 14, 33, 17, 3, -33 },
  { 3970, 3, 33, 9, 3, -33 },
  { 3983, 25, 23, 31, 3, -23 },
  { 4055, 15, 23, 21, 3, -23 },
  { 4099, 16, 23, 20, 2, -23 },
  { 4145, 16, 33, 21, 3, -23 },
  { 4211, 16, 33, 21, 2, -23 },
  { 4277, 10, 23, 14, 3, -23 },
  { 4306, 12, 23, 16, 2, -23 },
  { 4341, 10, 28, 11, 1, -28 },
  { 4376, 15, 23, 21, 3, -23 },
  { 4420, 16, 23, 16, 0, -23 },
  { 4466, 26, 23, 26, 0, -23 },
  { 4541, 15, 23, 17, 1, -23 },
  { 4585, 16, 33, 16, 0, -23 },
  { 4651, 12, 23, 14, 1, -23 },
  { 4686, 11, 38, 15, 2, -31 },
  { 4739, 2, 43, 19, 8, -33 },
  { 4750, 12, 38, 15, 2, -31 },
  { 4807, 16, 4, 20, 2, -17 },
};

const GFXfont NotoSans_Condensed_Light43pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light43pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light43pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _NOTOSANS_CONDENSED_LIGHT43PT7B_H_
