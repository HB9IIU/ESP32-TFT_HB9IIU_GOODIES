#ifndef _NOTOSANS_CONDENSED_LIGHT38PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light38pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x60, 0x00, 0xFF, 0x80,
  0xE3, 0xB1, 0xD8, 0xEC, 0x76, 0x33, 0x09, 0x84, 0x82, 0x41, 0x20, 0x80,
  0x03, 0x06, 0x01, 0x82, 0x00, 0xC1, 0x00, 0x41, 0x80, 0x20, 0xC0, 0x30,
  0x60, 0x18, 0x30, 0x0C, 0x18, 0x7F, 0xFF, 0xBF, 0xFF, 0xC1, 0x06, 0x00,
  0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x20, 0x0C, 0x10,
  0x7F, 0xFF, 0xBF, 0xFF, 0xC3, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60,
  0x80, 0x30, 0x40, 0x10, 0x60, 0x08, 0x30, 0x0C, 0x18, 0x00, 0x02, 0x00,
  0x08, 0x00, 0x20, 0x07, 0xF8, 0x3F, 0xF9, 0x88, 0x4C, 0x20, 0x30, 0x80,
  0xC2, 0x03, 0x08, 0x0C, 0x20, 0x30, 0x80, 0x62, 0x01, 0xE8, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x09, 0xC0, 0x21, 0x80, 0x86, 0x02, 0x0C, 0x08,
  0x30, 0x20, 0xC0, 0x86, 0x82, 0x3B, 0x8B, 0xCF, 0xFE, 0x07, 0xC0, 0x02,
  0x00, 0x08, 0x00, 0x20, 0x00, 0x08, 0x00, 0x00, 0xF8, 0x06, 0x06, 0x60,
  0x18, 0x30, 0xC0, 0xC0, 0xC3, 0x03, 0x03, 0x04, 0x08, 0x0C, 0x18, 0x60,
  0x30, 0x61, 0x80, 0xC1, 0x8C, 0x03, 0x06, 0x30, 0x0C, 0x18, 0x80, 0x30,
  0x66, 0x38, 0xC1, 0x19, 0xF3, 0x0C, 0xCC, 0x64, 0x33, 0x31, 0x99, 0x99,
  0x83, 0x3E, 0x66, 0x0C, 0x21, 0x98, 0x30, 0x0C, 0x60, 0xC0, 0x31, 0x83,
  0x01, 0x86, 0x0C, 0x06, 0x18, 0x30, 0x18, 0x60, 0xC0, 0xC1, 0x83, 0x03,
  0x02, 0x08, 0x18, 0x0C, 0x60, 0x60, 0x3B, 0x83, 0x80, 0x7C, 0x01, 0x00,
  0x03, 0xF8, 0x00, 0xC6, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01,
  0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x1C, 0x00, 0xC6, 0x00, 0x3B,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x66, 0x00, 0x30, 0xC1,
  0x98, 0x38, 0x66, 0x07, 0x19, 0x80, 0xC6, 0xE0, 0x1B, 0x38, 0x07, 0xC6,
  0x00, 0xE1, 0x80, 0x38, 0x60, 0x1F, 0x1C, 0x0E, 0xE3, 0xFF, 0x18, 0x7F,
  0x03, 0xED, 0xB6, 0xDA, 0x48, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x1C, 0x30,
  0x60, 0xC3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x38, 0x30, 0x60, 0xC0, 0xC1, 0x83, 0x83, 0x07, 0x06, 0x06, 0xE0, 0x70,
  0x30, 0x18, 0x18, 0x1C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x06, 0x07,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x06, 0x06, 0x0E, 0x0C,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0x60, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0xC6, 0x1F, 0xEF, 0x3F, 0xC0, 0x60, 0x0F, 0x01, 0x98, 0x30, 0xC7,
  0x0E, 0x20, 0x40, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x39,
  0x8C, 0x63, 0x31, 0x8C, 0xC0, 0xFF, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0x70,
  0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80,
  0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x00, 0x02, 0x00, 0x7F, 0x03, 0xDE, 0x0C, 0x1C, 0x70, 0x31,
  0x80, 0xE6, 0x01, 0xB8, 0x06, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xB0, 0x06, 0xC0, 0x1B, 0x80, 0x66, 0x01, 0x98, 0x0C, 0x70, 0x30, 0xC1,
  0xC1, 0xFE, 0x03, 0xF0, 0x07, 0x0F, 0x1F, 0x3B, 0x73, 0xE3, 0x43, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x02, 0x01, 0xFE, 0x3E, 0x78,
  0x80, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x02, 0x01, 0xFE, 0x3E, 0x79, 0x80, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x1C, 0x0F, 0xC0, 0x7F, 0x00, 0x1C, 0x00, 0x30, 0x01, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x3C, 0x03, 0xBF,
  0xF9, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00,
  0xB0, 0x01, 0xB0, 0x03, 0x30, 0x03, 0x30, 0x06, 0x30, 0x06, 0x30, 0x0C,
  0x30, 0x0C, 0x30, 0x18, 0x30, 0x18, 0x30, 0x30, 0x30, 0x70, 0x30, 0x60,
  0x30, 0xC0, 0x30, 0xC0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x7F, 0xF1, 0xFF,
  0xC6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x06, 0x00, 0x1F, 0xF0, 0xFB, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x06, 0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60,
  0x01, 0x80, 0x0C, 0x80, 0x73, 0xFF, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x3C,
  0x41, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60,
  0x03, 0x00, 0x0C, 0x7C, 0x33, 0xF8, 0xD8, 0x73, 0xC0, 0xEE, 0x01, 0xB0,
  0x06, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1D, 0x80, 0x66,
  0x01, 0x9C, 0x06, 0x30, 0x30, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00,
  0x60, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x00, 0x02, 0x00, 0x7F,
  0x83, 0xCF, 0x1C, 0x0C, 0x60, 0x1B, 0x80, 0x6C, 0x01, 0xB0, 0x06, 0xE0,
  0x19, 0x80, 0xE7, 0x03, 0x0E, 0x18, 0x1D, 0xC0, 0x1E, 0x00, 0xFC, 0x0E,
  0x38, 0x70, 0x71, 0x80, 0xEC, 0x01, 0xB0, 0x07, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xE0, 0x19, 0x80, 0xE3, 0xDF, 0x07, 0xF0, 0x02, 0x00,
  0xFE, 0x0F, 0x78, 0xE0, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x1D, 0x80, 0xEE, 0x1B,
  0x3F, 0xD8, 0x78, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x60, 0x0E, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x39, 0x8C, 0x67, 0x31, 0x8C, 0xC0, 0x00, 0x02, 0x00, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x06, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x08, 0x0F, 0xE3, 0xDE, 0x40,
  0xE0, 0x0C, 0x01, 0xC0, 0x18, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x38, 0x0E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0xF0, 0x0C, 0x00, 0x00, 0xFF,
  0x00, 0x07, 0xCF, 0x80, 0x1C, 0x03, 0x80, 0x60, 0x01, 0x81, 0x80, 0x01,
  0x87, 0x00, 0x03, 0x0C, 0x00, 0x03, 0x30, 0x0E, 0x06, 0x60, 0x7F, 0x0C,
  0xC1, 0x86, 0x0D, 0x06, 0x0C, 0x1E, 0x0C, 0x18, 0x3C, 0x10, 0x30, 0x78,
  0x60, 0x60, 0xF0, 0xC0, 0xC1, 0xE1, 0x81, 0x83, 0xC3, 0x03, 0x07, 0x86,
  0x06, 0x0F, 0x0C, 0x1C, 0x16, 0x0C, 0x28, 0x6C, 0x18, 0xD1, 0xC8, 0x1F,
  0x3F, 0x18, 0x1C, 0x38, 0x30, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x60, 0x04, 0x00, 0x78, 0x78, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0x30,
  0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x06, 0x18, 0x01, 0x86, 0x00,
  0x61, 0x80, 0x38, 0x70, 0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x60,
  0x18, 0x1F, 0xFE, 0x07, 0xFF, 0x83, 0x80, 0x70, 0xC0, 0x0C, 0x30, 0x03,
  0x0C, 0x00, 0xC6, 0x00, 0x39, 0x80, 0x06, 0x60, 0x01, 0xB8, 0x00, 0x7C,
  0x00, 0x0C, 0xFF, 0xC1, 0xFF, 0xE3, 0x00, 0xE6, 0x00, 0xEC, 0x01, 0xD8,
  0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x33, 0x00, 0xE6, 0x03,
  0x8F, 0xFC, 0x1F, 0xFE, 0x30, 0x0E, 0x60, 0x0E, 0xC0, 0x0D, 0x80, 0x1B,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB0, 0x03, 0x60, 0x0E, 0xC0,
  0x39, 0xFF, 0xE3, 0xFF, 0x00, 0x00, 0x20, 0x03, 0xFF, 0x0F, 0xDE, 0x1E,
  0x02, 0x18, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60,
  0x00, 0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x18, 0x00, 0x1E, 0x02, 0x0F, 0xFE, 0x03,
  0xFE, 0xFF, 0xC0, 0xFF, 0xF0, 0xC0, 0x78, 0xC0, 0x1C, 0xC0, 0x0C, 0xC0,
  0x0E, 0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x0C, 0xC0,
  0x1C, 0xC0, 0x78, 0xFF, 0xE0, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xEF, 0xFE, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0F, 0xFE, 0xFF, 0xEC, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x10, 0x00, 0xFF, 0xC0, 0x7E, 0xFC,
  0x38, 0x02, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x60,
  0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0D,
  0x80, 0x03, 0x60, 0x00, 0xDC, 0x00, 0x33, 0x00, 0x0C, 0xE0, 0x03, 0x1C,
  0x00, 0xC3, 0x80, 0x30, 0x7F, 0xFC, 0x0F, 0xFE, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xFE, 0x70, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0xF3, 0xF8, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0xFD, 0xF0, 0xC0, 0x0D, 0x80, 0x33,
  0x00, 0xE6, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x30, 0x70, 0x60, 0xC0, 0xC3,
  0x01, 0x8E, 0x03, 0x18, 0x06, 0x60, 0x0D, 0xE0, 0x1B, 0xC0, 0x3D, 0xC0,
  0x71, 0x80, 0xC1, 0x81, 0x83, 0x03, 0x03, 0x06, 0x07, 0x0C, 0x06, 0x18,
  0x0E, 0x30, 0x0C, 0x60, 0x1C, 0xC0, 0x19, 0x80, 0x1B, 0x00, 0x38, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xD8, 0x00, 0x6F, 0x60, 0x01, 0xBD, 0x80, 0x06, 0xF3,
  0x00, 0x33, 0xCC, 0x00, 0xCF, 0x30, 0x03, 0x3C, 0x60, 0x18, 0xF1, 0x80,
  0x63, 0xC6, 0x01, 0x8F, 0x0C, 0x0C, 0x3C, 0x30, 0x30, 0xF0, 0xC0, 0xC3,
  0xC1, 0x82, 0x0F, 0x06, 0x18, 0x3C, 0x18, 0x60, 0xF0, 0x31, 0x83, 0xC0,
  0xCC, 0x0F, 0x03, 0x30, 0x3C, 0x06, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x00, 0xE0, 0x3C, 0x03, 0x00, 0xC0, 0xE0, 0x03, 0xE0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xD8, 0x03, 0xD8, 0x03, 0xCC, 0x03, 0xCC, 0x03, 0xC6,
  0x03, 0xC6, 0x03, 0xC3, 0x03, 0xC3, 0x03, 0xC1, 0x83, 0xC1, 0x83, 0xC0,
  0xC3, 0xC0, 0xC3, 0xC0, 0x63, 0xC0, 0x73, 0xC0, 0x33, 0xC0, 0x3B, 0xC0,
  0x1B, 0xC0, 0x1F, 0xC0, 0x0D, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3E, 0xF8, 0x0E, 0x03, 0x83, 0x80,
  0x38, 0x60, 0x03, 0x1C, 0x00, 0x73, 0x00, 0x06, 0x60, 0x00, 0xDC, 0x00,
  0x1B, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00,
  0x66, 0x00, 0x0C, 0xC0, 0x01, 0x9C, 0x00, 0x71, 0x80, 0x0C, 0x38, 0x03,
  0x83, 0x80, 0xE0, 0x3F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x87, 0xFF, 0x30,
  0x1D, 0x80, 0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x7C, 0x03, 0x60, 0x7B, 0xFF, 0x9F, 0xE0, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x00, 0x00, 0x40, 0x00, 0xFF, 0x80, 0x3E, 0xF8, 0x0E,
  0x03, 0x83, 0x80, 0x38, 0x60, 0x03, 0x1C, 0x00, 0x73, 0x00, 0x06, 0x60,
  0x00, 0xDC, 0x00, 0x1B, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xB0, 0x00, 0x66, 0x00, 0x0C, 0xC0, 0x01, 0x9C, 0x00, 0x71, 0x80,
  0x0C, 0x38, 0x03, 0x83, 0x80, 0xE0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0x01,
  0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0xFF, 0x81, 0xFF, 0xC3, 0x01, 0xC6, 0x01, 0xCC, 0x01, 0x98, 0x03,
  0x30, 0x06, 0x60, 0x0C, 0xC0, 0x19, 0x80, 0x33, 0x00, 0x66, 0x01, 0xCC,
  0x07, 0x1F, 0xFC, 0x3F, 0xE0, 0x60, 0xC0, 0xC1, 0x81, 0x81, 0x83, 0x03,
  0x06, 0x03, 0x0C, 0x06, 0x18, 0x06, 0x30, 0x0C, 0x60, 0x0C, 0xC0, 0x19,
  0x80, 0x1B, 0x00, 0x38, 0x01, 0x00, 0xFF, 0x8F, 0xFE, 0xE0, 0x2E, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x34, 0x03, 0xBF, 0xF9,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x06, 0xE0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x3F, 0xF8, 0x0F, 0xF0, 0xC0,
  0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0x66, 0x00, 0x31, 0x80, 0x18,
  0xC0, 0x1C, 0x60, 0x0C, 0x38, 0x06, 0x0C, 0x03, 0x06, 0x03, 0x03, 0x01,
  0x81, 0xC0, 0xC0, 0x60, 0xE0, 0x30, 0x60, 0x18, 0x30, 0x06, 0x18, 0x03,
  0x18, 0x01, 0x8C, 0x00, 0xC6, 0x00, 0x33, 0x00, 0x1B, 0x00, 0x0D, 0x80,
  0x06, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xE0, 0x06, 0x00,
  0x36, 0x00, 0x70, 0x07, 0x60, 0x07, 0x00, 0x66, 0x00, 0xF0, 0x06, 0x70,
  0x0F, 0x00, 0x63, 0x00, 0xD0, 0x06, 0x30, 0x0D, 0x80, 0xE3, 0x01, 0x98,
  0x0C, 0x30, 0x19, 0x80, 0xC1, 0x81, 0x98, 0x0C, 0x18, 0x18, 0xC1, 0xC1,
  0x81, 0x0C, 0x18, 0x18, 0x30, 0xC1, 0x81, 0xC3, 0x0C, 0x18, 0x0C, 0x30,
  0x41, 0x80, 0xC3, 0x06, 0x30, 0x0C, 0x60, 0x63, 0x00, 0xE6, 0x06, 0x30,
  0x06, 0x60, 0x63, 0x00, 0x66, 0x03, 0x70, 0x06, 0x40, 0x36, 0x00, 0x6C,
  0x03, 0x60, 0x03, 0xC0, 0x36, 0x00, 0x3C, 0x01, 0x60, 0x03, 0xC0, 0x1C,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x06, 0x30, 0x0E,
  0x30, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x30, 0x06, 0x30,
  0x06, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x06, 0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30,
  0x18, 0x18, 0x18, 0x18, 0x38, 0x1C, 0x30, 0x0C, 0x70, 0x0E, 0x60, 0x06,
  0xE0, 0x07, 0xC0, 0x07, 0x60, 0x06, 0x60, 0x0C, 0x70, 0x0C, 0x30, 0x1C,
  0x30, 0x18, 0x18, 0x18, 0x18, 0x30, 0x1C, 0x30, 0x0C, 0x30, 0x0C, 0x60,
  0x06, 0x60, 0x06, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xF9, 0xFF, 0xE0,
  0x01, 0x80, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x01, 0x80,
  0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0xFF, 0xFF,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x01, 0x80, 0x03, 0x80, 0x03,
  0xC0, 0x06, 0xC0, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18, 0x30, 0x18,
  0x18, 0x30, 0x18, 0x30, 0x0C, 0x60, 0x0C, 0x60, 0x06, 0xC0, 0x06, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x01, 0x80,
  0xFF, 0x0E, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x1F, 0xC7, 0xFE, 0x70, 0x37, 0x01, 0xB0, 0x0D, 0x80, 0x7C, 0x07,
  0x60, 0x3B, 0x01, 0xD8, 0x16, 0x73, 0xB1, 0xF9, 0x80, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC1,
  0x03, 0x3F, 0x8D, 0x8F, 0x3C, 0x0C, 0xE0, 0x1B, 0x80, 0x6C, 0x01, 0xB0,
  0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x06, 0xE0, 0x1B, 0x80, 0xEF, 0x03, 0x37, 0x78, 0xCF, 0xC0,
  0x01, 0x01, 0xFC, 0xF1, 0x98, 0x06, 0x00, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x1F, 0xF0, 0xFE, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x02, 0x0C, 0x7F, 0x33, 0x8E,
  0xDC, 0x0F, 0x60, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xE0,
  0x1D, 0x80, 0x77, 0x02, 0xCF, 0x7B, 0x1F, 0xCC, 0x02, 0x00, 0xFE, 0x0E,
  0x38, 0xE0, 0x66, 0x03, 0x30, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03,
  0x00, 0x0C, 0x02, 0x7D, 0xE0, 0xFF, 0x00, 0x03, 0xE1, 0xFC, 0x30, 0x06,
  0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x1F, 0xF3, 0xFE, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x06,
  0x00, 0x7F, 0x33, 0x8E, 0xDC, 0x0F, 0x60, 0x1F, 0x80, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x07, 0xE0, 0x1D, 0x80, 0xF7, 0x02, 0xCF, 0x7B, 0x1F, 0x8C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x90, 0x1C,
  0x7F, 0xE0, 0xFF, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC3, 0x06, 0x7F, 0x36, 0x39, 0xE0, 0x6E,
  0x03, 0x70, 0x1B, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C,
  0x30, 0xC2, 0x00, 0x00, 0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x31, 0xFE, 0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x06, 0xC0, 0xCC, 0x1C, 0xC1, 0x8C, 0x30,
  0xC7, 0x0C, 0x60, 0xCC, 0x0D, 0xC0, 0xF6, 0x0F, 0x60, 0xE3, 0x0C, 0x30,
  0xC1, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x02, 0x01, 0x83, 0x3F, 0x1F,
  0xCD, 0x8E, 0xE7, 0xBC, 0x1A, 0x06, 0xE0, 0x78, 0x1B, 0x00, 0xC0, 0x7C,
  0x03, 0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0,
  0x0C, 0x03, 0xC0, 0x30, 0x0C, 0x03, 0x06, 0x7F, 0x37, 0x3D, 0xE0, 0x6E,
  0x03, 0x60, 0x1B, 0x00, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0x80, 0x03, 0x00, 0x7F, 0x83, 0x87, 0x1C, 0x0E, 0x60,
  0x19, 0x80, 0x6C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x60, 0x19, 0x80, 0x63,
  0x03, 0x0F, 0xFC, 0x0F, 0xC0, 0x03, 0x03, 0x3F, 0x8D, 0x8F, 0x3C, 0x0C,
  0xE0, 0x1B, 0x80, 0x6C, 0x01, 0xB0, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x06, 0xE0, 0x1B, 0x80,
  0xEF, 0x03, 0x37, 0x78, 0xCF, 0xC3, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00, 0x02, 0x00,
  0x7F, 0x33, 0x8E, 0xDC, 0x0B, 0x60, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xF0, 0x07, 0xE0, 0x1D, 0x80, 0xF7, 0x02, 0xCF, 0x73, 0x1F, 0x8C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x03, 0x67, 0xF7, 0xDE, 0x0E, 0x07, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x00, 0x02, 0x01, 0xFE, 0x38, 0x66, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x06,
  0x00, 0x60, 0x03, 0x00, 0x70, 0x06, 0x80, 0x6F, 0xBC, 0x7F, 0x80, 0x30,
  0x30, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3D, 0x1F,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7E, 0x0D, 0x7F, 0x93, 0xF1, 0xC0, 0x0D, 0x80, 0x76, 0x01, 0x98,
  0x06, 0x70, 0x18, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x18, 0x70, 0x61, 0x81,
  0x86, 0x06, 0x18, 0x0C, 0xC0, 0x33, 0x00, 0xCC, 0x01, 0xB0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x00, 0xC0, 0xE0, 0x38, 0x06, 0xC0, 0x70, 0x19, 0x80,
  0xE0, 0x33, 0x01, 0x60, 0x63, 0x06, 0xC0, 0xC6, 0x0D, 0x83, 0x8C, 0x19,
  0x06, 0x18, 0x33, 0x0C, 0x38, 0xC6, 0x18, 0x31, 0x8C, 0x30, 0x63, 0x08,
  0xC0, 0xC6, 0x19, 0x81, 0x98, 0x33, 0x01, 0xB0, 0x66, 0x03, 0x60, 0xD8,
  0x06, 0xC0, 0xF0, 0x0D, 0x01, 0xE0, 0x0E, 0x03, 0xC0, 0x1C, 0x07, 0x00,
  0x38, 0x06, 0x00, 0xE0, 0x3B, 0x01, 0x9C, 0x1C, 0x60, 0xC1, 0x8C, 0x0C,
  0x60, 0x36, 0x01, 0xB0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1B, 0x00, 0xD8,
  0x0C, 0x60, 0x63, 0x06, 0x0C, 0x30, 0x63, 0x01, 0xB8, 0x0D, 0x80, 0x30,
  0xE0, 0x0D, 0x80, 0x36, 0x01, 0xDC, 0x06, 0x30, 0x18, 0xC0, 0x63, 0x03,
  0x06, 0x0C, 0x18, 0x30, 0x61, 0x80, 0xC6, 0x03, 0x18, 0x0C, 0x60, 0x33,
  0x00, 0x6C, 0x01, 0xB0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x3F,
  0x00, 0xF0, 0x00, 0x7F, 0xEF, 0xF8, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00,
  0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0C, 0x01,
  0x80, 0x60, 0x0C, 0x03, 0xFF, 0xFF, 0xF0, 0x03, 0xC1, 0xF0, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x1C, 0x06,
  0x01, 0x83, 0xC0, 0xE0, 0x1E, 0x01, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x1F, 0x01,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0,
  0x3E, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x1E, 0x01, 0xC1, 0xE0, 0xE0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x07,
  0x01, 0x83, 0xE0, 0xE0, 0x00, 0x7F, 0x03, 0xCF, 0x8E, 0x03, 0xF0, 0x00,
  0x80,
};

const GFXglyph NotoSans_Condensed_Light38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 27, 9, 3, -27 },
  { 12, 9, 10, 13, 2, -27 },
  { 24, 17, 27, 19, 1, -27 },
  { 82, 14, 31, 17, 2, -29 },
  { 137, 22, 28, 26, 2, -28 },
  { 214, 18, 28, 20, 1, -28 },
  { 277, 3, 10, 7, 2, -27 },
  { 281, 7, 33, 11, 2, -27 },
  { 310, 8, 33, 11, 1, -27 },
  { 343, 12, 13, 16, 2, -29 },
  { 363, 15, 17, 18, 1, -22 },
  { 395, 5, 9, 8, 1, -4 },
  { 401, 9, 2, 11, 1, -11 },
  { 404, 3, 3, 8, 3, -3 },
  { 406, 12, 27, 13, 1, -27 },
  { 447, 14, 28, 17, 2, -28 },
  { 496, 8, 27, 17, 3, -27 },
  { 523, 13, 28, 17, 2, -28 },
  { 569, 13, 28, 17, 2, -28 },
  { 615, 16, 27, 17, 1, -27 },
  { 669, 14, 27, 17, 2, -27 },
  { 717, 14, 27, 17, 2, -27 },
  { 765, 14, 27, 17, 2, -27 },
  { 813, 14, 28, 17, 2, -28 },
  { 862, 13, 28, 17, 2, -28 },
  { 908, 3, 20, 8, 3, -20 },
  { 916, 5, 25, 8, 1, -20 },
  { 932, 15, 17, 18, 1, -22 },
  { 964, 15, 10, 18, 1, -18 },
  { 983, 15, 17, 18, 1, -22 },
  { 1015, 11, 28, 13, 1, -28 },
  { 1054, 23, 30, 27, 2, -27 },
  { 1141, 18, 27, 18, 0, -27 },
  { 1202, 15, 27, 19, 3, -27 },
  { 1253, 16, 28, 19, 2, -28 },
  { 1309, 16, 27, 21, 3, -27 },
  { 1363, 12, 27, 17, 3, -27 },
  { 1404, 12, 27, 16, 3, -27 },
  { 1445, 18, 28, 22, 2, -28 },
  { 1508, 16, 27, 22, 3, -27 },
  { 1562, 7, 27, 10, 2, -27 },
  { 1586, 7, 34, 8, -2, -27 },
  { 1616, 15, 27, 18, 3, -27 },
  { 1667, 12, 27, 15, 3, -27 },
  { 1708, 22, 27, 28, 3, -27 },
  { 1783, 16, 27, 23, 3, -27 },
  { 1837, 19, 28, 23, 2, -28 },
  { 1904, 13, 27, 18, 3, -27 },
  { 1948, 19, 34, 23, 2, -28 },
  { 2029, 15, 27, 18, 3, -27 },
  { 2080, 13, 28, 17, 2, -28 },
  { 2126, 15, 27, 16, 0, -27 },
  { 2177, 16, 27, 22, 3, -27 },
  { 2231, 17, 27, 17, 0, -27 },
  { 2289, 28, 27, 28, 0, -27 },
  { 2384, 16, 27, 16, 0, -27 },
  { 2438, 16, 27, 16, 0, -27 },
  { 2492, 14, 27, 16, 1, -27 },
  { 2540, 8, 33, 12, 3, -27 },
  { 2573, 12, 27, 13, 1, -27 },
  { 2614, 8, 33, 12, 1, -27 },
  { 2647, 16, 15, 18, 1, -27 },
  { 2677, 16, 2, 16, 0, 3 },
  { 2681, 6, 6, 10, 2, -29 },
  { 2686, 13, 21, 16, 1, -21 },
  { 2721, 14, 29, 19, 3, -29 },
  { 2772, 11, 21, 14, 2, -21 },
  { 2801, 14, 29, 19, 2, -29 },
  { 2852, 13, 21, 17, 2, -21 },
  { 2887, 11, 29, 10, 0, -29 },
  { 2927, 14, 30, 19, 2, -21 },
  { 2980, 13, 29, 18, 3, -29 },
  { 3028, 2, 28, 8, 3, -28 },
  { 3035, 6, 37, 8, -1, -28 },
  { 3063, 12, 29, 15, 3, -29 },
  { 3107, 2, 29, 8, 3, -29 },
  { 3115, 22, 21, 27, 3, -21 },
  { 3173, 13, 21, 18, 3, -21 },
  { 3208, 14, 21, 18, 2, -21 },
  { 3245, 14, 30, 19, 3, -21 },
  { 3298, 14, 30, 19, 2, -21 },
  { 3351, 9, 21, 12, 3, -21 },
  { 3375, 12, 21, 14, 1, -21 },
  { 3407, 8, 25, 10, 1, -25 },
  { 3432, 12, 20, 18, 3, -20 },
  { 3462, 14, 20, 14, 0, -20 },
  { 3497, 23, 20, 23, 0, -20 },
  { 3555, 13, 20, 15, 1, -20 },
  { 3588, 14, 29, 14, 0, -20 },
  { 3639, 11, 20, 13, 1, -20 },
  { 3667, 10, 33, 13, 2, -27 },
  { 3709, 2, 38, 17, 7, -29 },
  { 3719, 10, 33, 13, 2, -27 },
  { 3761, 15, 4, 18, 1, -15 },
};

const GFXfont NotoSans_Condensed_Light38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light38pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_CONDENSED_LIGHT38PT7B_H_
