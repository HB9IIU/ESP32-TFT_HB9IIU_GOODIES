#ifndef _NOTOSANS_CONDENSED_LIGHT47PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light47pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76, 0x66, 0x66, 0x66,
  0x66, 0x60, 0x00, 0x00, 0x7F, 0xF7, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1,
  0xF8, 0x7E, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x03, 0x40, 0xC0, 0x00,
  0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x01, 0x80,
  0xC0, 0x06, 0x03, 0x00, 0x18, 0x18, 0x00, 0x60, 0x60, 0x01, 0x81, 0x80,
  0x06, 0x06, 0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x03, 0x01, 0x80, 0x0C,
  0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0C, 0x0C,
  0x00, 0x70, 0x30, 0x01, 0x80, 0xC0, 0x06, 0x07, 0x03, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x06, 0x06, 0x00, 0x38, 0x18, 0x00, 0xC0,
  0x60, 0x03, 0x03, 0x80, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x00, 0xC0, 0xC0,
  0x03, 0x03, 0x00, 0x1C, 0x0C, 0x00, 0x60, 0x70, 0x00, 0x00, 0x80, 0x00,
  0x40, 0x00, 0x20, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xE2, 0x1C,
  0xE1, 0x00, 0x60, 0x80, 0x70, 0x40, 0x38, 0x20, 0x18, 0x10, 0x0E, 0x08,
  0x07, 0x04, 0x01, 0x82, 0x00, 0xE1, 0x00, 0x3C, 0x80, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x04, 0xF0, 0x02, 0x1C, 0x01, 0x07,
  0x00, 0x81, 0x80, 0x40, 0xC0, 0x20, 0x60, 0x10, 0x30, 0x08, 0x18, 0x04,
  0x1E, 0x02, 0x1D, 0xE1, 0x1E, 0xFF, 0xFC, 0x1F, 0xFC, 0x00, 0x20, 0x00,
  0x10, 0x00, 0x08, 0x00, 0x04, 0x00, 0x02, 0x00, 0x0F, 0x00, 0x1C, 0x03,
  0xF8, 0x01, 0x80, 0x31, 0xC0, 0x18, 0x06, 0x0C, 0x03, 0x80, 0x60, 0xE0,
  0x30, 0x06, 0x06, 0x07, 0x00, 0xE0, 0x60, 0x60, 0x0E, 0x06, 0x06, 0x00,
  0xC0, 0x60, 0xE0, 0x0C, 0x06, 0x0C, 0x00, 0xC0, 0x61, 0xC0, 0x0C, 0x06,
  0x18, 0x00, 0xC0, 0x61, 0x80, 0x0C, 0x06, 0x38, 0x60, 0xE0, 0x63, 0x1F,
  0x86, 0x0E, 0x73, 0x9C, 0x60, 0xC6, 0x30, 0xC6, 0x0C, 0x67, 0x06, 0x31,
  0xCE, 0x60, 0x63, 0xF8, 0xC6, 0x06, 0x0F, 0x1C, 0x60, 0x60, 0x01, 0x86,
  0x07, 0x00, 0x18, 0x60, 0x70, 0x03, 0x06, 0x07, 0x00, 0x30, 0x60, 0x70,
  0x07, 0x06, 0x07, 0x00, 0x60, 0x60, 0x70, 0x06, 0x06, 0x06, 0x00, 0xC0,
  0x60, 0x60, 0x0C, 0x06, 0x06, 0x01, 0xC0, 0x70, 0xE0, 0x18, 0x03, 0x0C,
  0x01, 0x80, 0x1F, 0xC0, 0x30, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01,
  0x80, 0xC0, 0x06, 0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x30, 0x01, 0xC1,
  0xC0, 0x03, 0x06, 0x00, 0x0E, 0x38, 0x00, 0x19, 0xC0, 0x00, 0x7E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x01, 0xCE, 0x00, 0x0E,
  0x1C, 0x0E, 0x70, 0x70, 0x39, 0x80, 0xE0, 0xCE, 0x01, 0xC3, 0x38, 0x07,
  0x1C, 0xC0, 0x0E, 0x63, 0x00, 0x1F, 0x8C, 0x00, 0x3E, 0x38, 0x00, 0xF0,
  0xE0, 0x03, 0xC3, 0x80, 0x1F, 0x87, 0x00, 0xF7, 0x1E, 0x07, 0x9C, 0x3F,
  0xFC, 0x38, 0x3F, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF4, 0x01, 0x81,
  0xC1, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x38, 0x1C, 0x0C, 0x0E, 0x07,
  0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60, 0x38, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0x80, 0xE0, 0x70,
  0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03,
  0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0xE0, 0x00, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xC1, 0x82, 0xF9, 0x9F, 0xFF, 0xFF,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x60, 0x0C, 0x30, 0x1C, 0x38,
  0x38, 0x1C, 0x18, 0x10, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x39, 0xCE, 0x67, 0x39, 0x8C, 0xE6,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0x07, 0xFC, 0x07, 0xCF, 0x03, 0x81, 0xC3, 0x80, 0x61, 0xC0,
  0x39, 0xC0, 0x1C, 0xE0, 0x06, 0x70, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0E, 0xC0, 0x07, 0x60, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0x63,
  0x00, 0x71, 0xC0, 0x30, 0x70, 0x38, 0x3C, 0x38, 0x0F, 0xFC, 0x03, 0xF8,
  0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x3F, 0x1D, 0xDE, 0x7F, 0x1F, 0x87, 0x41,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x07, 0xE0, 0x1F, 0xFC,
  0x3F, 0x1F, 0x0E, 0x01, 0xC4, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F,
  0xFC, 0x1F, 0x1F, 0x1C, 0x01, 0xC4, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0xF0, 0x1F, 0xE0, 0x0F, 0xC0, 0x07, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x3A, 0x00, 0x3D, 0xC0, 0x3C, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0x70, 0x00, 0x77, 0x00, 0x06, 0x70, 0x00, 0xE7, 0x00, 0x0C, 0x70, 0x01,
  0xC7, 0x00, 0x18, 0x70, 0x03, 0x87, 0x00, 0x30, 0x70, 0x06, 0x07, 0x00,
  0xE0, 0x70, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x07, 0x03, 0x80, 0x70,
  0x30, 0x07, 0x07, 0x00, 0x70, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x7F,
  0xFC, 0x7F, 0xFC, 0x7F, 0xFC, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x60, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x80,
  0x1C, 0xC0, 0x7C, 0xFF, 0xF0, 0x7F, 0xE0, 0x00, 0x7F, 0x01, 0xFF, 0x81,
  0xF0, 0xC1, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x0F,
  0x81, 0x9F, 0xF0, 0xDF, 0x7C, 0xEC, 0x07, 0x7C, 0x03, 0xBC, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0xB0, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x73, 0x00, 0x39, 0xC0, 0x18, 0xE0,
  0x1C, 0x3C, 0x1C, 0x0F, 0xFC, 0x03, 0xFC, 0x00, 0x10, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xE3, 0xE0, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x00,
  0xE7, 0x00, 0x39, 0x80, 0x0E, 0x60, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x30,
  0xC0, 0x1C, 0x38, 0x0E, 0x07, 0x07, 0x80, 0xF3, 0x80, 0x1F, 0xC0, 0x03,
  0xE0, 0x01, 0xFE, 0x01, 0xE3, 0xC0, 0xF0, 0x38, 0x70, 0x07, 0x1C, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x06, 0xE0, 0x03, 0x98, 0x00, 0xE7, 0x00, 0x70, 0xF0, 0x3C, 0x1F,
  0xFE, 0x03, 0xFE, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01,
  0xC7, 0x00, 0xE3, 0x80, 0x39, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0E,
  0xC0, 0x07, 0x70, 0x07, 0xB8, 0x07, 0xCF, 0x06, 0xE3, 0xFF, 0x70, 0xFE,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0,
  0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x3B, 0xDE, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9C, 0xEE, 0x73, 0x98, 0xCE,
  0x63, 0x00, 0x00, 0x00, 0x40, 0x00, 0x70, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x00,
  0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x38, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x3E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x03, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0x87, 0xFF, 0x3E,
  0x7C, 0x80, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x1C, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0x1F, 0x80, 0x03, 0x80, 0x1E, 0x00, 0x38, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x38, 0x00, 0x03, 0x03, 0x80, 0x00, 0x1C, 0x18, 0x00, 0x00,
  0x61, 0xC0, 0x00, 0x03, 0x8C, 0x03, 0xFC, 0x0C, 0x60, 0x3F, 0xE0, 0x67,
  0x03, 0x83, 0x03, 0x30, 0x18, 0x18, 0x1D, 0x81, 0xC0, 0xC0, 0xEC, 0x0C,
  0x06, 0x03, 0x60, 0x60, 0x30, 0x1B, 0x07, 0x01, 0x80, 0xF8, 0x38, 0x0C,
  0x07, 0xC1, 0x80, 0x60, 0x7E, 0x0C, 0x03, 0x03, 0xF0, 0x60, 0x38, 0x1F,
  0x83, 0x81, 0xC0, 0xCC, 0x1C, 0x0E, 0x06, 0x60, 0x60, 0x50, 0x73, 0x03,
  0x86, 0xC3, 0x18, 0x0E, 0x67, 0x38, 0xE0, 0x7F, 0x1F, 0x87, 0x00, 0xE0,
  0x70, 0x18, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07,
  0x80, 0x30, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xB0, 0x00, 0x0C, 0xC0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x06,
  0x18, 0x00, 0x18, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x00, 0x0C, 0x0C,
  0x00, 0x30, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x01, 0x80, 0x18, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x18, 0x00, 0x60, 0xE0, 0x01, 0xC3, 0x80, 0x07,
  0x0E, 0x00, 0x0C, 0x30, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x98,
  0x00, 0x06, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0xFF, 0x00, 0x3F, 0xFE,
  0x0F, 0xFF, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x3B,
  0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0,
  0x07, 0x38, 0x01, 0xCE, 0x00, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xFF,
  0x8E, 0x00, 0xF3, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06, 0xE0,
  0x03, 0xB8, 0x00, 0xEE, 0x00, 0x73, 0x81, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x1F, 0x9F, 0x07, 0x80, 0x21, 0xE0,
  0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00,
  0x06, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x06, 0x07, 0xFF, 0xC0, 0x3F, 0xF0, 0xFF, 0x80,
  0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x0E, 0x01, 0xF0, 0xE0, 0x07, 0x0E, 0x00,
  0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00,
  0x78, 0xE0, 0x0F, 0x0E, 0x0F, 0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0x1F, 0x83, 0xC0, 0x06, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00,
  0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x71, 0xE0, 0x01,
  0xC3, 0xE0, 0x0F, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x1E, 0xFF,
  0x3F, 0x83, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x38,
  0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38,
  0x38, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x0E, 0x70,
  0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3E, 0xE0, 0x0F, 0xB8, 0x03, 0xC7, 0x00,
  0xE1, 0xC0, 0x38, 0x38, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x38,
  0x0E, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00,
  0x73, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFD, 0x80, 0x00,
  0x37, 0xB0, 0x00, 0x0F, 0xF7, 0x00, 0x01, 0xFE, 0xE0, 0x00, 0x37, 0xCC,
  0x00, 0x0E, 0xF9, 0xC0, 0x01, 0xDF, 0x38, 0x00, 0x33, 0xE3, 0x00, 0x06,
  0x7C, 0x70, 0x01, 0xCF, 0x8E, 0x00, 0x31, 0xF0, 0xC0, 0x06, 0x3E, 0x1C,
  0x01, 0xC7, 0xC3, 0x80, 0x30, 0xF8, 0x30, 0x06, 0x1F, 0x07, 0x01, 0xC3,
  0xE0, 0xE0, 0x30, 0x7C, 0x0C, 0x06, 0x0F, 0x81, 0xC1, 0xC1, 0xF0, 0x38,
  0x30, 0x3E, 0x03, 0x06, 0x07, 0xC0, 0x71, 0xC0, 0xF8, 0x0E, 0x30, 0x1F,
  0x00, 0xC6, 0x03, 0xE0, 0x1D, 0xC0, 0x7C, 0x03, 0xB0, 0x0F, 0x80, 0x36,
  0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0xF8,
  0x01, 0xC0, 0x1C, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x3D, 0xC0, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x03, 0xCE,
  0x00, 0x3C, 0x70, 0x03, 0xC7, 0x00, 0x3C, 0x38, 0x03, 0xC3, 0x80, 0x3C,
  0x1C, 0x03, 0xC1, 0xC0, 0x3C, 0x0E, 0x03, 0xC0, 0xE0, 0x3C, 0x07, 0x03,
  0xC0, 0x70, 0x3C, 0x03, 0x83, 0xC0, 0x38, 0x3C, 0x01, 0xC3, 0xC0, 0x1C,
  0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0x73, 0xC0, 0x07, 0x3C, 0x00,
  0x3B, 0xC0, 0x03, 0xBC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x3F,
  0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x07, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x0E,
  0x38, 0x00, 0x1C, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x1C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80, 0x01,
  0xC3, 0x80, 0x03, 0x87, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x07, 0x81, 0xF0,
  0x07, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0xFF, 0xFC,
  0xE0, 0x3C, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0E, 0xE0, 0x1E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x3F, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x60, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0xD8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xB8, 0x00, 0x03, 0x70, 0x00, 0x0E, 0xE0,
  0x00, 0x1C, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x63, 0x80, 0x01, 0xC3, 0x80,
  0x03, 0x87, 0x00, 0x0E, 0x07, 0x00, 0x38, 0x07, 0x81, 0xF0, 0x07, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0xFE, 0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0x80, 0xF8,
  0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x03, 0x38,
  0x00, 0xCE, 0x00, 0x33, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00,
  0xE3, 0x80, 0x38, 0xE0, 0x3C, 0x3F, 0xFE, 0x0F, 0xFE, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x38,
  0x07, 0x0E, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x70, 0x03, 0xF8, 0x07, 0xFF,
  0x87, 0xEF, 0xC7, 0x00, 0x27, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x3A,
  0x00, 0x39, 0xC0, 0x7C, 0xFF, 0xFC, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0C, 0xE0, 0x03, 0x9E, 0x00, 0xE1, 0xE0, 0x3C, 0x1F, 0xFF,
  0x00, 0xFF, 0x80, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xD8, 0x00, 0x0E, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0x38, 0x00, 0x38, 0xC0, 0x01, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0x61, 0xC0, 0x07, 0x06, 0x00, 0x38, 0x38, 0x01, 0x81, 0xC0,
  0x1C, 0x06, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80,
  0x30, 0x1C, 0x01, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x30, 0x70, 0x01, 0x83,
  0x80, 0x0E, 0x18, 0x00, 0x70, 0xC0, 0x01, 0x8E, 0x00, 0x0C, 0x70, 0x00,
  0x73, 0x00, 0x03, 0xB8, 0x00, 0x0D, 0xC0, 0x00, 0x6C, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xEC, 0x00, 0x1C, 0x00, 0x1D, 0xC0, 0x03, 0x80, 0x03, 0x38, 0x00,
  0x70, 0x00, 0xE7, 0x00, 0x1B, 0x00, 0x1C, 0x60, 0x03, 0x60, 0x03, 0x8E,
  0x00, 0x6C, 0x00, 0x61, 0xC0, 0x0D, 0x80, 0x1C, 0x38, 0x03, 0xB8, 0x03,
  0x83, 0x00, 0x77, 0x00, 0x70, 0x60, 0x0C, 0x60, 0x0C, 0x0E, 0x01, 0x8C,
  0x03, 0x81, 0xC0, 0x31, 0xC0, 0x70, 0x38, 0x0E, 0x38, 0x0E, 0x03, 0x01,
  0x83, 0x01, 0xC0, 0x70, 0x30, 0x60, 0x30, 0x0E, 0x06, 0x0C, 0x0E, 0x01,
  0xC1, 0xC1, 0xC1, 0xC0, 0x18, 0x38, 0x38, 0x38, 0x03, 0x06, 0x03, 0x06,
  0x00, 0x70, 0xC0, 0x61, 0xC0, 0x0E, 0x38, 0x0E, 0x38, 0x01, 0xC7, 0x01,
  0xC7, 0x00, 0x18, 0xC0, 0x18, 0xC0, 0x03, 0x98, 0x03, 0x18, 0x00, 0x73,
  0x00, 0x67, 0x00, 0x0E, 0xE0, 0x0E, 0xE0, 0x00, 0xDC, 0x00, 0xD8, 0x00,
  0x1B, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x03, 0x60, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x07, 0x0C, 0x00, 0xE1,
  0xC0, 0x38, 0x18, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x07, 0x06, 0x00,
  0xE1, 0xC0, 0x0E, 0x30, 0x01, 0xCE, 0x00, 0x19, 0xC0, 0x03, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x19, 0x80, 0x07, 0x38, 0x00, 0xC3, 0x00, 0x38, 0x70, 0x06,
  0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x70,
  0x03, 0x0E, 0x00, 0x73, 0x80, 0x06, 0x70, 0x00, 0xFC, 0x00, 0x1C, 0xE0,
  0x00, 0xFC, 0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00, 0xE3, 0x00, 0x1C, 0x70,
  0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x18, 0x1C, 0x07, 0x01, 0x80, 0xE0, 0x38,
  0x38, 0x07, 0x07, 0x00, 0x70, 0xC0, 0x0E, 0x38, 0x00, 0xC7, 0x00, 0x1C,
  0xC0, 0x03, 0xB8, 0x00, 0x36, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0x80, 0x01,
  0xC0, 0x00, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0xFF, 0xFF, 0x80, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x19, 0x80, 0x03, 0x9C, 0x00, 0x30, 0xC0,
  0x07, 0x0E, 0x00, 0x60, 0x60, 0x0E, 0x07, 0x00, 0xC0, 0x30, 0x1C, 0x03,
  0x81, 0x80, 0x18, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00,
  0x06, 0xE0, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x70,
  0x38, 0x1C, 0x0E, 0x06, 0x03, 0x1F, 0xF0, 0x7F, 0xF0, 0xC0, 0x70, 0x00,
  0x60, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0C,
  0x01, 0xF8, 0x7F, 0xF1, 0xF8, 0x6F, 0x00, 0xDC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xFC, 0x02, 0xDC, 0x0D,
  0xBF, 0xF3, 0x1F, 0xC6, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x8F, 0xE0, 0xE7, 0xFE, 0x3B, 0x03, 0xCF,
  0x80, 0x73, 0xC0, 0x0E, 0xF0, 0x03, 0xBC, 0x00, 0x6E, 0x00, 0x1B, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xBC, 0x00, 0xEF,
  0x00, 0x3B, 0xC0, 0x0C, 0xF8, 0x07, 0x3B, 0x03, 0x8E, 0x7F, 0xE3, 0x8F,
  0xE0, 0x03, 0xFC, 0x3F, 0xF1, 0xE0, 0x4F, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xE0, 0x43, 0xFF, 0x07, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x1F, 0xC7,
  0x0F, 0xF9, 0xC7, 0x03, 0x73, 0x80, 0x7C, 0xC0, 0x0F, 0x70, 0x03, 0xDC,
  0x00, 0xF6, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0x60, 0x01, 0xDC, 0x00, 0xF7, 0x00, 0x3D, 0xC0, 0x0F, 0x38, 0x07, 0xC7,
  0x03, 0x71, 0xFF, 0x9C, 0x1F, 0xC7, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0x07,
  0x87, 0x01, 0xC3, 0x00, 0x73, 0x80, 0x19, 0xC0, 0x0C, 0xC0, 0x06, 0x60,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x08, 0x78, 0x0C, 0x1F, 0xFE, 0x07, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x83, 0xC4, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x01, 0xFF, 0x8F, 0xFC, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x07,
  0xF1, 0xC7, 0xFE, 0x71, 0xC0, 0xDC, 0xE0, 0x1F, 0x30, 0x03, 0xDC, 0x00,
  0xF7, 0x00, 0x3D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xD8, 0x00, 0x77, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xCE, 0x01,
  0xF1, 0xC0, 0xDC, 0x7F, 0xE7, 0x07, 0xF1, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x06, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x40,
  0x07, 0x1C, 0x07, 0x87, 0xFF, 0xC0, 0x7F, 0xE0, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE3, 0xF8, 0xE7, 0xFC, 0xEE, 0x0E,
  0xF8, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xEF, 0xF6, 0x00, 0x00,
  0x06, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x0E, 0x0F, 0x0E, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x0E, 0x0E, 0x0E, 0x1E, 0xFC, 0xF8, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x0E, 0xE0, 0x1C,
  0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0xE1, 0xC0,
  0xE3, 0x80, 0xE3, 0x00, 0xE7, 0x00, 0xEF, 0x80, 0xFD, 0x80, 0xF9, 0xC0,
  0xF0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x30, 0xE0, 0x38,
  0xE0, 0x18, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xE3, 0xF0, 0x3F, 0x8E, 0x7F, 0x87, 0xFC, 0xEC, 0x1C, 0xC1, 0xCF, 0x80,
  0xF8, 0x0E, 0xF0, 0x0F, 0x00, 0xEF, 0x00, 0xF0, 0x06, 0xE0, 0x07, 0x00,
  0x6E, 0x00, 0x60, 0x06, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0,
  0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60,
  0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E,
  0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06,
  0x00, 0x7E, 0x00, 0x60, 0x07, 0xE0, 0x06, 0x00, 0x7E, 0x00, 0x60, 0x07,
  0xE0, 0x06, 0x00, 0x70, 0xE3, 0xF8, 0xE7, 0xFE, 0xEC, 0x0E, 0xF8, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x07, 0xF8, 0x03, 0xFF, 0x81, 0xC0,
  0xE0, 0xE0, 0x1C, 0x30, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x19, 0x80, 0x07,
  0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x77, 0x00,
  0x19, 0xC0, 0x0E, 0x30, 0x03, 0x8E, 0x01, 0xC1, 0xC0, 0xE0, 0x3F, 0xF8,
  0x07, 0xF8, 0x00, 0xE3, 0xF8, 0x39, 0xFF, 0x8E, 0xC0, 0xF3, 0xE0, 0x1C,
  0xF8, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6F, 0x00, 0x3B, 0xC0, 0x0E,
  0xF8, 0x03, 0x3E, 0x01, 0xCE, 0xC0, 0xE3, 0x9F, 0xF8, 0xE3, 0xF8, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xF1, 0xC3, 0xFE, 0x71, 0xC0, 0xDC, 0xE0, 0x1F, 0x30, 0x03, 0xDC,
  0x00, 0xF7, 0x00, 0x3D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x3D, 0xC0, 0x0F, 0x70, 0x03, 0xCE,
  0x01, 0xF1, 0xC0, 0xDC, 0x7F, 0xE7, 0x07, 0xF1, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0xE3, 0xFC, 0xFF,
  0xB8, 0x76, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00, 0x1F, 0xF0, 0xFF, 0xE7,
  0x01, 0xB8, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x0E,
  0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x00, 0x1A, 0x00, 0xEC, 0x07,
  0xBF, 0xFC, 0x7F, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30,
  0x1F, 0xFF, 0xFF, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xC0, 0x1F, 0xC3, 0xF8, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x60, 0x0F, 0x70, 0x1B, 0x78, 0x3B, 0x3F, 0xF3, 0x1F,
  0xE3, 0xE0, 0x01, 0xB0, 0x01, 0xD8, 0x00, 0xEE, 0x00, 0x67, 0x00, 0x71,
  0x80, 0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x18, 0x0E, 0x0C, 0x07, 0x07, 0x03,
  0x03, 0x81, 0x80, 0xC1, 0xC0, 0x60, 0xE0, 0x38, 0x60, 0x0C, 0x70, 0x06,
  0x38, 0x03, 0x98, 0x01, 0xCC, 0x00, 0x6E, 0x00, 0x36, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x0E, 0x00, 0x78, 0x01,
  0xC0, 0x1F, 0x80, 0x78, 0x03, 0xF0, 0x0D, 0x80, 0x66, 0x01, 0xB0, 0x0C,
  0xC0, 0x36, 0x03, 0x9C, 0x0E, 0xC0, 0x73, 0x81, 0xDC, 0x0C, 0x30, 0x31,
  0x81, 0x86, 0x06, 0x30, 0x30, 0xE0, 0xC6, 0x0E, 0x1C, 0x38, 0xE1, 0xC3,
  0x86, 0x0C, 0x30, 0x30, 0xC1, 0x86, 0x06, 0x18, 0x31, 0xC0, 0xE7, 0x07,
  0x38, 0x1C, 0xC0, 0x66, 0x01, 0x98, 0x0C, 0xC0, 0x33, 0x01, 0x98, 0x07,
  0xE0, 0x37, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x38, 0x03,
  0x0C, 0x03, 0x87, 0x01, 0x81, 0x81, 0xC0, 0xE0, 0xC0, 0x30, 0xE0, 0x1C,
  0x60, 0x06, 0x70, 0x03, 0xB0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0x80, 0x0E, 0xE0, 0x0E, 0x70, 0x07, 0x1C, 0x07, 0x0E,
  0x03, 0x03, 0x83, 0x81, 0xC1, 0x80, 0x71, 0xC0, 0x38, 0xC0, 0x0E, 0xE0,
  0x03, 0x80, 0xE0, 0x01, 0xDC, 0x00, 0x67, 0x00, 0x38, 0xC0, 0x0E, 0x30,
  0x03, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x60, 0x18, 0x1C, 0x06, 0x07, 0x03,
  0x80, 0xC0, 0xE0, 0x30, 0x30, 0x0E, 0x0C, 0x03, 0x87, 0x00, 0x61, 0x80,
  0x1C, 0x60, 0x07, 0x38, 0x00, 0xCE, 0x00, 0x33, 0x00, 0x0E, 0xC0, 0x01,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7F,
  0xFB, 0xFF, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80,
  0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x18, 0x07, 0xC0, 0xFE, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x80, 0x78,
  0x0F, 0x80, 0x7C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x7F, 0x00, 0xF8, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80,
  0x07, 0xC0, 0x3F, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x7C, 0x0F,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x00, 0x7F, 0xF0, 0x3E, 0x3F,
  0xBE, 0x01, 0xFE, 0x80, 0x1E, 0x00,
};

const GFXglyph NotoSans_Condensed_Light47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 34, 11, 3, -34 },
  { 18, 10, 13, 16, 3, -34 },
  { 35, 22, 34, 24, 1, -34 },
  { 129, 17, 39, 22, 2, -36 },
  { 212, 28, 34, 32, 2, -34 },
  { 331, 22, 34, 24, 2, -34 },
  { 425, 3, 13, 9, 3, -34 },
  { 430, 9, 41, 13, 2, -34 },
  { 477, 9, 41, 13, 2, -34 },
  { 524, 16, 16, 20, 2, -36 },
  { 556, 18, 22, 22, 2, -28 },
  { 606, 5, 11, 10, 2, -5 },
  { 613, 11, 3, 13, 1, -14 },
  { 618, 4, 4, 10, 3, -4 },
  { 620, 15, 34, 16, 1, -34 },
  { 684, 17, 34, 22, 2, -34 },
  { 757, 10, 34, 22, 4, -34 },
  { 800, 17, 34, 22, 2, -34 },
  { 873, 17, 34, 22, 2, -34 },
  { 946, 20, 34, 22, 1, -34 },
  { 1031, 16, 34, 22, 3, -34 },
  { 1099, 17, 35, 22, 2, -34 },
  { 1174, 17, 34, 22, 2, -34 },
  { 1247, 18, 34, 22, 2, -34 },
  { 1324, 17, 34, 22, 2, -34 },
  { 1397, 4, 25, 10, 3, -25 },
  { 1410, 5, 31, 10, 2, -25 },
  { 1430, 18, 21, 22, 2, -27 },
  { 1478, 18, 13, 22, 2, -23 },
  { 1508, 18, 21, 22, 2, -27 },
  { 1556, 13, 34, 16, 1, -34 },
  { 1612, 29, 38, 33, 2, -34 },
  { 1750, 22, 34, 22, 0, -34 },
  { 1844, 18, 34, 24, 4, -34 },
  { 1921, 19, 34, 23, 3, -34 },
  { 2002, 20, 34, 26, 4, -34 },
  { 2087, 14, 34, 21, 4, -34 },
  { 2147, 14, 34, 19, 4, -34 },
  { 2207, 22, 34, 28, 3, -34 },
  { 2301, 19, 34, 27, 4, -34 },
  { 2382, 9, 34, 13, 2, -34 },
  { 2421, 10, 43, 10, -3, -34 },
  { 2475, 18, 34, 22, 4, -34 },
  { 2552, 14, 34, 19, 4, -34 },
  { 2612, 27, 34, 35, 4, -34 },
  { 2727, 20, 34, 28, 4, -34 },
  { 2812, 23, 34, 28, 3, -34 },
  { 2910, 16, 34, 22, 4, -34 },
  { 2978, 23, 42, 28, 3, -34 },
  { 3099, 18, 34, 23, 4, -34 },
  { 3176, 17, 34, 21, 2, -34 },
  { 3249, 19, 34, 19, 0, -34 },
  { 3330, 19, 34, 27, 4, -34 },
  { 3411, 21, 34, 21, 0, -34 },
  { 3501, 35, 34, 35, 0, -34 },
  { 3650, 19, 34, 20, 0, -34 },
  { 3731, 19, 34, 19, 0, -34 },
  { 3812, 17, 34, 19, 1, -34 },
  { 3885, 9, 41, 15, 4, -34 },
  { 3932, 15, 34, 16, 1, -34 },
  { 3996, 10, 41, 15, 1, -34 },
  { 4048, 20, 19, 22, 1, -34 },
  { 4096, 20, 2, 20, 0, 4 },
  { 4101, 8, 8, 12, 2, -36 },
  { 4109, 15, 25, 20, 2, -25 },
  { 4156, 18, 36, 23, 3, -36 },
  { 4237, 14, 25, 18, 2, -25 },
  { 4281, 18, 36, 23, 2, -36 },
  { 4362, 17, 25, 21, 2, -25 },
  { 4416, 13, 36, 12, 1, -36 },
  { 4475, 18, 36, 23, 2, -25 },
  { 4556, 16, 36, 23, 3, -36 },
  { 4628, 4, 34, 10, 3, -34 },
  { 4645, 8, 45, 10, -1, -34 },
  { 4690, 16, 36, 19, 3, -36 },
  { 4762, 3, 36, 10, 3, -36 },
  { 4776, 28, 25, 34, 3, -25 },
  { 4864, 16, 25, 23, 3, -25 },
  { 4914, 18, 25, 22, 2, -25 },
  { 4971, 18, 36, 23, 3, -25 },
  { 5052, 18, 36, 23, 2, -25 },
  { 5133, 11, 25, 15, 3, -25 },
  { 5168, 14, 25, 17, 2, -25 },
  { 5212, 11, 31, 13, 1, -31 },
  { 5255, 16, 25, 23, 3, -25 },
  { 5305, 17, 25, 18, 0, -25 },
  { 5359, 27, 25, 29, 1, -25 },
  { 5444, 17, 25, 18, 1, -25 },
  { 5498, 18, 36, 18, 0, -25 },
  { 5579, 13, 25, 16, 1, -25 },
  { 5620, 13, 41, 17, 2, -34 },
  { 5687, 2, 47, 21, 9, -36 },
  { 5699, 13, 41, 17, 2, -34 },
  { 5766, 18, 5, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_Light47pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light47pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light47pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _NOTOSANS_CONDENSED_LIGHT47PT7B_H_
