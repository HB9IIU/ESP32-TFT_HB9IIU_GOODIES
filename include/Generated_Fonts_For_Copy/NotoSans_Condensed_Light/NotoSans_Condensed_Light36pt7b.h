#ifndef _NOTOSANS_CONDENSED_LIGHT36PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light36pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x00, 0x06, 0xF8, 0xE3,
  0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x43, 0x43, 0x43, 0x43, 0x02, 0x0C, 0x02,
  0x0C, 0x02, 0x08, 0x06, 0x08, 0x06, 0x08, 0x06, 0x18, 0x06, 0x18, 0x04,
  0x18, 0x7F, 0xFF, 0x04, 0x10, 0x0C, 0x10, 0x0C, 0x10, 0x0C, 0x30, 0x0C,
  0x30, 0x08, 0x30, 0x08, 0x30, 0xFF, 0xFE, 0xFF, 0xFE, 0x18, 0x20, 0x18,
  0x20, 0x18, 0x60, 0x10, 0x60, 0x10, 0x60, 0x10, 0x60, 0x30, 0x40, 0x30,
  0x40, 0x06, 0x00, 0x30, 0x03, 0xE0, 0x7F, 0xE6, 0x63, 0x63, 0x03, 0x18,
  0x10, 0xC0, 0x86, 0x06, 0x30, 0x31, 0x80, 0xCC, 0x07, 0xE0, 0x0F, 0x00,
  0x1E, 0x00, 0xFC, 0x06, 0x70, 0x31, 0x81, 0x86, 0x0C, 0x30, 0x61, 0x83,
  0x0C, 0x18, 0xD8, 0xCC, 0xFF, 0xC0, 0xF8, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x00, 0x3C, 0x03, 0x03, 0xF0, 0x18, 0x31, 0x80, 0x81, 0x86, 0x0C, 0x0C,
  0x30, 0x60, 0x41, 0x86, 0x02, 0x0C, 0x30, 0x10, 0x61, 0x00, 0x83, 0x18,
  0x04, 0x18, 0xC0, 0x20, 0xCC, 0x71, 0x86, 0x67, 0xCC, 0x32, 0x63, 0x63,
  0x33, 0x19, 0xF9, 0x90, 0x47, 0x99, 0x83, 0x00, 0xCC, 0x18, 0x04, 0x60,
  0xC0, 0x63, 0x06, 0x02, 0x18, 0x30, 0x30, 0xC1, 0x81, 0x86, 0x08, 0x08,
  0x10, 0x40, 0xC0, 0xC6, 0x04, 0x07, 0x60, 0x60, 0x1F, 0x00, 0x07, 0x80,
  0x07, 0xE0, 0x06, 0x18, 0x03, 0x0C, 0x01, 0x02, 0x00, 0x81, 0x80, 0x60,
  0x80, 0x30, 0xC0, 0x18, 0x60, 0x06, 0x60, 0x03, 0x70, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0xE6, 0x0E, 0xE1, 0x86, 0x60, 0xE3, 0x30, 0x31,
  0xB0, 0x0D, 0xD8, 0x07, 0xCC, 0x01, 0xE3, 0x00, 0x61, 0x80, 0x78, 0xE0,
  0x6E, 0x3D, 0xE3, 0x0F, 0xE0, 0xC0, 0xFB, 0x6C, 0x92, 0x48, 0x06, 0x18,
  0x60, 0xC3, 0x06, 0x18, 0x30, 0x61, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x30, 0x60, 0xC0, 0xC1, 0x81, 0x83,
  0x03, 0x03, 0xC0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x0C, 0x1C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x86, 0x0C,
  0x18, 0x60, 0xC3, 0x06, 0x18, 0x60, 0x06, 0x00, 0x40, 0x04, 0x08, 0x42,
  0xF4, 0xF7, 0xFC, 0x0E, 0x00, 0xB0, 0x19, 0x03, 0x18, 0x60, 0xC2, 0x08,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x3F, 0xFF, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x33, 0x33, 0x66, 0x64, 0xC0, 0xFF,
  0xFF, 0x7D, 0x80, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00,
  0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00,
  0x40, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xC0, 0x18, 0x00, 0x0F, 0x80, 0xFE, 0x0C, 0x38, 0xC0, 0xC6, 0x03, 0x70,
  0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0D, 0x80, 0x6C,
  0x03, 0x30, 0x19, 0x81, 0x86, 0x0C, 0x3F, 0xC0, 0xFC, 0x00, 0x06, 0x1C,
  0x79, 0xF7, 0x78, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x1F, 0x83, 0xFE,
  0x38, 0x39, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x38, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0xFF, 0x8E, 0x07, 0x10, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00,
  0x78, 0x0F, 0x80, 0x3F, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01, 0xA0, 0x0C, 0xF9, 0xF1,
  0xFF, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x05, 0x80, 0x1B, 0x00,
  0x26, 0x00, 0xCC, 0x01, 0x18, 0x06, 0x30, 0x18, 0x60, 0x30, 0xC0, 0xC1,
  0x81, 0x83, 0x06, 0x06, 0x0C, 0x0C, 0x30, 0x18, 0x60, 0x31, 0x80, 0x63,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x7F, 0xE3, 0xFF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x40, 0x02, 0x00, 0x31, 0x01, 0xFF, 0x86, 0x1E,
  0x00, 0x38, 0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0xD0, 0x1C, 0xFF, 0xC3, 0xFC, 0x00, 0x03, 0xF0,
  0x7F, 0x87, 0x00, 0x70, 0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x31, 0xE1, 0xBF, 0xCF, 0x07, 0x70, 0x1B, 0x00, 0xD8, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xB0, 0x19, 0x80, 0xC6,
  0x0E, 0x3D, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x00,
  0x0F, 0xC0, 0x7F, 0xC3, 0x83, 0x0C, 0x06, 0x60, 0x19, 0x80, 0x66, 0x01,
  0x98, 0x06, 0x30, 0x18, 0xE0, 0xC1, 0xC6, 0x03, 0xF0, 0x07, 0x80, 0x3F,
  0x01, 0x87, 0x0C, 0x0E, 0x60, 0x19, 0x80, 0x36, 0x00, 0xF0, 0x03, 0xE0,
  0x0D, 0x80, 0x36, 0x01, 0x9C, 0x0E, 0x3E, 0xF0, 0x3F, 0x80, 0x1F, 0x01,
  0xFE, 0x1C, 0x39, 0xC0, 0xCC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x36, 0x00, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xB0, 0x2D, 0xFF, 0x47, 0xE6,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x38, 0x6F, 0x83, 0xF0, 0x00, 0x7D, 0x80, 0x00, 0x00, 0x00, 0x00, 0x7D,
  0x80, 0x37, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x33, 0x36, 0x66,
  0x4C, 0x00, 0x04, 0x00, 0x30, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x80, 0x03, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00,
  0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x7E, 0x3F, 0xE8, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0x00, 0x7C,
  0x00, 0x0F, 0xFC, 0x00, 0x70, 0x1C, 0x03, 0x00, 0x38, 0x18, 0x00, 0x60,
  0xC0, 0x00, 0xC3, 0x00, 0x01, 0x18, 0x0E, 0x06, 0x60, 0xFE, 0x19, 0x07,
  0x18, 0x2C, 0x18, 0x60, 0xB0, 0xC1, 0x83, 0xC3, 0x06, 0x0F, 0x0C, 0x18,
  0x3C, 0x30, 0x60, 0xF0, 0xC1, 0x83, 0xC3, 0x06, 0x0B, 0x0C, 0x18, 0x6C,
  0x30, 0xE1, 0xB0, 0xC2, 0x84, 0xC1, 0xFB, 0xF1, 0x03, 0xC7, 0x86, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x10,
  0x03, 0xE3, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x50,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x1B, 0x00, 0x08, 0x80, 0x0C, 0x60, 0x06,
  0x30, 0x03, 0x18, 0x03, 0x06, 0x01, 0x83, 0x00, 0xC1, 0x80, 0x60, 0xC0,
  0x60, 0x30, 0x3F, 0xF8, 0x1F, 0xFC, 0x1C, 0x07, 0x0C, 0x01, 0x86, 0x00,
  0xC3, 0x00, 0x63, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0xE0, 0x03, 0xE0,
  0x00, 0xC0, 0xFF, 0x03, 0xFF, 0x8C, 0x07, 0x30, 0x0E, 0xC0, 0x1B, 0x00,
  0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0x30, 0x78, 0xFF,
  0x83, 0x07, 0x8C, 0x03, 0x30, 0x06, 0xC0, 0x1B, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x1F, 0x00, 0x6C, 0x03, 0xB0, 0x1C, 0xFF, 0xE3, 0xFF, 0x00,
  0x03, 0xF8, 0x0F, 0xFC, 0x78, 0x10, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00,
  0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0xBC, 0x0F,
  0xF8, 0xFE, 0x01, 0xFF, 0x83, 0x03, 0xC6, 0x01, 0xCC, 0x01, 0x98, 0x01,
  0xB0, 0x03, 0x60, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x3E, 0x00, 0x6C, 0x00, 0xD8, 0x03, 0x30, 0x0E, 0x60, 0x38, 0xFF, 0xE1,
  0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0F, 0xFF, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0x80, 0xC3, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x37, 0x00, 0x19, 0x80,
  0x0C, 0xE0, 0x06, 0x38, 0x03, 0x0F, 0xDF, 0x81, 0xFF, 0x80, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0C, 0xFF,
  0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x3D, 0xFC, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61,
  0xE7, 0x7C, 0x60, 0xC0, 0x1B, 0x00, 0xEC, 0x03, 0x30, 0x18, 0xC0, 0xE3,
  0x03, 0x0C, 0x18, 0x30, 0xE0, 0xC3, 0x03, 0x18, 0x0C, 0xC0, 0x37, 0x00,
  0xDC, 0x03, 0xD8, 0x0E, 0x60, 0x30, 0xC0, 0xC3, 0x83, 0x06, 0x0C, 0x1C,
  0x30, 0x30, 0xC0, 0xE3, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x1B, 0x00,
  0x70, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF,
  0xFC, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x0D, 0xEC, 0x00, 0x6F, 0x60, 0x03, 0x7B, 0x00, 0x33, 0xCC, 0x01,
  0x9E, 0x60, 0x0C, 0xF3, 0x00, 0xC7, 0x8C, 0x06, 0x3C, 0x60, 0x31, 0xE3,
  0x03, 0x0F, 0x0C, 0x18, 0x78, 0x60, 0xC3, 0xC3, 0x0C, 0x1E, 0x08, 0x60,
  0xF0, 0x63, 0x07, 0x83, 0x10, 0x3C, 0x09, 0x81, 0xE0, 0x6C, 0x0F, 0x03,
  0x40, 0x78, 0x1E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x00, 0xC0, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7B, 0x00, 0xF6, 0x01, 0xE6,
  0x03, 0xCC, 0x07, 0x8C, 0x0F, 0x18, 0x1E, 0x18, 0x3C, 0x30, 0x78, 0x30,
  0xF0, 0x61, 0xE0, 0x63, 0xC0, 0xC7, 0x80, 0xCF, 0x01, 0xDE, 0x01, 0x9C,
  0x03, 0xB8, 0x03, 0x70, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x0C, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0, 0xE0, 0x18, 0x30, 0x03, 0x18, 0x00,
  0xC6, 0x00, 0x19, 0x80, 0x06, 0xC0, 0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xB0, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x8C, 0x00,
  0xC3, 0x00, 0x70, 0x60, 0x38, 0x0F, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0x07,
  0xFE, 0x30, 0x79, 0x80, 0xEC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x07, 0xC0,
  0x3E, 0x01, 0xB0, 0x0D, 0x80, 0x6C, 0x06, 0x61, 0xF3, 0xFE, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xC0, 0xE0,
  0xE0, 0x1C, 0x30, 0x03, 0x18, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x06, 0xC0,
  0x01, 0xB0, 0x00, 0x6C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x06, 0x60, 0x03, 0x8C, 0x00, 0xC3, 0x00, 0x70, 0x60, 0x38, 0x0F,
  0xFC, 0x01, 0xFE, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x03,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0xFE, 0x03, 0xFF, 0x0C, 0x1E, 0x30, 0x1C,
  0xC0, 0x33, 0x00, 0xCC, 0x03, 0xB0, 0x0E, 0xC0, 0x33, 0x00, 0xCC, 0x03,
  0x30, 0x1C, 0xC0, 0xE3, 0xFF, 0x0F, 0xF0, 0x30, 0xC0, 0xC1, 0x83, 0x06,
  0x0C, 0x0C, 0x30, 0x30, 0xC0, 0x63, 0x01, 0x8C, 0x03, 0x30, 0x0C, 0xC0,
  0x1B, 0x00, 0x70, 0x0F, 0xC3, 0xFF, 0x70, 0x3E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0x00, 0x78,
  0x01, 0xE0, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x78, 0x06, 0xFF, 0xCF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0x98, 0x03, 0x38,
  0x0C, 0x3E, 0xF8, 0x3F, 0xC0, 0xC0, 0x03, 0xC0, 0x03, 0x60, 0x03, 0x60,
  0x07, 0x60, 0x06, 0x60, 0x06, 0x30, 0x06, 0x30, 0x0C, 0x30, 0x0C, 0x18,
  0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x0C,
  0x30, 0x0C, 0x30, 0x06, 0x30, 0x06, 0x60, 0x06, 0x60, 0x02, 0x60, 0x03,
  0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x0C, 0x00,
  0xEC, 0x01, 0xC0, 0x19, 0x80, 0x38, 0x03, 0x30, 0x07, 0x00, 0x66, 0x01,
  0xA0, 0x0C, 0x60, 0x36, 0x03, 0x0C, 0x06, 0xC0, 0x61, 0x80, 0xD8, 0x0C,
  0x30, 0x13, 0x01, 0x86, 0x06, 0x20, 0x60, 0x60, 0xC6, 0x0C, 0x0C, 0x18,
  0xC1, 0x81, 0x83, 0x18, 0x30, 0x30, 0xC1, 0x06, 0x03, 0x18, 0x31, 0x80,
  0x63, 0x06, 0x30, 0x0C, 0x60, 0xC6, 0x01, 0x88, 0x18, 0xC0, 0x3B, 0x01,
  0x30, 0x03, 0x60, 0x36, 0x00, 0x6C, 0x06, 0xC0, 0x0D, 0x80, 0xD8, 0x01,
  0xA0, 0x0A, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x38, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x60, 0x18, 0xC0, 0x71, 0xC0, 0xC1, 0x81, 0x83, 0x06,
  0x03, 0x0C, 0x06, 0x30, 0x06, 0x60, 0x0D, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xF0, 0x03, 0x60, 0x06, 0x60, 0x18, 0xC0, 0x31,
  0xC0, 0xC1, 0x81, 0x83, 0x06, 0x03, 0x0C, 0x06, 0x38, 0x06, 0x60, 0x0D,
  0xC0, 0x1C, 0xC0, 0x0F, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xC3, 0x01, 0x86,
  0x03, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x60, 0x18, 0xC0, 0x31, 0x80, 0x36,
  0x00, 0x6C, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00,
  0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x30,
  0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x3F, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x08, 0x01, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x30, 0x06, 0x00,
  0x40, 0x0C, 0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xFF, 0xFF, 0x01, 0x00, 0x07, 0x00, 0x0E, 0x00,
  0x36, 0x00, 0x6C, 0x01, 0x8C, 0x03, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x60,
  0x30, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xD8, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x03, 0x01, 0xFC, 0x38, 0xE0,
  0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0x3E, 0x37,
  0x03, 0x60, 0x36, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x76, 0x07, 0x71, 0xB3,
  0xF1, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x18, 0x40, 0xCF, 0xC6, 0xC7, 0x38, 0x1D, 0xC0, 0x6C, 0x03, 0x60, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xDC, 0x06, 0xA0, 0x64, 0xEF, 0x23, 0xF0, 0x03, 0x03, 0xFC,
  0xE1, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xF3, 0x0F,
  0xE0, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0xC3, 0x1F, 0x99, 0xCE, 0xDC, 0x1E, 0xC0, 0x7C, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0xEC, 0x07, 0x70, 0x79, 0xCE, 0xC7, 0xE6, 0x02, 0x01, 0xFC,
  0x38, 0xC6, 0x06, 0x60, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF,
  0xFF, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x01,
  0x3C, 0xF1, 0xFE, 0x01, 0x81, 0xF0, 0xC4, 0x70, 0x18, 0x06, 0x01, 0x80,
  0x60, 0x18, 0x3F, 0xEF, 0xF8, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x80, 0x60, 0x02, 0x00, 0xFC, 0xCE, 0x36, 0xC0, 0xF6, 0x03, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x07, 0x60, 0x3B, 0x83, 0xCE, 0x76, 0x3F, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x30, 0x01, 0x98, 0x38, 0xFF, 0x81,
  0xE0, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x20, 0xDF, 0xCF, 0x8E, 0xE0, 0x6E, 0x06, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x7D, 0x80, 0x03, 0x6D, 0xB6,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x0C, 0x70, 0xC0, 0x00, 0x00, 0x03, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC6, 0x1B, 0xE6, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0xF8, 0x3B, 0x06, 0x61,
  0x8C, 0x61, 0x8C, 0x33, 0x06, 0xC0, 0xDC, 0x1F, 0x83, 0x98, 0x63, 0x0C,
  0x31, 0x87, 0x30, 0x66, 0x0E, 0xC0, 0xD8, 0x1F, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x02, 0x01, 0x09, 0xF8, 0xFE, 0xB1, 0xCC,
  0xEA, 0x0D, 0x03, 0xC0, 0x70, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06,
  0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0,
  0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0xC0, 0x60, 0x3C,
  0x06, 0x03, 0xC0, 0x60, 0x3C, 0x06, 0x03, 0x02, 0x09, 0xFC, 0x98, 0xEA,
  0x06, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0x02, 0x00, 0xFE, 0x0E, 0x38, 0xC0, 0x66, 0x03, 0x60, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x60, 0x33, 0x83, 0x8F, 0x78, 0x3F, 0x80, 0x02, 0x04,
  0x7E, 0x26, 0x39, 0x40, 0xEE, 0x03, 0x60, 0x1B, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x06,
  0xE0, 0x37, 0x03, 0x37, 0x79, 0x9F, 0x8C, 0x00, 0x60, 0x03, 0x00, 0x18,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x00, 0x02, 0x00,
  0xFC, 0xCE, 0x76, 0xE0, 0xF6, 0x03, 0xE0, 0x1F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07,
  0x60, 0x3B, 0x83, 0xCE, 0x76, 0x3F, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x8F, 0x9F,
  0xB0, 0xA0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x02, 0x07, 0xFD, 0xC3, 0x30, 0x04, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x70, 0x1B, 0xEF, 0x3F, 0xC0, 0x30, 0x30, 0x30,
  0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x39, 0x1F, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xB7, 0xBB,
  0x3F, 0x30, 0xC0, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x66, 0x03, 0x18, 0x18,
  0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC3, 0x06, 0x30, 0x31, 0x80, 0xCC, 0x06,
  0xC0, 0x36, 0x00, 0xB0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0xE0, 0x30, 0x0D,
  0x80, 0xE0, 0x66, 0x07, 0x81, 0x98, 0x1E, 0x06, 0x60, 0x68, 0x18, 0xC1,
  0x30, 0xC3, 0x0C, 0xC3, 0x0C, 0x33, 0x0C, 0x30, 0xCC, 0x30, 0x62, 0x19,
  0x81, 0x98, 0x66, 0x06, 0x61, 0x98, 0x19, 0x86, 0x60, 0x34, 0x09, 0x00,
  0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1C, 0x06, 0x00, 0x60,
  0x18, 0x00, 0xC0, 0x36, 0x06, 0x60, 0x63, 0x0C, 0x38, 0xC1, 0x98, 0x1D,
  0x80, 0xF0, 0x07, 0x00, 0x60, 0x0F, 0x00, 0xF0, 0x19, 0x81, 0x9C, 0x30,
  0xC7, 0x06, 0x60, 0x6E, 0x03, 0xC0, 0x30, 0xE0, 0x1D, 0x80, 0x66, 0x01,
  0x98, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x06, 0x18, 0x18, 0x60, 0x61,
  0x80, 0x8C, 0x03, 0x30, 0x0C, 0xC0, 0x33, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x0C, 0x00, 0x70, 0x0F, 0x80, 0x18, 0x00, 0x7F, 0xDF, 0xF0, 0x18,
  0x06, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x18,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x3F, 0xFF, 0xFC, 0x00, 0xC0, 0xF0, 0x70,
  0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x01, 0xC3, 0xC0, 0xF0, 0x07, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x3C, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x78, 0x0E,
  0x03, 0x01, 0x80, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x38, 0x0F, 0x07, 0x87, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x03, 0x01, 0x81, 0xC3, 0xC1, 0x80, 0x08, 0x01, 0xFC,
  0x1C, 0x3F, 0xE0, 0x3E,
};

const GFXglyph NotoSans_Condensed_Light36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 26, 8, 3, -26 },
  { 11, 8, 10, 12, 2, -26 },
  { 21, 16, 26, 18, 1, -26 },
  { 73, 13, 29, 17, 2, -27 },
  { 121, 21, 26, 24, 2, -26 },
  { 190, 17, 26, 19, 1, -26 },
  { 246, 3, 10, 7, 2, -26 },
  { 250, 7, 32, 10, 2, -26 },
  { 278, 7, 32, 10, 1, -26 },
  { 306, 12, 12, 15, 2, -27 },
  { 324, 14, 17, 17, 1, -21 },
  { 354, 4, 9, 7, 1, -4 },
  { 359, 8, 2, 10, 1, -11 },
  { 361, 3, 3, 8, 2, -3 },
  { 363, 11, 26, 13, 1, -26 },
  { 399, 13, 26, 17, 2, -26 },
  { 442, 7, 26, 17, 3, -26 },
  { 465, 13, 26, 17, 2, -26 },
  { 508, 14, 26, 17, 1, -26 },
  { 554, 15, 26, 17, 1, -26 },
  { 603, 13, 26, 17, 2, -26 },
  { 646, 13, 26, 17, 2, -26 },
  { 689, 13, 26, 17, 2, -26 },
  { 732, 14, 26, 17, 1, -26 },
  { 778, 13, 26, 17, 2, -26 },
  { 821, 3, 19, 8, 2, -19 },
  { 829, 4, 24, 8, 1, -19 },
  { 841, 14, 16, 17, 1, -21 },
  { 869, 14, 9, 17, 1, -17 },
  { 885, 14, 16, 17, 1, -21 },
  { 913, 10, 26, 12, 1, -26 },
  { 946, 22, 29, 25, 2, -26 },
  { 1026, 17, 26, 17, 0, -26 },
  { 1082, 14, 26, 18, 3, -26 },
  { 1128, 15, 26, 18, 2, -26 },
  { 1177, 15, 26, 20, 3, -26 },
  { 1226, 11, 26, 16, 3, -26 },
  { 1262, 11, 26, 15, 3, -26 },
  { 1298, 17, 26, 21, 2, -26 },
  { 1354, 15, 26, 21, 3, -26 },
  { 1403, 7, 26, 10, 1, -26 },
  { 1426, 7, 33, 8, -2, -26 },
  { 1455, 14, 26, 17, 3, -26 },
  { 1501, 11, 26, 15, 3, -26 },
  { 1537, 21, 26, 27, 3, -26 },
  { 1606, 15, 26, 21, 3, -26 },
  { 1655, 18, 26, 22, 2, -26 },
  { 1714, 13, 26, 17, 3, -26 },
  { 1757, 18, 32, 22, 2, -26 },
  { 1829, 14, 26, 17, 3, -26 },
  { 1875, 12, 26, 16, 2, -26 },
  { 1914, 14, 26, 15, 0, -26 },
  { 1960, 15, 26, 20, 3, -26 },
  { 2009, 16, 26, 16, 0, -26 },
  { 2061, 27, 26, 27, 0, -26 },
  { 2149, 15, 26, 15, 0, -26 },
  { 2198, 15, 26, 15, 0, -26 },
  { 2247, 13, 26, 15, 1, -26 },
  { 2290, 7, 32, 11, 3, -26 },
  { 2318, 11, 26, 13, 1, -26 },
  { 2354, 7, 32, 11, 1, -26 },
  { 2382, 15, 14, 17, 1, -26 },
  { 2409, 15, 2, 15, 0, 3 },
  { 2413, 7, 6, 9, 1, -28 },
  { 2419, 12, 20, 16, 1, -20 },
  { 2449, 13, 27, 18, 3, -27 },
  { 2493, 11, 20, 13, 2, -20 },
  { 2521, 13, 27, 18, 2, -27 },
  { 2565, 12, 20, 16, 2, -20 },
  { 2595, 10, 28, 9, 0, -28 },
  { 2630, 13, 29, 18, 2, -20 },
  { 2678, 12, 27, 17, 3, -27 },
  { 2719, 3, 26, 7, 2, -26 },
  { 2729, 6, 35, 7, -1, -26 },
  { 2756, 11, 27, 14, 3, -27 },
  { 2794, 2, 27, 7, 3, -27 },
  { 2801, 20, 20, 26, 3, -20 },
  { 2851, 12, 20, 17, 3, -20 },
  { 2881, 13, 20, 17, 2, -20 },
  { 2914, 13, 29, 18, 3, -20 },
  { 2962, 13, 29, 18, 2, -20 },
  { 3010, 8, 19, 11, 3, -19 },
  { 3029, 11, 20, 13, 1, -20 },
  { 3057, 8, 24, 10, 1, -24 },
  { 3081, 12, 19, 17, 3, -19 },
  { 3110, 13, 19, 13, 0, -19 },
  { 3141, 22, 19, 22, 0, -19 },
  { 3194, 12, 19, 14, 1, -19 },
  { 3223, 14, 28, 14, 0, -19 },
  { 3272, 10, 19, 12, 1, -19 },
  { 3296, 10, 32, 13, 1, -26 },
  { 3336, 2, 36, 16, 7, -27 },
  { 3345, 9, 32, 13, 2, -26 },
  { 3381, 14, 4, 17, 1, -15 },
};

const GFXfont NotoSans_Condensed_Light36pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light36pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light36pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _NOTOSANS_CONDENSED_LIGHT36PT7B_H_
