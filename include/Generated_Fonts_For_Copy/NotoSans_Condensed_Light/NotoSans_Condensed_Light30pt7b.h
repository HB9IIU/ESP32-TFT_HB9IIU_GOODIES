#ifndef _NOTOSANS_CONDENSED_LIGHT30PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light30pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x92, 0x49, 0x24, 0x90, 0x01, 0x7C, 0xC7, 0x1C, 0x71,
  0xC7, 0x18, 0x40, 0x04, 0x20, 0x61, 0x03, 0x08, 0x18, 0xC0, 0x86, 0x04,
  0x33, 0xFF, 0xE1, 0x08, 0x18, 0x40, 0xC2, 0x06, 0x30, 0x21, 0x81, 0x0C,
  0x7F, 0xFC, 0x42, 0x06, 0x10, 0x30, 0x81, 0x8C, 0x08, 0x60, 0x43, 0x02,
  0x10, 0x00, 0x04, 0x00, 0x80, 0x3C, 0x1F, 0xF6, 0x44, 0x88, 0x31, 0x06,
  0x20, 0xC4, 0x0C, 0x81, 0xD0, 0x0E, 0x00, 0x70, 0x0B, 0x81, 0x18, 0x23,
  0x04, 0x20, 0x84, 0x11, 0xC2, 0x3F, 0xFC, 0x7E, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x18, 0x00, 0x0F, 0x03, 0x04, 0x60, 0x81, 0x08, 0x20, 0x42, 0x18,
  0x30, 0x84, 0x0C, 0x23, 0x03, 0x08, 0x80, 0xC2, 0x20, 0x10, 0x99, 0xC4,
  0x24, 0x99, 0x9B, 0x62, 0x3C, 0x98, 0xC6, 0x24, 0x30, 0x19, 0x0C, 0x04,
  0x43, 0x03, 0x10, 0xC0, 0x84, 0x30, 0x61, 0x8C, 0x18, 0x62, 0x04, 0x09,
  0x83, 0x03, 0xC0, 0x0E, 0x00, 0x7E, 0x03, 0x18, 0x0C, 0x20, 0x30, 0x80,
  0xC2, 0x03, 0x08, 0x0C, 0x60, 0x1B, 0x00, 0x38, 0x00, 0xC0, 0x0F, 0x80,
  0x33, 0x0D, 0x8C, 0x2C, 0x18, 0xB0, 0x36, 0xC0, 0xD3, 0x01, 0xCC, 0x07,
  0x18, 0x36, 0x71, 0xD8, 0xFC, 0x30, 0xFF, 0xFC, 0x0C, 0x61, 0x0C, 0x30,
  0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x41, 0x86, 0x18, 0x20,
  0xC1, 0x06, 0x08, 0x10, 0xC1, 0x82, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x21, 0x86, 0x18, 0xC3, 0x18, 0x63, 0x00,
  0x04, 0x01, 0x00, 0x42, 0x11, 0xF7, 0xC7, 0x80, 0xE0, 0x6C, 0x31, 0x08,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x76, 0x66,
  0x4C, 0xC0, 0xFF, 0xFC, 0x7C, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30,
  0x18, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60,
  0x20, 0x30, 0x18, 0x08, 0x00, 0x06, 0x03, 0xF0, 0xC3, 0x10, 0x66, 0x06,
  0xC0, 0xD0, 0x1A, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x50, 0x0A, 0x03, 0x60, 0x6C, 0x0D, 0x81, 0x18, 0x63, 0x98, 0x3E, 0x00,
  0x0E, 0x3C, 0xDF, 0x34, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x0E, 0x0F, 0xF1, 0x83, 0x00,
  0x60, 0x04, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF,
  0xFF, 0xC0, 0x0E, 0x0F, 0xF3, 0x03, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x18,
  0x02, 0x00, 0xC0, 0x30, 0x7C, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x6C, 0x1C, 0xFE, 0x00, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x02, 0xC0, 0x6C, 0x0C, 0xC0, 0xCC, 0x18, 0xC1, 0x0C,
  0x30, 0xC2, 0x0C, 0x60, 0xC4, 0x0C, 0xC0, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x7F, 0x90, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xFE, 0x3F, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x10,
  0x04, 0x03, 0x00, 0xC0, 0x30, 0x1B, 0x0E, 0xFE, 0x00, 0x07, 0x87, 0xE3,
  0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x00, 0x80, 0x27, 0xCB, 0x1B, 0x03,
  0xC0, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x70, 0x1C, 0x0D, 0x83, 0x71, 0x8F,
  0xC0, 0xFF, 0xE0, 0x04, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C,
  0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x60, 0x0C,
  0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x0F, 0x03, 0xF8, 0x30, 0xC6, 0x06,
  0x60, 0x66, 0x06, 0x60, 0x66, 0x06, 0x30, 0xC1, 0x98, 0x0F, 0x01, 0xF0,
  0x31, 0xC6, 0x06, 0x40, 0x6C, 0x02, 0xC0, 0x3C, 0x02, 0xC0, 0x26, 0x06,
  0x70, 0xC1, 0xF8, 0x0E, 0x07, 0xF1, 0xC3, 0x30, 0x64, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x81, 0xB0, 0x73, 0xFE, 0x3C, 0xC0, 0x18,
  0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC4, 0x30, 0xFC, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x67, 0x60, 0x00, 0x00, 0x00, 0x00, 0x06, 0x66, 0x64, 0xCC,
  0x00, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x00, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x10, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E,
  0x00, 0x80, 0x00, 0x38, 0xFE, 0x83, 0x03, 0x03, 0x01, 0x03, 0x03, 0x02,
  0x06, 0x0C, 0x18, 0x10, 0x30, 0x30, 0x30, 0x00, 0x00, 0x00, 0x30, 0x30,
  0x30, 0x00, 0x00, 0x01, 0xFE, 0x00, 0xC0, 0xC0, 0x40, 0x08, 0x30, 0x03,
  0x18, 0x00, 0x64, 0x04, 0x1B, 0x07, 0xC2, 0xC2, 0x10, 0xA1, 0x84, 0x38,
  0x41, 0x0E, 0x10, 0x43, 0x8C, 0x10, 0xE3, 0x0C, 0x38, 0x43, 0x0A, 0x10,
  0xC2, 0x86, 0x31, 0xA0, 0xF3, 0xCC, 0x18, 0x61, 0x00, 0x00, 0x60, 0x00,
  0x0C, 0x00, 0x03, 0x80, 0x80, 0x3F, 0xE0, 0x01, 0xC0, 0x00, 0x03, 0x00,
  0x0E, 0x00, 0x78, 0x01, 0xA0, 0x04, 0x80, 0x33, 0x00, 0xCC, 0x02, 0x10,
  0x08, 0x60, 0x61, 0x81, 0x82, 0x04, 0x08, 0x3F, 0xF0, 0xFF, 0xC3, 0x01,
  0x08, 0x06, 0x60, 0x19, 0x80, 0x64, 0x00, 0xB0, 0x03, 0xC0, 0x0C, 0xFF,
  0x8C, 0x0E, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x02, 0xC0, 0x6C, 0x06, 0xC0,
  0xCF, 0xF0, 0xFF, 0xCC, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x02, 0xC0, 0x6C, 0x3C, 0xFF, 0x80, 0x03, 0x80, 0xFF, 0x38, 0x13,
  0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x20, 0xFE, 0xFF, 0x86, 0x0E, 0x30, 0x19, 0x80, 0x6C, 0x03,
  0x60, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x02, 0xC0, 0x36, 0x03, 0xB0, 0x39, 0xFF,
  0x8F, 0xF0, 0x00, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x3F, 0xEF, 0xFB, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFB, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x03, 0xC0, 0x3F,
  0xF1, 0x80, 0x8C, 0x00, 0x60, 0x01, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x02, 0x00, 0x08, 0x00, 0x20, 0x3F, 0x80, 0xFE, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0D, 0x80, 0x36, 0x00, 0xCC, 0x03, 0x1C, 0x1C, 0x3F, 0xE0,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0x80, 0xFC,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0xFC, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x30, 0xC3, 0x0F, 0xE0, 0xC0,
  0x7C, 0x0C, 0xC0, 0xCC, 0x18, 0xC3, 0x0C, 0x30, 0xC6, 0x0C, 0xC0, 0xCC,
  0x0D, 0xC0, 0xFC, 0x0E, 0x60, 0xC6, 0x0C, 0x30, 0xC1, 0x0C, 0x18, 0xC0,
  0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0, 0x30, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x40, 0x0F, 0xD8, 0x02, 0xF6, 0x01, 0xBC,
  0x80, 0x6F, 0x20, 0x13, 0xCC, 0x0C, 0xF1, 0x03, 0x3C, 0x40, 0x8F, 0x18,
  0x63, 0xC2, 0x18, 0xF0, 0x84, 0x3C, 0x33, 0x0F, 0x0C, 0xC3, 0xC1, 0x20,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xC0, 0xE0, 0x0F,
  0x00, 0x7C, 0x03, 0xA0, 0x1D, 0x80, 0xE4, 0x07, 0x30, 0x38, 0x81, 0xC6,
  0x0E, 0x10, 0x70, 0xC3, 0x82, 0x1C, 0x18, 0xE0, 0x47, 0x03, 0x38, 0x09,
  0xC0, 0x6E, 0x01, 0x70, 0x0F, 0x80, 0x3C, 0x01, 0x80, 0x03, 0x80, 0x7F,
  0x83, 0x83, 0x18, 0x06, 0x60, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0D, 0x00, 0x26, 0x01, 0x8C, 0x0C, 0x38, 0x70, 0x3F, 0x00,
  0xFF, 0x98, 0x3B, 0x03, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x1B, 0x0E, 0x7F, 0x8C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x00, 0x03, 0x80, 0x7F, 0x83, 0x83, 0x18, 0x06,
  0x60, 0x1B, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00,
  0x26, 0x01, 0x8C, 0x0C, 0x38, 0x70, 0x3F, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x00, 0xC0, 0x03, 0x80, 0xFF, 0x8C, 0x1C, 0xC0, 0xCC, 0x06, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x4C, 0x0C, 0xFF, 0x8F, 0xE0, 0xC3,
  0x0C, 0x30, 0xC1, 0x8C, 0x18, 0xC0, 0xCC, 0x0C, 0xC0, 0x6C, 0x06, 0xC0,
  0x30, 0x0F, 0x07, 0xFD, 0xC1, 0x30, 0x04, 0x01, 0x80, 0x10, 0x03, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x6E, 0x1C, 0xFE, 0x00, 0xFF, 0xF0, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1B, 0x01, 0x98, 0x0C, 0x71,
  0xC1, 0xFC, 0x00, 0xC0, 0x0D, 0x00, 0x66, 0x01, 0x98, 0x06, 0x60, 0x10,
  0x80, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x20, 0x41, 0x81, 0x86, 0x06, 0x10,
  0x08, 0xC0, 0x23, 0x00, 0xCC, 0x03, 0x20, 0x05, 0x80, 0x16, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0x00, 0xC0, 0x36, 0x03, 0x80,
  0xD8, 0x1E, 0x02, 0x60, 0x68, 0x18, 0x81, 0xA0, 0x63, 0x04, 0xC1, 0x8C,
  0x13, 0x04, 0x30, 0xCC, 0x30, 0x43, 0x10, 0xC1, 0x08, 0x43, 0x06, 0x21,
  0x88, 0x19, 0x86, 0x60, 0x66, 0x09, 0x80, 0x98, 0x26, 0x03, 0x40, 0xD8,
  0x0D, 0x03, 0x40, 0x3C, 0x07, 0x00, 0x70, 0x1C, 0x01, 0x80, 0x70, 0x06,
  0x01, 0x80, 0x60, 0x32, 0x02, 0x30, 0x61, 0x04, 0x18, 0xC1, 0x88, 0x0D,
  0x80, 0xD8, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0D, 0x80, 0x98, 0x18,
  0xC1, 0x8C, 0x30, 0x43, 0x06, 0x60, 0x26, 0x03, 0xC0, 0x30, 0xC0, 0x36,
  0x02, 0x60, 0x62, 0x06, 0x30, 0x43, 0x0C, 0x10, 0x81, 0x98, 0x09, 0x80,
  0xD0, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x10, 0x06, 0x00, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0x7F, 0xFF, 0xFE, 0xFF,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0x80, 0x60, 0x10, 0x0C, 0x06,
  0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18,
  0x0C, 0x02, 0x01, 0x80, 0xC0, 0x20, 0x18, 0xFC, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0xFF, 0xF0, 0x06, 0x00, 0x70, 0x0F, 0x00, 0x98, 0x19, 0x81, 0x08,
  0x30, 0xC2, 0x04, 0x60, 0x64, 0x02, 0xC0, 0x30, 0xFF, 0xF8, 0xC3, 0x0C,
  0x30, 0x80, 0x7F, 0x08, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x7F,
  0x70, 0xD8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x76, 0x34, 0xF9, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x7C, 0xD1, 0xDC, 0x1B,
  0x81, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xE0, 0x3E, 0x0D, 0xE3, 0xB7, 0xE0, 0x0F, 0xCE, 0x23, 0x01, 0x80, 0x60,
  0x10, 0x04, 0x03, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x80, 0x60, 0x18, 0x03,
  0x88, 0x7E, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x31, 0xF3, 0x39, 0xB6, 0x07, 0x60, 0x76, 0x03, 0x40, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x34, 0x03, 0x40, 0x36, 0x07, 0x60, 0x73, 0x8B, 0x1F,
  0x30, 0x1F, 0x06, 0x30, 0x83, 0x30, 0x24, 0x06, 0x80, 0xD0, 0x1F, 0xFF,
  0xC0, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0E, 0x10, 0xFE, 0x0F,
  0x8F, 0x86, 0x02, 0x01, 0x00, 0x80, 0x41, 0xFC, 0x10, 0x08, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x1F, 0x27, 0x35, 0x81, 0xB0, 0x36, 0x02, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x05, 0x00, 0xA0, 0x16, 0x06, 0xC0, 0xCC, 0x68, 0xF9, 0x00,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0xC3, 0x8F, 0xE0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x3E, 0xD1, 0xB8, 0x3C, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x04, 0xF4, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0xC2, 0x00, 0x00,
  0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18,
  0xC7, 0x7F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x07, 0xC1, 0x30, 0xCC, 0x63, 0x10, 0xCC, 0x36, 0x0F, 0xC3, 0xB0, 0xC6,
  0x31, 0x8C, 0x33, 0x0C, 0xC1, 0xB0, 0x6C, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xDF, 0x1F, 0x79, 0xD9, 0xF8, 0x38, 0x78, 0x18, 0x1C, 0x0C,
  0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x1C, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x03, 0x81, 0x81,
  0xCF, 0xB4, 0x7E, 0x0F, 0x03, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x1F, 0x83, 0x8C, 0x60,
  0x66, 0x06, 0x40, 0x24, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40,
  0x34, 0x02, 0x60, 0x62, 0x06, 0x38, 0xC1, 0xF8, 0xCF, 0x9A, 0x3B, 0x83,
  0x70, 0x3C, 0x07, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0,
  0x3C, 0x07, 0xC1, 0xB4, 0x76, 0x7C, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x00, 0x1F, 0x27, 0x35, 0x81, 0xB0, 0x34, 0x02, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x16, 0x06, 0xC0, 0xCE,
  0x28, 0xF9, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08,
  0xCF, 0xB7, 0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0x3F, 0xB0, 0xB0, 0x18, 0x0C, 0x02, 0x01, 0xC0, 0x78, 0x0E,
  0x01, 0x80, 0x60, 0x30, 0x18, 0x0F, 0x0D, 0xFC, 0x20, 0x86, 0x18, 0xFD,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x83, 0x0F, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0F, 0x03, 0xC0, 0xF0, 0x56, 0x34, 0xF9, 0xC0, 0x68, 0x0D, 0x01, 0x30,
  0x66, 0x0C, 0x41, 0x8C, 0x21, 0x8C, 0x11, 0x82, 0x20, 0x64, 0x0D, 0x80,
  0xB0, 0x14, 0x03, 0x80, 0x30, 0xC0, 0xC0, 0xD0, 0x30, 0x36, 0x0E, 0x09,
  0x82, 0x82, 0x61, 0xA1, 0x88, 0x48, 0x62, 0x13, 0x18, 0xC4, 0xC4, 0x33,
  0x13, 0x04, 0xC4, 0xC1, 0x21, 0xB0, 0x68, 0x68, 0x1E, 0x0A, 0x03, 0x83,
  0x80, 0xC0, 0xE0, 0x30, 0x30, 0xC0, 0xD0, 0x66, 0x18, 0x8C, 0x33, 0x05,
  0x81, 0xE0, 0x30, 0x0C, 0x07, 0x83, 0x20, 0xCC, 0x61, 0x18, 0x6C, 0x0B,
  0x03, 0xC0, 0x68, 0x0D, 0x81, 0xB0, 0x22, 0x0C, 0x61, 0x8C, 0x20, 0x8C,
  0x11, 0x83, 0x30, 0x64, 0x05, 0x80, 0xB0, 0x1C, 0x01, 0x80, 0x30, 0x04,
  0x01, 0x80, 0x30, 0x06, 0x01, 0x81, 0x30, 0x3C, 0x00, 0xFF, 0x03, 0x03,
  0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x40, 0xC0,
  0xFF, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x30, 0xE0, 0x70, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x0C, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x18, 0x18, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x0C, 0x03, 0x06, 0x0C, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x18, 0x18, 0xF0, 0xE0, 0x7C, 0x1C, 0xF7,
  0x81, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 21, 7, 2, -21 },
  { 9, 6, 7, 10, 2, -21 },
  { 15, 13, 21, 15, 1, -21 },
  { 50, 11, 25, 14, 1, -23 },
  { 85, 18, 22, 20, 1, -22 },
  { 135, 14, 22, 16, 1, -22 },
  { 174, 2, 7, 6, 2, -21 },
  { 176, 6, 26, 8, 1, -21 },
  { 196, 6, 26, 8, 1, -21 },
  { 216, 10, 10, 13, 1, -23 },
  { 229, 12, 14, 14, 1, -18 },
  { 250, 4, 7, 6, 1, -3 },
  { 254, 7, 2, 9, 1, -9 },
  { 256, 2, 3, 6, 2, -3 },
  { 257, 9, 21, 10, 1, -21 },
  { 281, 11, 22, 14, 1, -22 },
  { 312, 7, 21, 14, 2, -21 },
  { 331, 11, 22, 14, 1, -22 },
  { 362, 11, 22, 14, 1, -22 },
  { 393, 12, 22, 14, 1, -22 },
  { 426, 10, 21, 14, 2, -21 },
  { 453, 10, 22, 14, 2, -22 },
  { 481, 11, 21, 14, 1, -21 },
  { 510, 12, 22, 14, 1, -22 },
  { 543, 11, 22, 14, 1, -22 },
  { 574, 2, 16, 6, 2, -16 },
  { 578, 4, 20, 6, 1, -16 },
  { 588, 12, 13, 14, 1, -17 },
  { 608, 12, 7, 14, 1, -14 },
  { 619, 12, 13, 14, 1, -17 },
  { 639, 8, 22, 10, 1, -22 },
  { 661, 18, 25, 21, 2, -22 },
  { 718, 14, 21, 14, 0, -21 },
  { 755, 12, 21, 15, 2, -21 },
  { 787, 12, 22, 15, 2, -22 },
  { 820, 13, 21, 17, 2, -21 },
  { 855, 10, 21, 13, 2, -21 },
  { 882, 10, 21, 12, 2, -21 },
  { 909, 14, 22, 18, 2, -22 },
  { 948, 13, 21, 17, 2, -21 },
  { 983, 6, 21, 8, 1, -21 },
  { 999, 6, 26, 7, -2, -21 },
  { 1019, 12, 21, 14, 2, -21 },
  { 1051, 10, 21, 12, 2, -21 },
  { 1078, 18, 21, 22, 2, -21 },
  { 1126, 13, 21, 18, 2, -21 },
  { 1161, 14, 22, 18, 2, -22 },
  { 1200, 11, 21, 14, 2, -21 },
  { 1229, 14, 27, 18, 2, -22 },
  { 1277, 12, 21, 14, 2, -21 },
  { 1309, 11, 22, 13, 1, -22 },
  { 1340, 12, 21, 12, 0, -21 },
  { 1372, 13, 21, 17, 2, -21 },
  { 1407, 14, 21, 14, 0, -21 },
  { 1444, 22, 21, 22, 0, -21 },
  { 1502, 12, 21, 13, 0, -21 },
  { 1534, 12, 21, 12, 0, -21 },
  { 1566, 11, 21, 12, 1, -21 },
  { 1595, 6, 26, 9, 2, -21 },
  { 1615, 9, 21, 10, 1, -21 },
  { 1639, 6, 26, 9, 1, -21 },
  { 1659, 12, 11, 14, 1, -21 },
  { 1676, 13, 1, 12, 0, 3 },
  { 1678, 5, 5, 8, 1, -23 },
  { 1682, 10, 16, 13, 1, -16 },
  { 1702, 11, 23, 15, 2, -23 },
  { 1734, 10, 16, 11, 1, -16 },
  { 1754, 12, 23, 15, 1, -23 },
  { 1789, 11, 16, 13, 1, -16 },
  { 1811, 9, 23, 8, 0, -23 },
  { 1837, 11, 23, 15, 1, -16 },
  { 1869, 10, 23, 14, 2, -23 },
  { 1898, 2, 22, 6, 2, -22 },
  { 1904, 5, 29, 6, -1, -22 },
  { 1923, 10, 23, 12, 2, -23 },
  { 1952, 2, 23, 6, 2, -23 },
  { 1958, 17, 16, 22, 2, -16 },
  { 1992, 10, 16, 14, 2, -16 },
  { 2012, 12, 16, 14, 1, -16 },
  { 2036, 11, 23, 15, 2, -16 },
  { 2068, 11, 23, 15, 1, -16 },
  { 2100, 7, 16, 9, 2, -16 },
  { 2114, 9, 16, 11, 1, -16 },
  { 2132, 6, 20, 8, 1, -20 },
  { 2147, 10, 16, 14, 2, -16 },
  { 2167, 11, 16, 11, 0, -16 },
  { 2189, 18, 16, 18, 0, -16 },
  { 2225, 10, 16, 12, 1, -16 },
  { 2245, 11, 23, 11, 0, -16 },
  { 2277, 8, 16, 10, 1, -16 },
  { 2293, 8, 26, 11, 1, -21 },
  { 2319, 1, 30, 13, 6, -23 },
  { 2323, 8, 26, 11, 1, -21 },
  { 2349, 12, 3, 14, 1, -12 },
};

const GFXfont NotoSans_Condensed_Light30pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light30pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light30pt7bGlyphs,
  0x20, 0x7E, 41
};

#endif // _NOTOSANS_CONDENSED_LIGHT30PT7B_H_
