#ifndef _NOTOSANS_CONDENSED_LIGHT16PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xBA, 0xAA, 0x12, 0x14, 0x24, 0x7F, 0x24, 0x24, 0x24,
  0xFE, 0x28, 0x28, 0x48, 0x21, 0xEA, 0x28, 0xA3, 0x83, 0x0A, 0x24, 0x9B,
  0x98, 0x20, 0x40, 0x51, 0x25, 0x12, 0x89, 0x45, 0x5A, 0xB2, 0xA9, 0x14,
  0x8A, 0x49, 0x24, 0x60, 0x20, 0xA2, 0x22, 0x45, 0x04, 0x18, 0x49, 0x8D,
  0x1A, 0x37, 0x90, 0xF0, 0x6A, 0x49, 0x24, 0x92, 0x24, 0x40, 0x89, 0x22,
  0x49, 0x29, 0x29, 0x00, 0x25, 0x5C, 0xAD, 0x00, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x00, 0xF0, 0xF0, 0x80, 0x08, 0x44, 0x21, 0x10, 0x84, 0x42, 0x20,
  0x21, 0x68, 0xA2, 0x86, 0x18, 0x61, 0x8A, 0x28, 0x9C, 0x3D, 0x11, 0x11,
  0x11, 0x11, 0x10, 0x62, 0x60, 0x82, 0x08, 0x21, 0x04, 0x21, 0x08, 0x3F,
  0x64, 0xC2, 0x10, 0x89, 0xC1, 0x08, 0x43, 0xE0, 0x04, 0x18, 0x30, 0xA2,
  0x44, 0x91, 0x22, 0xFE, 0x08, 0x10, 0x20, 0xFA, 0x08, 0x20, 0xF0, 0x20,
  0x41, 0x08, 0x2F, 0x00, 0x19, 0x84, 0x20, 0x83, 0xE8, 0xA1, 0x86, 0x18,
  0x9E, 0xFC, 0x20, 0x84, 0x10, 0x42, 0x08, 0x21, 0x04, 0x00, 0x33, 0x28,
  0xA2, 0x89, 0xC5, 0x22, 0x86, 0x18, 0x9E, 0x23, 0x68, 0xA2, 0x86, 0x28,
  0x9E, 0x08, 0x21, 0x3C, 0xC0, 0x80, 0xC1, 0xE0, 0x0C, 0xCC, 0x20, 0x60,
  0x60, 0x40, 0xFC, 0x00, 0x3F, 0x81, 0x81, 0x83, 0x33, 0x08, 0x00, 0x64,
  0xC2, 0x10, 0x88, 0x84, 0x20, 0x00, 0xC0, 0x3F, 0x10, 0x28, 0x0A, 0x7A,
  0x92, 0x68, 0x9A, 0x26, 0x92, 0x9F, 0xA0, 0x04, 0x00, 0xF8, 0x18, 0x18,
  0x28, 0x28, 0x24, 0x24, 0x7C, 0x42, 0x42, 0x82, 0x83, 0xFE, 0x18, 0x61,
  0x8B, 0xE8, 0x61, 0x86, 0x1F, 0x80, 0x19, 0x94, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x04, 0x0F, 0xFD, 0x0A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0B,
  0xE0, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x3E, 0xFC, 0x21, 0x08, 0x7E,
  0x10, 0x84, 0x20, 0x1C, 0x45, 0x04, 0x08, 0x10, 0x23, 0xC1, 0x83, 0x05,
  0x09, 0xF0, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08,
  0xE9, 0x24, 0x92, 0x4B, 0x80, 0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x86,
  0x29, 0x24, 0xA3, 0x89, 0x22, 0x8A, 0x18, 0x40, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x3E, 0xC0, 0xF0, 0x3A, 0x16, 0x85, 0xA1, 0x64, 0x99, 0x26,
  0x49, 0x8C, 0x63, 0x18, 0xC4, 0xC3, 0x86, 0x8D, 0x19, 0x32, 0x62, 0xC5,
  0x87, 0x0E, 0x08, 0x18, 0x64, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x82, 0x42, 0x3C, 0xFA, 0x18, 0x61, 0x87, 0xE8, 0x20, 0x82, 0x08, 0x00,
  0x18, 0x64, 0x42, 0x82, 0x81, 0x81, 0x81, 0x81, 0x81, 0x82, 0x42, 0x3C,
  0x08, 0x04, 0x02, 0xFA, 0x18, 0x61, 0x87, 0xE9, 0x22, 0x8A, 0x18, 0x40,
  0x36, 0x61, 0x08, 0x20, 0xC1, 0x08, 0x43, 0xE0, 0xFC, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x00, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x89, 0xF0, 0x83, 0x05, 0x0A, 0x24, 0x44, 0x8A, 0x14, 0x28, 0x30,
  0x40, 0x86, 0x14, 0x62, 0x46, 0x24, 0x62, 0x49, 0x24, 0x94, 0x29, 0x42,
  0x94, 0x31, 0x43, 0x0C, 0x10, 0x80, 0xC6, 0x88, 0xA1, 0x41, 0x02, 0x0A,
  0x14, 0x44, 0x8A, 0x18, 0x86, 0x89, 0x21, 0x42, 0x86, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x7C, 0x10, 0x82, 0x10, 0x42, 0x08, 0x41, 0x0F, 0xC0, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC2, 0x10, 0x42, 0x10, 0x42, 0x10,
  0x42, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x10, 0x50, 0x92, 0x24,
  0x30, 0x40, 0xFE, 0x90, 0x74, 0x42, 0x17, 0xC6, 0x31, 0xF8, 0x82, 0x08,
  0x2C, 0xCA, 0x18, 0x61, 0x86, 0x1C, 0x6E, 0x3A, 0x21, 0x08, 0x42, 0x10,
  0x78, 0x04, 0x10, 0x4D, 0xCE, 0x18, 0x61, 0x86, 0x18, 0xDD, 0x32, 0x63,
  0x1F, 0xC2, 0x10, 0x78, 0x3A, 0x11, 0xE4, 0x21, 0x08, 0x42, 0x10, 0x80,
  0x37, 0x38, 0x61, 0x86, 0x18, 0x63, 0x74, 0x10, 0x62, 0x70, 0x82, 0x08,
  0x2C, 0xCA, 0x18, 0x61, 0x86, 0x18, 0x61, 0xDF, 0xF0, 0x51, 0x55, 0x55,
  0x56, 0x84, 0x21, 0x19, 0x4A, 0x9C, 0x94, 0xA3, 0x10, 0xFF, 0xF0, 0xB3,
  0x66, 0x62, 0x31, 0x18, 0x8C, 0x46, 0x23, 0x11, 0x88, 0x80, 0xB3, 0x28,
  0x61, 0x86, 0x18, 0x61, 0x84, 0x31, 0x28, 0x61, 0x86, 0x18, 0x62, 0x78,
  0xB3, 0x28, 0x61, 0x86, 0x18, 0x71, 0xBA, 0x08, 0x20, 0x80, 0x37, 0x38,
  0x61, 0x86, 0x18, 0x63, 0x74, 0x10, 0x41, 0x04, 0xBC, 0x88, 0x88, 0x88,
  0x80, 0x69, 0x88, 0x61, 0x11, 0xF0, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x30,
  0x86, 0x18, 0x61, 0x86, 0x18, 0x63, 0x74, 0x86, 0x14, 0x92, 0x49, 0x23,
  0x0C, 0x30, 0x88, 0x63, 0x24, 0xC9, 0x32, 0x54, 0x94, 0xA3, 0x30, 0xCC,
  0x21, 0x00, 0x85, 0x24, 0x8C, 0x10, 0xC2, 0x92, 0xC4, 0x86, 0x14, 0x92,
  0x48, 0xA3, 0x0C, 0x10, 0x82, 0x08, 0xC0, 0x78, 0x44, 0x22, 0x11, 0x08,
  0xF8, 0x34, 0x44, 0x44, 0x84, 0x44, 0x44, 0x21, 0xFF, 0xFF, 0xC4, 0x44,
  0x42, 0x12, 0x44, 0x44, 0x48, 0x42, 0xF0,
};

const GFXglyph NotoSans_Condensed_Light16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 4, 1, -11 },
  { 3, 4, 4, 6, 1, -11 },
  { 5, 8, 11, 8, 0, -11 },
  { 16, 6, 13, 7, 1, -12 },
  { 26, 9, 12, 11, 1, -12 },
  { 40, 7, 12, 8, 1, -12 },
  { 51, 1, 4, 3, 1, -11 },
  { 52, 3, 14, 4, 1, -11 },
  { 58, 3, 14, 4, 1, -11 },
  { 64, 5, 5, 7, 1, -12 },
  { 68, 6, 7, 7, 1, -9 },
  { 74, 1, 4, 3, 1, -2 },
  { 75, 4, 1, 5, 0, -5 },
  { 76, 1, 1, 3, 1, -1 },
  { 77, 5, 11, 6, 0, -11 },
  { 84, 6, 12, 7, 1, -12 },
  { 93, 4, 11, 7, 1, -11 },
  { 99, 6, 12, 7, 1, -12 },
  { 108, 5, 12, 7, 1, -12 },
  { 116, 7, 12, 7, 0, -12 },
  { 127, 6, 11, 7, 1, -11 },
  { 136, 6, 12, 7, 1, -12 },
  { 145, 6, 11, 7, 1, -11 },
  { 154, 6, 12, 7, 1, -12 },
  { 163, 6, 12, 7, 1, -12 },
  { 172, 1, 9, 3, 1, -9 },
  { 174, 1, 11, 3, 1, -9 },
  { 176, 6, 7, 7, 1, -9 },
  { 182, 6, 4, 7, 1, -8 },
  { 185, 6, 7, 7, 1, -9 },
  { 191, 5, 12, 5, 0, -12 },
  { 199, 10, 12, 11, 1, -11 },
  { 214, 8, 11, 8, 0, -11 },
  { 225, 6, 11, 8, 1, -11 },
  { 234, 6, 12, 8, 1, -12 },
  { 243, 7, 11, 9, 1, -11 },
  { 253, 5, 11, 7, 1, -11 },
  { 260, 5, 11, 7, 1, -11 },
  { 267, 7, 12, 9, 1, -12 },
  { 278, 7, 11, 9, 1, -11 },
  { 288, 3, 11, 4, 1, -11 },
  { 293, 3, 14, 4, -1, -11 },
  { 299, 6, 11, 7, 1, -11 },
  { 308, 5, 11, 6, 1, -11 },
  { 315, 10, 11, 12, 1, -11 },
  { 329, 7, 11, 10, 1, -11 },
  { 339, 8, 12, 10, 1, -12 },
  { 351, 6, 11, 8, 1, -11 },
  { 360, 8, 15, 10, 1, -12 },
  { 375, 6, 11, 8, 1, -11 },
  { 384, 5, 12, 7, 1, -12 },
  { 392, 6, 11, 7, 0, -11 },
  { 401, 7, 11, 9, 1, -11 },
  { 411, 7, 11, 7, 0, -11 },
  { 421, 12, 11, 12, 0, -11 },
  { 438, 7, 11, 7, 0, -11 },
  { 448, 7, 11, 7, 0, -11 },
  { 458, 6, 11, 7, 0, -11 },
  { 467, 4, 14, 5, 1, -11 },
  { 474, 5, 11, 6, 0, -11 },
  { 481, 4, 14, 5, 0, -11 },
  { 488, 7, 6, 7, 0, -11 },
  { 494, 7, 1, 7, 0, 1 },
  { 495, 2, 2, 4, 1, -12 },
  { 496, 5, 9, 7, 1, -9 },
  { 502, 6, 12, 8, 1, -12 },
  { 511, 5, 9, 6, 1, -9 },
  { 517, 6, 12, 8, 1, -12 },
  { 526, 5, 9, 7, 1, -9 },
  { 532, 5, 12, 4, 0, -12 },
  { 540, 6, 13, 8, 1, -9 },
  { 550, 6, 12, 8, 1, -12 },
  { 559, 1, 12, 3, 1, -12 },
  { 561, 2, 16, 3, 0, -12 },
  { 565, 5, 12, 6, 1, -12 },
  { 573, 1, 12, 3, 1, -12 },
  { 575, 9, 9, 12, 1, -9 },
  { 586, 6, 9, 8, 1, -9 },
  { 593, 6, 9, 8, 1, -9 },
  { 600, 6, 13, 8, 1, -9 },
  { 610, 6, 13, 8, 1, -9 },
  { 620, 4, 9, 5, 1, -9 },
  { 625, 4, 9, 6, 1, -9 },
  { 630, 4, 11, 4, 0, -11 },
  { 636, 6, 9, 8, 1, -9 },
  { 643, 6, 9, 6, 0, -9 },
  { 650, 10, 9, 10, 0, -9 },
  { 662, 6, 9, 6, 0, -9 },
  { 669, 6, 13, 6, 0, -9 },
  { 679, 5, 9, 5, 0, -9 },
  { 685, 4, 14, 6, 1, -11 },
  { 692, 1, 16, 7, 3, -12 },
  { 694, 4, 14, 6, 1, -11 },
  { 701, 6, 2, 7, 1, -7 },
};

const GFXfont NotoSans_Condensed_Light16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light16pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_CONDENSED_LIGHT16PT7B_H_
