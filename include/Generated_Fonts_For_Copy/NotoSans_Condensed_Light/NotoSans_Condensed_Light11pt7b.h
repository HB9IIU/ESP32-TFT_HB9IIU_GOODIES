#ifndef _NOTOSANS_CONDENSED_LIGHT11PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFD, 0xFC, 0x29, 0x5E, 0xA5, 0x7D, 0x4A, 0x75, 0x28, 0xC3, 0x16,
  0xAE, 0x20, 0x65, 0x52, 0xA5, 0xA7, 0xA3, 0x4A, 0x97, 0x71, 0x45, 0x08,
  0x66, 0x68, 0x9F, 0xE0, 0x6A, 0xAA, 0x90, 0x89, 0x12, 0x4A, 0x50, 0x2F,
  0x70, 0x21, 0x3E, 0x42, 0x00, 0x60, 0xE0, 0x80, 0x12, 0x22, 0x44, 0x48,
  0xEA, 0x99, 0x99, 0xAE, 0x75, 0x55, 0x71, 0x11, 0x12, 0x4F, 0xF1, 0x17,
  0x11, 0x1F, 0x11, 0x8C, 0xA5, 0x7C, 0x42, 0xE8, 0x8E, 0x21, 0x1E, 0x68,
  0x8E, 0x99, 0x9E, 0xF8, 0x84, 0x22, 0x10, 0x88, 0x74, 0x54, 0xE5, 0x46,
  0x2E, 0x79, 0x99, 0x71, 0x1E, 0x84, 0x40, 0x18, 0x1B, 0x30, 0x60, 0x80,
  0xF8, 0x3E, 0xC1, 0x86, 0xC8, 0x00, 0xE4, 0x94, 0x82, 0x7A, 0x1B, 0x75,
  0xD7, 0x5A, 0xE0, 0x70, 0x21, 0x14, 0xA7, 0x26, 0x31, 0xE9, 0x9E, 0x99,
  0x9E, 0x78, 0x88, 0x88, 0x87, 0xE4, 0xA3, 0x18, 0xC6, 0x5C, 0xF2, 0x79,
  0x27, 0xF2, 0x4F, 0x24, 0x7C, 0x21, 0x09, 0xC6, 0x2F, 0x99, 0x9F, 0x99,
  0x99, 0xE9, 0x24, 0x97, 0x24, 0x92, 0x49, 0x38, 0x9A, 0xAC, 0xCA, 0xA9,
  0x92, 0x49, 0x27, 0x86, 0x1C, 0xF3, 0xCE, 0xDB, 0x65, 0x8C, 0x73, 0x9A,
  0xD6, 0x71, 0x74, 0x63, 0x18, 0xC6, 0x2E, 0xE9, 0x99, 0xE8, 0x88, 0x74,
  0x63, 0x18, 0xC6, 0x2E, 0x10, 0x80, 0xE9, 0x99, 0xEA, 0x99, 0x78, 0x84,
  0x31, 0x1F, 0xF2, 0x22, 0x22, 0x22, 0x99, 0x99, 0x99, 0x9F, 0x8C, 0x62,
  0xA5, 0x28, 0x84, 0x89, 0x89, 0x99, 0x59, 0x56, 0x66, 0x26, 0x24, 0x92,
  0x94, 0x42, 0x29, 0x53, 0x99, 0x56, 0x22, 0x22, 0xF1, 0x22, 0x24, 0x4F,
  0xEA, 0xAA, 0xB0, 0x88, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0x3C, 0x22,
  0x95, 0x10, 0xF8, 0xC0, 0x71, 0x35, 0x97, 0x88, 0xE9, 0x99, 0x9E, 0xF2,
  0x49, 0xC0, 0x11, 0xF9, 0x99, 0x9F, 0xF7, 0xC9, 0xC0, 0x6B, 0xA4, 0x92,
  0xF9, 0x99, 0x9F, 0x11, 0xE0, 0x88, 0xE9, 0x99, 0x99, 0xBF, 0x45, 0x55,
  0x58, 0x92, 0xED, 0xAD, 0xFF, 0xEE, 0x5A, 0x69, 0xA6, 0x90, 0xE9, 0x99,
  0x99, 0xE9, 0x99, 0x9E, 0xE9, 0x99, 0x9E, 0x88, 0x80, 0xF9, 0x99, 0x9F,
  0x11, 0x10, 0xEA, 0xA0, 0x78, 0x42, 0x1E, 0x5D, 0x24, 0x98, 0xB6, 0xDB,
  0xC0, 0x99, 0x96, 0x62, 0x93, 0x6A, 0xB3, 0x66, 0xC9, 0x00, 0x96, 0x22,
  0x69, 0x99, 0x56, 0x62, 0x44, 0x80, 0xE4, 0xA5, 0xC0, 0x29, 0x2C, 0x92,
  0x44, 0xFF, 0xE0, 0xC9, 0x22, 0x52, 0x58, 0xF8,
};

const GFXglyph NotoSans_Condensed_Light11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 8, 2, 1, -8 },
  { 2, 2, 3, 4, 1, -8 },
  { 3, 5, 8, 6, 0, -8 },
  { 8, 5, 9, 5, 0, -8 },
  { 14, 7, 8, 7, 0, -8 },
  { 21, 6, 8, 6, 0, -8 },
  { 27, 1, 3, 2, 1, -8 },
  { 28, 2, 10, 3, 1, -8 },
  { 31, 3, 10, 3, 0, -8 },
  { 35, 4, 3, 5, 0, -8 },
  { 37, 5, 5, 5, 0, -6 },
  { 41, 2, 2, 2, 0, -1 },
  { 42, 3, 1, 3, 0, -3 },
  { 43, 1, 1, 2, 1, -1 },
  { 44, 4, 8, 4, 0, -8 },
  { 48, 4, 8, 5, 1, -8 },
  { 52, 2, 8, 5, 1, -8 },
  { 54, 4, 8, 5, 0, -8 },
  { 58, 4, 8, 5, 0, -8 },
  { 62, 5, 8, 5, 0, -8 },
  { 67, 4, 8, 5, 1, -8 },
  { 71, 4, 8, 5, 1, -8 },
  { 75, 5, 8, 5, 0, -8 },
  { 80, 5, 8, 5, 0, -8 },
  { 85, 4, 8, 5, 0, -8 },
  { 89, 1, 6, 2, 1, -6 },
  { 90, 2, 7, 2, 0, -6 },
  { 92, 5, 5, 5, 0, -6 },
  { 96, 5, 3, 5, 0, -5 },
  { 98, 5, 5, 5, 0, -6 },
  { 102, 3, 8, 4, 0, -8 },
  { 105, 6, 9, 8, 1, -8 },
  { 112, 5, 8, 5, 0, -8 },
  { 117, 4, 8, 6, 1, -8 },
  { 121, 4, 8, 5, 1, -8 },
  { 125, 5, 8, 6, 1, -8 },
  { 130, 3, 8, 5, 1, -8 },
  { 133, 3, 8, 4, 1, -8 },
  { 136, 5, 8, 6, 1, -8 },
  { 141, 4, 8, 6, 1, -8 },
  { 145, 3, 8, 3, 0, -8 },
  { 148, 3, 10, 2, -1, -8 },
  { 152, 4, 8, 5, 1, -8 },
  { 156, 3, 8, 4, 1, -8 },
  { 159, 6, 8, 8, 1, -8 },
  { 165, 5, 8, 7, 1, -8 },
  { 170, 5, 8, 7, 1, -8 },
  { 175, 4, 8, 5, 1, -8 },
  { 179, 5, 10, 7, 1, -8 },
  { 186, 4, 8, 5, 1, -8 },
  { 190, 4, 8, 5, 0, -8 },
  { 194, 4, 8, 5, 0, -8 },
  { 198, 4, 8, 6, 1, -8 },
  { 202, 5, 8, 5, 0, -8 },
  { 207, 8, 8, 8, 0, -8 },
  { 215, 5, 8, 5, 0, -8 },
  { 220, 4, 8, 4, 0, -8 },
  { 224, 4, 8, 5, 0, -8 },
  { 228, 2, 10, 3, 1, -8 },
  { 231, 4, 8, 4, 0, -8 },
  { 235, 3, 10, 3, 0, -8 },
  { 239, 5, 4, 5, 0, -8 },
  { 242, 5, 1, 5, 0, 1 },
  { 243, 2, 1, 3, 0, -8 },
  { 244, 4, 6, 5, 0, -6 },
  { 247, 4, 8, 5, 1, -8 },
  { 251, 3, 6, 4, 1, -6 },
  { 254, 4, 8, 5, 1, -8 },
  { 258, 3, 6, 5, 1, -6 },
  { 261, 3, 8, 3, 0, -8 },
  { 264, 4, 9, 5, 1, -6 },
  { 269, 4, 8, 5, 1, -8 },
  { 273, 1, 8, 2, 1, -8 },
  { 274, 2, 11, 2, 0, -8 },
  { 277, 3, 8, 4, 1, -8 },
  { 280, 1, 8, 2, 1, -8 },
  { 281, 6, 6, 8, 1, -6 },
  { 286, 4, 6, 5, 1, -6 },
  { 289, 4, 6, 5, 1, -6 },
  { 292, 4, 9, 5, 1, -6 },
  { 297, 4, 9, 5, 1, -6 },
  { 302, 2, 6, 3, 1, -6 },
  { 304, 4, 6, 4, 0, -6 },
  { 307, 3, 7, 3, 0, -7 },
  { 310, 3, 6, 5, 1, -6 },
  { 313, 4, 6, 4, 0, -6 },
  { 316, 7, 6, 7, 0, -6 },
  { 322, 4, 6, 4, 0, -6 },
  { 325, 4, 9, 4, 0, -6 },
  { 330, 3, 6, 4, 0, -6 },
  { 333, 3, 10, 4, 0, -8 },
  { 337, 1, 11, 5, 2, -8 },
  { 339, 3, 10, 4, 0, -8 },
  { 343, 5, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Light11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light11pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_CONDENSED_LIGHT11PT7B_H_
