#ifndef _NOTOSANS_CONDENSED_LIGHT64PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT64PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light64pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x77, 0xBF, 0xFF, 0xF8, 0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0,
  0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x19, 0xC0, 0x66, 0x01, 0x98, 0x06, 0x60,
  0x18, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38,
  0x00, 0x07, 0x00, 0xE0, 0x00, 0x18, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00,
  0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70,
  0x07, 0x00, 0x01, 0xC0, 0x18, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0xE0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00,
  0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0,
  0x38, 0x03, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xFC, 0x01, 0xC0, 0x38, 0x00, 0x06, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80,
  0x00, 0xE0, 0x0C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x00, 0x70, 0x00, 0x1C,
  0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x01,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x3F, 0x38, 0x78, 0xF8, 0x70, 0x11, 0xE0,
  0xE0, 0x07, 0x81, 0xC0, 0x0F, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E,
  0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0xE0,
  0x07, 0x81, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x87, 0x00, 0x0F, 0xCE, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xBF, 0x00, 0x07, 0x1F, 0x00, 0x0E, 0x1F, 0x00,
  0x1C, 0x1E, 0x00, 0x38, 0x1E, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0x70, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1C,
  0x0F, 0x00, 0x38, 0x1D, 0x00, 0x70, 0x7B, 0x80, 0xE3, 0xE7, 0xF9, 0xFF,
  0x8F, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0x80, 0x01, 0xC0,
  0x0F, 0x1E, 0x00, 0x1E, 0x00, 0x70, 0x70, 0x00, 0xE0, 0x07, 0x03, 0xC0,
  0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x03, 0x80, 0x1C,
  0x03, 0x80, 0x3C, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x0E, 0x00,
  0xE0, 0x70, 0x00, 0x70, 0x07, 0x03, 0x80, 0x03, 0x80, 0x38, 0x1C, 0x00,
  0x1C, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0x07, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x03, 0x87, 0x07, 0xC1, 0xC0, 0x1C, 0x38, 0x7F, 0x8E,
  0x01, 0xC3, 0x87, 0xFE, 0x38, 0x0E, 0x1C, 0x78, 0x71, 0xC0, 0x71, 0xC3,
  0x81, 0xCE, 0x07, 0x8E, 0x38, 0x0E, 0x38, 0x38, 0x71, 0xC0, 0x79, 0xF7,
  0xC7, 0x0E, 0x01, 0xC7, 0xFC, 0x38, 0x70, 0x0E, 0x1F, 0xC3, 0x83, 0x80,
  0x70, 0x00, 0x1C, 0x38, 0x03, 0x80, 0x00, 0xE1, 0xC0, 0x1C, 0x00, 0x0E,
  0x0E, 0x00, 0xE0, 0x00, 0x70, 0x70, 0x07, 0x00, 0x07, 0x03, 0x80, 0x38,
  0x00, 0x38, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x1C, 0x07,
  0x00, 0x70, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x0E, 0x00, 0xE0, 0x1C, 0x00,
  0x70, 0x07, 0x00, 0xE0, 0x07, 0x80, 0x38, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x70, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0xE0,
  0x00, 0xE3, 0xC0, 0x0F, 0x00, 0x07, 0xFC, 0x00, 0x70, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x38, 0x00,
  0x0F, 0x00, 0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xC0, 0x00,
  0x78, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x1E, 0x00, 0x01,
  0xE0, 0x38, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x70, 0x78, 0x1E,
  0x01, 0xE1, 0xE0, 0x3C, 0x03, 0xC3, 0x80, 0x3C, 0x07, 0x8F, 0x00, 0x3C,
  0x0E, 0x1E, 0x00, 0x3C, 0x1C, 0x38, 0x00, 0x78, 0x78, 0x70, 0x00, 0x78,
  0xE1, 0xE0, 0x00, 0x7B, 0xC3, 0xC0, 0x00, 0xF7, 0x83, 0x80, 0x00, 0xFE,
  0x07, 0x00, 0x00, 0xFC, 0x0E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x03, 0xE0,
  0x3C, 0x00, 0x0F, 0xE0, 0x3C, 0x00, 0x3F, 0xE0, 0x78, 0x00, 0xFB, 0xC0,
  0x7C, 0x03, 0xE3, 0xC0, 0xFF, 0xFF, 0x83, 0xC0, 0xFF, 0xFC, 0x03, 0xC0,
  0x7F, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x77, 0x77, 0x76, 0x60, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0F,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x18, 0x0E, 0x03, 0xF8, 0x70, 0xFF, 0xFB, 0xBF, 0xDF, 0xFF, 0xFC,
  0x07, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x71,
  0xC0, 0x07, 0x8F, 0x00, 0x78, 0x3C, 0x03, 0x80, 0xE0, 0x3C, 0x07, 0x81,
  0xC0, 0x18, 0x02, 0x00, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x31, 0xEF, 0xBF, 0xF9, 0xE2, 0x00, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7C, 0x1F,
  0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x1C,
  0x38, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7,
  0x00, 0x01, 0xEE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E,
  0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0xC7,
  0x00, 0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3E,
  0x01, 0xE0, 0x3E, 0x07, 0x80, 0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x38, 0x03, 0xC0, 0x3E, 0x03, 0xF0,
  0x3F, 0x87, 0xDC, 0x7C, 0xE7, 0xC7, 0x7C, 0x3F, 0xC1, 0xD8, 0x0E, 0x40,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0x07, 0x80, 0x1F, 0x04, 0x00,
  0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0x8F, 0x00, 0x0F, 0x0C,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x79, 0x00, 0x01, 0xF3, 0x80, 0x0F,
  0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x73, 0xC0,
  0x00, 0x0E, 0x3C, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x70, 0x3C,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x03, 0xC0, 0x01,
  0xC0, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0x70, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01,
  0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x03, 0xC0, 0x70, 0x00,
  0x3C, 0x07, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0xC3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE1, 0xC0,
  0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x0F, 0xF3, 0xFE, 0x04, 0x00, 0x7E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x79, 0x00, 0x01, 0xE3, 0xC0, 0x0F, 0xC7, 0xFF, 0xFF,
  0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF8, 0x03, 0xF0, 0x08, 0x07, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x70, 0x7F, 0x80, 0x71, 0xFF, 0xE0, 0xF3, 0xFF,
  0xF0, 0xF7, 0x80, 0xF8, 0xFE, 0x00, 0x78, 0xFC, 0x00, 0x3C, 0xF8, 0x00,
  0x1C, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00,
  0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1E, 0x00,
  0x3C, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0xF8, 0x07, 0xF7, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x1F, 0x01, 0xF8, 0x3E, 0x00, 0x78, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x70,
  0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78,
  0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1F,
  0x00, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xC7, 0xC0, 0x0F,
  0x03, 0xF0, 0x1E, 0x00, 0xF8, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x70,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F, 0xEF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0x38, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x1E, 0x1E, 0x00,
  0x1E, 0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0x77, 0x80, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x03, 0xEE, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x9E,
  0x00, 0x7F, 0x3E, 0x01, 0xDE, 0x3F, 0x1F, 0xBC, 0x3F, 0xFE, 0x78, 0x3F,
  0xF0, 0xF0, 0x0F, 0x81, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0xF8, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7B, 0xEF, 0xFF,
  0x79, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x31, 0xEF, 0xBF, 0xF9, 0xE2, 0x00,
  0x1E, 0x1F, 0x3F, 0x3F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x3C, 0x07, 0xC4, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x40, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x3C, 0x00, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x00, 0x01, 0xC1, 0xC0,
  0x00, 0x00, 0x03, 0x83, 0x80, 0x07, 0xF8, 0x07, 0x8F, 0x00, 0x3F, 0xFC,
  0x07, 0x1C, 0x00, 0xFF, 0xF0, 0x0E, 0x38, 0x03, 0xC0, 0xE0, 0x1C, 0xF0,
  0x0F, 0x01, 0xC0, 0x3D, 0xC0, 0x1C, 0x03, 0x80, 0x3B, 0x80, 0x70, 0x07,
  0x00, 0x77, 0x00, 0xE0, 0x0E, 0x00, 0xEE, 0x03, 0xC0, 0x1C, 0x01, 0xDC,
  0x07, 0x00, 0x38, 0x03, 0xF8, 0x0E, 0x00, 0x70, 0x07, 0xF0, 0x1C, 0x00,
  0xE0, 0x0F, 0xC0, 0x38, 0x01, 0xC0, 0x1F, 0x80, 0x70, 0x03, 0x80, 0x3F,
  0x00, 0xE0, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x0E, 0x00, 0xFC, 0x03, 0x80,
  0x3C, 0x03, 0xB8, 0x07, 0x00, 0x78, 0x07, 0x78, 0x0E, 0x00, 0xF0, 0x0E,
  0x70, 0x1E, 0x01, 0xE0, 0x1C, 0xE0, 0x1C, 0x06, 0xC0, 0x71, 0xC0, 0x3C,
  0x0D, 0xC0, 0xE3, 0x80, 0x7C, 0x39, 0xC7, 0x87, 0x00, 0x7F, 0xE3, 0xFF,
  0x0F, 0x00, 0x7F, 0x83, 0xFC, 0x0E, 0x00, 0x3C, 0x03, 0xE0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x08, 0x00, 0x00, 0xFE, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00,
  0x38, 0x78, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x1C,
  0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0x38, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x1C, 0x00, 0xF0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0xC0,
  0x00, 0xF0, 0x0F, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xF0, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1E, 0x01, 0xFF, 0x0F, 0x00, 0x0F, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x0F, 0x01, 0xFF,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0xF0, 0x00,
  0xFC, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x3C,
  0xF0, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x3C, 0x00, 0x7E, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x0F, 0xE0, 0x1E, 0x07, 0xE0, 0x01, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x38, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0xFC,
  0x3C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x9E, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x7E, 0x1E, 0x00,
  0x1F, 0x83, 0xC0, 0x3F, 0xE0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x01,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x7F, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0x30, 0x1F, 0x00, 0x00, 0x40, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x3C, 0xF8, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x0F, 0x80, 0x00, 0x3C, 0x1F, 0x80, 0x00, 0xF0, 0x3F, 0x80, 0x07, 0xC0,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x03, 0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0xFB, 0xFF, 0x9F,
  0xF8, 0xFF, 0x81, 0xE0, 0x00, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3,
  0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0,
  0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0x9F,
  0x00, 0x03, 0xDF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFE, 0x78, 0x00, 0x7E,
  0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xEF, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF7,
  0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x00, 0x00,
  0x77, 0xF7, 0x00, 0x00, 0x07, 0xBF, 0xB8, 0x00, 0x00, 0x39, 0xFD, 0xE0,
  0x00, 0x01, 0xCF, 0xE7, 0x00, 0x00, 0x1E, 0x7F, 0x38, 0x00, 0x00, 0xE3,
  0xF9, 0xE0, 0x00, 0x07, 0x1F, 0xC7, 0x00, 0x00, 0x78, 0xFE, 0x38, 0x00,
  0x03, 0x87, 0xF1, 0xE0, 0x00, 0x1C, 0x3F, 0x87, 0x00, 0x01, 0xE1, 0xFC,
  0x38, 0x00, 0x0E, 0x0F, 0xE1, 0xE0, 0x00, 0x70, 0x7F, 0x07, 0x00, 0x07,
  0x83, 0xF8, 0x38, 0x00, 0x38, 0x1F, 0xC1, 0xE0, 0x01, 0xC0, 0xFE, 0x07,
  0x00, 0x1E, 0x07, 0xF0, 0x38, 0x00, 0xE0, 0x3F, 0x81, 0xE0, 0x07, 0x01,
  0xFC, 0x07, 0x00, 0x78, 0x0F, 0xE0, 0x38, 0x03, 0x80, 0x7F, 0x01, 0xE0,
  0x1C, 0x03, 0xF8, 0x07, 0x01, 0xE0, 0x1F, 0xC0, 0x38, 0x0E, 0x00, 0xFE,
  0x01, 0xE0, 0x70, 0x07, 0xF0, 0x07, 0x07, 0x80, 0x3F, 0x80, 0x38, 0x38,
  0x01, 0xFC, 0x01, 0xE1, 0xC0, 0x0F, 0xE0, 0x0F, 0x1E, 0x00, 0x7F, 0x00,
  0x38, 0xE0, 0x03, 0xF8, 0x01, 0xE7, 0x00, 0x1F, 0xC0, 0x0F, 0x78, 0x00,
  0xFE, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF0, 0x00, 0x7F,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xEF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xF7, 0x80, 0x00, 0xFF, 0x78, 0x00, 0x0F, 0xF3, 0xC0, 0x00, 0xFF,
  0x3C, 0x00, 0x0F, 0xF1, 0xE0, 0x00, 0xFF, 0x1E, 0x00, 0x0F, 0xF0, 0xF0,
  0x00, 0xFF, 0x0F, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0xFF, 0x07, 0x80, 0x0F,
  0xF0, 0x3C, 0x00, 0xFF, 0x03, 0xC0, 0x0F, 0xF0, 0x1E, 0x00, 0xFF, 0x01,
  0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0xFF, 0x00, 0xF0, 0x0F, 0xF0, 0x07, 0x80,
  0xFF, 0x00, 0x78, 0x0F, 0xF0, 0x03, 0xC0, 0xFF, 0x00, 0x3C, 0x0F, 0xF0,
  0x01, 0xE0, 0xFF, 0x00, 0x1E, 0x0F, 0xF0, 0x00, 0xF0, 0xFF, 0x00, 0x0F,
  0x0F, 0xF0, 0x00, 0x78, 0xFF, 0x00, 0x07, 0x8F, 0xF0, 0x00, 0x3C, 0xFF,
  0x00, 0x03, 0xCF, 0xF0, 0x00, 0x1E, 0xFF, 0x00, 0x01, 0xEF, 0xF0, 0x00,
  0x0F, 0x7F, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xE0, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x01,
  0xC7, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x3C, 0xE0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC3, 0x80, 0x00,
  0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x1F, 0x80, 0x3E,
  0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x00, 0x3F, 0x1E, 0x00, 0x1F, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00,
  0x77, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x07, 0x9E, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0x78,
  0x03, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x1F, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF8, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01,
  0xE3, 0xC0, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x03, 0xC3, 0x80, 0x00, 0x07, 0x87, 0x80, 0x00, 0x0F, 0x0F, 0x80, 0x00,
  0x3C, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x0F,
  0x80, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0x00, 0x3F, 0x07, 0x80, 0x07, 0xC3, 0xC0, 0x01, 0xF1, 0xE0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x38, 0xF0, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x0F, 0x83, 0xC0, 0x1F, 0x81, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x3C, 0x07, 0x80, 0x1E,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78,
  0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x01,
  0xE1, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x1F, 0x3C, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7C, 0x01,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFC, 0x03, 0xC3, 0xE0,
  0x00, 0x8F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x79, 0x00, 0x01, 0xF3,
  0xC0, 0x0F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3B, 0xC0, 0x00,
  0x07, 0x78, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xE3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x03,
  0xE0, 0x7E, 0x00, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F,
  0x3C, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x1C, 0x3C,
  0x00, 0x01, 0xE0, 0xE0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x70, 0x3C, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x3C, 0x07, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x0E,
  0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x80, 0x38, 0x00, 0x38, 0x01,
  0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x1E,
  0x00, 0x0E, 0x00, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x0E, 0x03, 0x80, 0x00, 0x78, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0x70, 0x70, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1E, 0x3C,
  0x00, 0x00, 0x71, 0xC0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x39, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xFC, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1D, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x77,
  0x80, 0x03, 0xC3, 0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x38,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0xE0, 0x70, 0x00, 0xE3, 0xC0,
  0x03, 0x81, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x1C, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x70, 0x01, 0xE0, 0x38, 0x01, 0xE1, 0xC0, 0x07,
  0x00, 0xE0, 0x07, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0xF0,
  0x0F, 0x00, 0x70, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0xE0, 0x0E, 0x00,
  0x70, 0x0E, 0x03, 0xC0, 0x38, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xE0, 0x07,
  0x80, 0xE0, 0x1C, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x70, 0x1C, 0x00, 0x38,
  0x1E, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x70, 0x07, 0x83, 0xC0, 0x03, 0xC1,
  0xC0, 0x0E, 0x0F, 0x00, 0x0F, 0x07, 0x00, 0x38, 0x3C, 0x00, 0x1C, 0x3C,
  0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0x80,
  0x07, 0x1E, 0x00, 0x07, 0x8E, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x38, 0x00,
  0x71, 0xC0, 0x00, 0x39, 0xE0, 0x01, 0xC7, 0x00, 0x00, 0xE7, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x3B,
  0x80, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x78, 0x78, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x01, 0xC0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x3C, 0xE0, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x38, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0x3C, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F,
  0x03, 0x80, 0x00, 0xE0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0x3D, 0xE0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x0F, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x03,
  0x80, 0x07, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x38,
  0x01, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0,
  0xF0, 0x00, 0x78, 0x38, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xF1, 0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xE1, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x0E, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x00, 0xF0, 0x0E, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0,
  0xF0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1F, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x00,
  0x1F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0x8F, 0xC0, 0xC0, 0x1F, 0x04, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xF0, 0x0E, 0x3E,
  0x00, 0x73, 0xC0, 0x03, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00,
  0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x06, 0xE7, 0x80, 0x77, 0x3F, 0x0F, 0x38,
  0xFF, 0xF1, 0xC3, 0xFF, 0x06, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x07, 0x00, 0x70, 0x7F, 0xC0, 0xE3, 0xFF, 0xE1, 0xCF, 0xDF, 0xE3,
  0xBC, 0x07, 0xC7, 0x60, 0x03, 0xCF, 0xC0, 0x07, 0x9F, 0x00, 0x07, 0xBE,
  0x00, 0x0F, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1D, 0xE0, 0x00, 0x7B, 0xE0, 0x00, 0xF7,
  0xC0, 0x03, 0xCE, 0xC0, 0x0F, 0x9D, 0xE0, 0x3E, 0x39, 0xFB, 0xF8, 0x71,
  0xFF, 0xE0, 0xE1, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x1F,
  0xFC, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xF8, 0x02, 0x3E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x01,
  0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x38, 0x0F, 0x03, 0xFF, 0x0F, 0x07, 0xFF,
  0x8F, 0x0F, 0xEF, 0xCF, 0x1F, 0x00, 0xEF, 0x1E, 0x00, 0x7F, 0x3C, 0x00,
  0x3F, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x38, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x3E, 0x00,
  0x77, 0x1F, 0x00, 0xE7, 0x0F, 0xEF, 0xC7, 0x07, 0xFF, 0x87, 0x03, 0xFF,
  0x07, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFC,
  0x03, 0xF1, 0xF8, 0x0F, 0x01, 0xF0, 0x78, 0x03, 0xC3, 0xC0, 0x07, 0x8E,
  0x00, 0x0E, 0x38, 0x00, 0x39, 0xE0, 0x00, 0xF7, 0x00, 0x01, 0xDC, 0x00,
  0x07, 0x70, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x43, 0xE0, 0x06, 0x07, 0xFB, 0xF8, 0x0F,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x00, 0x7F, 0xC0,
  0x7F, 0xE0, 0x7C, 0x30, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x7F, 0xF8, 0xFF, 0xFC, 0x7F, 0xFE, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x07, 0x07, 0xFF,
  0x87, 0x0F, 0xFF, 0xC7, 0x1F, 0x00, 0xEF, 0x1E, 0x00, 0x7F, 0x3C, 0x00,
  0x3F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x70, 0x00,
  0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x38, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x3E, 0x00,
  0x6F, 0x1F, 0x00, 0xEF, 0x0F, 0xEF, 0xCF, 0x07, 0xFF, 0x8F, 0x03, 0xFF,
  0x0F, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x20, 0x00, 0x78, 0x38, 0x01,
  0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0xF0, 0x1C, 0x1F, 0xF0, 0xE3, 0xFF, 0xC7, 0x3F, 0x7F, 0x3B, 0xC0, 0x7D,
  0xD8, 0x01, 0xEF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x38, 0x73, 0xFF, 0xFF, 0xB8, 0x00,
  0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xC0, 0x03, 0x80, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07,
  0x81, 0xE0, 0xFB, 0xFC, 0xFE, 0x3F, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x1F, 0xE0,
  0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0xF0, 0xE0, 0x0F, 0x0E,
  0x01, 0xE0, 0xE0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x0F, 0x00,
  0xE0, 0xE0, 0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x7C, 0x00, 0xE7, 0xE0,
  0x0E, 0xEE, 0x00, 0xFC, 0xF0, 0x0F, 0xC7, 0x80, 0xF8, 0x78, 0x0F, 0x03,
  0xC0, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xE0, 0x03, 0xCE,
  0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x07, 0x0F, 0xF8,
  0x0F, 0xFC, 0x38, 0xFF, 0xE0, 0xFF, 0xF1, 0xCF, 0xBF, 0x8F, 0x9F, 0xCE,
  0xE0, 0x3C, 0xF0, 0x1E, 0x76, 0x00, 0xF6, 0x00, 0x7B, 0xE0, 0x07, 0xF0,
  0x03, 0xDF, 0x00, 0x1F, 0x00, 0x1E, 0xF0, 0x00, 0xF8, 0x00, 0x77, 0x80,
  0x07, 0x80, 0x03, 0xBC, 0x00, 0x3C, 0x00, 0x1D, 0xC0, 0x01, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x03,
  0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x01, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x80,
  0x03, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x01,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x3F,
  0x80, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x3C, 0x07, 0x0F, 0xFC, 0x38, 0xFF, 0xF1, 0xCF, 0xCF, 0xCE, 0xF0, 0x1F,
  0x76, 0x00, 0x7B, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0xE7, 0xF0, 0x1F, 0x00, 0xF8, 0x1E, 0x00,
  0x7C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x7C, 0x0F, 0x00, 0xF8, 0x0F, 0xF7, 0xF0, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x01, 0xC1, 0xFF,
  0x03, 0x8F, 0xFF, 0x87, 0x3F, 0x3F, 0x8E, 0x70, 0x0F, 0x1D, 0x80, 0x0F,
  0x3F, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x3B,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x77, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xDF, 0x80, 0x0F, 0x3B, 0x00, 0x3E,
  0x77, 0x80, 0xF8, 0xE7, 0xEF, 0xE1, 0xC7, 0xFF, 0x83, 0x83, 0xFE, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF,
  0x07, 0x07, 0xFF, 0x87, 0x0F, 0xFF, 0xC7, 0x1F, 0x00, 0xEF, 0x1E, 0x00,
  0x7F, 0x3C, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x1F, 0x70, 0x00, 0x1F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x1F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x38, 0x00, 0x3F, 0x3C, 0x00,
  0x3F, 0x3E, 0x00, 0x6F, 0x1F, 0x00, 0xEF, 0x0F, 0xEF, 0xCF, 0x07, 0xFF,
  0x8F, 0x03, 0xFF, 0x0F, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x3B, 0xC3, 0xFB, 0x8F, 0xF7, 0x3F, 0xEE, 0x70, 0x1D, 0xC0,
  0x3B, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x8F, 0xC3, 0xE3, 0xC0, 0x0C, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xF7, 0x00, 0x3E, 0xFF,
  0xFF, 0x9F, 0xFF, 0xE0, 0xFF, 0xF8, 0x01, 0xE0, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xF7,
  0x03, 0xFE, 0x07, 0xFC, 0x01, 0xC0, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0x70, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x78,
  0x00, 0xDC, 0xF0, 0x07, 0x73, 0xE0, 0x39, 0xC7, 0xFF, 0xE7, 0x0F, 0xFF,
  0x1C, 0x1F, 0xF0, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC3,
  0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0xE0, 0x01, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0xC0, 0x07,
  0x3C, 0x00, 0xEE, 0x00, 0x39, 0xE0, 0x07, 0x70, 0x01, 0xCF, 0x00, 0x3B,
  0x80, 0x1E, 0x38, 0x01, 0xCE, 0x00, 0xE1, 0xC0, 0x1E, 0x70, 0x07, 0x0F,
  0x00, 0xE3, 0x80, 0x38, 0x78, 0x07, 0x1C, 0x03, 0xC1, 0xC0, 0x38, 0x70,
  0x1E, 0x0E, 0x03, 0xC3, 0x80, 0xE0, 0x78, 0x1C, 0x1C, 0x07, 0x03, 0xC0,
  0xE0, 0xE0, 0x78, 0x0E, 0x07, 0x07, 0x83, 0xC0, 0x70, 0x38, 0x1C, 0x1C,
  0x03, 0xC3, 0x80, 0xE0, 0xE0, 0x1E, 0x1C, 0x07, 0x07, 0x00, 0x70, 0xE0,
  0x3C, 0x78, 0x03, 0x87, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x07, 0x1C, 0x00,
  0xF3, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x01, 0xEF, 0x00, 0x1C, 0xE0, 0x07,
  0x70, 0x00, 0xEF, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0x3F,
  0x80, 0x0E, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xE0,
  0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03,
  0x80, 0xE0, 0x07, 0x83, 0xC0, 0x07, 0x07, 0x00, 0x0F, 0x1E, 0x00, 0x0E,
  0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0x70,
  0x00, 0x1E, 0xF0, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xE0, 0x01, 0xC1, 0xC0,
  0x07, 0x83, 0xC0, 0x0E, 0x03, 0x80, 0x3C, 0x07, 0x80, 0x70, 0x07, 0x01,
  0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x73, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xE0, 0x70, 0x01,
  0xC0, 0xF0, 0x07, 0x81, 0xE0, 0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78,
  0x07, 0x80, 0xF0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x1E, 0x0F, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0, 0x00, 0xF1, 0xC0, 0x00,
  0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x0F, 0xC0,
  0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x80,
  0x07, 0xF0, 0x00, 0xF8, 0x03, 0xFC, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x9F, 0xF8, 0x00, 0x5F, 0xFF, 0x00, 0x7E, 0x0F,
  0xF8, 0xFE, 0x00, 0xFF, 0xF4, 0x00, 0x1F, 0xF2, 0x00, 0x01, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 47, 14, 5, -46 },
  { 31, 14, 17, 22, 4, -46 },
  { 61, 30, 46, 32, 1, -46 },
  { 234, 23, 53, 29, 3, -49 },
  { 387, 37, 47, 43, 3, -46 },
  { 605, 31, 47, 33, 2, -46 },
  { 788, 4, 17, 12, 4, -46 },
  { 797, 13, 56, 18, 3, -46 },
  { 888, 13, 56, 18, 2, -46 },
  { 979, 21, 22, 27, 3, -49 },
  { 1037, 25, 30, 30, 2, -38 },
  { 1131, 8, 15, 13, 2, -7 },
  { 1146, 14, 3, 18, 2, -19 },
  { 1152, 6, 7, 14, 4, -6 },
  { 1158, 20, 46, 22, 1, -46 },
  { 1273, 23, 47, 29, 3, -46 },
  { 1409, 13, 46, 29, 5, -46 },
  { 1484, 23, 46, 29, 3, -46 },
  { 1617, 23, 47, 29, 3, -46 },
  { 1753, 28, 46, 29, 1, -46 },
  { 1914, 23, 47, 29, 3, -46 },
  { 2050, 24, 47, 29, 3, -46 },
  { 2191, 23, 46, 29, 3, -46 },
  { 2324, 24, 47, 29, 3, -46 },
  { 2465, 23, 47, 29, 3, -46 },
  { 2601, 6, 35, 14, 4, -34 },
  { 2628, 8, 42, 14, 2, -34 },
  { 2670, 25, 28, 30, 2, -37 },
  { 2758, 25, 17, 30, 2, -31 },
  { 2812, 25, 28, 30, 2, -37 },
  { 2900, 19, 47, 21, 1, -46 },
  { 3012, 39, 52, 45, 3, -46 },
  { 3266, 30, 46, 30, 0, -46 },
  { 3439, 25, 46, 32, 5, -46 },
  { 3583, 26, 47, 31, 4, -46 },
  { 3736, 27, 46, 36, 5, -46 },
  { 3892, 20, 46, 28, 5, -46 },
  { 4007, 20, 46, 26, 5, -46 },
  { 4122, 30, 47, 38, 4, -46 },
  { 4299, 26, 46, 37, 5, -46 },
  { 4449, 12, 46, 17, 3, -46 },
  { 4518, 13, 58, 14, -4, -46 },
  { 4613, 25, 46, 30, 5, -46 },
  { 4757, 20, 46, 26, 5, -46 },
  { 4872, 37, 46, 47, 5, -46 },
  { 5085, 28, 46, 38, 5, -46 },
  { 5246, 31, 47, 39, 4, -46 },
  { 5429, 23, 46, 30, 5, -46 },
  { 5562, 31, 57, 39, 4, -46 },
  { 5783, 25, 46, 31, 5, -46 },
  { 5927, 23, 47, 28, 3, -46 },
  { 6063, 25, 46, 26, 1, -46 },
  { 6207, 27, 47, 36, 5, -46 },
  { 6366, 29, 46, 29, 0, -46 },
  { 6533, 46, 46, 48, 1, -46 },
  { 6798, 27, 46, 27, 0, -46 },
  { 6954, 26, 46, 26, 0, -46 },
  { 7104, 23, 46, 26, 2, -46 },
  { 7237, 13, 56, 20, 5, -46 },
  { 7328, 20, 46, 22, 1, -46 },
  { 7443, 13, 56, 20, 2, -46 },
  { 7534, 26, 25, 30, 2, -46 },
  { 7616, 27, 3, 27, 0, 6 },
  { 7627, 11, 10, 16, 3, -49 },
  { 7641, 21, 36, 28, 2, -35 },
  { 7736, 23, 50, 31, 5, -49 },
  { 7880, 19, 36, 24, 3, -35 },
  { 7966, 24, 50, 31, 3, -49 },
  { 8116, 22, 36, 28, 3, -35 },
  { 8215, 17, 49, 16, 1, -49 },
  { 8320, 24, 50, 31, 3, -35 },
  { 8470, 21, 49, 31, 5, -49 },
  { 8599, 5, 47, 13, 4, -47 },
  { 8629, 10, 62, 13, -1, -47 },
  { 8707, 20, 49, 26, 5, -49 },
  { 8830, 3, 49, 13, 5, -49 },
  { 8849, 37, 35, 46, 5, -35 },
  { 9011, 21, 35, 31, 5, -35 },
  { 9103, 24, 36, 30, 3, -35 },
  { 9211, 23, 50, 31, 5, -35 },
  { 9355, 24, 50, 31, 3, -35 },
  { 9505, 15, 35, 20, 5, -35 },
  { 9571, 19, 36, 24, 2, -35 },
  { 9657, 15, 43, 17, 1, -42 },
  { 9738, 22, 35, 31, 4, -34 },
  { 9835, 24, 34, 24, 0, -34 },
  { 9937, 37, 34, 39, 1, -34 },
  { 10095, 23, 34, 25, 1, -34 },
  { 10193, 23, 49, 24, 1, -34 },
  { 10334, 18, 34, 21, 2, -34 },
  { 10411, 17, 56, 23, 3, -46 },
  { 10530, 4, 64, 28, 12, -49 },
  { 10562, 17, 56, 23, 3, -46 },
  { 10681, 25, 7, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_Light64pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light64pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light64pt7bGlyphs,
  0x20, 0x7E, 87
};

#endif // _NOTOSANS_CONDENSED_LIGHT64PT7B_H_
