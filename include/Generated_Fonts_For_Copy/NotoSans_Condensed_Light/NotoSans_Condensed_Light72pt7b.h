#ifndef _NOTOSANS_CONDENSED_LIGHT72PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light72pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x31, 0xEF,
  0xFF, 0xFF, 0xF7, 0x8C, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F,
  0xC0, 0x18, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00,
  0xE0, 0x07, 0x00, 0x00, 0x70, 0x07, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x1E, 0x00,
  0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1C,
  0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03,
  0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x80, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x83, 0xF1, 0xC3, 0xE0, 0xF8, 0x38, 0x0C, 0x3E, 0x07,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x03, 0x80, 0x07,
  0x80, 0x70, 0x00, 0xF0, 0x0E, 0x00, 0x1E, 0x01, 0xC0, 0x03, 0xC0, 0x38,
  0x00, 0x78, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x1C, 0x00, 0x1F,
  0x03, 0x80, 0x01, 0xF0, 0x70, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xF9, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0E, 0x7E,
  0x00, 0x01, 0xC3, 0xE0, 0x00, 0x38, 0x3E, 0x00, 0x07, 0x03, 0xE0, 0x00,
  0xE0, 0x3C, 0x00, 0x1C, 0x07, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0F,
  0x00, 0x0E, 0x01, 0xE0, 0x01, 0xC0, 0x3C, 0x00, 0x38, 0x07, 0x00, 0x07,
  0x01, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1C, 0x0F, 0xA0, 0x03, 0x83, 0xE7,
  0x00, 0x70, 0xF8, 0xFE, 0x0E, 0x7E, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x78, 0x00, 0x78, 0x78, 0x00,
  0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x1C, 0x00, 0x78, 0x00, 0x70,
  0x07, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x00, 0x78,
  0x03, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0x80, 0x78,
  0x00, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x03,
  0xC0, 0x0E, 0x03, 0x80, 0x00, 0xF0, 0x03, 0x80, 0xE0, 0x00, 0x3C, 0x00,
  0xE0, 0x78, 0x00, 0x0F, 0x00, 0x38, 0x1C, 0x00, 0x03, 0xC0, 0x0E, 0x0F,
  0x00, 0x00, 0x70, 0x03, 0x83, 0x80, 0x60, 0x1C, 0x01, 0xE0, 0xE0, 0xFF,
  0x07, 0x00, 0x78, 0x78, 0x7F, 0xE1, 0xC0, 0x1E, 0x1C, 0x3E, 0xFC, 0x78,
  0x07, 0x0F, 0x0E, 0x0F, 0x1E, 0x01, 0xC3, 0x87, 0x81, 0xE3, 0x80, 0xF0,
  0xE1, 0xC0, 0x38, 0xF0, 0x38, 0x78, 0xF0, 0x0E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x03, 0xC7, 0xFF, 0x0F, 0x0E, 0x00, 0xF0, 0xFF, 0x83, 0x83, 0x80, 0x1C,
  0x0F, 0xC1, 0xE0, 0xE0, 0x07, 0x00, 0x00, 0x78, 0x38, 0x01, 0xC0, 0x00,
  0x1C, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x03, 0x80, 0x1C, 0x00, 0x03, 0x80,
  0xE0, 0x07, 0x00, 0x01, 0xE0, 0x38, 0x01, 0xC0, 0x00, 0x78, 0x0E, 0x00,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x1C, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0x00,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0x78,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x3C,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x00, 0x0E, 0x0F, 0x00, 0x0F,
  0x00, 0x03, 0xE7, 0xC0, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0x07, 0xC0, 0x78, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01, 0xF0, 0x3E, 0x00,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0F, 0x87, 0x80, 0x00, 0x01, 0xE3, 0xE0,
  0x00, 0x00, 0x3D, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x1F, 0x3C, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x07,
  0xC1, 0xF0, 0x03, 0xC3, 0xE0, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x3C,
  0x78, 0x01, 0xF0, 0x1E, 0x1E, 0x00, 0x3C, 0x07, 0x8F, 0x00, 0x07, 0x81,
  0xE3, 0xC0, 0x01, 0xF0, 0x78, 0xF0, 0x00, 0x3E, 0x3C, 0x3C, 0x00, 0x07,
  0x8F, 0x0F, 0x00, 0x01, 0xF7, 0x83, 0xC0, 0x00, 0x3F, 0xE0, 0xF0, 0x00,
  0x07, 0xF8, 0x3C, 0x00, 0x00, 0xFC, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x07, 0xF0, 0x1E, 0x00, 0x03, 0xFE, 0x07,
  0xC0, 0x01, 0xF7, 0xC0, 0xF8, 0x00, 0xF8, 0xF8, 0x1F, 0x80, 0xFC, 0x1E,
  0x07, 0xFF, 0xFE, 0x07, 0xC0, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0xFF, 0x00,
  0x1F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xEE, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x60, 0x1C, 0x07, 0x7C, 0x1C, 0x3F, 0xFF, 0x9D, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0xE7, 0x80, 0x01, 0xE3, 0x80, 0x03, 0xC3, 0xC0, 0x07, 0x81,
  0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x06, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0,
  0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x23, 0xEF, 0xFF, 0xFF,
  0xFF, 0x88, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x07, 0xFF, 0xE0, 0x01, 0xFD, 0xFE, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x03, 0xC0, 0x07, 0x80, 0xF8, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x07,
  0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x78, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x9E, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87,
  0x80, 0x00, 0xF0, 0xF0, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x7E, 0x01, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFB, 0xC7, 0xE7, 0x9F, 0x8F, 0x7C, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7B, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xDF, 0xF0, 0x7E, 0x00, 0x7C, 0x0E, 0x00, 0x0F, 0x83,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x81, 0xFF, 0x9F, 0xF0, 0xFE, 0x00, 0x7E, 0x1E, 0x00, 0x0F,
  0xC6, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE8, 0x00,
  0x01, 0xF3, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0xFA, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1D,
  0xC0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x03, 0xCE,
  0x00, 0x00, 0x07, 0x1C, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x78, 0x70,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x07, 0x83, 0x80,
  0x00, 0x1E, 0x07, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0, 0x1C, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x07, 0x80, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x07,
  0x80, 0x0E, 0x00, 0x0F, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x01, 0xE0, 0x00, 0xE0, 0x03, 0x80, 0x01, 0xC0, 0x0F, 0x00,
  0x03, 0x80, 0x3C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7B, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFE,
  0x1F, 0xF0, 0x30, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x20, 0x00,
  0x1F, 0x8C, 0x00, 0x0F, 0xC3, 0xE0, 0x0F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x07, 0xFE, 0xF8, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x1F, 0x80, 0x3C, 0x3F, 0xFC, 0x0F, 0x1F, 0xFF, 0x83,
  0xCF, 0xFF, 0xF0, 0xF7, 0x80, 0x7E, 0x3F, 0xC0, 0x07, 0x8F, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0x9E, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0F,
  0x80, 0x03, 0xC1, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF8, 0xFF, 0x00, 0xF8, 0x03, 0xF0,
  0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x8F, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00,
  0x3C, 0x3C, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x0F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xF9, 0xFC, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF9, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x8F, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0x80, 0x7C, 0x07, 0xC0,
  0x0F, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x1E,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F,
  0x78, 0x00, 0x07, 0xCF, 0x00, 0x03, 0xF3, 0xE0, 0x01, 0xFC, 0x7C, 0x00,
  0xEF, 0x1F, 0x80, 0xFB, 0xC3, 0xFF, 0xFC, 0xF0, 0x7F, 0xFE, 0x3C, 0x07,
  0xFE, 0x0F, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x20, 0x07, 0xE0, 0x07, 0xFF, 0xF0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x33,
  0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x23,
  0xEF, 0xFF, 0xFF, 0xFF, 0x88, 0x0C, 0x3E, 0x3F, 0x3F, 0x3F, 0x3F, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78,
  0x78, 0x70, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x80, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xFF, 0x7F, 0xC7, 0x80, 0x3E, 0x10, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0xFF, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0xFF, 0xC0, 0x1E, 0x3C, 0x00, 0x7F, 0xFC, 0x03, 0xC7, 0x00, 0x1F,
  0xFF, 0x80, 0x39, 0xE0, 0x07, 0xC0, 0x70, 0x07, 0x3C, 0x01, 0xF0, 0x0E,
  0x00, 0xF7, 0x00, 0x3C, 0x01, 0xC0, 0x1E, 0xE0, 0x0F, 0x00, 0x38, 0x03,
  0xFC, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0x80, 0x38, 0x01, 0xE0, 0x07, 0xF0,
  0x0F, 0x00, 0x3C, 0x00, 0xFE, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x38,
  0x00, 0xF0, 0x03, 0xF0, 0x07, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0xC0, 0x1C, 0x00, 0x78, 0x01, 0xF8, 0x03, 0x80, 0x0F, 0x00,
  0x3F, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0x3C, 0x01, 0xFC,
  0x01, 0xC0, 0x07, 0x80, 0x3F, 0x80, 0x38, 0x00, 0xF0, 0x07, 0x70, 0x07,
  0x00, 0x3E, 0x00, 0xEE, 0x00, 0xF0, 0x07, 0xC0, 0x1D, 0xE0, 0x1E, 0x00,
  0xD8, 0x07, 0xBC, 0x01, 0xC0, 0x3B, 0x00, 0xE7, 0x80, 0x3C, 0x0E, 0x70,
  0x3C, 0x70, 0x03, 0xE3, 0xCF, 0x1F, 0x0E, 0x00, 0x7F, 0xF0, 0xFF, 0xC1,
  0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x04, 0x00, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x73, 0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x00, 0xE1, 0xC0,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x01,
  0xE0, 0x1E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x0F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x07,
  0x83, 0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF9, 0xE0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF0, 0x78, 0x00, 0xFF, 0x0F, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x1F, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xF1, 0xE0, 0x00, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x83, 0xC0, 0x01, 0xFC, 0x78, 0x00,
  0x0F, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F,
  0xC0, 0x07, 0x01, 0xF8, 0x00, 0x08, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x02, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3C, 0x00, 0xFF, 0x80,
  0xF0, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x00, 0xFC, 0x3C,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x07, 0xCF, 0x00,
  0x00, 0x1F, 0x3C, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xFB, 0xC0, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x8F, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xEF, 0xFE, 0x00, 0xFE, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x00, 0xC0, 0x3F, 0x00, 0x00, 0x10, 0x1F, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x0F,
  0x78, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x3E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x0F, 0xC0,
  0x00, 0x03, 0xC1, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0x00, 0x00, 0x3C, 0x07,
  0xE0, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xE0, 0x07,
  0x80, 0x3E, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x3F, 0xC0, 0xF0, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x07,
  0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x0F,
  0x00, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F,
  0x80, 0x0F, 0x01, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0xF0, 0x7C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x1F,
  0x00, 0x00, 0xF1, 0xF0, 0x00, 0x0F, 0x3F, 0x00, 0x00, 0xF7, 0xF8, 0x00,
  0x0F, 0x7F, 0x80, 0x00, 0xFF, 0x7C, 0x00, 0x0F, 0xE3, 0xE0, 0x00, 0xFC,
  0x1E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0xF0, 0x01, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF8, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xDF,
  0xFC, 0x00, 0x00, 0x01, 0xEF, 0xEE, 0x00, 0x00, 0x00, 0xF7, 0xF7, 0x80,
  0x00, 0x00, 0x73, 0xFB, 0xC0, 0x00, 0x00, 0x79, 0xFC, 0xE0, 0x00, 0x00,
  0x3C, 0xFE, 0x78, 0x00, 0x00, 0x1C, 0x7F, 0x3C, 0x00, 0x00, 0x1E, 0x7F,
  0x9E, 0x00, 0x00, 0x0F, 0x3F, 0xC7, 0x80, 0x00, 0x07, 0x1F, 0xE3, 0xC0,
  0x00, 0x07, 0x8F, 0xF1, 0xE0, 0x00, 0x03, 0xC7, 0xF8, 0x78, 0x00, 0x01,
  0xC3, 0xFC, 0x3C, 0x00, 0x01, 0xE1, 0xFE, 0x1E, 0x00, 0x00, 0xF0, 0xFF,
  0x07, 0x80, 0x00, 0x70, 0x7F, 0x83, 0xC0, 0x00, 0x78, 0x3F, 0xC1, 0xE0,
  0x00, 0x3C, 0x1F, 0xE0, 0x78, 0x00, 0x1C, 0x0F, 0xF0, 0x3C, 0x00, 0x1E,
  0x07, 0xF8, 0x1E, 0x00, 0x0F, 0x03, 0xFC, 0x07, 0x80, 0x07, 0x01, 0xFE,
  0x03, 0xC0, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x03, 0xC0, 0x7F, 0x80, 0x78,
  0x01, 0xE0, 0x3F, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0xE0, 0x1E, 0x00, 0xF0,
  0x0F, 0xF0, 0x07, 0x80, 0x78, 0x07, 0xF8, 0x03, 0xC0, 0x78, 0x03, 0xFC,
  0x01, 0xE0, 0x3C, 0x01, 0xFE, 0x00, 0x70, 0x1E, 0x00, 0xFF, 0x00, 0x3C,
  0x0E, 0x00, 0x7F, 0x80, 0x1E, 0x0F, 0x00, 0x3F, 0xC0, 0x07, 0x07, 0x80,
  0x1F, 0xE0, 0x03, 0xC3, 0x80, 0x0F, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xF8,
  0x00, 0x71, 0xE0, 0x03, 0xFC, 0x00, 0x3C, 0xE0, 0x01, 0xFE, 0x00, 0x1E,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0x78, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xF7, 0x80,
  0x00, 0x1F, 0xEF, 0x80, 0x00, 0x3F, 0xCF, 0x00, 0x00, 0x7F, 0x9F, 0x00,
  0x00, 0xFF, 0x1E, 0x00, 0x01, 0xFE, 0x3E, 0x00, 0x03, 0xFC, 0x3C, 0x00,
  0x07, 0xF8, 0x7C, 0x00, 0x0F, 0xF0, 0x78, 0x00, 0x1F, 0xE0, 0xF8, 0x00,
  0x3F, 0xC0, 0xF0, 0x00, 0x7F, 0x81, 0xF0, 0x00, 0xFF, 0x01, 0xE0, 0x01,
  0xFE, 0x03, 0xE0, 0x03, 0xFC, 0x03, 0xC0, 0x07, 0xF8, 0x07, 0xC0, 0x0F,
  0xF0, 0x07, 0x80, 0x1F, 0xE0, 0x0F, 0x80, 0x3F, 0xC0, 0x0F, 0x00, 0x7F,
  0x80, 0x1F, 0x00, 0xFF, 0x00, 0x1E, 0x01, 0xFE, 0x00, 0x3E, 0x03, 0xFC,
  0x00, 0x3C, 0x07, 0xF8, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x78, 0x1F, 0xE0,
  0x00, 0xF8, 0x3F, 0xC0, 0x00, 0xF0, 0x7F, 0x80, 0x01, 0xF0, 0xFF, 0x00,
  0x01, 0xE1, 0xFE, 0x00, 0x03, 0xE3, 0xFC, 0x00, 0x03, 0xC7, 0xF8, 0x00,
  0x07, 0xCF, 0xF0, 0x00, 0x07, 0x9F, 0xE0, 0x00, 0x0F, 0xBF, 0xC0, 0x00,
  0x0F, 0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1F,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xF1,
  0xE0, 0x00, 0x00, 0x3E, 0x3C, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1E, 0x00,
  0xFF, 0x8F, 0x00, 0x0F, 0xC7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0x7D, 0xE0,
  0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xFB, 0xC0, 0x00,
  0x7D, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7C, 0x78, 0x00, 0xFE, 0x3F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x00, 0x3C, 0xF0,
  0x00, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3E,
  0x3C, 0x00, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x78, 0x07, 0xFE, 0x0F, 0x00,
  0x0F, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x3E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x01, 0xE0,
  0x1F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF8, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFE, 0x1F, 0xC0, 0x0F, 0x07, 0xC0, 0x00, 0x43, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC8, 0x00, 0x01, 0xF3, 0x80,
  0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x01, 0xFA, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xF8, 0x0F, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x01,
  0xF1, 0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00,
  0xF0, 0x01, 0xE0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x3C, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x0F, 0x07, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x78,
  0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3B, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x79, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x71, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x0F, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0E, 0x0F,
  0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x70, 0x01, 0xF0, 0x0F, 0x80, 0x1E,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x38, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x03, 0x80, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0x80, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x1E,
  0x07, 0x80, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00,
  0x1E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x0F,
  0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0x9E, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x07, 0x9C, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x3B, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0x00,
  0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x03, 0xC7, 0x80, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x01, 0xE0,
  0x1E, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x07, 0xDE, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x1F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x78,
  0x0F, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xE0, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00,
  0x78, 0x00, 0x7C, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xE0,
  0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x01, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0x78, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x38, 0x03, 0x80, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x7F,
  0xFF, 0xC0, 0xFE, 0x1F, 0xC0, 0xE0, 0x0F, 0xC1, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFE, 0xF1, 0xFC, 0x01, 0xE7, 0xE0, 0x03, 0xDF, 0x00, 0x07, 0xBC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0xDD, 0xF0, 0x03, 0xBB, 0xF0, 0x1E,
  0x73, 0xFF, 0xF8, 0xE3, 0xFF, 0xE1, 0xC3, 0xFF, 0x83, 0x80, 0x78, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0x1E, 0x0F, 0xFE,
  0x03, 0xC7, 0xFF, 0xF0, 0x79, 0xFF, 0xFF, 0x0F, 0x3C, 0x03, 0xE1, 0xEE,
  0x00, 0x3E, 0x3D, 0x80, 0x03, 0xE7, 0xF0, 0x00, 0x3C, 0xFC, 0x00, 0x07,
  0x9F, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBF,
  0x00, 0x01, 0xE7, 0xE0, 0x00, 0x3C, 0xFE, 0x00, 0x0F, 0x9E, 0xC0, 0x01,
  0xE3, 0xDC, 0x00, 0x7C, 0x79, 0xE0, 0x3F, 0x0F, 0x1F, 0xFF, 0xC1, 0xE1,
  0xFF, 0xF0, 0x38, 0x1F, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFC, 0x01, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x70, 0x7F, 0xFF, 0x81, 0xFF,
  0xFC, 0x07, 0xFF, 0xC0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x3F, 0x81, 0xE0, 0x3F, 0xFC, 0x3C, 0x0F, 0xFF, 0xC7, 0x83, 0xFF,
  0xFC, 0xF0, 0xFC, 0x03, 0xDE, 0x1F, 0x00, 0x3B, 0xC7, 0xC0, 0x03, 0xF8,
  0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3F,
  0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xFC, 0x3E, 0x00, 0x73, 0x87, 0xE0,
  0x3C, 0x70, 0x7F, 0xFF, 0x8E, 0x07, 0xFF, 0xE1, 0xC0, 0x3F, 0xF0, 0x38,
  0x01, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC,
  0x01, 0xFC, 0xFF, 0x01, 0xF8, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0xF8, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x9E, 0x00,
  0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x81, 0xF8, 0x03, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0x00, 0xFF, 0xE0, 0x1F, 0x8E, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x1C, 0x0F, 0xFF, 0xC3,
  0x83, 0xFF, 0xFC, 0xF0, 0xFC, 0x03, 0xDE, 0x1E, 0x00, 0x3B, 0xC7, 0xC0,
  0x03, 0xF8, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF9, 0xE0,
  0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xBC, 0x3E, 0x00, 0x77,
  0x87, 0xE0, 0x3C, 0xF0, 0x7F, 0xFF, 0x1E, 0x07, 0xFF, 0xC3, 0xC0, 0x3F,
  0xF0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF0, 0x80, 0x00, 0x3E, 0x1C, 0x00, 0x1F, 0x83, 0xF8, 0x0F,
  0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x1F, 0xC0, 0x78, 0x3F, 0xF8, 0x3C, 0x7F, 0xFE, 0x1E, 0x7F,
  0xFF, 0x8F, 0x3C, 0x07, 0xE7, 0xB8, 0x01, 0xF3, 0xD8, 0x00, 0x7D, 0xF8,
  0x00, 0x1E, 0xFC, 0x00, 0x0F, 0x7E, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xEF, 0x80, 0x00, 0x77, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1E, 0x27, 0xFF, 0xFF, 0xFD, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x00, 0x00, 0x40, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x01, 0xE0, 0x3E, 0xC7, 0xCF, 0xFC, 0xFF, 0x8F, 0xE0, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x02, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF8, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0xC0, 0xF0, 0x07,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x3C,
  0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xF0,
  0x00, 0xF3, 0xF8, 0x00, 0xF3, 0xF8, 0x00, 0xF7, 0xFC, 0x00, 0xF7, 0x3C,
  0x00, 0xFE, 0x3E, 0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F,
  0x00, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xC0, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x38, 0x3F, 0xF8, 0x07, 0xFF, 0x0F, 0x1F, 0xFF,
  0x07, 0xFF, 0xE3, 0xCF, 0xDF, 0xE3, 0xFB, 0xFC, 0xF7, 0x80, 0xF8, 0xE0,
  0x1F, 0x3D, 0xC0, 0x1F, 0x70, 0x03, 0xEF, 0xE0, 0x03, 0xD8, 0x00, 0xFB,
  0xF0, 0x00, 0xFE, 0x00, 0x1E, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xBE, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x1F, 0xC0, 0x70, 0x3F, 0xF8, 0x3C, 0x7F, 0xFE, 0x1E, 0x7F, 0x7F,
  0x8F, 0x38, 0x07, 0xE7, 0xB8, 0x00, 0xF3, 0xF8, 0x00, 0x7D, 0xF8, 0x00,
  0x1E, 0xFC, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0xEF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1E, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC,
  0x00, 0x7F, 0xDF, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xF0, 0x00, 0xF0, 0x1F,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x1F, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x81, 0xF0, 0x00,
  0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x03, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x1E, 0x0F, 0xFE, 0x03, 0xC3, 0xFF, 0xF0, 0x78, 0xFD, 0xFF, 0x0F,
  0x3C, 0x03, 0xE1, 0xEE, 0x00, 0x3E, 0x3D, 0x80, 0x03, 0xE7, 0xF0, 0x00,
  0x3C, 0xFC, 0x00, 0x07, 0x9F, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x7C,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3D,
  0xF0, 0x00, 0x07, 0xBF, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x3C, 0xFE, 0x00,
  0x0F, 0x9E, 0xE0, 0x01, 0xE3, 0xDE, 0x00, 0x7C, 0x79, 0xE0, 0x3F, 0x0F,
  0x1F, 0xFF, 0xC1, 0xE1, 0xFF, 0xF0, 0x3C, 0x1F, 0xF8, 0x07, 0x80, 0x7C,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFC, 0x1C, 0x0F, 0xFF, 0xC3, 0x83, 0xFF, 0xFC, 0xF0, 0xFC, 0x03, 0xDE,
  0x1E, 0x00, 0x3B, 0xC7, 0xC0, 0x03, 0xF8, 0xF0, 0x00, 0x3F, 0x3C, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xE3, 0xE0,
  0x01, 0xBC, 0x7E, 0x00, 0x77, 0x87, 0xE0, 0x3C, 0xF0, 0x7F, 0xFF, 0x1E,
  0x07, 0xFF, 0xC3, 0xC0, 0x3F, 0xF0, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x1F, 0x70, 0x3F, 0xFC, 0x3F, 0xFE, 0x3F,
  0xEF, 0x3C, 0x0F, 0xBC, 0x03, 0xDC, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F,
  0x8F, 0xE7, 0xE0, 0x06, 0x3C, 0x00, 0x13, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF4, 0x00, 0x07, 0xB0, 0x00, 0x7D, 0xE0,
  0x0F, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0xC0, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x10, 0x3F, 0xF8,
  0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x37, 0x7C, 0x00, 0x77, 0x7C, 0x00, 0xE7,
  0x3F, 0x01, 0xE7, 0x1F, 0xFF, 0xC7, 0x0F, 0xFF, 0x87, 0x07, 0xFE, 0x07,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x07, 0x00, 0x0E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0x80, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x07, 0x80,
  0x01, 0xE0, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78,
  0xF0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDC, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xFC, 0x00, 0x0E, 0x78, 0x00, 0x3F,
  0x80, 0x07, 0x9E, 0x00, 0x0F, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xB8, 0x00,
  0x78, 0xF0, 0x01, 0xEE, 0x00, 0x1C, 0x3C, 0x00, 0x73, 0x80, 0x0F, 0x0F,
  0x00, 0x1C, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x3C, 0x00, 0xF0, 0x78, 0x03,
  0xC7, 0x00, 0x38, 0x1E, 0x00, 0xE1, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x78,
  0x07, 0x81, 0xE0, 0x1E, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x83, 0x80, 0x78,
  0x0F, 0x01, 0xE0, 0xE0, 0x1C, 0x03, 0xC0, 0x70, 0x3C, 0x0F, 0x00, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x01, 0xC0, 0xF0, 0x07, 0x83, 0xC0,
  0x70, 0x38, 0x01, 0xE0, 0xE0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x07, 0x87,
  0x80, 0x1E, 0x1E, 0x01, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x38, 0x70, 0x00,
  0xF1, 0xC0, 0x0F, 0x1C, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x0F, 0x3C,
  0x00, 0xF3, 0xC0, 0x01, 0xCF, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x07,
  0x38, 0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x07, 0xB8, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x03, 0xC0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x3E, 0x0F, 0x00,
  0x0F, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xF0,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x79, 0xE0, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03,
  0xC0, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78,
  0x07, 0x80, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x02, 0x1F, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x1F,
  0xF0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x13, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x7F,
  0x87, 0xFC, 0x1F, 0xE0, 0x0F, 0xFF, 0xE8, 0x00, 0x3F, 0xFC, 0x80, 0x00,
  0xFF, 0x00,
};

const GFXglyph NotoSans_Condensed_Light72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 52, 16, 5, -51 },
  { 40, 15, 18, 25, 5, -51 },
  { 74, 33, 51, 36, 2, -51 },
  { 285, 27, 59, 33, 3, -55 },
  { 485, 42, 53, 49, 3, -52 },
  { 764, 34, 53, 37, 3, -52 },
  { 990, 4, 18, 14, 5, -51 },
  { 999, 15, 63, 20, 3, -52 },
  { 1118, 15, 63, 20, 2, -52 },
  { 1237, 24, 24, 30, 3, -55 },
  { 1309, 28, 33, 33, 3, -42 },
  { 1425, 8, 17, 15, 3, -8 },
  { 1442, 16, 3, 21, 2, -21 },
  { 1448, 6, 8, 15, 5, -7 },
  { 1454, 23, 51, 25, 1, -51 },
  { 1601, 27, 53, 33, 3, -52 },
  { 1780, 15, 51, 33, 6, -51 },
  { 1876, 26, 52, 33, 3, -52 },
  { 2045, 26, 53, 33, 3, -52 },
  { 2218, 31, 52, 33, 1, -52 },
  { 2420, 26, 52, 33, 4, -51 },
  { 2589, 26, 53, 33, 4, -52 },
  { 2762, 27, 51, 33, 3, -51 },
  { 2935, 27, 53, 33, 3, -52 },
  { 3114, 26, 53, 33, 3, -52 },
  { 3287, 6, 40, 16, 5, -39 },
  { 3317, 8, 48, 15, 3, -39 },
  { 3365, 28, 32, 33, 3, -42 },
  { 3477, 27, 19, 33, 3, -35 },
  { 3542, 28, 32, 33, 3, -42 },
  { 3654, 21, 53, 24, 1, -52 },
  { 3794, 43, 58, 51, 4, -52 },
  { 4106, 34, 51, 34, 0, -51 },
  { 4323, 27, 51, 37, 6, -51 },
  { 4496, 29, 53, 35, 4, -52 },
  { 4689, 30, 51, 40, 6, -51 },
  { 4881, 22, 51, 32, 6, -51 },
  { 5022, 22, 51, 29, 6, -51 },
  { 5163, 34, 53, 42, 4, -52 },
  { 5389, 29, 51, 41, 6, -51 },
  { 5574, 13, 51, 19, 3, -51 },
  { 5657, 14, 64, 16, -4, -51 },
  { 5769, 28, 51, 34, 6, -51 },
  { 5948, 22, 51, 29, 6, -51 },
  { 6089, 41, 51, 53, 6, -51 },
  { 6351, 31, 51, 43, 6, -51 },
  { 6549, 35, 53, 43, 4, -52 },
  { 6781, 25, 51, 34, 6, -51 },
  { 6941, 35, 64, 43, 4, -52 },
  { 7221, 27, 51, 35, 6, -51 },
  { 7394, 26, 53, 32, 3, -52 },
  { 7567, 28, 51, 30, 1, -51 },
  { 7746, 31, 52, 41, 5, -51 },
  { 7948, 33, 51, 33, 0, -51 },
  { 8159, 52, 51, 54, 1, -51 },
  { 8491, 30, 51, 30, 0, -51 },
  { 8683, 29, 51, 29, 0, -51 },
  { 8868, 26, 51, 30, 2, -51 },
  { 9034, 14, 63, 23, 6, -52 },
  { 9145, 23, 51, 25, 1, -51 },
  { 9292, 15, 63, 23, 2, -52 },
  { 9411, 30, 27, 33, 2, -51 },
  { 9513, 30, 4, 30, 0, 6 },
  { 9528, 12, 11, 18, 3, -55 },
  { 9545, 23, 40, 31, 3, -39 },
  { 9660, 27, 56, 35, 5, -55 },
  { 9849, 21, 40, 27, 4, -39 },
  { 9954, 27, 56, 35, 3, -55 },
  { 10143, 25, 40, 32, 4, -39 },
  { 10268, 20, 55, 18, 1, -55 },
  { 10406, 27, 56, 35, 3, -39 },
  { 10595, 25, 55, 35, 5, -55 },
  { 10767, 5, 53, 15, 5, -53 },
  { 10801, 12, 70, 15, -2, -53 },
  { 10906, 24, 55, 29, 5, -55 },
  { 11071, 4, 55, 15, 5, -55 },
  { 11099, 42, 39, 52, 5, -39 },
  { 11304, 25, 39, 35, 5, -39 },
  { 11426, 28, 40, 34, 3, -39 },
  { 11566, 27, 56, 35, 5, -39 },
  { 11755, 27, 56, 35, 3, -39 },
  { 11944, 17, 39, 23, 5, -39 },
  { 12027, 21, 40, 27, 3, -39 },
  { 12132, 17, 48, 19, 1, -47 },
  { 12234, 24, 39, 35, 5, -38 },
  { 12351, 27, 38, 27, 0, -38 },
  { 12480, 42, 38, 44, 1, -38 },
  { 12680, 26, 38, 28, 1, -38 },
  { 12804, 26, 55, 27, 1, -38 },
  { 12983, 20, 38, 24, 2, -38 },
  { 13078, 19, 62, 26, 3, -51 },
  { 13226, 4, 72, 31, 14, -55 },
  { 13262, 20, 62, 26, 3, -51 },
  { 13417, 28, 7, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_Light72pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light72pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light72pt7bGlyphs,
  0x20, 0x7E, 98
};

#endif // _NOTOSANS_CONDENSED_LIGHT72PT7B_H_
