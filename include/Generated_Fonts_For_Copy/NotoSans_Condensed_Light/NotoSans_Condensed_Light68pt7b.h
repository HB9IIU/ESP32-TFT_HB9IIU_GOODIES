#ifndef _NOTOSANS_CONDENSED_LIGHT68PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT68PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light68pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF9, 0x80, 0xF8, 0x1F, 0xF0,
  0x3F, 0xC0, 0x7F, 0x80, 0xF7, 0x01, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F,
  0x70, 0x1E, 0xE0, 0x3D, 0xC0, 0x7B, 0x80, 0xF7, 0x01, 0xEE, 0x03, 0xDC,
  0x07, 0xB8, 0x06, 0x70, 0x0C, 0xE0, 0x18, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x38, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00,
  0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03,
  0x80, 0x78, 0x00, 0x07, 0x00, 0x70, 0x00, 0x07, 0x00, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x1F, 0xDD, 0xFE, 0x1F, 0x0E, 0x07, 0x1F, 0x07, 0x00, 0x8F, 0x03, 0x80,
  0x07, 0x01, 0xC0, 0x07, 0x80, 0xE0, 0x03, 0xC0, 0x70, 0x01, 0xC0, 0x38,
  0x00, 0xE0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1E, 0x03,
  0x80, 0x07, 0x81, 0xC0, 0x03, 0xC0, 0xE0, 0x00, 0xF0, 0x70, 0x00, 0x7E,
  0x38, 0x00, 0x1F, 0xDC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x77, 0xF0,
  0x00, 0x38, 0xFC, 0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x01,
  0xC0, 0x03, 0x80, 0xF0, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0x70,
  0x1E, 0x00, 0x38, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x07,
  0x03, 0xC0, 0x03, 0x81, 0xEC, 0x01, 0xC3, 0xE7, 0xC0, 0xE3, 0xE3, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0x00, 0x0F,
  0xF8, 0x00, 0x0E, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x1C, 0x00, 0x38, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x78, 0x00, 0x70, 0x0F,
  0x00, 0x70, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0x01, 0xE0, 0x00, 0xE0,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x03,
  0x80, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x07, 0x80, 0x00,
  0xE0, 0x07, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x0F, 0x03, 0xC0, 0xF0, 0x07,
  0x0E, 0x0F, 0xF0, 0x70, 0x0F, 0x0E, 0x1F, 0xF8, 0x70, 0x0E, 0x1E, 0x3C,
  0x3C, 0x70, 0x0E, 0x1C, 0x38, 0x1C, 0x78, 0x0E, 0x3C, 0x78, 0x1C, 0x38,
  0x1C, 0x38, 0x70, 0x0E, 0x3C, 0x3C, 0x38, 0x70, 0x0E, 0x1F, 0xF8, 0x78,
  0xF0, 0x0E, 0x0F, 0xF0, 0x70, 0xE0, 0x0E, 0x07, 0xE0, 0xF0, 0xE0, 0x0F,
  0x00, 0x00, 0xE0, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0xE0, 0x07, 0x00, 0x01,
  0xE0, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x03, 0xC0, 0xE0,
  0x07, 0x00, 0x03, 0x80, 0xE0, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x07, 0x00,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0x0F, 0x00,
  0xE0, 0x0F, 0x00, 0x0E, 0x00, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x00, 0x3E,
  0x78, 0x00, 0x70, 0x00, 0x1F, 0xF8, 0x00, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x07, 0x00, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xDE, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x07, 0x80, 0x3C,
  0x78, 0x07, 0xC0, 0x3C, 0x78, 0x03, 0xC0, 0x38, 0xF0, 0x01, 0xE0, 0x38,
  0xF0, 0x00, 0xF0, 0x78, 0xF0, 0x00, 0xF8, 0x78, 0xF0, 0x00, 0x78, 0x70,
  0xE0, 0x00, 0x3C, 0xF0, 0xE0, 0x00, 0x3E, 0xF0, 0xE0, 0x00, 0x1F, 0xE0,
  0xE0, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0,
  0xF0, 0x00, 0x0F, 0xC0, 0x78, 0x00, 0x1F, 0xE0, 0x78, 0x00, 0x3F, 0xF0,
  0x7C, 0x00, 0x7C, 0xF8, 0x3F, 0x01, 0xF8, 0x78, 0x1F, 0xFF, 0xF0, 0x3C,
  0x0F, 0xFF, 0xC0, 0x3E, 0x07, 0xFF, 0x80, 0x1F, 0x00, 0x78, 0x00, 0x00,
  0xFF, 0xFF, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80,
  0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x40, 0x1C, 0x02, 0xF0, 0x38, 0x3D, 0xFC, 0x73, 0xFB, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3B,
  0x80, 0x00, 0xF7, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0F,
  0x00, 0x78, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xC0, 0x1C, 0x01, 0x00, 0x30,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x1E, 0x3C, 0xF9, 0xF3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xE3, 0x8F,
  0x1C, 0x38, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xF7, 0xFF, 0xFF,
  0xFC, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x78, 0x03, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F,
  0x0F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00,
  0x79, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x07, 0xB8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xBC, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0xF3, 0xC0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x1C, 0x3C, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x07, 0x80, 0xF8,
  0x07, 0x80, 0x3E, 0x07, 0xC0, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8,
  0x07, 0xF0, 0x1F, 0xE0, 0x7B, 0xC3, 0xE7, 0x8F, 0x8F, 0x3E, 0x1E, 0xF8,
  0x3F, 0xE0, 0x7B, 0x80, 0xF2, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xF0, 0x7F, 0x07, 0xC0, 0x0F, 0x81, 0x80, 0x03, 0xE0, 0x80, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0x7F,
  0x0F, 0x80, 0x0F, 0xC3, 0x80, 0x01, 0xE1, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xCC, 0x00, 0x07, 0xC7, 0x80, 0x0F, 0xC3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xFA, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1C,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x07, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0x3C, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0,
  0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x78, 0x03, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x78, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x1E,
  0x03, 0x80, 0x00, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x78, 0x03, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x80,
  0x01, 0xF8, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xC1, 0xC0, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x07, 0xF8, 0x07, 0x0F, 0xFF, 0x03, 0x8F,
  0xFF, 0xC1, 0xCF, 0x83, 0xF0, 0xEF, 0x00, 0x7C, 0x76, 0x00, 0x1E, 0x7E,
  0x00, 0x07, 0xBF, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07,
  0xB8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC0, 0xF0,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF,
  0xFE, 0x01, 0xF8, 0x1F, 0x81, 0xF0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0xF0,
  0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E,
  0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xBE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFB,
  0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xE0, 0x07, 0xC1, 0xE0,
  0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xE3, 0xE0, 0x03,
  0xE0, 0xF8, 0x03, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xF8, 0x7E, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x38, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x0F,
  0x3C, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07, 0x78, 0x00,
  0x03, 0xBC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFB, 0x80,
  0x00, 0x7D, 0xE0, 0x00, 0x7E, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x3F, 0x9F,
  0x00, 0x3B, 0xC7, 0xC0, 0x39, 0xC3, 0xFF, 0xFC, 0xE0, 0xFF, 0xFC, 0x70,
  0x1F, 0xF8, 0x38, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x01, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x27, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0x90, 0x04, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F,
  0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38,
  0x78, 0x70, 0x70, 0xF0, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x40, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xC1, 0xFC, 0x60, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x00, 0x0E,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0x81, 0xC0, 0x00, 0x00, 0x01, 0xC1, 0xE0,
  0x00, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0xFF, 0x80, 0x38, 0x70, 0x01, 0xFF,
  0xE0, 0x1C, 0x78, 0x01, 0xFF, 0xF0, 0x0F, 0x38, 0x01, 0xE0, 0x38, 0x03,
  0x9C, 0x01, 0xE0, 0x1C, 0x01, 0xCE, 0x00, 0xE0, 0x0E, 0x00, 0xEF, 0x00,
  0xF0, 0x07, 0x00, 0x77, 0x00, 0x70, 0x03, 0x80, 0x3B, 0x80, 0x78, 0x01,
  0xC0, 0x1F, 0xC0, 0x3C, 0x00, 0xE0, 0x0F, 0xE0, 0x1C, 0x00, 0x70, 0x07,
  0xF0, 0x0E, 0x00, 0x38, 0x03, 0xF8, 0x07, 0x00, 0x1C, 0x01, 0xFC, 0x03,
  0x80, 0x0E, 0x00, 0xFE, 0x01, 0xC0, 0x0F, 0x00, 0x77, 0x00, 0xE0, 0x07,
  0x80, 0x3B, 0x80, 0x70, 0x03, 0xC0, 0x1D, 0xC0, 0x38, 0x01, 0xE0, 0x0E,
  0xE0, 0x1C, 0x00, 0xF0, 0x07, 0x70, 0x0E, 0x00, 0x78, 0x07, 0xB8, 0x07,
  0x80, 0x7C, 0x03, 0x9C, 0x03, 0xC0, 0x36, 0x01, 0xCE, 0x00, 0xF0, 0x3B,
  0x01, 0xE7, 0x80, 0x78, 0x39, 0xC1, 0xE3, 0xC0, 0x1F, 0xFC, 0x7F, 0xE0,
  0xE0, 0x07, 0xFC, 0x3F, 0xE0, 0x70, 0x01, 0xFC, 0x0F, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x02,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x1C, 0x38, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x38,
  0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70,
  0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0,
  0x07, 0x00, 0x00, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0E, 0x00, 0x0F, 0xC7, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x79,
  0xC0, 0x00, 0x3E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0xDC, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x3D, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x38, 0x00,
  0x07, 0x9C, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xC7, 0x00, 0x1F, 0xC3, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x70, 0x01, 0xFC, 0x38,
  0x00, 0x1F, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xB8, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xCE, 0x00, 0x07, 0xE7, 0x00,
  0x1F, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0x83, 0xF0, 0x3F, 0x00, 0x0C, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x03, 0xF8, 0x03, 0xC0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0xE0, 0x03, 0xFC, 0x0E, 0x00, 0x07, 0xE0, 0xE0, 0x00,
  0x3F, 0x0E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F, 0x8E, 0x00, 0x00, 0x7C,
  0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x3C, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0xE0, 0xE0,
  0x01, 0xFC, 0x0E, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x01, 0xF8, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x0F, 0x7C, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00,
  0x0F, 0x3C, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x0F, 0x1F, 0x00, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x00, 0x0F, 0x07, 0xC0, 0x00,
  0x0F, 0x03, 0xF0, 0x00, 0x0F, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x81, 0xFF, 0x9F, 0xFF, 0xFF, 0xF8, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xF4, 0x0F, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x00, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x78,
  0xE0, 0x00, 0x3C, 0x38, 0x00, 0x1F, 0x0E, 0x00, 0x07, 0x83, 0x80, 0x03,
  0xC0, 0xE0, 0x01, 0xF0, 0x38, 0x00, 0x78, 0x0E, 0x00, 0x3C, 0x03, 0x80,
  0x1F, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x03,
  0x80, 0xF8, 0x00, 0xE0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x0F, 0x80,
  0x03, 0x83, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0xF8, 0x00, 0x0E, 0x3E,
  0x00, 0x03, 0x9F, 0xC0, 0x00, 0xEF, 0xF0, 0x00, 0x3B, 0xBE, 0x00, 0x0F,
  0xC7, 0x80, 0x03, 0xF0, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3C, 0x07, 0x80,
  0x0E, 0x01, 0xE0, 0x03, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x80, 0x38, 0x01,
  0xE0, 0x0E, 0x00, 0x7C, 0x03, 0x80, 0x0F, 0x00, 0xE0, 0x01, 0xE0, 0x38,
  0x00, 0x78, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0x78,
  0x38, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF8, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1E, 0xE0,
  0x00, 0x07, 0xC0, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFB,
  0x80, 0x00, 0x00, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0xEF, 0xEF, 0x00, 0x00,
  0x01, 0xDF, 0xDE, 0x00, 0x00, 0x07, 0xBF, 0x9C, 0x00, 0x00, 0x0E, 0x7F,
  0x3C, 0x00, 0x00, 0x1C, 0xFE, 0x78, 0x00, 0x00, 0x79, 0xFC, 0x70, 0x00,
  0x00, 0xF3, 0xF8, 0xF0, 0x00, 0x01, 0xC7, 0xF1, 0xE0, 0x00, 0x07, 0x8F,
  0xE1, 0xC0, 0x00, 0x0F, 0x1F, 0xC3, 0xC0, 0x00, 0x1C, 0x3F, 0x87, 0x80,
  0x00, 0x78, 0x7F, 0x07, 0x00, 0x00, 0xF0, 0xFE, 0x0F, 0x00, 0x01, 0xC1,
  0xFC, 0x1E, 0x00, 0x07, 0x83, 0xF8, 0x1C, 0x00, 0x0F, 0x07, 0xF0, 0x3C,
  0x00, 0x1C, 0x0F, 0xE0, 0x78, 0x00, 0x78, 0x1F, 0xC0, 0x70, 0x00, 0xF0,
  0x3F, 0x80, 0xF0, 0x01, 0xC0, 0x7F, 0x01, 0xE0, 0x07, 0x80, 0xFE, 0x01,
  0xC0, 0x0F, 0x01, 0xFC, 0x03, 0xC0, 0x1C, 0x03, 0xF8, 0x07, 0x80, 0x78,
  0x07, 0xF0, 0x07, 0x00, 0xF0, 0x0F, 0xE0, 0x0F, 0x01, 0xC0, 0x1F, 0xC0,
  0x1E, 0x07, 0x80, 0x3F, 0x80, 0x1C, 0x0F, 0x00, 0x7F, 0x00, 0x3C, 0x1C,
  0x00, 0xFE, 0x00, 0x78, 0x78, 0x01, 0xFC, 0x00, 0x70, 0xF0, 0x03, 0xF8,
  0x00, 0xF1, 0xC0, 0x07, 0xF0, 0x01, 0xE3, 0x80, 0x0F, 0xE0, 0x01, 0xCF,
  0x00, 0x1F, 0xC0, 0x03, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xB8, 0x00, 0x7F,
  0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFD, 0xE0, 0x00, 0x0F, 0xEF, 0x00,
  0x00, 0x7F, 0x3C, 0x00, 0x03, 0xF9, 0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x00,
  0xFE, 0x3C, 0x00, 0x07, 0xF0, 0xF0, 0x00, 0x3F, 0x87, 0x80, 0x01, 0xFC,
  0x1E, 0x00, 0x0F, 0xE0, 0xF0, 0x00, 0x7F, 0x03, 0xC0, 0x03, 0xF8, 0x1E,
  0x00, 0x1F, 0xC0, 0x78, 0x00, 0xFE, 0x03, 0xC0, 0x07, 0xF0, 0x0F, 0x00,
  0x3F, 0x80, 0x78, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xE0, 0x0F, 0x00, 0x7F,
  0x00, 0x3C, 0x03, 0xF8, 0x01, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0xFE, 0x00,
  0x3C, 0x07, 0xF0, 0x00, 0xF0, 0x3F, 0x80, 0x07, 0x81, 0xFC, 0x00, 0x1E,
  0x0F, 0xE0, 0x00, 0xF0, 0x7F, 0x00, 0x03, 0xC3, 0xF8, 0x00, 0x1E, 0x1F,
  0xC0, 0x00, 0x78, 0xFE, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x0F, 0x3F, 0x80,
  0x00, 0x79, 0xFC, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x0F, 0x7F, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0E, 0x00, 0x7F, 0x1C, 0x00, 0x1F, 0x38,
  0x00, 0x1F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x1F,
  0x70, 0x00, 0x7C, 0xE0, 0x01, 0xF1, 0xC0, 0x3F, 0xE3, 0xFF, 0xFF, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x3E, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0xF8,
  0x1E, 0x00, 0x00, 0x3C, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0x07,
  0x8F, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x00, 0xF8, 0xF0, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C,
  0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x1E,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0xF8, 0x38, 0x00, 0x3E, 0x0E, 0x00,
  0x07, 0xC3, 0x80, 0x00, 0xF0, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8E,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07,
  0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00,
  0x07, 0x8E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF8, 0xE0, 0x00, 0x3C, 0x38,
  0x00, 0x1F, 0x0E, 0x00, 0x0F, 0x83, 0x80, 0x07, 0xC0, 0xE0, 0x0F, 0xE0,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xE0, 0x1E,
  0x00, 0x38, 0x03, 0xC0, 0x0E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xE0,
  0x07, 0x80, 0x38, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03, 0x80, 0x07, 0x80,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x01,
  0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x0F, 0x0E, 0x00, 0x03, 0xC3, 0x80,
  0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0xFE, 0x1F, 0x00, 0x0E, 0x3E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0xC0, 0x00, 0x7C, 0xF8, 0x01,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xE0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x78, 0x7C, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x7C,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0x1E, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x03, 0xC0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xC0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x1E, 0x03, 0xC0, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x38, 0x0E, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x01,
  0xC1, 0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x70, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0x87, 0x80, 0x01, 0xCF, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xE7, 0x80, 0x01,
  0xC0, 0xF0, 0x00, 0x71, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0xE0, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x07, 0x00,
  0x1E, 0x01, 0xE0, 0x07, 0x83, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0x81, 0xE0,
  0x07, 0x80, 0x78, 0x01, 0xC0, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0xE0, 0x38,
  0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0xE0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x78, 0x1E, 0x00, 0x1E, 0x07, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x03, 0x80,
  0x1E, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x07, 0x07, 0x80, 0x01, 0xE1, 0xE0,
  0x03, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x38, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x1C, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCE,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0xEF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x77, 0x80, 0x00, 0x1F,
  0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x78, 0x07, 0x80, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x03, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x01, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x87, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x3D, 0xE0, 0x00,
  0x03, 0x8E, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3E, 0x3C,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE0, 0x70, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x0F, 0x0E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x3B,
  0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x06, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x0F, 0x0F,
  0x00, 0x00, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xC0, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1E, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x70,
  0x1C, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x1C, 0x70, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE,
  0x07, 0xF1, 0xFC, 0x1C, 0x01, 0xF0, 0x40, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x3F, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xF0, 0x0F, 0x3E,
  0x00, 0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0x78, 0x01, 0xFD, 0xF0,
  0x0E, 0x73, 0xF9, 0xF1, 0xC7, 0xFF, 0x87, 0x0F, 0xFC, 0x1C, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0xF0, 0xFF, 0xE0, 0x78, 0xFF, 0xF8, 0x3C, 0xFF, 0xFE,
  0x1E, 0xF0, 0x0F, 0x8F, 0xE0, 0x03, 0xC7, 0xE0, 0x00, 0xF3, 0xF0, 0x00,
  0x79, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xE0, 0x00,
  0xF3, 0xF0, 0x00, 0xF9, 0xDC, 0x00, 0x78, 0xE7, 0x80, 0xFC, 0x71, 0xFF,
  0xFC, 0x38, 0x7F, 0xFC, 0x1C, 0x1F, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0xFC, 0x01,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x00, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0xFC, 0x07, 0x01, 0xFF, 0x83, 0x81, 0xFF, 0xF1, 0xC1,
  0xFF, 0xFC, 0xE1, 0xF0, 0x0E, 0x71, 0xF0, 0x03, 0xB8, 0xF0, 0x00, 0xFC,
  0xF0, 0x00, 0x3E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0xF9,
  0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x6E, 0x3E, 0x00, 0x77, 0x0F, 0x80, 0x73,
  0x87, 0xFF, 0xF1, 0xC1, 0xFF, 0xF0, 0xE0, 0x3F, 0xF0, 0x70, 0x03, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x07, 0xE3,
  0xF0, 0x0F, 0x80, 0xF8, 0x1F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00,
  0x1E, 0x3C, 0x00, 0x1E, 0x38, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00,
  0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x02, 0x0F, 0xC0, 0x0E, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x1F, 0xFC,
  0x07, 0xFF, 0x00, 0xF8, 0x60, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x7F, 0xFE, 0x1F,
  0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xE1, 0xC1, 0xFF, 0xF8, 0xE1, 0xFF, 0xFE, 0x70,
  0xF8, 0x07, 0xB8, 0xF8, 0x01, 0xDC, 0x78, 0x00, 0x7E, 0x78, 0x00, 0x1F,
  0x3C, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x7B, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x3E,
  0x7C, 0x00, 0x37, 0x1F, 0x00, 0x3B, 0x87, 0xC0, 0x39, 0xC3, 0xFF, 0xF8,
  0xE0, 0xFF, 0xF8, 0x70, 0x1F, 0xF8, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x30, 0x00, 0x3E, 0x1F, 0x00, 0x7E, 0x0F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x1F, 0x80, 0xF0, 0xFF, 0xE1, 0xE3, 0xFF,
  0xE3, 0xCF, 0xDF, 0xE7, 0xBC, 0x07, 0xCF, 0xE0, 0x07, 0xDF, 0x80, 0x07,
  0xBF, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xF0, 0x67, 0xBF, 0xFF, 0x78, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80, 0x01,
  0x80, 0x78, 0x0F, 0x03, 0xF0, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x38, 0x0F,
  0x23, 0xE7, 0xF8, 0xFF, 0x1F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x00, 0x1E, 0x3C, 0x00,
  0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0,
  0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xFC, 0x00, 0xF7, 0xF0,
  0x03, 0xDD, 0xE0, 0x0F, 0xE7, 0x80, 0x3F, 0x0F, 0x00, 0xFC, 0x3C, 0x03,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0x8F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x0F, 0x81,
  0xC1, 0xFF, 0x00, 0xFF, 0xC3, 0x8F, 0xFF, 0x03, 0xFF, 0xC7, 0x3F, 0x7F,
  0x0F, 0x9F, 0xCE, 0x70, 0x1F, 0x38, 0x07, 0xDD, 0xC0, 0x1E, 0xE0, 0x07,
  0xBB, 0x00, 0x1F, 0x80, 0x0F, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00,
  0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xC0, 0x01, 0xFE, 0x00,
  0x07, 0x80, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x00, 0x1C, 0x00,
  0x0F, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xC0,
  0x00, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0x80,
  0x01, 0xFE, 0x00, 0x07, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xF8,
  0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x70,
  0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0x80, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x03, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xF0, 0x00, 0x38, 0x00, 0x1F,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x3F, 0x01, 0xC1,
  0xFF, 0xC3, 0x87, 0xFF, 0xC7, 0x1F, 0x9F, 0xCE, 0x70, 0x0F, 0x9D, 0xC0,
  0x0F, 0xBB, 0x00, 0x0F, 0x7E, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xCF, 0xE0, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x07, 0x81, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x03, 0x9C, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x1E, 0x38, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0x78, 0x00, 0x78, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x00, 0x7F, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x70, 0x7F, 0xF0, 0x38, 0x7F, 0xFC, 0x1C, 0x7E, 0x7F, 0x0E,
  0x78, 0x07, 0xC7, 0x30, 0x01, 0xF3, 0xB0, 0x00, 0x79, 0xF8, 0x00, 0x3C,
  0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xDF,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xF0, 0x00, 0x79,
  0xFC, 0x00, 0x7C, 0xF7, 0x00, 0x3C, 0x7B, 0xC0, 0x7E, 0x3C, 0xFF, 0xFE,
  0x1E, 0x3F, 0xFE, 0x0F, 0x0F, 0xFC, 0x07, 0x80, 0xF8, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFF, 0xC1, 0xC0, 0xFF, 0xF8, 0xE0, 0xFF, 0xFE, 0x70, 0xF8, 0x07,
  0x38, 0xF8, 0x01, 0xDC, 0x78, 0x00, 0x6E, 0x78, 0x00, 0x1F, 0x3C, 0x00,
  0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x7B, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0x7C, 0x00,
  0x37, 0x1F, 0x00, 0x3B, 0x87, 0xC0, 0x79, 0xC3, 0xFF, 0xF8, 0xE0, 0xFF,
  0xF8, 0x70, 0x1F, 0xF8, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x3C, 0xE0, 0xFF, 0xE1,
  0xFE, 0xE3, 0xFE, 0xE7, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xEC, 0x00, 0xFC,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE3, 0xF8, 0xFE, 0x7C, 0x00, 0xC7, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x80, 0x03, 0xEE, 0x00, 0x7C, 0xFF, 0xFF,
  0x8F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x38, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xDE, 0x00, 0x3F, 0xBE, 0x00, 0xEF,
  0x3E, 0x03, 0xDE, 0x7F, 0xFF, 0x1C, 0x7F, 0xFC, 0x38, 0x7F, 0xE0, 0x70,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xCF, 0x00, 0x01, 0xE3, 0x80, 0x00, 0xF1, 0xE0, 0x00, 0x78, 0xF0, 0x00,
  0x78, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x1E, 0x0F, 0x00, 0x0E, 0x07, 0x80,
  0x0F, 0x01, 0xC0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x70, 0x03, 0xC0, 0x78, 0x00,
  0xE0, 0x3C, 0x00, 0x70, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x07, 0x80, 0x03, 0xC3, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0x71, 0xE0,
  0x00, 0x38, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0xF0, 0x00, 0x7E, 0x00, 0x0E, 0x70,
  0x00, 0x7E, 0x00, 0x1E, 0x78, 0x00, 0x7E, 0x00, 0x1E, 0x78, 0x00, 0x7E,
  0x00, 0x1E, 0x78, 0x00, 0xFF, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x3C,
  0x3C, 0x00, 0xE7, 0x00, 0x3C, 0x3C, 0x00, 0xE7, 0x00, 0x3C, 0x3C, 0x01,
  0xE7, 0x80, 0x38, 0x1C, 0x01, 0xC7, 0x80, 0x38, 0x1C, 0x01, 0xC3, 0x80,
  0x78, 0x1E, 0x01, 0xC3, 0x80, 0x78, 0x1E, 0x03, 0xC3, 0xC0, 0x70, 0x1E,
  0x03, 0x83, 0xC0, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x0F, 0x03, 0x81,
  0xC0, 0xF0, 0x0F, 0x07, 0x81, 0xE0, 0xE0, 0x0F, 0x07, 0x01, 0xE0, 0xE0,
  0x07, 0x07, 0x00, 0xE1, 0xE0, 0x07, 0x87, 0x00, 0xE1, 0xE0, 0x07, 0x8F,
  0x00, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0xF1, 0xC0, 0x03, 0x8E, 0x00, 0x71,
  0xC0, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x03, 0xDE, 0x00, 0x73, 0xC0, 0x03,
  0xDE, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x78, 0x00, 0x0F, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x0F,
  0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x03,
  0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xE7, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xF7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x03,
  0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0x70, 0x0F,
  0x00, 0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xC7, 0x80, 0x01, 0xE3,
  0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x3C,
  0x0E, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07,
  0x80, 0x70, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x00,
  0xF0, 0x03, 0xC0, 0x70, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x3C, 0x00, 0x38,
  0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0x87, 0x80, 0x01,
  0xC3, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1C, 0xE0, 0x00,
  0x0F, 0x70, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x87, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x40, 0x03, 0xF0, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x17, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x0F, 0xE0, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xE8, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x40,
};

const GFXglyph NotoSans_Condensed_Light68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 50, 15, 5, -49 },
  { 33, 15, 18, 23, 4, -49 },
  { 67, 32, 49, 34, 1, -49 },
  { 263, 25, 56, 31, 3, -52 },
  { 438, 40, 50, 46, 3, -49 },
  { 688, 32, 50, 35, 3, -49 },
  { 888, 5, 18, 13, 4, -49 },
  { 900, 14, 60, 19, 3, -49 },
  { 1005, 14, 60, 19, 2, -49 },
  { 1110, 23, 23, 29, 3, -52 },
  { 1177, 27, 32, 31, 2, -40 },
  { 1285, 7, 16, 14, 3, -7 },
  { 1299, 15, 3, 19, 2, -20 },
  { 1305, 5, 7, 15, 5, -6 },
  { 1310, 22, 49, 24, 1, -49 },
  { 1445, 25, 50, 31, 3, -49 },
  { 1602, 15, 49, 31, 5, -49 },
  { 1694, 25, 49, 31, 3, -49 },
  { 1848, 25, 50, 31, 3, -49 },
  { 2005, 29, 49, 31, 1, -49 },
  { 2183, 24, 50, 31, 4, -49 },
  { 2333, 25, 50, 31, 3, -49 },
  { 2490, 25, 49, 31, 3, -49 },
  { 2644, 25, 50, 31, 3, -49 },
  { 2801, 25, 50, 31, 3, -49 },
  { 2958, 5, 38, 15, 5, -37 },
  { 2982, 8, 46, 15, 2, -37 },
  { 3028, 27, 30, 31, 2, -39 },
  { 3130, 26, 18, 31, 3, -33 },
  { 3189, 26, 30, 31, 3, -39 },
  { 3287, 20, 50, 22, 1, -49 },
  { 3412, 41, 55, 48, 4, -49 },
  { 3694, 32, 49, 32, 0, -49 },
  { 3890, 25, 49, 34, 6, -49 },
  { 4044, 27, 50, 33, 4, -49 },
  { 4213, 28, 49, 38, 6, -49 },
  { 4385, 20, 49, 30, 6, -49 },
  { 4508, 21, 49, 28, 6, -49 },
  { 4637, 32, 50, 40, 4, -49 },
  { 4837, 27, 49, 39, 6, -49 },
  { 5003, 13, 49, 18, 3, -49 },
  { 5083, 13, 61, 15, -4, -49 },
  { 5183, 26, 49, 32, 6, -49 },
  { 5343, 20, 49, 27, 6, -49 },
  { 5466, 39, 49, 50, 6, -49 },
  { 5705, 29, 49, 40, 6, -49 },
  { 5883, 33, 50, 41, 4, -49 },
  { 6090, 23, 49, 32, 6, -49 },
  { 6231, 33, 61, 41, 4, -49 },
  { 6483, 26, 49, 33, 6, -49 },
  { 6643, 24, 50, 30, 3, -49 },
  { 6793, 26, 49, 28, 1, -49 },
  { 6953, 29, 50, 39, 5, -49 },
  { 7135, 31, 49, 31, 0, -49 },
  { 7325, 49, 49, 51, 1, -49 },
  { 7626, 28, 49, 29, 0, -49 },
  { 7798, 28, 49, 28, 0, -49 },
  { 7970, 24, 49, 28, 2, -49 },
  { 8117, 14, 60, 21, 5, -49 },
  { 8222, 22, 49, 24, 1, -49 },
  { 8357, 14, 60, 21, 2, -49 },
  { 8462, 28, 27, 32, 2, -49 },
  { 8557, 28, 3, 28, 0, 6 },
  { 8568, 11, 11, 17, 3, -52 },
  { 8584, 22, 38, 30, 3, -37 },
  { 8689, 25, 53, 33, 5, -52 },
  { 8855, 21, 38, 25, 3, -37 },
  { 8955, 25, 53, 33, 3, -52 },
  { 9121, 24, 38, 30, 3, -37 },
  { 9235, 19, 52, 17, 1, -52 },
  { 9359, 25, 53, 33, 3, -37 },
  { 9525, 23, 52, 33, 5, -52 },
  { 9675, 5, 50, 14, 5, -50 },
  { 9707, 11, 66, 14, -1, -50 },
  { 9798, 22, 52, 27, 5, -52 },
  { 9941, 4, 52, 14, 5, -52 },
  { 9967, 39, 37, 49, 5, -37 },
  { 10148, 23, 37, 33, 5, -37 },
  { 10255, 26, 38, 32, 3, -37 },
  { 10379, 25, 53, 33, 5, -37 },
  { 10545, 25, 53, 33, 3, -37 },
  { 10711, 16, 37, 21, 5, -37 },
  { 10785, 20, 38, 25, 3, -37 },
  { 10880, 16, 46, 18, 1, -45 },
  { 10972, 23, 37, 33, 5, -36 },
  { 11079, 25, 36, 25, 0, -36 },
  { 11192, 40, 36, 42, 1, -36 },
  { 11372, 24, 36, 27, 1, -36 },
  { 11480, 25, 52, 26, 1, -36 },
  { 11643, 19, 36, 23, 2, -36 },
  { 11729, 18, 60, 24, 3, -49 },
  { 11864, 4, 68, 30, 13, -52 },
  { 11898, 18, 60, 24, 3, -49 },
  { 12033, 26, 8, 31, 3, -28 },
};

const GFXfont NotoSans_Condensed_Light68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light68pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_CONDENSED_LIGHT68PT7B_H_
