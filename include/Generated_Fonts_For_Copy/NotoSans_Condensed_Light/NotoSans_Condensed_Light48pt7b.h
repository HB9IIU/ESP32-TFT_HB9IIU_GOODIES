#ifndef _NOTOSANS_CONDENSED_LIGHT48PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light48pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76,
  0x66, 0x60, 0x00, 0x00, 0x7F, 0xF7, 0xE1, 0xF8, 0x3E, 0x0F, 0x83, 0xE0,
  0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x36, 0x0D, 0x83, 0x00, 0xC0, 0xE0,
  0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x30, 0x30, 0x01, 0xC0, 0xC0, 0x06,
  0x03, 0x00, 0x18, 0x0C, 0x00, 0x60, 0x70, 0x01, 0x81, 0x80, 0x06, 0x06,
  0x07, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x03, 0x01, 0x80, 0x0C, 0x06, 0x00,
  0x30, 0x18, 0x00, 0xC0, 0xE0, 0x03, 0x03, 0x00, 0x0C, 0x0C, 0x00, 0x70,
  0x30, 0x01, 0xC0, 0xC0, 0x06, 0x03, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x81, 0x81, 0x80, 0x06, 0x06, 0x00, 0x18, 0x18, 0x00, 0xE0, 0x60, 0x03,
  0x01, 0x80, 0x0C, 0x06, 0x00, 0x30, 0x38, 0x00, 0xC0, 0xC0, 0x03, 0x03,
  0x00, 0x0C, 0x0C, 0x00, 0x70, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x1F, 0xF0, 0x1F, 0xFF, 0x8F, 0x33, 0xC7, 0x0C, 0x11, 0xC3,
  0x00, 0xE0, 0xC0, 0x38, 0x30, 0x0E, 0x0C, 0x03, 0x83, 0x00, 0xE0, 0xC0,
  0x38, 0x30, 0x07, 0x0C, 0x00, 0xE3, 0x00, 0x3E, 0xC0, 0x03, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x33, 0xC0, 0x0C, 0x38, 0x03,
  0x0E, 0x00, 0xC1, 0xC0, 0x30, 0x70, 0x0C, 0x1C, 0x03, 0x07, 0x00, 0xC1,
  0x80, 0x30, 0xE8, 0x0C, 0x7B, 0xC3, 0x3C, 0xFF, 0xFE, 0x0F, 0xFE, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0xC0, 0x39, 0xC0, 0x1C, 0x07, 0x0C, 0x01,
  0x80, 0x60, 0xE0, 0x38, 0x06, 0x06, 0x03, 0x00, 0x60, 0x60, 0x30, 0x0E,
  0x06, 0x07, 0x00, 0xE0, 0x60, 0x60, 0x0C, 0x06, 0x0E, 0x00, 0xC0, 0x60,
  0xC0, 0x0C, 0x06, 0x0C, 0x00, 0xC0, 0x61, 0xC0, 0x0E, 0x06, 0x18, 0x00,
  0xE0, 0x63, 0x8F, 0x86, 0x06, 0x31, 0xFC, 0x60, 0x63, 0x18, 0xE6, 0x0E,
  0x73, 0x06, 0x70, 0xC6, 0x30, 0x73, 0x9C, 0xE7, 0x03, 0x1F, 0x8C, 0x70,
  0x30, 0xE0, 0xC6, 0x03, 0x00, 0x1C, 0x60, 0x30, 0x01, 0x86, 0x03, 0x00,
  0x38, 0x60, 0x30, 0x03, 0x06, 0x03, 0x00, 0x30, 0x60, 0x30, 0x07, 0x06,
  0x03, 0x00, 0x60, 0x60, 0x30, 0x0E, 0x07, 0x03, 0x00, 0xC0, 0x30, 0x70,
  0x0C, 0x03, 0x06, 0x01, 0x80, 0x38, 0xE0, 0x18, 0x01, 0xFC, 0x03, 0x80,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xE0,
  0xE0, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0xC0, 0x06, 0x03, 0x80, 0x0C, 0x07,
  0x00, 0x18, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x70, 0x30, 0x00, 0xE0, 0xE0,
  0x00, 0xE1, 0x80, 0x01, 0xC7, 0x00, 0x01, 0xDC, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7B, 0x80, 0x01, 0xE7, 0x00, 0xC3,
  0x87, 0x01, 0x8E, 0x07, 0x07, 0x18, 0x0F, 0x0E, 0x70, 0x0E, 0x1C, 0xE0,
  0x0E, 0x31, 0xC0, 0x0E, 0xE3, 0x80, 0x1D, 0x87, 0x00, 0x1F, 0x0E, 0x00,
  0x1C, 0x1C, 0x00, 0x7C, 0x18, 0x00, 0xF8, 0x38, 0x03, 0xB8, 0x3C, 0x1E,
  0x38, 0x7F, 0xF8, 0x70, 0x3F, 0xC0, 0x78, 0xFF, 0xFF, 0xFF, 0xFD, 0xB0,
  0x03, 0xC0, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E,
  0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80,
  0x70, 0x0C, 0x03, 0x80, 0x70, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x0E, 0x03, 0x01, 0xC0, 0xE0, 0x70, 0x18, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x03, 0x81, 0xC1, 0xC0,
  0xC0, 0xE0, 0xE0, 0x60, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x81, 0x81, 0xF1, 0x8F, 0xFF, 0xFF, 0x1F, 0xF8, 0x01, 0xC0, 0x03,
  0xC0, 0x06, 0x60, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x08,
  0x10, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x39, 0xCE, 0x67, 0x39, 0xCC, 0x67, 0x30, 0xFF, 0xFF,
  0xFC, 0x7F, 0xF7, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x01, 0xFE, 0x00,
  0xFF, 0xC0, 0x78, 0x38, 0x1C, 0x07, 0x0E, 0x01, 0xC3, 0x00, 0x31, 0xC0,
  0x0E, 0x70, 0x03, 0x9C, 0x00, 0xE6, 0x00, 0x19, 0x80, 0x06, 0xE0, 0x01,
  0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80,
  0x06, 0x60, 0x01, 0x9C, 0x00, 0x67, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03,
  0x8E, 0x00, 0xC3, 0x80, 0x70, 0x70, 0x38, 0x1E, 0x1E, 0x03, 0xFF, 0x00,
  0x7F, 0x80, 0x01, 0xC1, 0xF0, 0xFC, 0x7F, 0x3D, 0xDE, 0x7E, 0x1D, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x03, 0xE0, 0x07,
  0xFE, 0x07, 0xFF, 0xC1, 0xC0, 0x78, 0x20, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xE0, 0x0F, 0xFC, 0x1F, 0xFF, 0x9E, 0x01,
  0xC4, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x78, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1D, 0x00, 0x1E,
  0xE0, 0x1E, 0x7F, 0xFE, 0x1F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x37,
  0x00, 0x07, 0x70, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xC7, 0x00, 0x1C,
  0x70, 0x01, 0x87, 0x00, 0x30, 0x70, 0x07, 0x07, 0x00, 0x60, 0x70, 0x0E,
  0x07, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x70, 0x38, 0x07, 0x03,
  0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x70, 0xC0, 0x07, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x7F,
  0xFE, 0x3F, 0xFF, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x3E, 0x03, 0xFF, 0xE1, 0xFF, 0xF8, 0x40, 0x1E, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x72, 0x00, 0x79, 0x80, 0xF8, 0xFF, 0xF8, 0x3F, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x3F, 0xC1, 0x9F, 0xF8,
  0x6E, 0x0F, 0x3B, 0x01, 0xCF, 0x80, 0x3B, 0xC0, 0x0E, 0xF0, 0x01, 0xB8,
  0x00, 0x7E, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x77, 0x00,
  0x1D, 0xC0, 0x07, 0x70, 0x01, 0x8C, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x1C,
  0x1E, 0x0F, 0x03, 0xFF, 0x80, 0x7F, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF0, 0x3C, 0x38,
  0x07, 0x1C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0x9C, 0x00,
  0xE7, 0x00, 0x38, 0xC0, 0x0E, 0x38, 0x07, 0x07, 0x03, 0x80, 0xE1, 0xC0,
  0x1F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0xF7, 0xC0, 0x78, 0x78, 0x38,
  0x0F, 0x1C, 0x01, 0xE7, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x39,
  0xC0, 0x1E, 0x3C, 0x0F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0x80, 0x39, 0x80, 0x0D,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0x70, 0x03, 0xB8, 0x03, 0xCE,
  0x03, 0x67, 0xC7, 0xB1, 0xFF, 0x98, 0x3F, 0x0C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x40, 0x78, 0x1F, 0xF8, 0x0F, 0xF0, 0x00,
  0x6F, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0xF7, 0x33, 0xDE, 0xF3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0xE7, 0x33, 0x9C, 0xE6, 0x73, 0x18, 0x00, 0x00, 0x40,
  0x00, 0x30, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xC0, 0x00, 0x00,
  0x0F, 0x81, 0xFF, 0x8F, 0xFF, 0x10, 0x1E, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x06,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x78, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x00, 0x70,
  0x38, 0x00, 0x01, 0x83, 0x80, 0x00, 0x0E, 0x18, 0x00, 0x00, 0x31, 0xC0,
  0x1F, 0x01, 0x8C, 0x03, 0xFE, 0x0E, 0x60, 0x38, 0x70, 0x37, 0x03, 0x83,
  0x81, 0xB0, 0x18, 0x1C, 0x0D, 0x81, 0xC0, 0xE0, 0x6C, 0x0C, 0x07, 0x03,
  0x60, 0x60, 0x38, 0x1B, 0x03, 0x01, 0xC0, 0xD8, 0x38, 0x0E, 0x07, 0xC1,
  0xC0, 0x70, 0x3E, 0x0E, 0x03, 0x01, 0xB0, 0x70, 0x18, 0x0D, 0x81, 0x80,
  0xC0, 0x6C, 0x0C, 0x0E, 0x07, 0x60, 0x60, 0x78, 0x33, 0x03, 0x86, 0xC3,
  0x98, 0x0F, 0xF3, 0xF8, 0xE0, 0x3F, 0x1F, 0x83, 0x00, 0x60, 0x38, 0x18,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x60, 0x00, 0x0E, 0xC0, 0x00, 0x1D,
  0xC0, 0x00, 0x33, 0x80, 0x00, 0x63, 0x00, 0x01, 0xC6, 0x00, 0x03, 0x8E,
  0x00, 0x06, 0x1C, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x38, 0x00, 0x60, 0x70,
  0x00, 0xC0, 0xE0, 0x03, 0x80, 0xC0, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x80,
  0x38, 0x03, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07,
  0x00, 0x18, 0x0E, 0x00, 0x38, 0x18, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0,
  0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x1C, 0x00,
  0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1C, 0xFF, 0xF8,
  0x3F, 0xFF, 0x8E, 0x01, 0xF3, 0x80, 0x1C, 0xE0, 0x03, 0xB8, 0x00, 0xEE,
  0x00, 0x1B, 0x80, 0x06, 0xE0, 0x01, 0xB8, 0x00, 0x6E, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x03, 0x38, 0x01, 0xCE, 0x01, 0xE3, 0xFF, 0xE0, 0xFF, 0xFC,
  0x38, 0x07, 0x8E, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x7B, 0x81, 0xFC, 0xFF, 0xFC,
  0x3F, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0xF8, 0x1F, 0xFF, 0x87, 0xC0,
  0x21, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xE0, 0x7F, 0xFC,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0xE0, 0x3F, 0x0E, 0x00,
  0xF8, 0xE0, 0x03, 0x8E, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x06, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00,
  0x1C, 0xE0, 0x03, 0xCE, 0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x0F, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFE, 0xFF, 0xFD,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xF7, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xE0, 0x0E, 0x0F,
  0x00, 0x08, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0D, 0x80, 0x00, 0x37,
  0x00, 0x00, 0xDC, 0x00, 0x03, 0x38, 0x00, 0x0C, 0xF0, 0x00, 0x31, 0xE0,
  0x00, 0xC3, 0xC0, 0x03, 0x07, 0xC0, 0x3C, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xFF, 0xBF, 0x87, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0xFF, 0x3F, 0x87, 0x80, 0xE0,
  0x03, 0xF8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38, 0x07,
  0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x0E, 0x1E, 0x03,
  0x87, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0xBC, 0x00, 0xFF,
  0x80, 0x3E, 0xE0, 0x0F, 0x1C, 0x03, 0xC7, 0x00, 0xE0, 0xE0, 0x38, 0x38,
  0x0E, 0x07, 0x03, 0x80, 0xE0, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x01, 0xC3,
  0x80, 0x38, 0xE0, 0x0E, 0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0E, 0xE0,
  0x01, 0xF8, 0x00, 0x70, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFD, 0x80, 0x00, 0x3F, 0xD8, 0x00, 0x03, 0xFD, 0xC0, 0x00,
  0x37, 0xEC, 0x00, 0x07, 0x7E, 0xC0, 0x00, 0x77, 0xEE, 0x00, 0x06, 0x7E,
  0xE0, 0x00, 0x67, 0xE6, 0x00, 0x0E, 0x7E, 0x70, 0x00, 0xC7, 0xE7, 0x00,
  0x0C, 0x7E, 0x30, 0x01, 0xC7, 0xE3, 0x80, 0x18, 0x7E, 0x38, 0x01, 0x87,
  0xE1, 0x80, 0x38, 0x7E, 0x1C, 0x03, 0x07, 0xE1, 0xC0, 0x30, 0x7E, 0x0C,
  0x07, 0x07, 0xE0, 0xE0, 0x60, 0x7E, 0x0E, 0x06, 0x07, 0xE0, 0x60, 0xE0,
  0x7E, 0x07, 0x0C, 0x07, 0xE0, 0x70, 0xC0, 0x7E, 0x03, 0x1C, 0x07, 0xE0,
  0x39, 0x80, 0x7E, 0x03, 0x98, 0x07, 0xE0, 0x1B, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xE0, 0x1F, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x7E,
  0x00, 0xE0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7D, 0xC0, 0x03, 0xEE, 0x00, 0x1F, 0x38, 0x00, 0xF9, 0xC0, 0x07,
  0xC7, 0x00, 0x3F, 0x38, 0x01, 0xF8, 0xE0, 0x0F, 0xC7, 0x00, 0x7E, 0x1C,
  0x03, 0xF0, 0xE0, 0x1F, 0x83, 0x80, 0xFC, 0x1C, 0x07, 0xE0, 0x70, 0x3F,
  0x03, 0x81, 0xF8, 0x0E, 0x0F, 0xC0, 0x70, 0x7E, 0x01, 0xC3, 0xF0, 0x0E,
  0x1F, 0x80, 0x38, 0xFC, 0x01, 0xC7, 0xE0, 0x07, 0x3F, 0x00, 0x39, 0xF8,
  0x00, 0xEF, 0xC0, 0x07, 0x7E, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xC0, 0x07, 0x07,
  0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0,
  0x00, 0x3B, 0x80, 0x00, 0x37, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x19,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x87, 0x00, 0x07, 0x0F,
  0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0F, 0x83, 0xE0, 0x0F, 0xFF, 0x80, 0x07,
  0xFC, 0x00, 0xFF, 0xE0, 0x7F, 0xFC, 0x38, 0x1F, 0x9C, 0x01, 0xCE, 0x00,
  0x77, 0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x37, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1C,
  0xE0, 0x1E, 0x70, 0xFE, 0x3F, 0xFE, 0x1F, 0xF8, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x78, 0x0F, 0x01, 0xC0, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x00, 0x0E, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x19, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7,
  0x00, 0x03, 0x87, 0x00, 0x07, 0x0F, 0x00, 0x1C, 0x0F, 0x00, 0x78, 0x0F,
  0x83, 0xE0, 0x0F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0xFF, 0xF0, 0x3F, 0xFF, 0x0E,
  0x07, 0xE3, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x03,
  0x38, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x78, 0xE0, 0x7C, 0x3F, 0xFE, 0x0F,
  0xFE, 0x03, 0x83, 0x80, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x03, 0x83, 0x80,
  0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x38, 0xE0, 0x07,
  0x38, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xF8, 0x00, 0x70,
  0x01, 0xF8, 0x07, 0xFF, 0x87, 0xFF, 0xE7, 0x80, 0x67, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1D, 0x00, 0x1E, 0xF0, 0x1E, 0x7F, 0xFE,
  0x1F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x6E, 0x00, 0x0E, 0xE0, 0x00,
  0xE7, 0x00, 0x1C, 0x78, 0x03, 0xC3, 0xE0, 0x78, 0x1F, 0xFF, 0x00, 0x7F,
  0xE0, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x67, 0x00, 0x03, 0x9C, 0x00, 0x0E,
  0x70, 0x00, 0x38, 0xC0, 0x00, 0xC3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0x60, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1C, 0x00,
  0xC0, 0x30, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x06, 0x01, 0x80,
  0x1C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC0, 0xC0, 0x03, 0x03, 0x00, 0x0E,
  0x1C, 0x00, 0x38, 0x70, 0x00, 0x61, 0x80, 0x01, 0x8E, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x33, 0x00, 0x00, 0xDC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x6E, 0x00, 0x1E, 0x00, 0x1D, 0xC0, 0x03, 0xC0, 0x03,
  0xB8, 0x00, 0x78, 0x00, 0x73, 0x00, 0x0F, 0x00, 0x0C, 0x70, 0x03, 0xE0,
  0x03, 0x8E, 0x00, 0x6E, 0x00, 0x71, 0xC0, 0x0C, 0xC0, 0x0E, 0x38, 0x01,
  0x98, 0x01, 0x83, 0x00, 0x73, 0x00, 0x70, 0x70, 0x0E, 0x70, 0x0E, 0x0E,
  0x01, 0x8E, 0x01, 0xC1, 0xC0, 0x30, 0xC0, 0x38, 0x18, 0x0E, 0x18, 0x06,
  0x03, 0x81, 0xC3, 0x81, 0xC0, 0x70, 0x38, 0x70, 0x38, 0x0E, 0x06, 0x06,
  0x07, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0x18, 0x38, 0x18, 0x38, 0x03, 0x87,
  0x03, 0x87, 0x00, 0x70, 0xC0, 0x70, 0xE0, 0x0E, 0x18, 0x06, 0x18, 0x00,
  0xC7, 0x00, 0xC3, 0x00, 0x1C, 0xE0, 0x1C, 0xE0, 0x03, 0x9C, 0x03, 0x9C,
  0x00, 0x73, 0x00, 0x33, 0x80, 0x06, 0x60, 0x06, 0x60, 0x00, 0xDC, 0x00,
  0xDC, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x03, 0xE0, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF3, 0x80, 0x0E, 0x18, 0x01, 0xC1,
  0xC0, 0x1C, 0x1C, 0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x00, 0x70, 0x70,
  0x07, 0x06, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00, 0x19, 0xC0, 0x01, 0xDC,
  0x00, 0x0D, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x00, 0x1D, 0x80, 0x01, 0x9C, 0x00, 0x38, 0xC0, 0x03,
  0x0E, 0x00, 0x70, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x03, 0x81,
  0xC0, 0x38, 0x1C, 0x01, 0x83, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x00, 0x0E,
  0x70, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00,
  0xC3, 0x00, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x18, 0x18, 0x03, 0x81, 0xC0,
  0x30, 0x0C, 0x07, 0x00, 0xE0, 0x70, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x07,
  0x0C, 0x00, 0x31, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0x80, 0x01, 0xB8, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE0, 0x00,
  0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03, 0x80,
  0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x1C, 0xFF, 0xFF, 0xF0, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x60, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1D, 0x80, 0x01,
  0x98, 0x00, 0x39, 0xC0, 0x03, 0x0C, 0x00, 0x70, 0xE0, 0x07, 0x06, 0x00,
  0xE0, 0x70, 0x0E, 0x03, 0x01, 0xC0, 0x38, 0x1C, 0x01, 0x81, 0x80, 0x1C,
  0x38, 0x00, 0xC3, 0x00, 0x0E, 0x70, 0x00, 0x6E, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x07,
  0xF0, 0x7F, 0xF0, 0xF8, 0xF0, 0x80, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x0F, 0xF0, 0xFF, 0xE7,
  0xE0, 0xDE, 0x01, 0xB8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xB8, 0x1B, 0x3F, 0xE6, 0x3F, 0x8C,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0xFC, 0x19,
  0xFF, 0x8D, 0xE3, 0xE6, 0xC0, 0x73, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x03,
  0x70, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1D, 0xE0, 0x0E, 0xF0, 0x0E, 0x6E, 0x0F,
  0x33, 0xFF, 0x18, 0xFF, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3E, 0x70, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x03, 0x0F, 0xFE, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x3F, 0x1C, 0x3F, 0xE7, 0x1F, 0x3D, 0xCF,
  0x01, 0xF3, 0x80, 0x2D, 0xC0, 0x0F, 0x70, 0x01, 0xDC, 0x00, 0x76, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1D, 0x80, 0x07, 0x60, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x3C, 0xE0, 0x0F, 0x38, 0x06, 0xC7, 0x03, 0x31, 0xFF,
  0xCC, 0x1F, 0xC3, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0x87, 0x83, 0x81, 0xC3,
  0x80, 0x71, 0x80, 0x19, 0xC0, 0x0C, 0xE0, 0x07, 0x60, 0x03, 0xB0, 0x00,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xF0, 0x02, 0x3C, 0x06, 0x0F, 0xFF, 0x01, 0xFF, 0x00, 0x01,
  0xE0, 0x3F, 0xC3, 0xFC, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0x8F, 0xFC, 0x7F, 0xE0, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x03, 0xF0, 0xC3, 0xFE, 0x31, 0xF3, 0xCC, 0xF0, 0x1B, 0x38, 0x03, 0xDC,
  0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x03, 0xCC,
  0x00, 0xF3, 0x80, 0x7C, 0x70, 0x37, 0x0F, 0xF9, 0xC1, 0xFC, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06,
  0x00, 0x03, 0x90, 0x01, 0xE7, 0x00, 0xF1, 0xFF, 0xF8, 0x1F, 0xF8, 0x00,
  0x20, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC3, 0xF0,
  0xCF, 0xF8, 0xDE, 0x7C, 0xD8, 0x1E, 0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x07,
  0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x6F, 0xF6, 0x00, 0x00, 0x06, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0x0F, 0x0F, 0x06,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x0E, 0x0E, 0x0E, 0xFC, 0xF8, 0x20, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x76, 0x00, 0xEC, 0x03, 0x98, 0x0E, 0x30, 0x1C, 0x60,
  0x70, 0xC1, 0xC1, 0x83, 0x03, 0x0E, 0x06, 0x38, 0x0C, 0xE0, 0x19, 0xE0,
  0x37, 0xC0, 0x7D, 0xC0, 0xF3, 0x81, 0xC3, 0x83, 0x07, 0x06, 0x07, 0x0C,
  0x0E, 0x18, 0x0E, 0x30, 0x1C, 0x60, 0x1C, 0xC0, 0x39, 0x80, 0x3B, 0x00,
  0x76, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC3, 0xE0, 0x3F, 0x19, 0xFE, 0x1F, 0xF3, 0x71, 0xE3, 0x9F, 0x6C, 0x0E,
  0xC0, 0xEF, 0x01, 0xF0, 0x0F, 0xC0, 0x1E, 0x01, 0xF8, 0x03, 0x80, 0x3F,
  0x00, 0x70, 0x07, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0,
  0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x78, 0x01, 0xC0, 0x0C, 0xC3, 0xF0, 0xCF, 0xF8, 0xDE, 0x3C, 0xD8, 0x0E,
  0xF0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0x03, 0xF8, 0x03, 0xFF,
  0x01, 0xF1, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x8C, 0x00, 0xE7, 0x00, 0x1D,
  0xC0, 0x07, 0x60, 0x01, 0xD8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xD8, 0x00,
  0x77, 0x00, 0x1D, 0xC0, 0x07, 0x70, 0x01, 0x8E, 0x00, 0xE3, 0x80, 0x70,
  0x78, 0x3C, 0x0F, 0xFE, 0x01, 0xFF, 0x00, 0xC3, 0xF0, 0x63, 0xFE, 0x33,
  0x8F, 0x9B, 0x01, 0xCF, 0x00, 0x77, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x77, 0x80, 0x3B, 0x60, 0x39, 0xB8, 0x3C, 0xCF, 0xFC,
  0x63, 0xFC, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C,
  0x00, 0x00, 0x03, 0xF0, 0xC3, 0xFE, 0x31, 0xF1, 0xCC, 0xF0, 0x1B, 0x38,
  0x03, 0xDC, 0x00, 0xF7, 0x00, 0x1D, 0xC0, 0x07, 0x60, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x76, 0x00, 0x1D, 0xC0, 0x07, 0x70,
  0x03, 0xCE, 0x00, 0xF3, 0x80, 0x7C, 0x70, 0x37, 0x1F, 0xF9, 0xC1, 0xFC,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0xC3, 0xF8, 0xFB, 0x3F, 0x6C, 0x0D, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x00, 0x0F, 0xE0, 0xFF, 0xF7, 0xC7, 0x9C, 0x02, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x03, 0xB0, 0x1E, 0xFF, 0xF1, 0xFF, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x0F, 0xFF, 0xFF, 0xFF,
  0xE3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0xC0, 0x38, 0x03, 0xF8, 0x7F, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xF6, 0x00, 0x7B, 0x80, 0x7D, 0xC0, 0x3E, 0x70, 0x77, 0x3F,
  0xF3, 0x8F, 0xF1, 0xC0, 0xE0, 0x01, 0xF8, 0x00, 0x66, 0x00, 0x39, 0xC0,
  0x0E, 0x70, 0x03, 0x8C, 0x00, 0xC3, 0x80, 0x70, 0xE0, 0x1C, 0x38, 0x06,
  0x06, 0x01, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x0C, 0x03, 0x07, 0x00,
  0xE1, 0xC0, 0x38, 0x60, 0x06, 0x18, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x0C,
  0xC0, 0x03, 0x30, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xC0, 0x0E, 0x00, 0x7C, 0x00, 0xE0, 0x07, 0xE0, 0x0F,
  0x00, 0x6E, 0x00, 0xF0, 0x06, 0xE0, 0x1F, 0x00, 0xE6, 0x01, 0xB0, 0x0E,
  0x70, 0x1B, 0x80, 0xC7, 0x01, 0x98, 0x0C, 0x70, 0x39, 0x81, 0xC3, 0x03,
  0x98, 0x1C, 0x30, 0x31, 0xC1, 0x83, 0x83, 0x0C, 0x18, 0x38, 0x70, 0xC1,
  0x81, 0x87, 0x0C, 0x38, 0x18, 0x60, 0xE3, 0x81, 0xC6, 0x0E, 0x30, 0x1C,
  0xE0, 0x63, 0x00, 0xCE, 0x06, 0x70, 0x0C, 0xC0, 0x77, 0x00, 0xEC, 0x07,
  0x60, 0x0E, 0xC0, 0x36, 0x00, 0x7C, 0x03, 0x60, 0x07, 0x80, 0x3E, 0x00,
  0x78, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x01, 0xC0, 0xE0, 0x03,
  0xB8, 0x03, 0x9C, 0x01, 0xC7, 0x01, 0xC3, 0x80, 0xC0, 0xE0, 0xE0, 0x70,
  0x60, 0x1C, 0x70, 0x06, 0x30, 0x03, 0xB8, 0x00, 0xD8, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x80, 0x0E, 0xC0, 0x07, 0x70, 0x07, 0x18,
  0x03, 0x8E, 0x03, 0x83, 0x01, 0xC1, 0xC1, 0xC0, 0x70, 0xE0, 0x38, 0xE0,
  0x0E, 0x60, 0x07, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00,
  0x19, 0xC0, 0x0E, 0x30, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x30, 0x60, 0x1C,
  0x18, 0x07, 0x07, 0x01, 0x81, 0xC0, 0x60, 0x30, 0x38, 0x0E, 0x0E, 0x03,
  0x83, 0x00, 0x61, 0xC0, 0x18, 0x70, 0x07, 0x18, 0x00, 0xC6, 0x00, 0x33,
  0x80, 0x0E, 0xC0, 0x03, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x18, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x00, 0x7F, 0xFD, 0xFF, 0xF7,
  0xFF, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0xF0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70, 0x03,
  0x80, 0xF8, 0x0F, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xC0, 0x06, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x07,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0x80, 0xFC, 0x0F, 0x00,
  0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x38, 0x1F, 0x80, 0xF8, 0x04, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x3C,
  0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_Condensed_Light48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 34, 11, 3, -34 },
  { 18, 10, 12, 17, 3, -34 },
  { 33, 22, 34, 24, 1, -34 },
  { 127, 18, 39, 22, 2, -36 },
  { 215, 28, 35, 32, 2, -35 },
  { 338, 23, 35, 25, 2, -35 },
  { 439, 3, 12, 9, 3, -34 },
  { 444, 10, 42, 13, 2, -34 },
  { 497, 9, 42, 13, 2, -34 },
  { 545, 16, 16, 20, 2, -36 },
  { 577, 18, 22, 22, 2, -28 },
  { 627, 5, 11, 10, 2, -5 },
  { 634, 11, 2, 14, 1, -14 },
  { 637, 4, 4, 10, 3, -4 },
  { 639, 15, 34, 17, 1, -34 },
  { 703, 18, 35, 22, 2, -35 },
  { 782, 10, 34, 22, 4, -34 },
  { 825, 18, 35, 22, 2, -35 },
  { 904, 17, 35, 22, 2, -35 },
  { 979, 20, 35, 22, 1, -35 },
  { 1067, 17, 34, 22, 3, -34 },
  { 1140, 18, 36, 22, 2, -35 },
  { 1221, 18, 34, 22, 2, -34 },
  { 1298, 18, 35, 22, 2, -35 },
  { 1377, 17, 35, 22, 2, -35 },
  { 1452, 4, 26, 10, 3, -26 },
  { 1465, 5, 32, 10, 2, -26 },
  { 1485, 18, 21, 22, 2, -28 },
  { 1533, 18, 12, 22, 2, -23 },
  { 1560, 18, 21, 22, 2, -28 },
  { 1608, 14, 35, 16, 1, -35 },
  { 1670, 29, 38, 34, 2, -34 },
  { 1808, 23, 34, 23, 0, -34 },
  { 1906, 18, 34, 24, 4, -34 },
  { 1983, 19, 35, 23, 3, -35 },
  { 2067, 20, 34, 27, 4, -34 },
  { 2152, 15, 34, 21, 4, -34 },
  { 2216, 15, 34, 20, 4, -34 },
  { 2280, 22, 35, 28, 3, -35 },
  { 2377, 20, 34, 28, 4, -34 },
  { 2462, 9, 34, 13, 2, -34 },
  { 2501, 10, 43, 11, -3, -34 },
  { 2555, 18, 34, 22, 4, -34 },
  { 2632, 14, 34, 19, 4, -34 },
  { 2692, 28, 34, 36, 4, -34 },
  { 2811, 21, 34, 29, 4, -34 },
  { 2901, 23, 35, 29, 3, -35 },
  { 3002, 17, 34, 23, 4, -34 },
  { 3075, 23, 43, 29, 3, -35 },
  { 3199, 18, 34, 23, 4, -34 },
  { 3276, 17, 35, 21, 2, -35 },
  { 3351, 19, 34, 20, 0, -34 },
  { 3432, 20, 34, 27, 4, -34 },
  { 3517, 22, 34, 22, 0, -34 },
  { 3611, 35, 34, 36, 0, -34 },
  { 3760, 20, 34, 20, 0, -34 },
  { 3845, 20, 34, 20, 0, -34 },
  { 3930, 18, 34, 20, 1, -34 },
  { 4007, 10, 42, 15, 4, -34 },
  { 4060, 15, 34, 17, 1, -34 },
  { 4124, 10, 42, 15, 1, -34 },
  { 4177, 20, 18, 22, 1, -34 },
  { 4222, 20, 2, 20, 0, 4 },
  { 4227, 8, 8, 12, 2, -37 },
  { 4235, 15, 26, 21, 2, -26 },
  { 4284, 17, 36, 24, 4, -36 },
  { 4361, 15, 26, 18, 2, -26 },
  { 4410, 18, 36, 24, 2, -36 },
  { 4491, 17, 26, 21, 2, -26 },
  { 4547, 13, 37, 12, 1, -37 },
  { 4608, 18, 38, 23, 2, -26 },
  { 4694, 16, 36, 23, 4, -36 },
  { 4766, 4, 35, 10, 3, -35 },
  { 4784, 8, 47, 10, -1, -35 },
  { 4831, 15, 36, 19, 4, -36 },
  { 4899, 2, 36, 10, 4, -36 },
  { 4908, 27, 26, 35, 4, -26 },
  { 4996, 16, 26, 23, 4, -26 },
  { 5048, 18, 26, 23, 2, -26 },
  { 5107, 17, 37, 23, 4, -26 },
  { 5186, 18, 37, 23, 2, -26 },
  { 5270, 11, 26, 15, 4, -26 },
  { 5306, 14, 26, 18, 2, -26 },
  { 5352, 11, 32, 13, 1, -32 },
  { 5396, 17, 26, 23, 3, -26 },
  { 5452, 18, 26, 18, 0, -26 },
  { 5511, 28, 26, 29, 1, -26 },
  { 5602, 17, 26, 19, 1, -26 },
  { 5658, 18, 38, 18, 0, -26 },
  { 5744, 14, 26, 16, 1, -26 },
  { 5790, 13, 42, 17, 2, -34 },
  { 5859, 3, 49, 21, 9, -37 },
  { 5878, 13, 42, 17, 2, -34 },
  { 5947, 18, 5, 22, 2, -19 },
};

const GFXfont NotoSans_Condensed_Light48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light48pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_CONDENSED_LIGHT48PT7B_H_
