#ifndef _NOTOSANS_CONDENSED_LIGHT69PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light69pt7bBitmaps[] PROGMEM = {
  0x00, 0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x1C, 0x71, 0xC7, 0x1C, 0x71, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0xFB, 0xFF,
  0xFE, 0xF8, 0x80, 0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7, 0x81,
  0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70, 0x1E, 0xE0, 0x1D, 0xC0, 0x3B,
  0x80, 0x77, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0,
  0x1C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x1C, 0x01,
  0xE0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x38, 0x03, 0x80, 0x3F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x03,
  0x80, 0x00, 0x78, 0x03, 0x80, 0x00, 0x70, 0x03, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x00, 0xE0, 0x07,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x1E, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xC0, 0x1C,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x3C,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x3F, 0x1C, 0x1E, 0x1E, 0x0E, 0x03,
  0x1E, 0x07, 0x00, 0x0F, 0x03, 0x80, 0x0F, 0x01, 0xC0, 0x07, 0x80, 0xE0,
  0x03, 0xC0, 0x70, 0x01, 0xE0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0E,
  0x00, 0x3C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x03, 0xE0,
  0xE0, 0x00, 0xF8, 0x70, 0x00, 0x3F, 0x38, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x73, 0xF0, 0x00, 0x38, 0x7C, 0x00, 0x1C, 0x1F,
  0x00, 0x0E, 0x07, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x80, 0xF0, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x07, 0x00, 0x1C,
  0x03, 0x80, 0x0E, 0x03, 0xC0, 0x07, 0x01, 0xE0, 0x03, 0x81, 0xEC, 0x01,
  0xC1, 0xE7, 0xE0, 0xE3, 0xF3, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x07, 0xFE,
  0x00, 0x03, 0x80, 0x07, 0x87, 0x80, 0x03, 0xC0, 0x03, 0x81, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0xF0, 0x00,
  0xE0, 0x1E, 0x00, 0x70, 0x00, 0x70, 0x07, 0x00, 0x78, 0x00, 0x38, 0x03,
  0x80, 0x38, 0x00, 0x3C, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x00, 0xE0, 0x1E,
  0x00, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x00, 0xE0, 0x07,
  0x03, 0xC0, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x00, 0x38, 0x01, 0xC1, 0xE0,
  0x00, 0x1E, 0x00, 0xE0, 0xE0, 0x00, 0x0F, 0x00, 0x70, 0x70, 0x7F, 0x03,
  0x80, 0x38, 0x78, 0x7F, 0xC1, 0xC0, 0x3C, 0x38, 0x7F, 0xF0, 0xE0, 0x1E,
  0x3C, 0x78, 0x38, 0x70, 0x0E, 0x1C, 0x38, 0x1E, 0x1C, 0x07, 0x0E, 0x1C,
  0x07, 0x0F, 0x07, 0x0F, 0x1C, 0x03, 0xC3, 0xC7, 0x87, 0x0E, 0x00, 0xE1,
  0xFF, 0x87, 0x87, 0x00, 0x70, 0x7F, 0x83, 0x83, 0x80, 0x38, 0x0F, 0x81,
  0xC1, 0xC0, 0x1C, 0x00, 0x01, 0xE1, 0xE0, 0x0E, 0x00, 0x00, 0xE0, 0xF0,
  0x07, 0x00, 0x00, 0xF0, 0x78, 0x03, 0x80, 0x00, 0x70, 0x3C, 0x01, 0xE0,
  0x00, 0x38, 0x1E, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x78, 0x00, 0x1C,
  0x07, 0x80, 0x38, 0x00, 0x1E, 0x03, 0xC0, 0x1C, 0x00, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x07, 0x00, 0x70, 0x07, 0x00, 0x07, 0x00, 0x38, 0x03, 0x80,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x01, 0xC0,
  0x07, 0x80, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x00, 0xF0,
  0x78, 0x00, 0x70, 0x00, 0x3C, 0x78, 0x00, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x38, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE3,
  0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x03, 0xC1,
  0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x1F, 0x0F,
  0x00, 0x1E, 0x1E, 0x0F, 0x80, 0x1C, 0x3C, 0x07, 0x80, 0x1C, 0x78, 0x03,
  0xC0, 0x3C, 0x78, 0x01, 0xE0, 0x3C, 0xF0, 0x01, 0xF0, 0x3C, 0xF0, 0x00,
  0xF0, 0x38, 0xF0, 0x00, 0x78, 0x78, 0xF0, 0x00, 0x7C, 0x78, 0xF0, 0x00,
  0x3C, 0xF0, 0xE0, 0x00, 0x1E, 0xF0, 0xF0, 0x00, 0x0F, 0xE0, 0xF0, 0x00,
  0x0F, 0xE0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x0F, 0xE0, 0x78, 0x00, 0x1F, 0xF0, 0x78, 0x00, 0x3E, 0xF0, 0x3C, 0x00,
  0x7C, 0x78, 0x3F, 0x01, 0xF8, 0x7C, 0x1F, 0xFF, 0xF0, 0x3E, 0x0F, 0xFF,
  0xE0, 0x1E, 0x03, 0xFF, 0x80, 0x1F, 0x00, 0x78, 0x00, 0x00, 0xFF, 0xDE,
  0xF7, 0xB9, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00, 0x7C,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0xF8, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x30, 0x1C, 0x07, 0xFC, 0x38, 0x7F, 0xFF, 0x77, 0xFD, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0xE3, 0x80, 0x03, 0xC7, 0x80, 0x0F, 0x07, 0x80, 0x1E, 0x07, 0x00, 0x78,
  0x0F, 0x01, 0xE0, 0x0F, 0x01, 0xC0, 0x1C, 0x00, 0x80, 0x10, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x78, 0xF3, 0xE7, 0x8F, 0x1E, 0x3C, 0xF1,
  0xE3, 0xC7, 0x0E, 0x3C, 0x70, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x7C,
  0x0F, 0x80, 0x78, 0x03, 0xE0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC7, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x39, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x07,
  0x83, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x7C, 0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0,
  0xFB, 0xC3, 0xE7, 0x8F, 0x8F, 0x3E, 0x1F, 0xF8, 0x3D, 0xC0, 0x79, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0xFE,
  0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x07, 0xE0,
  0x0F, 0x81, 0xC0, 0x03, 0xE0, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x0F, 0xFD, 0xFF, 0x0F,
  0xC0, 0x0F, 0xC7, 0x80, 0x01, 0xE1, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE6, 0x00, 0x03, 0xE3, 0xE0,
  0x07, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x0F, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0xE0, 0xE0, 0x00,
  0x07, 0x83, 0x80, 0x00, 0x3C, 0x0E, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07,
  0x80, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x70, 0x03, 0x80, 0x03, 0xC0, 0x0E,
  0x00, 0x0E, 0x00, 0x38, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x03, 0x80,
  0x0E, 0x00, 0x0E, 0x00, 0x78, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x0F,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x38, 0x07, 0x00,
  0x00, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x3F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x71, 0xFC, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x30, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0xC0,
  0x00, 0xF8, 0xF0, 0x03, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x01, 0x80, 0x0F, 0x0F, 0xFC, 0x07, 0x0F,
  0xFF, 0x83, 0x8F, 0xFF, 0xE1, 0xCF, 0x01, 0xF8, 0xEE, 0x00, 0x3C, 0x76,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0x9F, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x07,
  0x78, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x87, 0x80, 0x03, 0xC3, 0xE0,
  0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x8F, 0xF0, 0x1F, 0x00, 0x7E, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00,
  0x07, 0x1E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C,
  0x00, 0x0F, 0x07, 0x80, 0x07, 0x81, 0xF0, 0x03, 0xC0, 0x3E, 0x01, 0xF0,
  0x07, 0xC0, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0x3F, 0x00, 0x3F,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x83, 0xC0, 0x01, 0xF1,
  0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x07,
  0xC1, 0xF8, 0x07, 0xE0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xF0, 0x0F, 0x81, 0xF0, 0x03, 0xE0,
  0xF0, 0x00, 0xF0, 0xF8, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x1C, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7D, 0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x9E,
  0x00, 0x1F, 0xCF, 0x80, 0x1D, 0xE3, 0xF0, 0x3C, 0xF0, 0xFF, 0xFE, 0x78,
  0x3F, 0xFC, 0x3C, 0x07, 0xFC, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x80, 0x3F, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x77, 0xFF, 0xFF,
  0xFD, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x90, 0x0E, 0x1F, 0x1F,
  0x1F, 0x1F, 0x1F, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x0F, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF,
  0xE0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x70, 0x07, 0xC4, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3C,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00,
  0x00, 0x38, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x00, 0x07,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x00, 0x00, 0xE1, 0xE0,
  0x00, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xFF, 0xE0, 0x1C, 0x70, 0x01, 0xFF,
  0xF0, 0x0E, 0x78, 0x01, 0xF0, 0x78, 0x07, 0x38, 0x01, 0xE0, 0x3C, 0x03,
  0xDC, 0x01, 0xE0, 0x1E, 0x01, 0xFE, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0x00,
  0xF0, 0x07, 0x80, 0x3F, 0x80, 0x70, 0x03, 0xC0, 0x1F, 0x80, 0x38, 0x01,
  0xE0, 0x0F, 0xC0, 0x3C, 0x00, 0xF0, 0x07, 0xE0, 0x1E, 0x00, 0x70, 0x03,
  0xF0, 0x0F, 0x00, 0x38, 0x01, 0xF8, 0x07, 0x00, 0x1C, 0x00, 0xFC, 0x03,
  0x80, 0x0E, 0x00, 0x7E, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0x00, 0xE0, 0x03,
  0x80, 0x1F, 0x80, 0x70, 0x01, 0xC0, 0x0F, 0xC0, 0x38, 0x01, 0xE0, 0x0F,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x70, 0x0F, 0x00, 0x78, 0x03, 0xB8, 0x07,
  0x80, 0x3C, 0x01, 0xDC, 0x01, 0xC0, 0x3F, 0x01, 0xEF, 0x00, 0xF0, 0x1B,
  0x80, 0xE7, 0x80, 0x3C, 0x1C, 0xE0, 0xF1, 0xC0, 0x1F, 0xFC, 0x7F, 0xF0,
  0xE0, 0x07, 0xFC, 0x1F, 0xF0, 0x78, 0x01, 0xFC, 0x07, 0xF0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x00,
  0x3D, 0xC0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00,
  0x0F, 0x1C, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0x87, 0x80, 0x00,
  0x03, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xE0, 0x00, 0x00, 0xF0, 0x78, 0x00,
  0x00, 0x70, 0x3C, 0x00, 0x00, 0x78, 0x0E, 0x00, 0x00, 0x3C, 0x07, 0x80,
  0x00, 0x1C, 0x03, 0xC0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0x80, 0x1E, 0x00, 0x03, 0xC0, 0x07,
  0x00, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0x80,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x3C, 0x1E,
  0x00, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80, 0x00, 0x03, 0xC7,
  0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x83, 0xC0, 0x07, 0xF0, 0xF0, 0x00,
  0x7E, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x3C, 0x03, 0xFC, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x3C, 0x00, 0x3F, 0x0F, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0x3C,
  0x00, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0xE0, 0x3F, 0x00, 0x02, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x02, 0x01, 0xFC, 0x01, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x01, 0xE0,
  0x0F, 0xF8, 0x0F, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x1F, 0x83, 0xC0, 0x00,
  0x7E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00, 0x1E,
  0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0xFB, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0xF8, 0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x7C, 0x3C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0xFC, 0x0F, 0x00, 0x1F, 0xC0, 0x78, 0x1F, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x01, 0xFC, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0x06, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07,
  0x78, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x07,
  0x3C, 0x00, 0x00, 0x07, 0x3E, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07,
  0x1F, 0x00, 0x00, 0x07, 0x0F, 0x80, 0x00, 0x07, 0x0F, 0xC0, 0x00, 0x07,
  0x07, 0xE0, 0x00, 0x07, 0x03, 0xF0, 0x00, 0x07, 0x01, 0xFE, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xCF,
  0xF0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x81, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFA, 0x07, 0xCF, 0xFF, 0x3F,
  0xF8, 0xFF, 0x80, 0x70, 0x00, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xCF,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F,
  0x0F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00,
  0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x3C,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x1E, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00, 0xF1, 0xE0,
  0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3E, 0x00, 0x03, 0xDF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0xC7, 0xC0, 0x03, 0xE0, 0xF0, 0x00,
  0xF8, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0,
  0x0F, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFD, 0xC0, 0x00, 0x00, 0x1D, 0xFB,
  0xC0, 0x00, 0x00, 0x3B, 0xF7, 0x80, 0x00, 0x00, 0xF7, 0xEF, 0x00, 0x00,
  0x01, 0xEF, 0xCE, 0x00, 0x00, 0x03, 0x9F, 0x9E, 0x00, 0x00, 0x0F, 0x3F,
  0x3C, 0x00, 0x00, 0x1E, 0x7E, 0x38, 0x00, 0x00, 0x38, 0xFC, 0x78, 0x00,
  0x00, 0xF1, 0xF8, 0xF0, 0x00, 0x01, 0xE3, 0xF0, 0xE0, 0x00, 0x03, 0x87,
  0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0xC3, 0xC0, 0x00, 0x1E, 0x1F, 0x83, 0x80,
  0x00, 0x38, 0x3F, 0x07, 0x80, 0x00, 0xF0, 0x7E, 0x0F, 0x00, 0x01, 0xE0,
  0xFC, 0x0E, 0x00, 0x03, 0x81, 0xF8, 0x1E, 0x00, 0x0F, 0x03, 0xF0, 0x3C,
  0x00, 0x1E, 0x07, 0xE0, 0x38, 0x00, 0x38, 0x0F, 0xC0, 0x78, 0x00, 0xF0,
  0x1F, 0x80, 0xF0, 0x01, 0xE0, 0x3F, 0x00, 0xE0, 0x03, 0x80, 0x7E, 0x01,
  0xE0, 0x0F, 0x00, 0xFC, 0x03, 0xC0, 0x1E, 0x01, 0xF8, 0x03, 0x80, 0x38,
  0x03, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0xE0, 0x0F, 0x01, 0xE0, 0x0F, 0xC0,
  0x0E, 0x03, 0x80, 0x1F, 0x80, 0x1E, 0x0F, 0x00, 0x3F, 0x00, 0x3C, 0x1E,
  0x00, 0x7E, 0x00, 0x38, 0x38, 0x00, 0xFC, 0x00, 0x78, 0x70, 0x01, 0xF8,
  0x00, 0xF1, 0xE0, 0x03, 0xF0, 0x00, 0xE3, 0x80, 0x07, 0xE0, 0x01, 0xE7,
  0x00, 0x0F, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0x80, 0x07, 0xB8, 0x00, 0x3F,
  0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0E, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xBC, 0x00, 0x00, 0xFD, 0xE0, 0x00, 0x07, 0xE7, 0x80,
  0x00, 0x3F, 0x3C, 0x00, 0x01, 0xF8, 0xF0, 0x00, 0x0F, 0xC7, 0x80, 0x00,
  0x7E, 0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x83, 0xC0, 0x00, 0xFC,
  0x1E, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x3F, 0x03, 0xC0, 0x01, 0xF8, 0x0F,
  0x00, 0x0F, 0xC0, 0x78, 0x00, 0x7E, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0x00,
  0x1F, 0x80, 0x3C, 0x00, 0xFC, 0x01, 0xE0, 0x07, 0xE0, 0x07, 0x80, 0x3F,
  0x00, 0x3C, 0x01, 0xF8, 0x00, 0xF0, 0x0F, 0xC0, 0x07, 0x80, 0x7E, 0x00,
  0x1E, 0x03, 0xF0, 0x00, 0xF0, 0x1F, 0x80, 0x03, 0xC0, 0xFC, 0x00, 0x1E,
  0x07, 0xE0, 0x00, 0x78, 0x3F, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x0F, 0x0F,
  0xC0, 0x00, 0x78, 0x7E, 0x00, 0x01, 0xE3, 0xF0, 0x00, 0x0F, 0x1F, 0x80,
  0x00, 0x3C, 0xFC, 0x00, 0x01, 0xE7, 0xE0, 0x00, 0x07, 0xBF, 0x00, 0x00,
  0x3D, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x01,
  0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x0F, 0x80, 0x00, 0x07, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x7C, 0x00, 0x00, 0x0F, 0x1E, 0x00,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x1E, 0x07, 0x80, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x07, 0x80,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xF0, 0x0F, 0xF8, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0xF8, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x00,
  0x07, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00, 0x3C, 0x7C, 0x00,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79,
  0xE0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F, 0x9E, 0x00, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x07, 0x80, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F,
  0x80, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xC0, 0x3F, 0xE0, 0xF0, 0x01, 0xF8, 0x3C,
  0x00, 0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x0F,
  0xC0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0xF8, 0x00, 0xF0, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x0F, 0x00, 0x1E,
  0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC1,
  0xF8, 0x01, 0xE1, 0xF0, 0x00, 0x10, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE6, 0x00, 0x03, 0xE3, 0xE0,
  0x07, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x0F, 0x8F, 0x00, 0x00,
  0x78, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7C, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7A, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x01,
  0xC0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x00, 0x01,
  0xE0, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x1C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xDE, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0x1E, 0x00,
  0x0F, 0x38, 0x00, 0x1E, 0x07, 0x80, 0x03, 0x8F, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0xE3, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x70, 0x00, 0xF0, 0x1E,
  0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x03, 0xC0, 0x07, 0x07, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xC1, 0xE0, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x38, 0x01, 0xE0,
  0x0F, 0x00, 0x3C, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x1E,
  0x00, 0x78, 0x03, 0x80, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xE0, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x00, 0x3C, 0x07, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xC0, 0x1E,
  0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x03, 0x81, 0xE0, 0x00, 0xF0, 0x3C, 0x00,
  0xE0, 0x78, 0x00, 0x1E, 0x0E, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0x80,
  0x0F, 0x07, 0x80, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xC0, 0x00, 0x78, 0x78,
  0x00, 0x70, 0xF0, 0x00, 0x0E, 0x1E, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC7,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0xF0, 0x00, 0x39, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7B, 0x80, 0x00, 0xF7, 0x80, 0x00,
  0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x70, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00,
  0x78, 0x1E, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3C, 0x07, 0xC0, 0x03, 0xC0,
  0x1E, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x0F, 0x0F, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x3C, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x07, 0xC0,
  0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x3E, 0x1E, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0xF8,
  0xF0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x1E, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x01,
  0xE0, 0x03, 0xC0, 0x3C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x38, 0x00,
  0x1E, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x39, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x0F, 0x07, 0x00, 0x00, 0xE0, 0x78, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0,
  0x3C, 0x00, 0x3C, 0x01, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x3C, 0x38, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x07,
  0xC0, 0x7C, 0x08, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xE3, 0xC7, 0xE0, 0x0F, 0x3E, 0x00,
  0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x37, 0x78, 0x01, 0xDD, 0xF0, 0x0E,
  0x73, 0xF9, 0xF1, 0xC7, 0xFF, 0x87, 0x0F, 0xFC, 0x1C, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC1, 0xFF, 0x00, 0xF0, 0xFF, 0xF0, 0x3C, 0xFF, 0xFE, 0x0F, 0x3C,
  0x0F, 0xC3, 0xDC, 0x00, 0xF8, 0xFE, 0x00, 0x1E, 0x3F, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0xF3, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x3C, 0xF8,
  0x00, 0x0F, 0x3F, 0x00, 0x07, 0xCF, 0xE0, 0x01, 0xE3, 0xDC, 0x00, 0xF8,
  0xE7, 0x80, 0xFC, 0x38, 0xFF, 0xFE, 0x0E, 0x1F, 0xFF, 0x03, 0x83, 0xFF,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x0F, 0xC0, 0x60, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0xC1, 0xFF,
  0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x03, 0xFE,
  0x0F, 0x03, 0xFF, 0xC3, 0xC1, 0xFF, 0xFC, 0xF0, 0xFC, 0x0F, 0x3C, 0x3C,
  0x00, 0xEF, 0x1E, 0x00, 0x1F, 0xCF, 0x80, 0x03, 0xF3, 0xC0, 0x00, 0xFC,
  0xF0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x7D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xF7, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xCF,
  0x00, 0x03, 0xF1, 0xE0, 0x01, 0xFC, 0x7C, 0x00, 0xEF, 0x0F, 0x80, 0x7B,
  0xC1, 0xFF, 0xFC, 0x70, 0x3F, 0xFE, 0x1C, 0x07, 0xFE, 0x07, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F,
  0xC0, 0xF8, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x1E, 0x3C, 0x00, 0x0E, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0x78, 0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x02, 0x0F, 0xC0, 0x0E, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x0F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x1F, 0xFE,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0x81, 0xC0, 0xFF, 0xF8, 0xF0, 0x7F, 0xFF, 0x3C,
  0x3F, 0x03, 0xCF, 0x1F, 0x00, 0x3B, 0xC7, 0x80, 0x07, 0xF3, 0xE0, 0x00,
  0xFC, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07,
  0xCF, 0x00, 0x03, 0xF3, 0xC0, 0x00, 0xFC, 0x78, 0x00, 0x7F, 0x1F, 0x00,
  0x3B, 0xC3, 0xE0, 0x1C, 0xF0, 0x7F, 0xFF, 0x3C, 0x0F, 0xFF, 0x8F, 0x01,
  0xFF, 0x83, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x7C, 0x30, 0x00, 0x3E, 0x0F, 0x00, 0x3F, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x3F, 0xE0, 0xF0, 0xFF, 0xF1, 0xE7,
  0xFF, 0xF3, 0xCF, 0x03, 0xE7, 0xB8, 0x03, 0xEF, 0xE0, 0x03, 0xDF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x70, 0xF7, 0xFF, 0xFF, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0x80,
  0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0F, 0x03, 0xE7, 0xFC, 0xFF, 0x1F, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xCF, 0x00,
  0x1E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0xF0,
  0x3C, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xC7, 0x80, 0x0F, 0x1E, 0x00, 0x3C, 0xFC,
  0x00, 0xF7, 0xF0, 0x03, 0xDD, 0xE0, 0x0F, 0xE7, 0x80, 0x3F, 0x0F, 0x00,
  0xFC, 0x3E, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xC0, 0xF0,
  0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0xF0, 0x03,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xFB,
  0xC0, 0x01, 0xEF, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0x80, 0x3F, 0xE0, 0xE1, 0xFF, 0xC0, 0x7F, 0xF0, 0xE3, 0xFF, 0xE0, 0xFF,
  0xF8, 0xE7, 0x81, 0xF1, 0xE0, 0xFC, 0xE6, 0x00, 0xF3, 0x80, 0x3E, 0xFE,
  0x00, 0x7B, 0x00, 0x1E, 0xFC, 0x00, 0x7F, 0x00, 0x1E, 0xF8, 0x00, 0x7E,
  0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0xE0, 0x7F, 0xC1, 0xC3, 0xFF, 0xE3, 0x8F, 0xFF, 0xE7,
  0x3E, 0x07, 0xCE, 0x70, 0x07, 0xDD, 0xC0, 0x07, 0xBB, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80,
  0x3F, 0x01, 0xF0, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x07, 0xC3, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x07,
  0x8F, 0x00, 0x01, 0xE3, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x00,
  0x1E, 0x03, 0xF0, 0x1F, 0x00, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x7F, 0xC0, 0x38, 0x3F, 0xFC,
  0x0E, 0x1F, 0xFF, 0x83, 0x8F, 0x03, 0xF0, 0xE7, 0x00, 0x3E, 0x3B, 0x80,
  0x07, 0x8F, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x3E,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E,
  0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00,
  0x1E, 0xF8, 0x00, 0x0F, 0x3F, 0x00, 0x03, 0xCF, 0xC0, 0x01, 0xE3, 0xF8,
  0x00, 0x78, 0xF7, 0x00, 0x3C, 0x3D, 0xE0, 0x3F, 0x0F, 0x3F, 0xFF, 0x83,
  0xC7, 0xFF, 0xC0, 0xF0, 0x7F, 0xE0, 0x3C, 0x03, 0xC0, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x81, 0xC0, 0xFF, 0xF8, 0xF0, 0x7F, 0xFF, 0x3C, 0x3F, 0x03, 0xCF,
  0x0F, 0x80, 0x3B, 0xC7, 0x80, 0x07, 0xF3, 0xE0, 0x00, 0xFC, 0xF0, 0x00,
  0x3F, 0x3C, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0x78, 0x00, 0x03, 0xDC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x03,
  0xF3, 0xC0, 0x00, 0xFC, 0x78, 0x00, 0x6F, 0x1F, 0x00, 0x3B, 0xC3, 0xE0,
  0x1C, 0xF0, 0x7F, 0xFE, 0x3C, 0x0F, 0xFF, 0x0F, 0x01, 0xFF, 0x83, 0xC0,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0xE0, 0x7F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xE7,
  0xE7, 0x80, 0xE7, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0x3F,
  0xFF, 0xE7, 0xE0, 0x1E, 0x78, 0x00, 0x4F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x80, 0x03, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x38, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xBC, 0x00, 0x37, 0x7C, 0x00, 0xEE,
  0x7C, 0x07, 0x9C, 0xFF, 0xFE, 0x38, 0xFF, 0xF8, 0x70, 0x7F, 0xE0, 0xE0,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x38, 0x1C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0x81,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x0E, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0xF0, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x00, 0x0E, 0x03, 0xC0, 0x03, 0xC0, 0xF0, 0x00,
  0xF0, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x78, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3E,
  0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x70, 0x00, 0x7E, 0x00, 0x0F,
  0x78, 0x00, 0x7E, 0x00, 0x0E, 0x78, 0x00, 0x7F, 0x00, 0x0E, 0x78, 0x00,
  0x77, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0x00, 0x1E, 0x38, 0x00, 0xF7, 0x00,
  0x1E, 0x3C, 0x00, 0xE7, 0x80, 0x1C, 0x3C, 0x00, 0xE7, 0x80, 0x3C, 0x3C,
  0x01, 0xE3, 0x80, 0x3C, 0x1C, 0x01, 0xE3, 0x80, 0x3C, 0x1E, 0x01, 0xC3,
  0xC0, 0x38, 0x1E, 0x01, 0xC3, 0xC0, 0x38, 0x1E, 0x03, 0xC1, 0xC0, 0x78,
  0x0E, 0x03, 0xC1, 0xC0, 0x78, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x0F, 0x03,
  0x81, 0xE0, 0x70, 0x0F, 0x07, 0x80, 0xE0, 0xF0, 0x07, 0x07, 0x80, 0xE0,
  0xF0, 0x07, 0x87, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0xF0, 0xE0, 0x07,
  0x8F, 0x00, 0xF1, 0xE0, 0x07, 0x8F, 0x00, 0x71, 0xE0, 0x03, 0x8E, 0x00,
  0x71, 0xE0, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x03, 0xCE, 0x00, 0x79, 0xC0,
  0x03, 0xDE, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x0F,
  0x3E, 0x00, 0x07, 0x8F, 0x00, 0x07, 0x87, 0xC0, 0x03, 0xC1, 0xE0, 0x03,
  0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E,
  0x3C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC7, 0x80,
  0x01, 0xE3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x3C, 0x00,
  0x78, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x1E,
  0x07, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x70, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x0F, 0x07, 0x00, 0x03, 0x83, 0x80, 0x01, 0xC3, 0xC0, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x80, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x1F,
  0xF0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x4F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xE3, 0xFE, 0x0F, 0xC0, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xE8, 0x00, 0x1F, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 6, 50, 15, 5, -49 },
  { 39, 15, 18, 24, 4, -49 },
  { 73, 32, 49, 35, 1, -49 },
  { 269, 25, 56, 32, 3, -52 },
  { 444, 41, 51, 47, 3, -50 },
  { 706, 32, 51, 36, 3, -50 },
  { 910, 5, 18, 13, 4, -49 },
  { 922, 14, 60, 19, 3, -49 },
  { 1027, 14, 60, 19, 2, -49 },
  { 1132, 23, 23, 29, 3, -52 },
  { 1199, 27, 33, 32, 2, -41 },
  { 1311, 7, 17, 14, 3, -8 },
  { 1326, 16, 4, 20, 2, -21 },
  { 1334, 5, 7, 15, 5, -6 },
  { 1339, 22, 49, 24, 1, -49 },
  { 1474, 25, 51, 32, 3, -50 },
  { 1634, 15, 49, 32, 5, -49 },
  { 1726, 25, 50, 32, 3, -50 },
  { 1883, 25, 51, 32, 3, -50 },
  { 2043, 30, 50, 32, 1, -50 },
  { 2231, 24, 50, 32, 4, -49 },
  { 2381, 25, 51, 32, 4, -50 },
  { 2541, 25, 49, 32, 3, -49 },
  { 2695, 26, 51, 32, 3, -50 },
  { 2861, 25, 51, 32, 3, -50 },
  { 3021, 5, 38, 15, 5, -37 },
  { 3045, 8, 46, 15, 2, -37 },
  { 3091, 27, 31, 32, 2, -40 },
  { 3196, 26, 18, 32, 3, -33 },
  { 3255, 26, 31, 32, 3, -40 },
  { 3356, 20, 51, 23, 1, -50 },
  { 3484, 41, 55, 49, 4, -49 },
  { 3766, 33, 49, 33, 0, -49 },
  { 3969, 26, 49, 35, 6, -49 },
  { 4129, 28, 51, 34, 4, -50 },
  { 4308, 29, 49, 39, 6, -49 },
  { 4486, 21, 49, 30, 6, -49 },
  { 4615, 21, 49, 28, 6, -49 },
  { 4744, 32, 51, 41, 4, -50 },
  { 4948, 28, 49, 40, 6, -49 },
  { 5120, 13, 49, 19, 3, -49 },
  { 5200, 14, 62, 15, -4, -49 },
  { 5309, 26, 49, 32, 6, -49 },
  { 5469, 21, 49, 28, 6, -49 },
  { 5598, 39, 49, 51, 6, -49 },
  { 5837, 29, 49, 41, 6, -49 },
  { 6015, 34, 51, 42, 4, -50 },
  { 6232, 24, 49, 32, 6, -49 },
  { 6379, 34, 62, 42, 4, -50 },
  { 6643, 26, 49, 33, 6, -49 },
  { 6803, 25, 51, 31, 3, -50 },
  { 6963, 27, 49, 28, 1, -49 },
  { 7129, 29, 50, 39, 5, -49 },
  { 7311, 32, 49, 32, 0, -49 },
  { 7507, 50, 49, 52, 1, -49 },
  { 7814, 29, 49, 29, 0, -49 },
  { 7992, 28, 49, 28, 0, -49 },
  { 8164, 25, 49, 28, 2, -49 },
  { 8318, 13, 60, 22, 6, -49 },
  { 8416, 22, 49, 24, 1, -49 },
  { 8551, 14, 60, 22, 2, -49 },
  { 8656, 28, 26, 32, 2, -49 },
  { 8747, 29, 3, 29, 0, 6 },
  { 8758, 12, 11, 17, 3, -53 },
  { 8775, 22, 38, 30, 3, -37 },
  { 8880, 26, 53, 34, 5, -52 },
  { 9053, 21, 38, 26, 3, -37 },
  { 9153, 26, 53, 34, 3, -52 },
  { 9326, 24, 38, 31, 3, -37 },
  { 9440, 19, 53, 18, 1, -53 },
  { 9566, 26, 54, 34, 3, -37 },
  { 9742, 23, 52, 33, 5, -52 },
  { 9892, 5, 50, 14, 5, -50 },
  { 9924, 11, 67, 14, -1, -50 },
  { 10017, 22, 52, 28, 5, -52 },
  { 10160, 4, 52, 14, 5, -52 },
  { 10186, 40, 37, 50, 5, -37 },
  { 10371, 23, 37, 33, 5, -37 },
  { 10478, 26, 38, 33, 3, -37 },
  { 10602, 26, 53, 34, 5, -37 },
  { 10775, 26, 53, 34, 3, -37 },
  { 10948, 16, 37, 22, 5, -37 },
  { 11022, 20, 38, 25, 3, -37 },
  { 11117, 16, 46, 18, 1, -45 },
  { 11209, 23, 38, 33, 5, -37 },
  { 11319, 26, 37, 26, 0, -37 },
  { 11440, 40, 37, 42, 1, -37 },
  { 11625, 25, 37, 27, 1, -37 },
  { 11741, 25, 54, 26, 1, -37 },
  { 11910, 19, 37, 23, 2, -37 },
  { 11998, 19, 60, 25, 3, -49 },
  { 12141, 4, 70, 30, 13, -53 },
  { 12176, 19, 60, 25, 3, -49 },
  { 12319, 26, 7, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_Light69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light69pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_CONDENSED_LIGHT69PT7B_H_
