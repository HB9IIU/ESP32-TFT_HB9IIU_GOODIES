#ifndef _NOTOSANS_CONDENSED_LIGHT23PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light23pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x0B, 0xCA, 0x52, 0x94, 0xA4, 0x08, 0x81, 0x10,
  0x22, 0x04, 0x47, 0xFE, 0x11, 0x04, 0x40, 0x88, 0x11, 0x02, 0x23, 0xFF,
  0x08, 0x81, 0x10, 0x46, 0x08, 0x81, 0x10, 0x08, 0x3E, 0x6B, 0xC8, 0x88,
  0x88, 0xC8, 0x68, 0x38, 0x0E, 0x0B, 0x09, 0x09, 0x09, 0x8B, 0xFE, 0x08,
  0x08, 0x30, 0x21, 0x61, 0x08, 0x84, 0x22, 0x20, 0x88, 0x82, 0x22, 0x08,
  0x90, 0x22, 0x5C, 0x8A, 0x49, 0x6A, 0x23, 0x28, 0x81, 0x23, 0x04, 0x8C,
  0x22, 0x20, 0x88, 0x82, 0x12, 0x10, 0x70, 0x18, 0x06, 0x81, 0x88, 0x21,
  0x06, 0x20, 0x4C, 0x09, 0x00, 0xC0, 0x38, 0x0D, 0x0B, 0x11, 0x43, 0x28,
  0x29, 0x03, 0x20, 0x62, 0x16, 0x7C, 0x60, 0xD5, 0x50, 0x19, 0x08, 0x84,
  0x23, 0x10, 0x84, 0x21, 0x0C, 0x61, 0x08, 0x61, 0x04, 0x30, 0xC4, 0x22,
  0x31, 0x11, 0x11, 0x11, 0x11, 0x32, 0x24, 0x48, 0x18, 0x10, 0xD3, 0x3C,
  0x18, 0x24, 0x46, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC, 0x20, 0x10,
  0x08, 0x04, 0x02, 0x00, 0x57, 0xA0, 0xF8, 0xC0, 0x03, 0x02, 0x06, 0x04,
  0x04, 0x0C, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40, 0xC0,
  0x18, 0x3E, 0x62, 0x41, 0xC1, 0xC1, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC1,
  0xC1, 0x41, 0x43, 0x62, 0x3C, 0x3B, 0xF7, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0x7E, 0x83, 0x03, 0x01, 0x01, 0x03, 0x02, 0x02,
  0x04, 0x0C, 0x18, 0x10, 0x20, 0x60, 0xC0, 0xFF, 0x38, 0xEE, 0x83, 0x01,
  0x01, 0x01, 0x02, 0x06, 0x38, 0x06, 0x03, 0x01, 0x01, 0x01, 0x01, 0x82,
  0xFC, 0x01, 0x00, 0xC0, 0x30, 0x14, 0x05, 0x02, 0x41, 0x90, 0x44, 0x31,
  0x08, 0x44, 0x11, 0x04, 0xFF, 0xC0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x7F,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x7C, 0xC6, 0x01, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x82, 0xFC, 0x06, 0x0F, 0x88, 0x0C, 0x04, 0x02, 0x03, 0x01, 0xBC,
  0xA3, 0x60, 0xB0, 0x58, 0x3C, 0x12, 0x09, 0x04, 0xC6, 0x3E, 0x00, 0xFF,
  0x01, 0x01, 0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x30, 0x20, 0x1C, 0x3B, 0x10, 0xD8, 0x2C, 0x12, 0x09, 0x88, 0x68,
  0x1C, 0x13, 0x10, 0xD0, 0x28, 0x1C, 0x0F, 0x04, 0x86, 0x3E, 0x00, 0x18,
  0x7E, 0x42, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x67, 0x39, 0x01, 0x01,
  0x03, 0x02, 0x04, 0x78, 0xC0, 0x30, 0x50, 0x00, 0x15, 0xE8, 0x01, 0x83,
  0x87, 0x0E, 0x0C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x40, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x18,
  0x30, 0x60, 0xC0, 0x40, 0x00, 0x39, 0xF8, 0x18, 0x10, 0x20, 0x41, 0x86,
  0x08, 0x20, 0x41, 0x83, 0x00, 0x00, 0x18, 0x30, 0x0F, 0xE0, 0x40, 0x42,
  0x00, 0x98, 0x02, 0x43, 0xC5, 0x11, 0x1C, 0xC4, 0x62, 0x11, 0x88, 0x46,
  0x21, 0x18, 0x8C, 0x62, 0x33, 0x47, 0x79, 0x00, 0x04, 0x00, 0x08, 0x00,
  0x10, 0x20, 0x3F, 0x00, 0x0C, 0x01, 0x40, 0x28, 0x05, 0x01, 0x30, 0x22,
  0x04, 0x41, 0x88, 0x21, 0x87, 0xF0, 0x82, 0x30, 0x64, 0x04, 0x80, 0xB0,
  0x14, 0x03, 0xFE, 0x41, 0xA0, 0x50, 0x28, 0x14, 0x0A, 0x09, 0xF8, 0x83,
  0x40, 0xA0, 0x70, 0x38, 0x1C, 0x0A, 0x0D, 0xF8, 0x07, 0x07, 0xF3, 0x01,
  0x80, 0x40, 0x10, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x40,
  0x18, 0x02, 0x00, 0xC1, 0x1F, 0x80, 0xFE, 0x20, 0xC8, 0x1A, 0x02, 0x80,
  0xA0, 0x28, 0x0E, 0x03, 0x80, 0xE0, 0x28, 0x0A, 0x02, 0x81, 0xA0, 0x48,
  0x63, 0xF0, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7F, 0x81, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x7F, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x07, 0x83, 0xFC, 0xC0, 0x30, 0x04,
  0x00, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x3F, 0x00, 0xA0, 0x14, 0x02,
  0xC0, 0x48, 0x09, 0x81, 0x0F, 0xE0, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0xFF, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0xF6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x6F, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x3E, 0x83, 0xC1, 0x21, 0x91, 0x88, 0x84,
  0x82, 0xC1, 0x60, 0xD8, 0x44, 0x23, 0x10, 0x88, 0x64, 0x12, 0x0D, 0x03,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x7F, 0xC0, 0x1E, 0x00, 0xF8, 0x0B, 0x40, 0x5A, 0x02, 0xD8, 0x36,
  0x41, 0x32, 0x09, 0x98, 0xCC, 0x44, 0x62, 0x23, 0x1B, 0x18, 0x50, 0xC2,
  0x86, 0x1C, 0x30, 0x41, 0xC0, 0x70, 0x1A, 0x06, 0x81, 0x90, 0x64, 0x18,
  0x86, 0x21, 0x84, 0x61, 0x18, 0x26, 0x09, 0x81, 0x60, 0x58, 0x0E, 0x03,
  0x06, 0x01, 0xF8, 0x20, 0x46, 0x06, 0x40, 0x24, 0x02, 0xC0, 0x2C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x2C, 0x02, 0x40, 0x24, 0x06, 0x60, 0x43, 0x0C,
  0x1F, 0x80, 0xFC, 0x82, 0x83, 0x81, 0x81, 0x81, 0x83, 0x86, 0xFC, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x06, 0x01, 0xF8, 0x20, 0xC6, 0x06,
  0x40, 0x24, 0x02, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02,
  0x40, 0x24, 0x06, 0x60, 0x43, 0x0C, 0x1F, 0x80, 0x10, 0x01, 0x80, 0x08,
  0x00, 0x40, 0xFE, 0x41, 0x20, 0xD0, 0x28, 0x14, 0x1A, 0x09, 0x0C, 0xF8,
  0x44, 0x21, 0x10, 0x88, 0x24, 0x12, 0x0D, 0x03, 0x1C, 0x7F, 0x40, 0xC0,
  0x80, 0xC0, 0x40, 0x60, 0x38, 0x06, 0x03, 0x01, 0x01, 0x01, 0x03, 0x82,
  0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0E, 0x0D, 0x84,
  0x7C, 0xC0, 0x68, 0x09, 0x03, 0x20, 0x46, 0x08, 0x41, 0x08, 0x61, 0x08,
  0x31, 0x02, 0x60, 0x48, 0x0D, 0x00, 0xA0, 0x1C, 0x03, 0x00, 0x60, 0xC0,
  0x81, 0xA0, 0x60, 0xD0, 0x50, 0x48, 0x28, 0x26, 0x14, 0x11, 0x0B, 0x18,
  0x8C, 0x88, 0x44, 0x44, 0x32, 0x22, 0x19, 0x13, 0x05, 0x8D, 0x02, 0x82,
  0x81, 0x41, 0x40, 0xE0, 0xA0, 0x30, 0x70, 0x18, 0x10, 0x40, 0x88, 0x42,
  0x10, 0xCC, 0x12, 0x07, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x81, 0x20, 0xCC,
  0x21, 0x18, 0x44, 0x1B, 0x03, 0xC0, 0xA0, 0xD8, 0x44, 0x22, 0x21, 0x90,
  0x58, 0x28, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0xFF,
  0x02, 0x06, 0x04, 0x04, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40,
  0xC0, 0x80, 0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88,
  0x8F, 0xC0, 0x40, 0x20, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C,
  0x04, 0x04, 0x02, 0x02, 0x03, 0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x1F, 0x08, 0x0A, 0x05, 0x04, 0x42, 0x22, 0x19, 0x05, 0x03,
  0xFF, 0xC0, 0x84, 0x63, 0x7E, 0x04, 0x08, 0x10, 0x27, 0xD0, 0xC1, 0x83,
  0x07, 0x1B, 0xD0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBE, 0xC2, 0x83, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC2, 0xBC, 0x3E, 0xC1, 0x06, 0x08,
  0x10, 0x20, 0x40, 0xC0, 0x81, 0x81, 0xF0, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x19, 0xFD, 0x0E, 0x83, 0xC1, 0xC0, 0xE0, 0x70, 0x38, 0x1E, 0x0D, 0x06,
  0xC7, 0x3C, 0x80, 0x3E, 0x42, 0x41, 0xC1, 0x81, 0xFF, 0x80, 0x80, 0xC0,
  0x40, 0x61, 0x3F, 0x0E, 0x38, 0xC1, 0x02, 0x04, 0x3E, 0x10, 0x20, 0x40,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x3F, 0xA1, 0xD0, 0x78, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0xC1, 0xA0, 0xD8, 0xE7, 0xB0, 0x18, 0x0C, 0x04,
  0x06, 0x7E, 0x0C, 0x00, 0x81, 0x02, 0x04, 0x08, 0x17, 0xF0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0xC7, 0xFF, 0x80, 0x24, 0x00,
  0x49, 0x24, 0x92, 0x49, 0x24, 0x93, 0xE0, 0x81, 0x02, 0x04, 0x08, 0x10,
  0xE3, 0x44, 0x91, 0x43, 0xC6, 0x89, 0x91, 0x23, 0x42, 0x86, 0xFF, 0xFF,
  0x80, 0xBC, 0xF6, 0x38, 0xE0, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0x41, 0x82, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x10, 0xBF, 0x86, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0x3E, 0x21, 0x90, 0x58,
  0x38, 0x1C, 0x06, 0x03, 0x03, 0xC1, 0xA0, 0x98, 0xC7, 0xC0, 0xBE, 0xC2,
  0x83, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xC2, 0xBC, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x3F, 0xA1, 0xD0, 0x78, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0xC1, 0xA0, 0xD8, 0xE7, 0xB0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xBE,
  0x31, 0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x7F, 0x02, 0x04, 0x0C, 0x06,
  0x07, 0x02, 0x06, 0x0E, 0x17, 0xC0, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x20, 0x83, 0xC0, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x07, 0x1B, 0xD0, 0xC1, 0xA0, 0x90, 0xC8, 0x46, 0x21, 0x10,
  0x98, 0x48, 0x14, 0x0A, 0x06, 0x03, 0x00, 0xC3, 0x0D, 0x0C, 0x24, 0x30,
  0x91, 0xA2, 0x64, 0x88, 0x92, 0x42, 0x49, 0x09, 0x34, 0x38, 0x50, 0x61,
  0xC1, 0x86, 0x06, 0x18, 0x41, 0x11, 0x88, 0x82, 0x81, 0x40, 0x40, 0x70,
  0x28, 0x36, 0x11, 0x18, 0xD8, 0x30, 0xC1, 0xA0, 0x90, 0x4C, 0x62, 0x21,
  0x10, 0x98, 0x28, 0x14, 0x0A, 0x07, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x20,
  0xE0, 0x20, 0x00, 0xFC, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x3F,
  0x1C, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x23, 0x02, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC1, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x31, 0x84, 0x10, 0x41, 0x04, 0x10, 0xC6, 0x20,
  0xF8, 0xC7, 0x80,
};

const GFXglyph NotoSans_Condensed_Light23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 16, 5, 2, -16 },
  { 5, 5, 6, 8, 1, -16 },
  { 9, 11, 16, 12, 0, -16 },
  { 31, 8, 18, 11, 1, -17 },
  { 49, 14, 17, 16, 1, -17 },
  { 79, 11, 17, 12, 1, -17 },
  { 103, 2, 6, 4, 1, -16 },
  { 105, 5, 20, 6, 1, -16 },
  { 118, 4, 20, 6, 1, -16 },
  { 128, 8, 7, 10, 1, -17 },
  { 135, 9, 11, 11, 1, -14 },
  { 148, 2, 6, 5, 1, -3 },
  { 150, 5, 1, 7, 1, -7 },
  { 151, 1, 2, 5, 2, -2 },
  { 152, 8, 16, 8, 0, -16 },
  { 168, 8, 17, 11, 1, -17 },
  { 185, 5, 16, 11, 2, -16 },
  { 195, 8, 17, 11, 1, -17 },
  { 212, 8, 17, 11, 1, -17 },
  { 229, 10, 17, 11, 0, -17 },
  { 251, 8, 16, 11, 1, -16 },
  { 267, 9, 17, 11, 1, -17 },
  { 287, 8, 16, 11, 1, -16 },
  { 303, 9, 17, 11, 1, -17 },
  { 323, 8, 17, 11, 1, -17 },
  { 340, 1, 12, 5, 2, -12 },
  { 342, 2, 15, 5, 1, -12 },
  { 346, 9, 10, 11, 1, -13 },
  { 358, 9, 6, 11, 1, -11 },
  { 365, 9, 10, 11, 1, -13 },
  { 377, 7, 17, 8, 0, -17 },
  { 392, 14, 18, 16, 1, -16 },
  { 424, 11, 16, 11, 0, -16 },
  { 446, 9, 16, 12, 2, -16 },
  { 464, 10, 17, 11, 1, -17 },
  { 486, 10, 16, 13, 2, -16 },
  { 506, 7, 16, 10, 2, -16 },
  { 520, 7, 16, 9, 2, -16 },
  { 534, 11, 17, 14, 1, -17 },
  { 558, 9, 16, 13, 2, -16 },
  { 576, 4, 16, 6, 1, -16 },
  { 584, 4, 20, 5, -1, -16 },
  { 594, 9, 16, 11, 2, -16 },
  { 612, 7, 16, 9, 2, -16 },
  { 626, 13, 16, 17, 2, -16 },
  { 652, 10, 16, 14, 2, -16 },
  { 672, 12, 17, 14, 1, -17 },
  { 698, 8, 16, 11, 2, -16 },
  { 714, 12, 21, 14, 1, -17 },
  { 746, 9, 16, 11, 2, -16 },
  { 764, 8, 17, 10, 1, -17 },
  { 781, 9, 16, 9, 0, -16 },
  { 799, 9, 16, 13, 2, -16 },
  { 817, 11, 16, 11, 0, -16 },
  { 839, 17, 16, 17, 0, -16 },
  { 873, 10, 16, 10, 0, -16 },
  { 893, 9, 16, 9, 0, -16 },
  { 911, 8, 16, 9, 1, -16 },
  { 927, 4, 20, 7, 2, -16 },
  { 937, 8, 16, 8, 0, -16 },
  { 953, 4, 20, 7, 1, -16 },
  { 963, 9, 8, 11, 1, -16 },
  { 972, 10, 1, 10, 0, 2 },
  { 974, 4, 4, 6, 1, -18 },
  { 976, 7, 12, 10, 1, -12 },
  { 987, 8, 17, 11, 2, -17 },
  { 1004, 7, 12, 9, 1, -12 },
  { 1015, 9, 17, 11, 1, -17 },
  { 1035, 8, 12, 10, 1, -12 },
  { 1047, 7, 18, 6, 0, -18 },
  { 1063, 9, 18, 11, 1, -12 },
  { 1084, 7, 17, 11, 2, -17 },
  { 1099, 1, 17, 5, 2, -17 },
  { 1102, 3, 23, 5, 0, -17 },
  { 1111, 7, 17, 9, 2, -17 },
  { 1126, 1, 17, 5, 2, -17 },
  { 1129, 13, 12, 17, 2, -12 },
  { 1149, 7, 12, 11, 2, -12 },
  { 1160, 9, 12, 11, 1, -12 },
  { 1174, 8, 17, 11, 2, -12 },
  { 1191, 9, 17, 11, 1, -12 },
  { 1211, 5, 12, 7, 2, -12 },
  { 1219, 7, 12, 8, 1, -12 },
  { 1230, 6, 15, 6, 0, -15 },
  { 1242, 7, 12, 11, 2, -12 },
  { 1253, 9, 12, 9, 0, -12 },
  { 1267, 14, 12, 14, 0, -12 },
  { 1288, 9, 12, 9, 0, -12 },
  { 1302, 9, 18, 9, 0, -12 },
  { 1323, 6, 12, 8, 1, -12 },
  { 1332, 6, 20, 8, 1, -16 },
  { 1347, 2, 24, 10, 4, -18 },
  { 1353, 6, 20, 8, 1, -16 },
  { 1368, 9, 2, 11, 1, -9 },
};

const GFXfont NotoSans_Condensed_Light23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light23pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_CONDENSED_LIGHT23PT7B_H_
