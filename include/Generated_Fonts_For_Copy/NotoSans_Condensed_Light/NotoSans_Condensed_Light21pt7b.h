#ifndef _NOTOSANS_CONDENSED_LIGHT21PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT21PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 21pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light21pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x54, 0x1C, 0xCE, 0x73, 0x18, 0x80, 0x08, 0x82, 0x40,
  0x90, 0x44, 0x7F, 0xC4, 0x41, 0x10, 0x44, 0x12, 0x3F, 0xF2, 0x20, 0x88,
  0x22, 0x08, 0x82, 0x20, 0x10, 0x10, 0x7E, 0x90, 0x90, 0x90, 0x90, 0x70,
  0x18, 0x16, 0x12, 0x11, 0x13, 0x92, 0xFC, 0x10, 0x10, 0x70, 0xC9, 0x08,
  0x88, 0x88, 0x90, 0x89, 0x08, 0xA0, 0x8A, 0xE9, 0x29, 0x75, 0x10, 0x51,
  0x09, 0x10, 0x91, 0x09, 0x11, 0x09, 0x10, 0xE0, 0x3C, 0x11, 0x04, 0x41,
  0x10, 0x44, 0x0B, 0x03, 0x80, 0xC0, 0x48, 0xA3, 0x28, 0x4A, 0x0C, 0x83,
  0x31, 0xE7, 0xCC, 0xFF, 0x80, 0x12, 0x64, 0x4C, 0x88, 0x88, 0x88, 0x84,
  0x44, 0x23, 0x84, 0x42, 0x22, 0x31, 0x11, 0x13, 0x22, 0x26, 0x48, 0x10,
  0x22, 0x4B, 0xE2, 0x85, 0x11, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10,
  0x10, 0x10, 0x10, 0x5E, 0x80, 0xF0, 0x70, 0x02, 0x08, 0x10, 0x20, 0x81,
  0x02, 0x08, 0x10, 0x60, 0x81, 0x04, 0x08, 0x30, 0x00, 0x3C, 0x46, 0x42,
  0xC2, 0x82, 0x83, 0x83, 0x83, 0x83, 0x83, 0x82, 0xC2, 0x42, 0x46, 0x3C,
  0x37, 0xD9, 0x11, 0x11, 0x11, 0x11, 0x11, 0x10, 0x7C, 0x86, 0x02, 0x02,
  0x02, 0x02, 0x06, 0x04, 0x08, 0x18, 0x10, 0x20, 0x40, 0xC0, 0xFF, 0x7C,
  0x86, 0x02, 0x02, 0x02, 0x06, 0x0C, 0x38, 0x06, 0x02, 0x03, 0x02, 0x02,
  0x86, 0xFC, 0x02, 0x03, 0x01, 0x81, 0x40, 0xA0, 0x90, 0x48, 0x44, 0x62,
  0x21, 0x3F, 0xE0, 0x40, 0x20, 0x10, 0x08, 0x7E, 0x40, 0x40, 0x40, 0x40,
  0xC0, 0xFC, 0x06, 0x02, 0x03, 0x03, 0x03, 0x02, 0x86, 0xFC, 0x1E, 0x20,
  0x40, 0x40, 0xC0, 0x80, 0xBC, 0xC2, 0xC2, 0x83, 0x81, 0x83, 0x42, 0x42,
  0x3C, 0xFF, 0x02, 0x02, 0x02, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10,
  0x10, 0x30, 0x20, 0x60, 0x3C, 0x42, 0xC2, 0x82, 0xC2, 0x46, 0x3C, 0x38,
  0x46, 0xC2, 0x81, 0x81, 0x83, 0xC2, 0x7C, 0x7C, 0x46, 0x82, 0x82, 0x82,
  0x83, 0x83, 0xC7, 0x7E, 0x02, 0x02, 0x02, 0x04, 0x0C, 0x78, 0xD0, 0x00,
  0x1C, 0xD0, 0x00, 0x16, 0xA0, 0x01, 0x06, 0x18, 0x60, 0x80, 0x60, 0x18,
  0x06, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01,
  0x06, 0x18, 0x60, 0x80, 0x7A, 0x10, 0x41, 0x04, 0x10, 0x84, 0x10, 0x82,
  0x00, 0x00, 0x83, 0x00, 0x0F, 0x80, 0x83, 0x08, 0x08, 0x80, 0x24, 0x79,
  0x66, 0x46, 0x22, 0x31, 0x11, 0x88, 0x8C, 0x44, 0x62, 0x65, 0x13, 0x24,
  0x66, 0x20, 0x01, 0x80, 0x06, 0x08, 0x0F, 0x80, 0x0C, 0x03, 0x00, 0xC0,
  0x48, 0x12, 0x04, 0x83, 0x30, 0x84, 0x21, 0x0F, 0xC4, 0x19, 0x02, 0x40,
  0xB0, 0x28, 0x04, 0xFC, 0x86, 0x82, 0x82, 0x82, 0x82, 0x8C, 0xFC, 0x82,
  0x83, 0x83, 0x83, 0x82, 0x86, 0xFC, 0x1F, 0x98, 0x58, 0x08, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0x80, 0x60, 0x30, 0x08, 0x06, 0x01, 0x80, 0x7C, 0xF8,
  0x43, 0x20, 0xD0, 0x28, 0x14, 0x0A, 0x07, 0x03, 0x81, 0xC0, 0xA0, 0x50,
  0x28, 0x24, 0x33, 0xE0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x82, 0x08,
  0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x82, 0x08,
  0x20, 0x82, 0x08, 0x00, 0x1F, 0xCC, 0x16, 0x01, 0x00, 0x40, 0x30, 0x08,
  0x02, 0x0F, 0x80, 0x70, 0x1C, 0x05, 0x01, 0x60, 0x4C, 0x11, 0xFC, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x44, 0xF0, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xE0, 0x83, 0x86, 0x84, 0x88,
  0x98, 0xB0, 0xA0, 0xF0, 0x90, 0x98, 0x88, 0x84, 0x84, 0x82, 0x83, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC0,
  0x3C, 0x03, 0xC0, 0x5E, 0x05, 0xA0, 0x5A, 0x09, 0xB0, 0x99, 0x09, 0x91,
  0x19, 0x91, 0x89, 0x18, 0xA1, 0x8E, 0x18, 0x61, 0x84, 0x10, 0x80, 0xE0,
  0x70, 0x34, 0x1A, 0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0x30, 0x58,
  0x2C, 0x0E, 0x06, 0x1F, 0x08, 0x64, 0x0D, 0x01, 0xC0, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x05, 0x01, 0x40, 0xC8, 0x61, 0xF0, 0xF9, 0x0A,
  0x0C, 0x18, 0x30, 0x61, 0xC6, 0xF9, 0x02, 0x04, 0x08, 0x10, 0x20, 0x00,
  0x1F, 0x08, 0x64, 0x0D, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x05, 0x01, 0x40, 0xC8, 0x61, 0xF0, 0x08, 0x01, 0x00, 0x60, 0x08,
  0xF8, 0x84, 0x82, 0x82, 0x82, 0x82, 0x86, 0xFC, 0x98, 0x88, 0x8C, 0x84,
  0x86, 0x82, 0x83, 0x3E, 0x86, 0x04, 0x08, 0x18, 0x18, 0x0C, 0x06, 0x04,
  0x08, 0x10, 0x30, 0xFF, 0x00, 0xFF, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x7E, 0x80,
  0xF0, 0x24, 0x09, 0x06, 0x41, 0x08, 0x42, 0x10, 0x8C, 0x22, 0x04, 0x81,
  0x20, 0x50, 0x1C, 0x03, 0x00, 0xC0, 0xC1, 0x83, 0x41, 0x82, 0x41, 0x82,
  0x43, 0x82, 0x42, 0x84, 0x62, 0x44, 0x22, 0x44, 0x22, 0x44, 0x24, 0x4C,
  0x34, 0x68, 0x14, 0x28, 0x14, 0x28, 0x14, 0x28, 0x18, 0x30, 0x18, 0x10,
  0x41, 0xA0, 0x88, 0x84, 0x41, 0x40, 0xA0, 0x30, 0x10, 0x14, 0x0A, 0x09,
  0x84, 0x46, 0x32, 0x0B, 0x06, 0x81, 0xA0, 0x90, 0xCC, 0x42, 0x21, 0x20,
  0x50, 0x38, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0xFE, 0x0C,
  0x10, 0x60, 0x81, 0x04, 0x08, 0x20, 0x41, 0x82, 0x0C, 0x10, 0x3F, 0x80,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x81, 0x01,
  0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0x80, 0x80, 0xF1,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x1F, 0x0C, 0x06, 0x05, 0x82,
  0x42, 0x31, 0x09, 0x05, 0x81, 0xFF, 0x80, 0xC8, 0x80, 0x7C, 0x08, 0x18,
  0x30, 0xEE, 0x60, 0xC3, 0x87, 0x0D, 0xE8, 0x81, 0x02, 0x04, 0x08, 0x1F,
  0xB1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x71, 0x5E, 0x3D, 0x0C, 0x20,
  0x82, 0x08, 0x20, 0xC1, 0x03, 0xC0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x7D,
  0x43, 0xC3, 0x81, 0x81, 0x81, 0x81, 0x83, 0xC3, 0x43, 0x3D, 0x3C, 0x87,
  0x0C, 0x18, 0x3F, 0xE0, 0x40, 0xC0, 0x84, 0xF8, 0x1C, 0x82, 0x08, 0x23,
  0xE2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x7D, 0x43, 0xC3, 0x81,
  0x81, 0x81, 0x81, 0x83, 0xC3, 0x45, 0x3D, 0x01, 0x01, 0x02, 0x86, 0x7C,
  0x81, 0x02, 0x04, 0x08, 0x1F, 0xB1, 0x43, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0xD0, 0x55, 0x55, 0x54, 0x64, 0x02, 0x49, 0x24, 0x92, 0x49,
  0x25, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x38, 0xA4, 0xA2, 0x8F, 0x24, 0x9A,
  0x28, 0xE1, 0xFF, 0xFF, 0xF9, 0xE8, 0x62, 0x84, 0x38, 0x43, 0x84, 0x38,
  0x43, 0x84, 0x38, 0x43, 0x84, 0x38, 0x43, 0x84, 0x30, 0xFD, 0x8A, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0x3C, 0x42, 0xC3, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC3, 0x42, 0x3C, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x8A, 0xF4, 0x08, 0x10, 0x20, 0x40, 0x7D, 0x43, 0xC3, 0x83,
  0x81, 0x81, 0x81, 0x83, 0xC3, 0x45, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01,
  0xBC, 0x88, 0x88, 0x88, 0x88, 0x80, 0x7E, 0x08, 0x20, 0x60, 0xC0, 0xC1,
  0x06, 0x3F, 0x80, 0x21, 0x09, 0xF2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x1C,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x43, 0x45, 0x79, 0x83,
  0x42, 0x42, 0x42, 0x64, 0x24, 0x24, 0x2C, 0x18, 0x18, 0x18, 0xC2, 0x1A,
  0x28, 0x91, 0x44, 0x8A, 0x24, 0x53, 0x14, 0x90, 0xA2, 0x85, 0x14, 0x28,
  0xA0, 0xC6, 0x04, 0x10, 0x43, 0x62, 0x24, 0x14, 0x18, 0x18, 0x18, 0x24,
  0x26, 0x42, 0xC3, 0xC1, 0x42, 0x42, 0x42, 0x26, 0x24, 0x24, 0x34, 0x18,
  0x18, 0x18, 0x10, 0x10, 0x10, 0x20, 0xE0, 0xF8, 0x46, 0x23, 0x11, 0x88,
  0xC4, 0x3E, 0x1C, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x63, 0x02, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x70, 0xFF, 0xFF, 0xF8, 0xC0, 0x82, 0x08, 0x20, 0x82,
  0x0C, 0x10, 0x73, 0x08, 0x20, 0x82, 0x08, 0x23, 0x80, 0x40, 0xF9, 0x86,
};

const GFXglyph NotoSans_Condensed_Light21pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 15, 5, 1, -15 },
  { 5, 5, 5, 7, 1, -15 },
  { 9, 10, 15, 11, 0, -15 },
  { 28, 8, 17, 10, 1, -16 },
  { 45, 12, 15, 14, 1, -15 },
  { 68, 10, 15, 11, 1, -15 },
  { 87, 2, 5, 4, 1, -15 },
  { 89, 4, 18, 6, 1, -15 },
  { 98, 4, 18, 6, 1, -15 },
  { 107, 7, 7, 9, 1, -16 },
  { 114, 8, 9, 10, 1, -12 },
  { 123, 2, 5, 4, 1, -2 },
  { 125, 4, 1, 6, 1, -6 },
  { 126, 2, 2, 5, 1, -2 },
  { 127, 7, 15, 7, 0, -15 },
  { 141, 8, 15, 10, 1, -15 },
  { 156, 4, 15, 10, 2, -15 },
  { 164, 8, 15, 10, 1, -15 },
  { 179, 8, 15, 10, 1, -15 },
  { 194, 9, 15, 10, 0, -15 },
  { 211, 8, 15, 10, 1, -15 },
  { 226, 8, 15, 10, 1, -15 },
  { 241, 8, 15, 10, 1, -15 },
  { 256, 8, 15, 10, 1, -15 },
  { 271, 8, 15, 10, 1, -15 },
  { 286, 2, 11, 5, 1, -11 },
  { 289, 2, 14, 5, 1, -11 },
  { 293, 8, 9, 10, 1, -12 },
  { 302, 8, 5, 10, 1, -10 },
  { 307, 8, 9, 10, 1, -12 },
  { 316, 6, 15, 7, 0, -15 },
  { 328, 13, 17, 15, 1, -15 },
  { 356, 10, 15, 10, 0, -15 },
  { 375, 8, 15, 11, 2, -15 },
  { 390, 9, 15, 10, 1, -15 },
  { 407, 9, 15, 12, 2, -15 },
  { 424, 6, 15, 9, 2, -15 },
  { 436, 6, 15, 9, 2, -15 },
  { 448, 10, 15, 12, 1, -15 },
  { 467, 8, 15, 12, 2, -15 },
  { 482, 4, 15, 6, 1, -15 },
  { 490, 4, 19, 5, -1, -15 },
  { 500, 8, 15, 10, 2, -15 },
  { 515, 6, 15, 8, 2, -15 },
  { 527, 12, 15, 16, 2, -15 },
  { 550, 9, 15, 12, 2, -15 },
  { 567, 10, 15, 13, 1, -15 },
  { 586, 7, 15, 10, 2, -15 },
  { 600, 10, 19, 13, 1, -15 },
  { 624, 8, 15, 10, 2, -15 },
  { 639, 7, 15, 9, 1, -15 },
  { 653, 8, 15, 9, 0, -15 },
  { 668, 8, 15, 12, 2, -15 },
  { 683, 10, 15, 10, 0, -15 },
  { 702, 16, 15, 16, 0, -15 },
  { 732, 9, 15, 9, 0, -15 },
  { 749, 9, 15, 9, 0, -15 },
  { 766, 7, 15, 9, 1, -15 },
  { 780, 4, 18, 7, 2, -15 },
  { 789, 7, 15, 7, 0, -15 },
  { 803, 4, 18, 7, 1, -15 },
  { 812, 9, 8, 10, 0, -15 },
  { 821, 9, 1, 9, 0, 2 },
  { 823, 3, 3, 5, 1, -16 },
  { 825, 7, 11, 9, 1, -11 },
  { 835, 7, 16, 10, 2, -16 },
  { 849, 6, 11, 8, 1, -11 },
  { 858, 8, 16, 10, 1, -16 },
  { 874, 7, 11, 9, 1, -11 },
  { 884, 6, 16, 5, 0, -16 },
  { 896, 8, 16, 10, 1, -11 },
  { 912, 7, 16, 10, 2, -16 },
  { 926, 2, 15, 4, 1, -15 },
  { 930, 3, 20, 4, 0, -15 },
  { 938, 6, 16, 8, 2, -16 },
  { 950, 1, 16, 4, 2, -16 },
  { 952, 12, 11, 15, 2, -11 },
  { 969, 7, 11, 10, 2, -11 },
  { 979, 8, 11, 10, 1, -11 },
  { 990, 7, 16, 10, 2, -11 },
  { 1004, 8, 16, 10, 1, -11 },
  { 1020, 4, 11, 7, 2, -11 },
  { 1026, 6, 11, 8, 1, -11 },
  { 1035, 5, 14, 6, 0, -14 },
  { 1044, 8, 11, 10, 1, -11 },
  { 1055, 8, 11, 8, 0, -11 },
  { 1066, 13, 11, 13, 0, -11 },
  { 1084, 8, 11, 8, 0, -11 },
  { 1095, 8, 16, 8, 0, -11 },
  { 1111, 5, 11, 7, 1, -11 },
  { 1118, 6, 18, 7, 1, -15 },
  { 1132, 1, 21, 9, 4, -16 },
  { 1135, 6, 18, 7, 1, -15 },
  { 1149, 8, 3, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Light21pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light21pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light21pt7bGlyphs,
  0x20, 0x7E, 29
};

#endif // _NOTOSANS_CONDENSED_LIGHT21PT7B_H_
