#ifndef _NOTOSANS_CONDENSED_LIGHT7PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT7PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 7pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light7pt7bBitmaps[] PROGMEM = {
  0x00, 0xF8, 0xF0, 0x7D, 0xDA, 0x79, 0x3C, 0xDE, 0xF7, 0x50, 0xEA, 0x4A,
  0xF0, 0xC0, 0x6A, 0x90, 0x95, 0x60, 0xE8, 0x5D, 0x00, 0xC0, 0xC0, 0x80,
  0x56, 0x80, 0xF6, 0xDE, 0xF8, 0xE4, 0xAE, 0xE5, 0x1E, 0x4A, 0xF2, 0xF1,
  0x9E, 0x73, 0xDE, 0xE5, 0x24, 0xF5, 0x5E, 0xF7, 0x96, 0x90, 0x98, 0x71,
  0x80, 0xE0, 0xC7, 0x00, 0xD6, 0x80, 0x75, 0x77, 0xAA, 0x30, 0x4A, 0xFA,
  0xFF, 0xC0, 0x72, 0x46, 0xD6, 0xDC, 0xEE, 0xC0, 0xEE, 0x80, 0x78, 0xB9,
  0x70, 0xFF, 0xC0, 0xEA, 0xC0, 0xFC, 0xEA, 0xC0, 0xAA, 0xC0, 0x99, 0xBB,
  0xD0, 0xB6, 0xFA, 0x79, 0x99, 0x70, 0xFE, 0x80, 0x79, 0x99, 0x52, 0xFF,
  0xC0, 0xF1, 0x1E, 0xE9, 0x24, 0xFF, 0xC0, 0xB6, 0xA4, 0xAD, 0x6A, 0xA5,
  0x00, 0xA9, 0x5A, 0xB5, 0x24, 0xE9, 0x4E, 0xFC, 0xA5, 0x40, 0xD5, 0x70,
  0x56, 0x80, 0xE0, 0x80, 0x47, 0xF0, 0xBF, 0xC0, 0x6B, 0x2E, 0xDE, 0x57,
  0x70, 0xFA, 0x80, 0x76, 0xF2, 0x80, 0xBF, 0xC0, 0xF8, 0xFE, 0xBA, 0xC0,
  0xF8, 0xAD, 0xDD, 0xFF, 0x56, 0xF0, 0xFF, 0xA0, 0x76, 0xF2, 0x40, 0xF0,
  0x67, 0xBA, 0xC0, 0xB6, 0xF0, 0xB7, 0x20, 0xBB, 0x56, 0xA9, 0x50, 0xB7,
  0x25, 0x00, 0xDB, 0x57, 0x50, 0xFE, 0xD5, 0x70, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light7pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 5, 2, 0, -5 },
  { 2, 2, 2, 2, 0, -5 },
  { 3, 3, 5, 4, 0, -5 },
  { 5, 3, 5, 3, 0, -5 },
  { 7, 4, 5, 5, 0, -5 },
  { 10, 4, 5, 4, 0, -5 },
  { 13, 1, 2, 1, 0, -5 },
  { 14, 2, 6, 2, 0, -5 },
  { 16, 2, 6, 2, 0, -5 },
  { 18, 3, 2, 3, 0, -5 },
  { 19, 3, 3, 3, 0, -4 },
  { 21, 1, 2, 1, 0, -1 },
  { 22, 2, 1, 2, 0, -2 },
  { 23, 1, 1, 2, 0, -1 },
  { 24, 2, 5, 2, 0, -5 },
  { 26, 3, 5, 3, 0, -5 },
  { 28, 1, 5, 3, 1, -5 },
  { 29, 3, 5, 3, 0, -5 },
  { 31, 3, 5, 3, 0, -5 },
  { 33, 3, 5, 3, 0, -5 },
  { 35, 3, 5, 3, 0, -5 },
  { 37, 3, 5, 3, 0, -5 },
  { 39, 3, 5, 3, 0, -5 },
  { 41, 3, 5, 3, 0, -5 },
  { 43, 3, 5, 3, 0, -5 },
  { 45, 1, 4, 2, 0, -4 },
  { 46, 1, 5, 2, 0, -4 },
  { 47, 3, 3, 3, 0, -4 },
  { 49, 3, 1, 3, 0, -3 },
  { 50, 3, 3, 3, 0, -4 },
  { 52, 2, 5, 2, 0, -5 },
  { 54, 5, 6, 5, 0, -5 },
  { 58, 3, 5, 3, 0, -5 },
  { 60, 2, 5, 4, 1, -5 },
  { 62, 3, 5, 3, 0, -5 },
  { 64, 3, 5, 4, 1, -5 },
  { 66, 2, 5, 3, 1, -5 },
  { 68, 2, 5, 3, 1, -5 },
  { 70, 4, 5, 4, 0, -5 },
  { 73, 2, 5, 4, 1, -5 },
  { 75, 2, 5, 2, 0, -5 },
  { 77, 1, 6, 2, 0, -5 },
  { 78, 2, 5, 3, 1, -5 },
  { 80, 2, 5, 3, 1, -5 },
  { 82, 4, 5, 5, 1, -5 },
  { 85, 3, 5, 4, 1, -5 },
  { 87, 4, 5, 4, 0, -5 },
  { 90, 2, 5, 3, 1, -5 },
  { 92, 4, 6, 4, 0, -5 },
  { 95, 2, 5, 3, 1, -5 },
  { 97, 3, 5, 3, 0, -5 },
  { 99, 3, 5, 3, 0, -5 },
  { 101, 2, 5, 4, 1, -5 },
  { 103, 3, 5, 3, 0, -5 },
  { 105, 5, 5, 5, 0, -5 },
  { 109, 3, 5, 3, 0, -5 },
  { 111, 3, 5, 3, 0, -5 },
  { 113, 3, 5, 3, 0, -5 },
  { 115, 1, 6, 2, 1, -5 },
  { 116, 2, 5, 2, 0, -5 },
  { 118, 2, 6, 2, 0, -5 },
  { 120, 3, 3, 3, 0, -5 },
  { 122, 3, 1, 3, 0, 0 },
  { 123, 1, 1, 2, 0, -5 },
  { 124, 3, 4, 3, 0, -4 },
  { 126, 2, 5, 3, 1, -5 },
  { 128, 2, 4, 3, 0, -4 },
  { 129, 3, 5, 3, 0, -5 },
  { 131, 3, 4, 3, 0, -4 },
  { 133, 2, 5, 2, 0, -5 },
  { 135, 3, 6, 3, 0, -4 },
  { 138, 2, 5, 3, 1, -5 },
  { 140, 1, 5, 1, 0, -5 },
  { 141, 1, 7, 1, 0, -5 },
  { 142, 2, 5, 3, 1, -5 },
  { 144, 1, 5, 1, 0, -5 },
  { 145, 4, 4, 5, 1, -4 },
  { 147, 2, 4, 3, 1, -4 },
  { 148, 3, 4, 3, 0, -4 },
  { 150, 2, 6, 3, 1, -4 },
  { 152, 3, 6, 3, 0, -4 },
  { 155, 1, 4, 2, 1, -4 },
  { 156, 2, 4, 3, 0, -4 },
  { 157, 2, 5, 2, 0, -5 },
  { 159, 3, 4, 3, 0, -4 },
  { 161, 3, 4, 3, 0, -4 },
  { 163, 4, 4, 4, 0, -4 },
  { 165, 3, 4, 3, 0, -4 },
  { 167, 3, 6, 3, 0, -4 },
  { 170, 2, 4, 2, 0, -4 },
  { 171, 2, 6, 2, 0, -5 },
  { 173, 1, 7, 3, 1, -5 },
  { 174, 2, 6, 2, 0, -5 },
  { 176, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Light7pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light7pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light7pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _NOTOSANS_CONDENSED_LIGHT7PT7B_H_
