#ifndef _NOTOSANS_CONDENSED_LIGHT29PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT29PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 29pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light29pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xD5, 0x55, 0x07, 0xC0, 0xCF, 0x3C, 0xF3, 0x86, 0x18,
  0x61, 0x0C, 0x20, 0x63, 0x03, 0x18, 0x10, 0x80, 0x84, 0x04, 0x23, 0xFF,
  0xFF, 0xFF, 0x18, 0xC0, 0xC6, 0x04, 0x30, 0x21, 0x01, 0x08, 0x7F, 0xFB,
  0xFF, 0xC6, 0x30, 0x31, 0x81, 0x0C, 0x08, 0x40, 0x42, 0x02, 0x10, 0x00,
  0x04, 0x00, 0x80, 0x7E, 0x1A, 0xE6, 0x41, 0x88, 0x31, 0x06, 0x20, 0x44,
  0x0C, 0x80, 0xF0, 0x07, 0x00, 0x78, 0x09, 0x81, 0x18, 0x23, 0x04, 0x60,
  0x8E, 0x11, 0x7B, 0xE7, 0xF0, 0x08, 0x01, 0x00, 0x20, 0x38, 0x0C, 0x32,
  0x04, 0x11, 0x86, 0x08, 0xC2, 0x0C, 0x21, 0x06, 0x11, 0x83, 0x08, 0x81,
  0x84, 0xC0, 0xC2, 0x46, 0x23, 0x27, 0x91, 0xB6, 0x6D, 0x92, 0x13, 0x99,
  0x08, 0x09, 0x84, 0x04, 0xC2, 0x06, 0x61, 0x02, 0x10, 0x83, 0x08, 0x41,
  0x04, 0x60, 0x83, 0x20, 0xC0, 0xF0, 0x0E, 0x00, 0x6C, 0x03, 0x18, 0x08,
  0x20, 0x20, 0x80, 0x86, 0x03, 0x18, 0x04, 0x40, 0x1B, 0x00, 0x38, 0x01,
  0xC0, 0x0D, 0x82, 0x63, 0x1B, 0x04, 0x6C, 0x19, 0x30, 0x3C, 0xC0, 0x73,
  0x01, 0x84, 0x0F, 0x1C, 0x66, 0x3F, 0x0C, 0xFF, 0xAA, 0x0C, 0x21, 0x8C,
  0x30, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0x41, 0x06, 0x18,
  0x20, 0xC3, 0x06, 0x08, 0x30, 0xC1, 0x06, 0x0C, 0x30, 0x41, 0x86, 0x08,
  0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x08, 0x21, 0x86, 0x10, 0xC3, 0x18, 0x43,
  0x00, 0x0C, 0x03, 0x00, 0x43, 0x13, 0xFF, 0xC3, 0x01, 0xA0, 0x4C, 0x31,
  0x88, 0x40, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x3F, 0xF8,
  0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x00, 0x6D, 0xB5,
  0xA0, 0xFF, 0xF0, 0x7C, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20, 0x30, 0x10,
  0x18, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x18, 0x08, 0x00, 0x0F, 0x07, 0xF0, 0xC3, 0x30, 0x66, 0x04, 0x80,
  0x90, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD0,
  0x1A, 0x03, 0x60, 0x4C, 0x18, 0x83, 0x1C, 0xC1, 0xF0, 0x04, 0x33, 0xD9,
  0xC4, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x1F, 0x0F, 0xF1, 0x03, 0x00, 0x60, 0x04, 0x00, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x10, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x0F, 0xFE, 0x3F, 0x0E, 0x73, 0x03, 0x00, 0x60,
  0x04, 0x00, 0x80, 0x10, 0x06, 0x01, 0x80, 0xE0, 0x7C, 0x00, 0xC0, 0x0C,
  0x00, 0x80, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x60, 0xCF, 0xF0, 0x01,
  0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x80, 0x48, 0x0C, 0x81, 0x88, 0x10,
  0x83, 0x08, 0x20, 0x86, 0x08, 0x40, 0x8C, 0x08, 0x80, 0x8F, 0xFF, 0x00,
  0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0xBF, 0xEC, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC8, 0x3F, 0xC0, 0x38, 0x06, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x1A, 0x0C, 0xFE, 0x00, 0x07, 0xC3,
  0xD8, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x18, 0x02, 0x00, 0x4F, 0x0B, 0xF3,
  0x83, 0x70, 0x3C, 0x06, 0x80, 0xD0, 0x1A, 0x03, 0x40, 0x6C, 0x0C, 0x83,
  0x18, 0xE1, 0xF8, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x20, 0x0C, 0x01, 0x80,
  0x20, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x01, 0x00,
  0x60, 0x0C, 0x01, 0x00, 0x60, 0x0C, 0x03, 0x00, 0x1F, 0x07, 0x71, 0x83,
  0x30, 0x24, 0x06, 0x80, 0xD8, 0x13, 0x06, 0x31, 0x83, 0xE0, 0x3C, 0x18,
  0xC6, 0x0C, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x81, 0xB8, 0xE3,
  0xF8, 0x1E, 0x07, 0x71, 0x82, 0x20, 0x6C, 0x05, 0x80, 0xB0, 0x1E, 0x03,
  0xC0, 0x68, 0x0D, 0x83, 0xB8, 0xB3, 0xE6, 0x00, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x06, 0x23, 0x87, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x2D, 0x80,
  0x00, 0x00, 0x00, 0xDB, 0x4B, 0x40, 0x00, 0x20, 0x0C, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x02,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x18, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x08, 0x00, 0x7C, 0xEE, 0x02, 0x03, 0x03, 0x03, 0x03,
  0x02, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x30, 0x20, 0x20, 0x00, 0x00, 0x20,
  0x30, 0x30, 0x01, 0xE0, 0x07, 0xBC, 0x06, 0x03, 0x06, 0x00, 0xC6, 0x00,
  0x32, 0x00, 0x0B, 0x07, 0xC5, 0x86, 0x63, 0x86, 0x31, 0xC2, 0x18, 0x63,
  0x0C, 0x31, 0x86, 0x18, 0xC3, 0x0C, 0x61, 0x8E, 0x30, 0xC7, 0x08, 0xA2,
  0x87, 0xDF, 0x61, 0xC7, 0x30, 0x00, 0x0C, 0x00, 0x02, 0x00, 0x01, 0xC0,
  0x40, 0x3F, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x60,
  0x05, 0x80, 0x32, 0x00, 0xCC, 0x02, 0x30, 0x08, 0x40, 0x61, 0x01, 0x86,
  0x04, 0x18, 0x3F, 0xE0, 0xFF, 0xC3, 0x03, 0x08, 0x0C, 0x60, 0x11, 0x80,
  0x64, 0x01, 0xB0, 0x02, 0xC0, 0x0C, 0xFE, 0x1F, 0xFB, 0x03, 0x60, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xDF, 0xF3, 0xFE, 0x60, 0x6C, 0x07,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xE1, 0xEF, 0xF0, 0x07,
  0xC3, 0xFC, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x30, 0x06, 0x00, 0x40, 0x0C, 0x00,
  0xC0, 0x1E, 0x10, 0xFE, 0xFE, 0x07, 0xFC, 0x30, 0x31, 0x80, 0xCC, 0x03,
  0x60, 0x1B, 0x00, 0xD8, 0x02, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0B, 0x00, 0xD8, 0x06, 0xC0, 0x36, 0x03, 0x30, 0x31, 0x8F,
  0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x7F, 0xFF, 0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0F, 0xF8, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x00, 0x07, 0xE0, 0xFF, 0xCE, 0x02, 0xC0, 0x06, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0x80, 0x04, 0x00, 0x20, 0x3F, 0x01, 0xF8, 0x00,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0x40, 0x0B, 0x00, 0x4C, 0x02, 0x38, 0x70,
  0xFF, 0x80, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x10, 0xFD, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0xFC, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x1B, 0xE0, 0xC0, 0x6C,
  0x04, 0xC0, 0xCC, 0x18, 0xC1, 0x0C, 0x30, 0xC6, 0x0C, 0xC0, 0xCC, 0x0D,
  0x80, 0xFC, 0x0E, 0xC0, 0xC6, 0x0C, 0x20, 0xC3, 0x0C, 0x10, 0xC1, 0x8C,
  0x0C, 0xC0, 0xCC, 0x06, 0xC0, 0x70, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0F, 0xF8, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x5D, 0x00, 0x6E, 0x80, 0x37, 0x60, 0x13, 0x90, 0x19, 0xC8,
  0x0C, 0xE6, 0x04, 0x71, 0x06, 0x38, 0x83, 0x1C, 0x61, 0x0E, 0x31, 0x87,
  0x08, 0xC3, 0x86, 0x41, 0xC3, 0x60, 0xE0, 0xB0, 0x70, 0x70, 0x38, 0x38,
  0x1C, 0x0C, 0x08, 0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x3D, 0x01, 0xEC,
  0x0F, 0x20, 0x79, 0x83, 0xC4, 0x1E, 0x30, 0xF0, 0x87, 0x86, 0x3C, 0x11,
  0xE0, 0xCF, 0x02, 0x78, 0x1B, 0xC0, 0x5E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0x80, 0x0F, 0x80, 0xFF, 0x83, 0x03, 0x18, 0x04, 0xC0, 0x1B, 0x00,
  0x6C, 0x00, 0xA0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x02, 0xC0, 0x19, 0x80, 0x66, 0x03, 0x0E,
  0x38, 0x0F, 0xC0, 0xFC, 0x1F, 0xF3, 0x07, 0x60, 0x6C, 0x05, 0x80, 0xB0,
  0x1E, 0x02, 0xC0, 0x58, 0x1B, 0x06, 0x7F, 0x8F, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x0F, 0x80, 0xFF, 0x83,
  0x03, 0x18, 0x04, 0xC0, 0x1B, 0x00, 0x6C, 0x00, 0xA0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x02,
  0xC0, 0x19, 0x80, 0x66, 0x03, 0x0E, 0x38, 0x1F, 0xC0, 0x02, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x60, 0x00, 0xC0, 0xFC, 0x1F, 0xF3, 0x07, 0x60, 0x6C,
  0x05, 0x80, 0xF0, 0x1E, 0x02, 0xC0, 0xD8, 0x1B, 0x1E, 0x7F, 0x0C, 0x21,
  0x86, 0x30, 0xC6, 0x0C, 0xC1, 0x98, 0x1B, 0x03, 0x60, 0x3C, 0x06, 0x1F,
  0x87, 0xF9, 0x80, 0x20, 0x0C, 0x01, 0x80, 0x10, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x61, 0xCF, 0xF0, 0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x34, 0x03, 0x60, 0x23, 0x0E, 0x1F, 0xC0, 0xC0, 0x0E, 0x00, 0xD0,
  0x06, 0xC0, 0x26, 0x03, 0x30, 0x18, 0x80, 0xC6, 0x04, 0x30, 0x60, 0x83,
  0x04, 0x10, 0x30, 0x81, 0x8C, 0x04, 0x60, 0x22, 0x01, 0xB0, 0x0D, 0x80,
  0x28, 0x01, 0x40, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x30, 0x0A, 0x01, 0x80,
  0xD0, 0x0C, 0x06, 0xC0, 0xE0, 0x36, 0x07, 0x81, 0x30, 0x2C, 0x08, 0x81,
  0x20, 0xC6, 0x19, 0x06, 0x30, 0xC8, 0x31, 0x84, 0x61, 0x04, 0x23, 0x18,
  0x23, 0x08, 0xC1, 0x98, 0x46, 0x0C, 0xC3, 0x20, 0x24, 0x19, 0x01, 0x20,
  0x58, 0x0F, 0x02, 0xC0, 0x78, 0x14, 0x03, 0x80, 0xE0, 0x0C, 0x07, 0x00,
  0x60, 0x18, 0x00, 0x60, 0x36, 0x02, 0x20, 0x63, 0x04, 0x10, 0xC1, 0x88,
  0x09, 0x80, 0xD0, 0x07, 0x00, 0x70, 0x06, 0x00, 0x70, 0x0D, 0x00, 0x98,
  0x19, 0x81, 0x0C, 0x30, 0xC3, 0x04, 0x60, 0x66, 0x02, 0xC0, 0x30, 0xC0,
  0x3C, 0x02, 0x60, 0x66, 0x06, 0x20, 0xC3, 0x0C, 0x30, 0x81, 0x98, 0x19,
  0x80, 0x90, 0x0F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xFF, 0xFF, 0xF0, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x04,
  0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x00, 0xFF, 0xC0, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xFF, 0xF0, 0x80, 0x60, 0x30, 0x08, 0x06, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x08, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x10, 0x0C,
  0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0xFF, 0xF0, 0x04, 0x00, 0x60, 0x0E, 0x00, 0xB0, 0x19, 0x01, 0x18, 0x30,
  0x82, 0x0C, 0x60, 0x44, 0x06, 0xC0, 0x30, 0xFF, 0xF0, 0xC3, 0x0C, 0x30,
  0x0E, 0x1F, 0xE4, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x0C, 0x7F, 0x38, 0xD8,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x76, 0x2C, 0xFB, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x33, 0x86, 0xFC, 0xE0, 0xDC, 0x1B, 0x01, 0x60,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x70, 0x6F,
  0x19, 0x3E, 0x00, 0x07, 0x0F, 0xCC, 0x0C, 0x06, 0x02, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x10, 0x08, 0x06, 0x03, 0x00, 0xC2, 0x3F, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC3, 0x99, 0xF9, 0x30, 0xAC, 0x0D, 0x81,
  0xA0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x68, 0x0D, 0x81, 0xB0,
  0x53, 0x1A, 0x3E, 0x40, 0x0E, 0x03, 0xF0, 0xC2, 0x30, 0x64, 0x04, 0x80,
  0xB0, 0x1F, 0xFF, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x06, 0x00, 0xC0, 0x0E,
  0x10, 0xFE, 0x0F, 0x19, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFE, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10,
  0x0E, 0x07, 0xF4, 0xC2, 0xB0, 0x34, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xA0, 0x36, 0x06, 0xC1, 0x4C, 0x78, 0xFB, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x34, 0x0C, 0xF7, 0x0F, 0xC0, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x63, 0x7E, 0xE1, 0xB8, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xED, 0xC0,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x06, 0xC3, 0x31,
  0x8C, 0x43, 0x30, 0xD8, 0x3E, 0x0E, 0xC3, 0x30, 0xC6, 0x31, 0x8C, 0x33,
  0x04, 0xC1, 0xB0, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x0C,
  0x4F, 0x9F, 0xB8, 0x78, 0xD8, 0x38, 0x3C, 0x0C, 0x1E, 0x04, 0x0F, 0x02,
  0x07, 0x81, 0x03, 0xC0, 0x81, 0xE0, 0x40, 0xF0, 0x20, 0x78, 0x10, 0x3C,
  0x08, 0x1E, 0x04, 0x0F, 0x02, 0x07, 0x81, 0x03, 0x06, 0x27, 0xEE, 0x1B,
  0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0x0F, 0x03, 0xF0, 0xC3, 0x30, 0x34, 0x06, 0x80,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x05, 0x00, 0xA0, 0x36, 0x06, 0xC0, 0x8C,
  0x30, 0xFC, 0x06, 0x13, 0xF3, 0x83, 0x70, 0x6C, 0x05, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x05, 0xC1, 0xBC, 0x66, 0xF8,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x0E, 0x07,
  0xE4, 0xC2, 0xB0, 0x34, 0x06, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xA0, 0x36, 0x06, 0xC1, 0x4C, 0x78, 0xFB, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x3F, 0xC7, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x1E, 0x3F, 0x90, 0x58,
  0x0C, 0x06, 0x01, 0x80, 0x70, 0x1E, 0x03, 0x80, 0x40, 0x30, 0x18, 0x0B,
  0x0D, 0xFC, 0x10, 0x60, 0xC1, 0x8F, 0xE6, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x20, 0x78, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xD8,
  0xF3, 0xEC, 0xC0, 0x68, 0x09, 0x83, 0x30, 0x66, 0x08, 0x43, 0x0C, 0x61,
  0x88, 0x11, 0x02, 0x60, 0x6C, 0x0D, 0x00, 0xA0, 0x1C, 0x03, 0x00, 0xC0,
  0xC0, 0xA0, 0x60, 0xD8, 0x78, 0x6C, 0x3C, 0x36, 0x12, 0x11, 0x09, 0x08,
  0xCC, 0x8C, 0x66, 0x66, 0x32, 0x32, 0x09, 0x09, 0x05, 0x85, 0x83, 0xC3,
  0xC1, 0xC1, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x60, 0xE6, 0x18, 0xC6, 0x0C,
  0xC1, 0xB0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x60, 0x64, 0x18, 0xC3,
  0x0C, 0xC1, 0xB8, 0x18, 0xC0, 0x68, 0x09, 0x83, 0x30, 0x62, 0x08, 0x61,
  0x0C, 0x60, 0x8C, 0x11, 0x03, 0x60, 0x2C, 0x05, 0x00, 0xE0, 0x1C, 0x01,
  0x80, 0x20, 0x0C, 0x01, 0x80, 0x20, 0x0C, 0x0B, 0x01, 0xC0, 0x00, 0xFF,
  0x02, 0x06, 0x06, 0x0C, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x40,
  0xC0, 0xFF, 0x01, 0x0F, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x10, 0xE0, 0xF0, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x0C, 0x0F, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0, 0xF0, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x07, 0x07, 0x0C, 0x08,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xF0, 0x80, 0x38, 0x3F,
  0xC6, 0x0F, 0x80,
};

const GFXglyph NotoSans_Condensed_Light29pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 21, 7, 2, -21 },
  { 7, 6, 8, 10, 2, -21 },
  { 13, 13, 21, 15, 1, -21 },
  { 48, 11, 24, 13, 1, -22 },
  { 81, 17, 21, 20, 1, -21 },
  { 126, 14, 21, 15, 1, -21 },
  { 163, 2, 8, 5, 2, -21 },
  { 165, 6, 26, 8, 1, -21 },
  { 185, 6, 26, 8, 1, -21 },
  { 205, 10, 10, 12, 1, -22 },
  { 218, 11, 14, 13, 1, -17 },
  { 238, 3, 7, 6, 1, -3 },
  { 241, 6, 2, 8, 1, -9 },
  { 243, 2, 3, 6, 2, -3 },
  { 244, 9, 21, 10, 1, -21 },
  { 268, 11, 21, 13, 1, -21 },
  { 297, 6, 21, 13, 2, -21 },
  { 313, 11, 21, 13, 1, -21 },
  { 342, 11, 21, 13, 1, -21 },
  { 371, 12, 21, 13, 1, -21 },
  { 403, 10, 21, 13, 2, -21 },
  { 430, 11, 21, 13, 1, -21 },
  { 459, 11, 21, 13, 1, -21 },
  { 488, 11, 21, 13, 1, -21 },
  { 517, 11, 21, 13, 1, -21 },
  { 546, 2, 16, 6, 2, -16 },
  { 550, 3, 20, 6, 1, -16 },
  { 558, 11, 13, 13, 1, -17 },
  { 576, 11, 8, 13, 1, -14 },
  { 587, 11, 13, 13, 1, -17 },
  { 605, 8, 21, 10, 1, -21 },
  { 626, 17, 24, 20, 2, -21 },
  { 677, 14, 21, 14, 0, -21 },
  { 714, 11, 21, 15, 2, -21 },
  { 743, 11, 21, 14, 2, -21 },
  { 772, 13, 21, 16, 2, -21 },
  { 807, 9, 21, 13, 2, -21 },
  { 831, 9, 21, 12, 2, -21 },
  { 855, 13, 21, 17, 2, -21 },
  { 890, 12, 21, 17, 2, -21 },
  { 922, 6, 21, 8, 1, -21 },
  { 938, 6, 26, 6, -2, -21 },
  { 958, 12, 21, 14, 2, -21 },
  { 990, 9, 21, 12, 2, -21 },
  { 1014, 17, 21, 21, 2, -21 },
  { 1059, 13, 21, 17, 2, -21 },
  { 1094, 14, 21, 17, 2, -21 },
  { 1131, 11, 21, 14, 2, -21 },
  { 1160, 14, 26, 17, 2, -21 },
  { 1206, 11, 21, 14, 2, -21 },
  { 1235, 11, 21, 13, 1, -21 },
  { 1264, 12, 21, 12, 0, -21 },
  { 1296, 12, 21, 17, 2, -21 },
  { 1328, 13, 21, 13, 0, -21 },
  { 1363, 21, 21, 22, 0, -21 },
  { 1419, 12, 21, 12, 0, -21 },
  { 1451, 12, 21, 12, 0, -21 },
  { 1483, 10, 21, 12, 1, -21 },
  { 1510, 6, 26, 9, 2, -21 },
  { 1530, 9, 21, 10, 1, -21 },
  { 1554, 6, 26, 9, 1, -21 },
  { 1574, 12, 11, 13, 1, -21 },
  { 1591, 12, 1, 12, 0, 3 },
  { 1593, 5, 4, 7, 1, -22 },
  { 1596, 10, 16, 13, 1, -16 },
  { 1616, 11, 22, 14, 2, -22 },
  { 1647, 9, 16, 11, 1, -16 },
  { 1665, 11, 22, 14, 1, -22 },
  { 1696, 11, 16, 13, 1, -16 },
  { 1718, 8, 22, 7, 0, -22 },
  { 1740, 11, 23, 14, 1, -16 },
  { 1772, 10, 22, 14, 2, -22 },
  { 1800, 2, 21, 6, 2, -21 },
  { 1806, 5, 28, 6, -1, -21 },
  { 1824, 10, 22, 12, 2, -22 },
  { 1852, 2, 22, 6, 2, -22 },
  { 1858, 17, 16, 21, 2, -16 },
  { 1892, 10, 16, 14, 2, -16 },
  { 1912, 11, 16, 14, 1, -16 },
  { 1934, 11, 23, 14, 2, -16 },
  { 1966, 11, 23, 14, 1, -16 },
  { 1998, 7, 16, 9, 2, -16 },
  { 2012, 9, 16, 11, 1, -16 },
  { 2030, 7, 19, 8, 0, -19 },
  { 2047, 10, 15, 14, 2, -15 },
  { 2066, 11, 15, 11, 0, -15 },
  { 2087, 17, 15, 18, 0, -15 },
  { 2119, 11, 15, 11, 0, -15 },
  { 2140, 11, 22, 11, 0, -15 },
  { 2171, 8, 15, 10, 1, -15 },
  { 2186, 8, 26, 10, 1, -21 },
  { 2212, 1, 29, 13, 6, -22 },
  { 2216, 8, 26, 10, 1, -21 },
  { 2242, 11, 3, 13, 1, -12 },
};

const GFXfont NotoSans_Condensed_Light29pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light29pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light29pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _NOTOSANS_CONDENSED_LIGHT29PT7B_H_
