#ifndef _NOTOSANS_CONDENSED_LIGHT10PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT10PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light10pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xF0, 0x32, 0xBE, 0xAF, 0xA9, 0x80, 0x27, 0xAA, 0x63, 0x3E,
  0x20, 0xEA, 0xAB, 0x2F, 0x6C, 0xB2, 0xC0, 0x72, 0x98, 0xCA, 0xC9, 0xE0,
  0xC0, 0x5A, 0xA5, 0x40, 0xD5, 0x55, 0x80, 0x2F, 0x25, 0x22, 0xF2, 0x20,
  0x60, 0xE0, 0x80, 0x24, 0xA4, 0xA0, 0x79, 0x99, 0x99, 0x70, 0x75, 0x54,
  0xF1, 0x11, 0x24, 0xF0, 0xF1, 0x16, 0x11, 0xF0, 0x13, 0x55, 0x97, 0x10,
  0xF3, 0x12, 0x78, 0xF3, 0x5B, 0x78, 0xF1, 0x12, 0x24, 0x40, 0x79, 0x56,
  0x99, 0x70, 0x79, 0x95, 0x31, 0xE0, 0x88, 0x40, 0x60, 0x12, 0xC2, 0x10,
  0xF0, 0xF0, 0x86, 0x16, 0x80, 0xE4, 0xA4, 0x10, 0x7A, 0x2F, 0x75, 0xD6,
  0xA8, 0x1C, 0x23, 0x14, 0xAF, 0x4A, 0x20, 0xE9, 0xAE, 0x99, 0xE0, 0xF8,
  0x88, 0x88, 0x70, 0xE9, 0x99, 0x99, 0xE0, 0xF2, 0x79, 0x38, 0xF2, 0x79,
  0x20, 0xF8, 0x8B, 0x99, 0x70, 0x99, 0x9F, 0x99, 0x90, 0xD5, 0x5C, 0x55,
  0x55, 0xC0, 0xBA, 0xCC, 0xCA, 0x90, 0x92, 0x49, 0x38, 0x86, 0x38, 0xF5,
  0xD6, 0x9A, 0x40, 0x99, 0xDB, 0xB9, 0x90, 0xF9, 0x99, 0x99, 0xF0, 0xF6,
  0xF9, 0x20, 0xF9, 0x99, 0x99, 0xD2, 0x10, 0xE9, 0xAE, 0xAA, 0x90, 0x78,
  0x42, 0x11, 0xF0, 0xF2, 0x22, 0x22, 0x20, 0x99, 0x99, 0x99, 0xE0, 0x8C,
  0xA4, 0xA6, 0x10, 0x80, 0x93, 0x26, 0x6B, 0x56, 0xAD, 0x89, 0x00, 0x95,
  0x62, 0x65, 0x90, 0x99, 0x66, 0x22, 0x20, 0xF2, 0x22, 0x44, 0xF0, 0xEA,
  0xAA, 0xC0, 0x89, 0x22, 0x48, 0xD5, 0x55, 0xC0, 0x25, 0x59, 0xF0, 0x90,
  0x71, 0x79, 0xF0, 0x93, 0x5B, 0x6F, 0x78, 0x88, 0x70, 0x11, 0x35, 0x99,
  0x97, 0x79, 0xE8, 0x70, 0x6B, 0x24, 0x92, 0x79, 0x99, 0x71, 0x70, 0x93,
  0x5B, 0x6D, 0xBE, 0xBF, 0x80, 0x92, 0xED, 0xB5, 0xFF, 0xFD, 0x6B, 0x5A,
  0x80, 0xF6, 0xDA, 0x79, 0x99, 0x70, 0xF6, 0xDF, 0x20, 0x79, 0x99, 0x71,
  0x10, 0xEA, 0x80, 0xF1, 0x9E, 0x75, 0x54, 0xB6, 0xDE, 0x9A, 0x66, 0x40,
  0x96, 0xD7, 0x52, 0x48, 0xB6, 0x46, 0x90, 0x9A, 0x66, 0x44, 0xC0, 0xE5,
  0x2E, 0x69, 0x2C, 0x92, 0x20, 0xFF, 0xC0, 0xC9, 0x22, 0x92, 0x80, 0xF0,
};

const GFXglyph NotoSans_Condensed_Light10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 7, 2, 1, -7 },
  { 2, 2, 2, 3, 1, -7 },
  { 3, 5, 7, 5, 0, -7 },
  { 8, 4, 9, 5, 0, -8 },
  { 13, 6, 7, 7, 0, -7 },
  { 19, 5, 7, 5, 0, -7 },
  { 24, 1, 2, 2, 0, -7 },
  { 25, 2, 9, 3, 0, -7 },
  { 28, 2, 9, 3, 0, -7 },
  { 31, 4, 4, 4, 0, -8 },
  { 33, 4, 5, 5, 0, -6 },
  { 36, 2, 2, 2, 0, -1 },
  { 37, 3, 1, 3, 0, -3 },
  { 38, 1, 1, 2, 1, -1 },
  { 39, 3, 7, 3, 0, -7 },
  { 42, 4, 7, 5, 0, -7 },
  { 46, 2, 7, 5, 1, -7 },
  { 48, 4, 7, 5, 0, -7 },
  { 52, 4, 7, 5, 0, -7 },
  { 56, 4, 7, 5, 0, -7 },
  { 60, 3, 7, 5, 1, -7 },
  { 63, 3, 7, 5, 1, -7 },
  { 66, 4, 7, 5, 0, -7 },
  { 70, 4, 7, 5, 0, -7 },
  { 74, 4, 7, 5, 0, -7 },
  { 78, 1, 5, 2, 1, -5 },
  { 79, 2, 6, 2, 0, -5 },
  { 81, 4, 5, 5, 0, -6 },
  { 84, 4, 3, 5, 0, -5 },
  { 86, 4, 5, 5, 0, -6 },
  { 89, 3, 7, 3, 0, -7 },
  { 92, 6, 8, 7, 1, -7 },
  { 98, 5, 7, 5, 0, -7 },
  { 103, 4, 7, 5, 1, -7 },
  { 107, 4, 7, 5, 1, -7 },
  { 111, 4, 7, 6, 1, -7 },
  { 115, 3, 7, 4, 1, -7 },
  { 118, 3, 7, 4, 1, -7 },
  { 121, 4, 7, 6, 1, -7 },
  { 125, 4, 7, 6, 1, -7 },
  { 129, 2, 7, 3, 0, -7 },
  { 131, 2, 9, 2, -1, -7 },
  { 134, 4, 7, 5, 1, -7 },
  { 138, 3, 7, 4, 1, -7 },
  { 141, 6, 7, 7, 1, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 4, 7, 6, 1, -7 },
  { 155, 3, 7, 5, 1, -7 },
  { 158, 4, 9, 6, 1, -7 },
  { 163, 4, 7, 5, 1, -7 },
  { 167, 4, 7, 4, 0, -7 },
  { 171, 4, 7, 4, 0, -7 },
  { 175, 4, 7, 6, 1, -7 },
  { 179, 5, 7, 5, 0, -7 },
  { 184, 7, 7, 7, 0, -7 },
  { 191, 4, 7, 4, 0, -7 },
  { 195, 4, 7, 4, 0, -7 },
  { 199, 4, 7, 4, 0, -7 },
  { 203, 2, 9, 3, 1, -7 },
  { 206, 3, 7, 3, 0, -7 },
  { 209, 2, 9, 3, 0, -7 },
  { 212, 4, 4, 5, 0, -7 },
  { 214, 4, 1, 4, 0, 1 },
  { 215, 2, 2, 3, 0, -8 },
  { 216, 4, 5, 4, 0, -5 },
  { 219, 3, 8, 5, 1, -8 },
  { 222, 4, 5, 4, 0, -5 },
  { 225, 4, 8, 5, 0, -8 },
  { 229, 4, 5, 4, 0, -5 },
  { 232, 3, 8, 3, 0, -8 },
  { 235, 4, 7, 5, 0, -5 },
  { 239, 3, 8, 5, 1, -8 },
  { 242, 1, 7, 2, 1, -7 },
  { 243, 1, 9, 2, 0, -7 },
  { 245, 3, 8, 4, 1, -8 },
  { 248, 1, 8, 2, 1, -8 },
  { 249, 5, 5, 7, 1, -5 },
  { 253, 3, 5, 5, 1, -5 },
  { 255, 4, 5, 5, 0, -5 },
  { 258, 3, 7, 5, 1, -5 },
  { 261, 4, 7, 5, 0, -5 },
  { 265, 2, 5, 3, 1, -5 },
  { 267, 3, 5, 4, 0, -5 },
  { 269, 2, 7, 3, 0, -7 },
  { 271, 3, 5, 5, 1, -5 },
  { 273, 4, 5, 4, 0, -5 },
  { 276, 6, 5, 6, 0, -5 },
  { 280, 4, 5, 4, 0, -5 },
  { 283, 4, 7, 4, 0, -5 },
  { 287, 3, 5, 3, 0, -5 },
  { 289, 3, 9, 4, 0, -7 },
  { 293, 1, 10, 4, 2, -8 },
  { 295, 3, 9, 4, 0, -7 },
  { 299, 4, 1, 5, 0, -4 },
};

const GFXfont NotoSans_Condensed_Light10pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light10pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light10pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _NOTOSANS_CONDENSED_LIGHT10PT7B_H_
