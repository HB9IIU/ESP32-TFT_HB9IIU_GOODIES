#ifndef _NOTOSANS_CONDENSED_LIGHT53PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light53pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x00, 0x00, 0x06, 0xFF, 0xFF, 0xF0, 0x7F, 0x07, 0xF0,
  0x77, 0x07, 0x70, 0x76, 0x07, 0x60, 0x76, 0x07, 0x60, 0x76, 0x07, 0x60,
  0x66, 0x06, 0x60, 0x66, 0x06, 0x00, 0x60, 0x38, 0x00, 0x30, 0x1C, 0x00,
  0x18, 0x0C, 0x00, 0x0C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x07, 0x01, 0x80,
  0x03, 0x80, 0xC0, 0x01, 0x80, 0xE0, 0x00, 0xC0, 0x70, 0x00, 0x60, 0x30,
  0x00, 0x30, 0x18, 0x07, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xFC, 0x06, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x00, 0xC0,
  0x60, 0x00, 0xE0, 0x30, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0C, 0x00, 0x18,
  0x0E, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x80, 0xFF, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFF, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x60, 0x38, 0x00,
  0x30, 0x1C, 0x00, 0x18, 0x0E, 0x00, 0x0C, 0x06, 0x00, 0x06, 0x03, 0x00,
  0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x70,
  0x00, 0x60, 0x38, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x0F, 0x00, 0x07, 0xFF, 0x81, 0xFF, 0xFE, 0x3E, 0x63, 0xC3, 0x86, 0x04,
  0x70, 0x60, 0x07, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60,
  0x0E, 0x06, 0x00, 0x60, 0x60, 0x07, 0x06, 0x00, 0x78, 0x60, 0x03, 0xC6,
  0x00, 0x1F, 0x60, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x06, 0x78, 0x00, 0x63, 0xC0, 0x06, 0x0E, 0x00, 0x60, 0xE0,
  0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07,
  0x00, 0x60, 0xE0, 0x06, 0x0E, 0xE0, 0x63, 0xCF, 0xF7, 0xF8, 0xFF, 0xFF,
  0x01, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x3F, 0xC0, 0x06, 0x00,
  0xE3, 0x80, 0x1C, 0x01, 0x83, 0x80, 0x30, 0x07, 0x07, 0x00, 0x60, 0x0C,
  0x06, 0x01, 0xC0, 0x18, 0x0E, 0x03, 0x00, 0x30, 0x1C, 0x0E, 0x00, 0x60,
  0x38, 0x18, 0x01, 0xC0, 0x70, 0x70, 0x03, 0x80, 0xE0, 0xE0, 0x07, 0x01,
  0xC1, 0x80, 0x0E, 0x03, 0x87, 0x00, 0x1C, 0x07, 0x0C, 0x00, 0x18, 0x0E,
  0x38, 0x00, 0x30, 0x1C, 0x71, 0xF8, 0x60, 0x38, 0xC7, 0xF8, 0xC0, 0x63,
  0x8E, 0x39, 0xC1, 0xC6, 0x38, 0x31, 0x83, 0x9C, 0x60, 0x73, 0x8E, 0x38,
  0xC0, 0xE3, 0xFC, 0x63, 0x80, 0xC3, 0xE1, 0xC7, 0x01, 0x80, 0x03, 0x0E,
  0x03, 0x00, 0x0E, 0x1C, 0x06, 0x00, 0x1C, 0x30, 0x0C, 0x00, 0x30, 0x60,
  0x18, 0x00, 0xE0, 0xC0, 0x30, 0x01, 0x81, 0xC0, 0x60, 0x07, 0x03, 0x80,
  0xC0, 0x0E, 0x07, 0x01, 0x80, 0x18, 0x0E, 0x03, 0x00, 0x70, 0x0C, 0x0E,
  0x00, 0xC0, 0x18, 0x1C, 0x03, 0x80, 0x38, 0x30, 0x07, 0x00, 0x30, 0xE0,
  0x0C, 0x00, 0x7F, 0x80, 0x38, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x03, 0xC3, 0x80, 0x01, 0xC0, 0xE0, 0x00, 0xC0, 0x70, 0x00,
  0xE0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x38, 0x06, 0x00, 0x1C, 0x03, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x01, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0xE0,
  0x00, 0x38, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x07, 0x70, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xE7,
  0x00, 0x01, 0xE1, 0xC0, 0x38, 0xE0, 0x70, 0x18, 0xE0, 0x3C, 0x1C, 0x70,
  0x0E, 0x0E, 0x70, 0x03, 0x87, 0x38, 0x01, 0xE3, 0x1C, 0x00, 0x73, 0x8E,
  0x00, 0x1D, 0xC7, 0x00, 0x07, 0xC3, 0x80, 0x03, 0xE1, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0xF8, 0x38, 0x00, 0xFE, 0x1E, 0x00, 0xE7, 0x87, 0xC1, 0xE1,
  0xC1, 0xFF, 0xE0, 0x70, 0x7F, 0xE0, 0x3C, 0x02, 0x00, 0x00, 0xFF, 0xF7,
  0x76, 0x66, 0x66, 0x66, 0x66, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70,
  0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0xE0, 0x70, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x10, 0x30, 0x37, 0x8C, 0x7F, 0xFF,
  0xFF, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x07, 0x38,
  0x03, 0x87, 0x00, 0xE0, 0xE0, 0x70, 0x3C, 0x1C, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x9C, 0x71, 0xC6, 0x38, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xEF, 0xFF, 0xF0, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x0F, 0x8F, 0x01,
  0xE0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x0E,
  0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C,
  0x3C, 0x01, 0xC1, 0xC0, 0x38, 0x1E, 0x07, 0x80, 0xF9, 0xF0, 0x07, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0xE0, 0x3C, 0x0F, 0x83, 0xF0, 0xFE, 0x3D, 0xDE,
  0x3F, 0x87, 0x60, 0xE8, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x07, 0xFC, 0x01, 0xFF,
  0xE0, 0x7E, 0x3F, 0x07, 0x80, 0x78, 0x20, 0x03, 0xC0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFC, 0x07, 0xFF, 0xE1,
  0xF8, 0x7E, 0x78, 0x03, 0xC6, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0xFF, 0x80, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x3B, 0x00, 0x1F, 0x7C, 0x0F, 0xCF, 0xFF, 0xF0, 0x7F,
  0xF8, 0x00, 0x30, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xB8, 0x00, 0x07, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00,
  0x07, 0x0E, 0x00, 0x0C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x60, 0x70, 0x01,
  0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x18, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF,
  0xFE, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x18, 0x00, 0x03, 0x3F, 0x80, 0x7F, 0xFC, 0x1F, 0xFF,
  0xC0, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xF2, 0x00, 0x3C, 0x78, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0,
  0x00, 0x40, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x1F, 0x86, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x30, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x18, 0x07, 0x1F, 0xE0, 0xE7, 0xFF, 0x1D, 0xC1, 0xF3, 0xE0, 0x0E,
  0x78, 0x01, 0xEF, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x70,
  0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x10, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0x0F, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC3,
  0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x3C, 0x1E, 0x07,
  0x80, 0xF0, 0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x70,
  0x00, 0xE7, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0xE7, 0x80, 0x0E,
  0x3C, 0x01, 0xC1, 0xE0, 0x7C, 0x0F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x20,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x1F, 0x03, 0xC0, 0x78, 0x38,
  0x03, 0x87, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x0C, 0x70, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x1F, 0x78, 0x01,
  0xE3, 0x80, 0x36, 0x3E, 0x06, 0x61, 0xFF, 0xEE, 0x0F, 0xF8, 0xE0, 0x1E,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x1E, 0x02, 0x07, 0xC0, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x03, 0x00, 0x00, 0xFF, 0xFF, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0E, 0xFF, 0xFE, 0x3C, 0xF3, 0xCF, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xCF, 0x3C,
  0xE3, 0x8E, 0x71, 0xC7, 0x18, 0x63, 0x8C, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x03, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x3F, 0xE1,
  0xFF, 0xF3, 0xE3, 0xF2, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xE0,
  0x03, 0xC0, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x0E, 0x00,
  0x00, 0x30, 0x1C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x1C, 0x38, 0x00,
  0x00, 0x1C, 0x38, 0x00, 0x00, 0x0C, 0x30, 0x07, 0xFC, 0x0E, 0x70, 0x0F,
  0xFC, 0x0E, 0x70, 0x1C, 0x0C, 0x06, 0x60, 0x38, 0x0C, 0x06, 0xE0, 0x38,
  0x0C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x60,
  0x1C, 0x07, 0xC0, 0x60, 0x1C, 0x07, 0xC0, 0x60, 0x1C, 0x07, 0xC0, 0xE0,
  0x1C, 0x07, 0xC0, 0xE0, 0x1C, 0x07, 0xC0, 0xE0, 0x1C, 0x07, 0xC0, 0x60,
  0x1C, 0x06, 0xC0, 0x60, 0x1C, 0x06, 0xC0, 0x60, 0x3C, 0x0E, 0xE0, 0x70,
  0x3C, 0x0C, 0xE0, 0x70, 0x6C, 0x1C, 0xE0, 0x3C, 0xE7, 0x38, 0x60, 0x1F,
  0xC7, 0xF8, 0x70, 0x0F, 0x83, 0xE0, 0x70, 0x00, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x06, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x06, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0xC6, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x71, 0xC0, 0x00, 0x38, 0xE0,
  0x00, 0x18, 0x30, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x07, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xC0,
  0x18, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1C, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xC0, 0x0F, 0x8E,
  0x00, 0x1E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1E, 0xE0, 0x00,
  0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70,
  0x00, 0x73, 0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x0F, 0x87, 0xFF, 0xF0,
  0x3F, 0xFF, 0x81, 0xC0, 0x7F, 0x0E, 0x00, 0x3C, 0x70, 0x00, 0x73, 0x80,
  0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x38, 0x00, 0xF1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0x7F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFE,
  0x7E, 0x0F, 0x00, 0x30, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x02, 0x0F, 0xE0, 0xF0, 0x1F, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x10, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0x00, 0x7E, 0x0E,
  0x00, 0x3E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0xE0,
  0x00, 0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00,
  0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77, 0x00, 0x01, 0xEE, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x78, 0xE0, 0x00, 0xE1, 0xC0,
  0x07, 0xC3, 0x80, 0x1F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xEE, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEF, 0xFF, 0xF7, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0xFE, 0x0F, 0xE0, 0xF8, 0x00, 0xE0, 0xF0, 0x00, 0x10,
  0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x39, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x07,
  0x1E, 0x00, 0x03, 0x87, 0x80, 0x01, 0xC1, 0xF0, 0x00, 0xE0, 0x7E, 0x03,
  0xF0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xE0, 0x00, 0x1A, 0x00, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x70, 0xFF, 0xFF, 0xF1, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x0F, 0x87, 0xBF, 0xEF, 0xF1, 0xE0, 0xE0, 0x00, 0x77, 0x00, 0x07,
  0x38, 0x00, 0x79, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x70, 0x03, 0xC3, 0x80,
  0x3C, 0x1C, 0x01, 0xC0, 0xE0, 0x1E, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x70, 0x03, 0x87, 0x00, 0x1C, 0x78,
  0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00, 0x3B, 0xF0, 0x01, 0xDB, 0x80, 0x0F,
  0xCE, 0x00, 0x7C, 0x78, 0x03, 0xC1, 0xC0, 0x1C, 0x0F, 0x00, 0xE0, 0x38,
  0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70,
  0x03, 0x83, 0x80, 0x1E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0xC7, 0x00, 0x0E,
  0x38, 0x00, 0x79, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x3C, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFD, 0x80,
  0x00, 0x0F, 0xFB, 0x80, 0x00, 0x3B, 0xF7, 0x00, 0x00, 0x77, 0xE6, 0x00,
  0x00, 0xEF, 0xCE, 0x00, 0x01, 0x9F, 0x9C, 0x00, 0x07, 0x3F, 0x18, 0x00,
  0x0E, 0x7E, 0x38, 0x00, 0x18, 0xFC, 0x70, 0x00, 0x71, 0xF8, 0x60, 0x00,
  0xE3, 0xF0, 0xE0, 0x01, 0x87, 0xE1, 0xC0, 0x07, 0x0F, 0xC3, 0x80, 0x0E,
  0x1F, 0x83, 0x80, 0x18, 0x3F, 0x07, 0x00, 0x70, 0x7E, 0x0E, 0x00, 0xE0,
  0xFC, 0x0E, 0x01, 0x81, 0xF8, 0x1C, 0x07, 0x03, 0xF0, 0x38, 0x0E, 0x07,
  0xE0, 0x38, 0x18, 0x0F, 0xC0, 0x70, 0x70, 0x1F, 0x80, 0xE0, 0xE0, 0x3F,
  0x00, 0xE1, 0x80, 0x7E, 0x01, 0xC7, 0x00, 0xFC, 0x03, 0x8E, 0x01, 0xF8,
  0x03, 0x98, 0x03, 0xF0, 0x07, 0x70, 0x07, 0xE0, 0x0E, 0xE0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x00,
  0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01,
  0xFB, 0x80, 0x03, 0xF7, 0x80, 0x07, 0xE7, 0x00, 0x0F, 0xCF, 0x00, 0x1F,
  0x8E, 0x00, 0x3F, 0x1E, 0x00, 0x7E, 0x1C, 0x00, 0xFC, 0x3C, 0x01, 0xF8,
  0x38, 0x03, 0xF0, 0x78, 0x07, 0xE0, 0x70, 0x0F, 0xC0, 0xF0, 0x1F, 0x80,
  0xE0, 0x3F, 0x01, 0xE0, 0x7E, 0x01, 0xC0, 0xFC, 0x03, 0xC1, 0xF8, 0x03,
  0x83, 0xF0, 0x07, 0x87, 0xE0, 0x07, 0x0F, 0xC0, 0x0F, 0x1F, 0x80, 0x0E,
  0x3F, 0x00, 0x1E, 0x7E, 0x00, 0x1C, 0xFC, 0x00, 0x3D, 0xF8, 0x00, 0x3B,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3C, 0x01, 0xF0, 0x1E, 0x00,
  0x1C, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x1C, 0x78,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80,
  0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x07, 0x80,
  0xF0, 0x03, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70,
  0x07, 0xCE, 0x00, 0x79, 0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x73, 0x80,
  0x1E, 0x70, 0x1F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF0, 0x3F, 0xE0, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x3F, 0x80, 0x3C, 0x01, 0xF0,
  0x1E, 0x00, 0x1E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00, 0xF0, 0xE0, 0x00,
  0x1C, 0x78, 0x00, 0x07, 0x9C, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9E, 0x00, 0x01,
  0xE3, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x03, 0xC0, 0x1F, 0x87, 0xE0, 0x03, 0xFF, 0xF0, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xE0, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xC1, 0xC0, 0x1F, 0x0E, 0x00, 0x3C, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x3C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0xC7, 0x00, 0x3C, 0x38, 0x07, 0xC1, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0x70,
  0x70, 0x03, 0x83, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x07, 0x70, 0x00, 0x3C,
  0x03, 0xFF, 0x01, 0xFF, 0xFC, 0x7F, 0x3F, 0x1F, 0x00, 0x63, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x7B, 0x00, 0x1E, 0x7E,
  0x0F, 0xCF, 0xFF, 0xE0, 0x7F, 0xF8, 0x00, 0x30, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F,
  0x00, 0x01, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x38, 0xE0, 0x01, 0xE3, 0xC0,
  0x0F, 0x07, 0xE0, 0xF8, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x02, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x38, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0xC0, 0x01, 0xC1, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x00, 0xC3,
  0x80, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x67,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1E,
  0x00, 0x0E, 0x70, 0x00, 0xF8, 0x00, 0x39, 0xC0, 0x03, 0xE0, 0x00, 0xE7,
  0x00, 0x0D, 0xC0, 0x03, 0x9C, 0x00, 0x37, 0x00, 0x1C, 0x70, 0x01, 0xDC,
  0x00, 0x70, 0xE0, 0x07, 0x30, 0x01, 0xC3, 0x80, 0x1C, 0xE0, 0x07, 0x0E,
  0x00, 0x63, 0x80, 0x1C, 0x38, 0x01, 0x8E, 0x00, 0xE0, 0x70, 0x0E, 0x38,
  0x03, 0x81, 0xC0, 0x38, 0x60, 0x0E, 0x07, 0x00, 0xE1, 0xC0, 0x38, 0x1C,
  0x03, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x1C, 0x07, 0x00, 0xE0, 0x70, 0x30,
  0x1C, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x0E, 0x06, 0x03, 0x83, 0x80, 0x38,
  0x18, 0x0E, 0x0E, 0x00, 0x70, 0xE0, 0x18, 0x38, 0x01, 0xC3, 0x80, 0x60,
  0xE0, 0x07, 0x0E, 0x01, 0xC3, 0x80, 0x1C, 0x30, 0x07, 0x1C, 0x00, 0x71,
  0xC0, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x31, 0xC0, 0x03, 0x9C, 0x00, 0xE7,
  0x00, 0x0E, 0x60, 0x03, 0xB8, 0x00, 0x39, 0x80, 0x0E, 0xE0, 0x00, 0x6E,
  0x00, 0x1B, 0x80, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x01, 0xB0,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0xE0,
  0x00, 0xE1, 0xC0, 0x07, 0x87, 0x00, 0x1C, 0x1E, 0x00, 0xF0, 0x38, 0x03,
  0x80, 0xE0, 0x0E, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x0E, 0x0E, 0x00,
  0x38, 0x38, 0x00, 0x71, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x38, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00,
  0x73, 0x80, 0x01, 0xC7, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0x38, 0x01, 0xC0,
  0xE0, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0xF0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x0E, 0x70,
  0x00, 0x3B, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00,
  0x03, 0x9C, 0x00, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x03, 0x81, 0xC0, 0x0E,
  0x07, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x01,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1C, 0x00, 0x38, 0x70, 0x00, 0xE1,
  0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80,
  0x01, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01,
  0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xC0, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x1C, 0x60, 0x00, 0x71,
  0xC0, 0x03, 0x83, 0x00, 0x0E, 0x0E, 0x00, 0x70, 0x18, 0x01, 0xC0, 0x70,
  0x0E, 0x00, 0xC0, 0x38, 0x03, 0x81, 0xC0, 0x06, 0x07, 0x00, 0x1C, 0x38,
  0x00, 0x70, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x07, 0xE0, 0x00,
  0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x38, 0x1E, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0x80, 0x01, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x83, 0x01, 0xE1, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0xF8, 0x1F, 0xFC,
  0x3F, 0xFE, 0x7C, 0x07, 0x38, 0x03, 0xB8, 0x01, 0xFC, 0x00, 0xFC, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xB8,
  0x06, 0xDE, 0x06, 0x67, 0xFF, 0x31, 0xFE, 0x18, 0x08, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x38, 0x0E, 0x3F, 0xE1, 0xCF, 0xFE, 0x3B, 0x81, 0xE7, 0xE0, 0x1C,
  0xF8, 0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3B, 0xC0, 0x07, 0x7C, 0x01, 0xEF,
  0xC0, 0x39, 0x9C, 0x1F, 0x31, 0xFF, 0xC6, 0x1F, 0xE0, 0x00, 0x20, 0x00,
  0x00, 0x70, 0x07, 0xFF, 0x0F, 0xFE, 0x1E, 0x02, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x06, 0x0F, 0xFE, 0x07, 0xFE, 0x00, 0x40,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0xF0, 0x70, 0xFF, 0x8E, 0x3F, 0xF9, 0xCF, 0x83, 0xB9,
  0xC0, 0x1F, 0x78, 0x03, 0xEE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3D, 0xC0, 0x07, 0xB8,
  0x01, 0xF3, 0x80, 0x7E, 0x7C, 0x1C, 0xC7, 0xFF, 0x18, 0x3F, 0xC3, 0x00,
  0xC0, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0x01, 0xFF, 0xE0, 0x70, 0x3C, 0x38,
  0x07, 0x1C, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x06, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x21, 0xF0, 0x38, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0x08, 0x00, 0x00, 0x60,
  0x0F, 0xF0, 0x7F, 0xC1, 0xC1, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xFF, 0xCF, 0xFF,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x01, 0xE0,
  0x01, 0xFF, 0x0C, 0x7F, 0xF3, 0x9F, 0x07, 0x73, 0x80, 0x3E, 0xE0, 0x07,
  0xDC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x03, 0xE7, 0x00, 0xDC,
  0xF8, 0x3B, 0x8F, 0xFE, 0x70, 0x7F, 0x8E, 0x01, 0x81, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x80, 0x07, 0x1C, 0x03, 0xE3, 0xFF, 0xF8, 0x3F, 0xFC, 0x00,
  0x7C, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x83, 0xC0, 0xE3, 0xFE, 0x39, 0xFF, 0xCE, 0xE0, 0xF3,
  0xF0, 0x1E, 0xF8, 0x03, 0xBC, 0x00, 0xEF, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0x07, 0x0F, 0x07, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x0F, 0x0E,
  0xFE, 0xFC, 0x70, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x77, 0x00, 0x73, 0x80, 0x71, 0xC0,
  0x38, 0xE0, 0x38, 0x70, 0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0E, 0x1C, 0x07,
  0x1C, 0x03, 0x8E, 0x01, 0xCF, 0x00, 0xEF, 0x80, 0x76, 0xE0, 0x3E, 0x70,
  0x1F, 0x1C, 0x0F, 0x0E, 0x07, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0x70, 0xE0,
  0x38, 0x70, 0x0E, 0x38, 0x07, 0x1C, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x3B,
  0x80, 0x1D, 0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x03, 0x83, 0x0F,
  0xF0, 0x7F, 0x8C, 0xFF, 0xE3, 0xFF, 0xB3, 0x07, 0x9C, 0x1E, 0xF8, 0x0F,
  0x60, 0x3F, 0xC0, 0x1F, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xE0,
  0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x01,
  0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x7E,
  0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80,
  0x0E, 0x00, 0x7E, 0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03,
  0x80, 0x1F, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x01, 0xF8, 0x00, 0xE0,
  0x07, 0xE0, 0x03, 0x80, 0x1F, 0x80, 0x0E, 0x00, 0x7E, 0x00, 0x38, 0x01,
  0xF8, 0x00, 0xE0, 0x07, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x30, 0xFF,
  0x8C, 0x7F, 0xF3, 0x38, 0x3C, 0xD8, 0x07, 0xBE, 0x00, 0xEF, 0x00, 0x3B,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x01, 0xE0, 0x78,
  0x38, 0x03, 0x87, 0x00, 0x1C, 0x70, 0x01, 0xCF, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0xE7,
  0x00, 0x1C, 0x78, 0x01, 0xC3, 0xC0, 0x38, 0x1E, 0x0F, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xF0, 0x18, 0x7F, 0xC3, 0x1F, 0xFC,
  0x67, 0x03, 0xCD, 0xC0, 0x39, 0xF0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x77,
  0x80, 0x0E, 0xF8, 0x03, 0xDF, 0x80, 0x73, 0xB8, 0x3C, 0x73, 0xFF, 0x8E,
  0x3F, 0xC1, 0xC0, 0x40, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x3F, 0xC3, 0x0F, 0xFE, 0x31, 0xF0, 0x77, 0x1C, 0x01, 0xF3, 0xC0, 0x1F,
  0x38, 0x00, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x77, 0x00, 0x07, 0x70, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0x60, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70,
  0x00, 0x77, 0x00, 0x0F, 0x70, 0x00, 0xF3, 0x80, 0x0F, 0x3C, 0x01, 0xF1,
  0xC0, 0x37, 0x1F, 0x07, 0x70, 0xFF, 0xE7, 0x03, 0xFC, 0x70, 0x04, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xEC, 0x3F, 0xC7, 0xFC, 0xF1,
  0xCC, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x1F, 0xFC, 0x3F, 0xFE, 0x78, 0x0E, 0x70, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x0E, 0x00, 0x0E, 0x80, 0x1E, 0xF0, 0x3C, 0xFF, 0xF8, 0x7F, 0xF0,
  0x02, 0x00, 0x0C, 0x00, 0xC0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x0F, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x0E, 0x10, 0xFF, 0x07, 0xF0, 0x08, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0xC0, 0x1F, 0x70, 0x0D, 0xDF, 0x0E, 0x73, 0xFF, 0x9C, 0x7F, 0x87, 0x01,
  0x00, 0x00, 0xE0, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x1C, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x07, 0x00, 0xE0,
  0x70, 0x0E, 0x06, 0x00, 0x60, 0xE0, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07,
  0x1C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0x80, 0x01, 0xB8, 0x00,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x0F, 0x00, 0x1B, 0x80, 0x1F, 0x00, 0x77,
  0x00, 0x3E, 0x00, 0xE7, 0x00, 0x6C, 0x01, 0xCE, 0x01, 0xD8, 0x03, 0x9C,
  0x03, 0xB8, 0x0E, 0x38, 0x06, 0x70, 0x1C, 0x38, 0x0C, 0xE0, 0x38, 0x70,
  0x38, 0xC0, 0x70, 0xE0, 0x71, 0xC0, 0xC1, 0xC0, 0xE3, 0x83, 0x81, 0x81,
  0x87, 0x07, 0x03, 0x87, 0x06, 0x0E, 0x07, 0x0E, 0x0C, 0x18, 0x0E, 0x1C,
  0x1C, 0x70, 0x0C, 0x30, 0x38, 0xE0, 0x1C, 0xE0, 0x31, 0xC0, 0x39, 0xC0,
  0x63, 0x00, 0x73, 0x80, 0xE6, 0x00, 0xE6, 0x01, 0xDC, 0x00, 0xCC, 0x03,
  0xB8, 0x01, 0xF8, 0x03, 0x60, 0x03, 0xF0, 0x06, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x07, 0x80, 0x1F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xCE, 0x00, 0x78, 0xE0, 0x0E, 0x1E, 0x03, 0xC1, 0xC0,
  0x70, 0x3C, 0x1C, 0x03, 0x83, 0x80, 0x78, 0xE0, 0x07, 0x1C, 0x00, 0x77,
  0x00, 0x0E, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x1C, 0x70, 0x07, 0x8E,
  0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x03,
  0x8E, 0x00, 0x79, 0xC0, 0x07, 0x70, 0x00, 0xF0, 0x70, 0x00, 0x77, 0x00,
  0x0E, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x1C, 0x18,
  0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x07, 0x00, 0x60, 0x70, 0x07, 0x07, 0x00, 0x70, 0x60,
  0x07, 0x0E, 0x00, 0x38, 0xE0, 0x03, 0x8C, 0x00, 0x39, 0xC0, 0x01, 0x9C,
  0x00, 0x1D, 0xC0, 0x01, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x78, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0xFC, 0x07, 0xF8, 0x0F, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x03, 0xC0, 0x3F, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0xE0, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x1F,
  0x00, 0xFC, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x04, 0x00, 0x01, 0xFE, 0x00, 0x5F,
  0xFC, 0x07, 0xC1, 0xFD, 0xF8, 0x03, 0xFF, 0x40, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 38, 12, 4, -38 },
  { 20, 12, 14, 18, 3, -38 },
  { 41, 25, 38, 27, 1, -38 },
  { 160, 20, 43, 24, 2, -40 },
  { 268, 31, 38, 36, 2, -38 },
  { 416, 25, 39, 27, 2, -38 },
  { 538, 4, 14, 10, 3, -38 },
  { 545, 11, 46, 15, 2, -38 },
  { 609, 10, 46, 15, 2, -38 },
  { 667, 18, 17, 22, 2, -40 },
  { 706, 20, 25, 24, 2, -31 },
  { 769, 6, 13, 11, 2, -6 },
  { 779, 11, 3, 15, 2, -16 },
  { 784, 4, 5, 11, 4, -5 },
  { 787, 17, 38, 19, 1, -38 },
  { 868, 20, 38, 24, 2, -38 },
  { 963, 11, 38, 24, 4, -38 },
  { 1016, 20, 38, 24, 2, -38 },
  { 1111, 19, 39, 24, 2, -38 },
  { 1204, 23, 38, 24, 1, -38 },
  { 1314, 19, 39, 24, 3, -38 },
  { 1407, 19, 39, 24, 3, -38 },
  { 1500, 20, 38, 24, 2, -38 },
  { 1595, 20, 39, 24, 2, -38 },
  { 1693, 20, 39, 24, 2, -38 },
  { 1791, 4, 28, 11, 4, -28 },
  { 1805, 6, 35, 11, 2, -28 },
  { 1832, 20, 24, 24, 2, -31 },
  { 1892, 20, 14, 24, 2, -26 },
  { 1927, 21, 24, 24, 2, -31 },
  { 1990, 15, 38, 17, 1, -38 },
  { 2062, 32, 43, 37, 3, -38 },
  { 2234, 25, 38, 25, 0, -38 },
  { 2353, 21, 38, 27, 4, -38 },
  { 2453, 21, 39, 26, 3, -38 },
  { 2556, 23, 38, 30, 4, -38 },
  { 2666, 17, 38, 23, 4, -38 },
  { 2747, 17, 38, 22, 4, -38 },
  { 2828, 25, 39, 31, 3, -38 },
  { 2950, 22, 38, 30, 4, -38 },
  { 3055, 10, 38, 14, 2, -38 },
  { 3103, 10, 48, 12, -3, -38 },
  { 3163, 21, 38, 25, 4, -38 },
  { 3263, 16, 38, 21, 4, -38 },
  { 3339, 31, 38, 39, 4, -38 },
  { 3487, 23, 38, 31, 4, -38 },
  { 3597, 26, 39, 32, 3, -38 },
  { 3724, 19, 38, 25, 4, -38 },
  { 3815, 26, 47, 32, 3, -38 },
  { 3968, 21, 38, 26, 4, -38 },
  { 4068, 19, 39, 24, 2, -38 },
  { 4161, 21, 38, 22, 0, -38 },
  { 4261, 22, 39, 30, 4, -38 },
  { 4369, 24, 38, 24, 0, -38 },
  { 4483, 38, 38, 40, 1, -38 },
  { 4664, 22, 38, 22, 0, -38 },
  { 4769, 22, 38, 22, 0, -38 },
  { 4874, 18, 38, 22, 2, -38 },
  { 4960, 11, 46, 17, 4, -38 },
  { 5024, 17, 38, 18, 1, -38 },
  { 5105, 10, 46, 17, 2, -38 },
  { 5163, 22, 21, 25, 1, -38 },
  { 5221, 22, 2, 22, 0, 5 },
  { 5227, 9, 9, 13, 2, -41 },
  { 5238, 17, 30, 23, 2, -29 },
  { 5302, 19, 41, 26, 4, -40 },
  { 5400, 16, 30, 20, 3, -29 },
  { 5460, 19, 41, 26, 3, -40 },
  { 5558, 18, 30, 24, 3, -29 },
  { 5626, 14, 41, 14, 1, -41 },
  { 5698, 19, 42, 26, 3, -29 },
  { 5798, 18, 40, 26, 4, -40 },
  { 5888, 3, 39, 11, 4, -39 },
  { 5903, 8, 52, 11, -1, -39 },
  { 5955, 17, 40, 21, 4, -40 },
  { 6040, 3, 40, 11, 4, -40 },
  { 6055, 30, 29, 38, 4, -29 },
  { 6164, 18, 29, 26, 4, -29 },
  { 6230, 20, 30, 25, 3, -29 },
  { 6305, 19, 42, 26, 4, -29 },
  { 6405, 20, 42, 26, 2, -29 },
  { 6510, 12, 29, 17, 4, -29 },
  { 6554, 16, 30, 20, 2, -29 },
  { 6614, 12, 36, 14, 1, -35 },
  { 6668, 18, 29, 26, 4, -28 },
  { 6734, 20, 28, 20, 0, -28 },
  { 6804, 31, 28, 32, 1, -28 },
  { 6913, 19, 28, 21, 1, -28 },
  { 6980, 20, 41, 20, 0, -28 },
  { 7083, 14, 28, 18, 2, -28 },
  { 7132, 15, 46, 19, 2, -38 },
  { 7219, 3, 53, 23, 10, -40 },
  { 7239, 15, 46, 19, 2, -38 },
  { 7326, 21, 6, 24, 2, -22 },
};

const GFXfont NotoSans_Condensed_Light53pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light53pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light53pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _NOTOSANS_CONDENSED_LIGHT53PT7B_H_
