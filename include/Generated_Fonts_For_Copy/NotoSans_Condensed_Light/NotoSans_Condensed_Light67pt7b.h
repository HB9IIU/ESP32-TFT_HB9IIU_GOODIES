#ifndef _NOTOSANS_CONDENSED_LIGHT67PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT67PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 67pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light67pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xDC, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE0,
  0x00, 0x00, 0x00, 0x1D, 0xFF, 0xFF, 0xFF, 0x20, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x80, 0xFF, 0x01, 0xEE, 0x03, 0xDC, 0x07, 0xB8, 0x0F, 0x70,
  0x1C, 0xE0, 0x39, 0xC0, 0x73, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x1C, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xC0, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x0F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x07,
  0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80,
  0x3F, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x01,
  0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x07, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0xC0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x03, 0x80, 0x38, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x06, 0x00, 0x00, 0x03, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F,
  0x98, 0x7C, 0x1E, 0x0C, 0x06, 0x1E, 0x06, 0x00, 0x0F, 0x03, 0x00, 0x0F,
  0x01, 0x80, 0x07, 0x80, 0xC0, 0x03, 0x80, 0x60, 0x01, 0xC0, 0x30, 0x00,
  0xE0, 0x18, 0x00, 0x70, 0x0C, 0x00, 0x3C, 0x06, 0x00, 0x1E, 0x03, 0x00,
  0x07, 0x81, 0x80, 0x03, 0xE0, 0xC0, 0x00, 0xF8, 0x60, 0x00, 0x3F, 0x30,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xDF, 0xC0, 0x00, 0x63, 0xF0, 0x00,
  0x30, 0x7C, 0x00, 0x18, 0x1E, 0x00, 0x0C, 0x07, 0x80, 0x06, 0x01, 0xC0,
  0x03, 0x00, 0xE0, 0x01, 0x80, 0x70, 0x00, 0xC0, 0x3C, 0x00, 0x60, 0x1C,
  0x00, 0x30, 0x0E, 0x00, 0x18, 0x07, 0x00, 0x0C, 0x07, 0x80, 0x06, 0x07,
  0x90, 0x03, 0x07, 0xCF, 0x81, 0x87, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x06,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x60, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1C, 0x00,
  0x7F, 0xE0, 0x00, 0x70, 0x00, 0xF3, 0xC0, 0x00, 0xE0, 0x03, 0x83, 0xC0,
  0x03, 0xC0, 0x07, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x07, 0x80, 0x0E, 0x00,
  0x38, 0x07, 0x00, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x01, 0xE0, 0x1C,
  0x01, 0xE0, 0x03, 0x80, 0x3C, 0x03, 0x80, 0x07, 0x00, 0x78, 0x07, 0x00,
  0x0E, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x01,
  0xC0, 0xF0, 0x00, 0x70, 0x03, 0x81, 0xC0, 0x00, 0xE0, 0x07, 0x07, 0x80,
  0x01, 0xC0, 0x0E, 0x0E, 0x00, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0x07, 0x00,
  0x78, 0x78, 0x00, 0x0E, 0x00, 0xF0, 0xE0, 0xFE, 0x1E, 0x01, 0xC3, 0xC3,
  0xFE, 0x1C, 0x03, 0x87, 0x0F, 0xBE, 0x38, 0x07, 0x0E, 0x3C, 0x1C, 0x70,
  0x1E, 0x3C, 0x70, 0x3C, 0x70, 0x38, 0x70, 0xE0, 0x38, 0xF0, 0xF1, 0xE3,
  0x80, 0x70, 0xF3, 0xC3, 0x87, 0x00, 0xF1, 0xFF, 0x07, 0x0E, 0x00, 0xE1,
  0xFC, 0x1C, 0x1C, 0x01, 0xC0, 0x60, 0x38, 0x38, 0x03, 0x80, 0x00, 0xF0,
  0x70, 0x07, 0x00, 0x01, 0xC0, 0xE0, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x1C,
  0x00, 0x0E, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x70, 0x00, 0x78,
  0x0E, 0x00, 0xE0, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x07, 0x00, 0x70, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x3C,
  0x01, 0xC0, 0x3C, 0x00, 0x70, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x03, 0x80,
  0xE0, 0x03, 0x80, 0x07, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0x07, 0x00, 0x1E,
  0x00, 0x0F, 0x1E, 0x00, 0x38, 0x00, 0x0F, 0xF8, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x08, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x78, 0x1E,
  0x00, 0x01, 0xE0, 0x1E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x07, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xC0,
  0x00, 0x70, 0x03, 0x80, 0x00, 0xE0, 0x07, 0x00, 0x01, 0xC0, 0x0E, 0x00,
  0x03, 0xC0, 0x3C, 0x00, 0x07, 0x80, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x0E, 0x0F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3E,
  0x78, 0x00, 0x00, 0xF0, 0x78, 0x01, 0xE3, 0xC0, 0xF0, 0x03, 0x8F, 0x80,
  0xF0, 0x07, 0x1E, 0x00, 0xF0, 0x1E, 0x38, 0x01, 0xF0, 0x3C, 0xF0, 0x01,
  0xE0, 0x79, 0xE0, 0x01, 0xE0, 0xE3, 0x80, 0x01, 0xE3, 0xC7, 0x00, 0x03,
  0xC7, 0x8E, 0x00, 0x03, 0xDE, 0x1C, 0x00, 0x03, 0xFC, 0x38, 0x00, 0x07,
  0xF0, 0x70, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1F,
  0x83, 0xC0, 0x00, 0x7F, 0x83, 0xC0, 0x01, 0xFF, 0x07, 0xC0, 0x07, 0xCF,
  0x07, 0xC0, 0x3F, 0x1F, 0x07, 0xFF, 0xFC, 0x1E, 0x07, 0xFF, 0xE0, 0x1E,
  0x07, 0xFF, 0x00, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x70, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0x80, 0x0E, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x10, 0x0E, 0x03, 0xF8, 0x30, 0x7F, 0xFC, 0xCF, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x73,
  0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78,
  0x1E, 0x01, 0xE0, 0x30, 0x03, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x3C, 0xF9, 0xE3, 0xC7, 0x8F, 0x1C, 0x78, 0xF1, 0xC3, 0x8F, 0x1C, 0x38,
  0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x79, 0xF7, 0xFF,
  0x7D, 0xE1, 0x00, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x7C, 0x1F,
  0x00, 0x78, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00,
  0x1C, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x00, 0x01, 0xC7, 0x80,
  0x00, 0xE3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x70,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xDE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0x38, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x71, 0xE0, 0x00, 0x38, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x0F, 0x80, 0xF0, 0x07, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0xF0, 0x0F, 0xC0, 0x7F, 0x03, 0xFC, 0x1F, 0x70, 0xF9, 0xC7, 0xC7,
  0x3E, 0x1F, 0xE0, 0x77, 0x01, 0xC8, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x10,
  0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x7E, 0x01,
  0xF0, 0x78, 0x00, 0xF8, 0x30, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x10, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF0, 0xFE, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x60, 0x00, 0x3C, 0x40, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x07, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x80, 0x00, 0x7C, 0xF0, 0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xC7, 0x80, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x70,
  0x78, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x38, 0x1E, 0x00, 0x03, 0x80, 0xF0,
  0x00, 0x3C, 0x07, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x70, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1C, 0x00, 0x3C,
  0x01, 0xE0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x03, 0xC0, 0x70, 0x00, 0x1E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03,
  0xC0, 0x3F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xC3, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x9F, 0xF0, 0x0F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFC, 0x1F, 0x83, 0xFC, 0x10, 0x00, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE4, 0x00, 0x0F, 0x8F, 0x00, 0x7F, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x00, 0x80, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1C, 0x07, 0xC0, 0x0E, 0x0F, 0xFC,
  0x07, 0x1F, 0xFF, 0x03, 0x9F, 0xFF, 0xC1, 0xDE, 0x01, 0xF1, 0xEE, 0x00,
  0x7C, 0xFE, 0x00, 0x1E, 0x7E, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1E, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x38, 0xE0, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x07,
  0x81, 0xE0, 0x07, 0x80, 0xF8, 0x07, 0xC0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x0E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xCF, 0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00,
  0x38, 0x70, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0F, 0x00, 0x1E, 0x07, 0xC0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0xBF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x07, 0xC1, 0xE0, 0x01, 0xE0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3E, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0x9E, 0x00, 0x03, 0xCF, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xF8,
  0x03, 0xE0, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xE0, 0x1F, 0x81, 0xF0, 0x3E, 0x00, 0xF8, 0x3C, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x1F, 0x78, 0x00, 0x3F, 0x3C, 0x00, 0x7F, 0x3E, 0x00, 0xEF,
  0x1F, 0xC7, 0xEF, 0x0F, 0xFF, 0xCF, 0x07, 0xFF, 0x0F, 0x01, 0xFC, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x39, 0xF7, 0xFF,
  0x7D, 0xE3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x9F, 0xFF, 0xF7, 0xDE,
  0x10, 0x0E, 0x1F, 0x1F, 0x1F, 0x1F, 0x1F, 0x0C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x0F, 0x1F, 0x1E, 0x1E, 0x1E,
  0x1C, 0x3C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xE0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x10,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0xC0,
  0x01, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0xC7, 0x80, 0xFC, 0xC0, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF8, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x00,
  0x00, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x01, 0xC0, 0x00, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xFF,
  0xE0, 0x3C, 0x78, 0x01, 0xFF, 0xF0, 0x0E, 0x38, 0x01, 0xF0, 0x78, 0x07,
  0x1C, 0x01, 0xE0, 0x1C, 0x03, 0x8E, 0x00, 0xE0, 0x0E, 0x01, 0xEF, 0x00,
  0xF0, 0x0F, 0x00, 0xF7, 0x00, 0x70, 0x07, 0x80, 0x3B, 0x80, 0x78, 0x03,
  0xC0, 0x1D, 0xC0, 0x38, 0x01, 0xE0, 0x0E, 0xE0, 0x1C, 0x00, 0xF0, 0x07,
  0x70, 0x0E, 0x00, 0x78, 0x03, 0xB8, 0x07, 0x00, 0x3C, 0x01, 0xDC, 0x03,
  0x80, 0x1C, 0x00, 0xFE, 0x03, 0xC0, 0x0E, 0x00, 0x7F, 0x01, 0xE0, 0x07,
  0x00, 0x3F, 0x80, 0xF0, 0x03, 0x80, 0x3D, 0xC0, 0x38, 0x01, 0xC0, 0x1C,
  0xE0, 0x1C, 0x00, 0xE0, 0x0E, 0x70, 0x0E, 0x00, 0xF0, 0x07, 0x38, 0x07,
  0x00, 0x78, 0x03, 0x9C, 0x03, 0xC0, 0x3E, 0x03, 0x8E, 0x00, 0xE0, 0x3F,
  0x01, 0xC7, 0x00, 0x78, 0x39, 0xC1, 0xC3, 0xC0, 0x1F, 0x7C, 0xFB, 0xE0,
  0xE0, 0x0F, 0xFC, 0x3F, 0xE0, 0x70, 0x03, 0xFC, 0x0F, 0xE0, 0x3C, 0x00,
  0x10, 0x00, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x06,
  0x00, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x1C,
  0x78, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x78,
  0x1C, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x70, 0x1E, 0x00, 0x00, 0xF0,
  0x0E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xE0,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x0F, 0x00, 0x01, 0xE0, 0x0F, 0x00,
  0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x00, 0x3C, 0x38, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1C, 0x03, 0xFF, 0x0E, 0x00,
  0x0F, 0xC7, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x79, 0xC0, 0x00, 0x3C, 0xE0,
  0x00, 0x0F, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEE,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x0F,
  0x8E, 0x00, 0x1F, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x7E, 0x38, 0x00, 0x0F, 0x9C, 0x00,
  0x03, 0xCE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xB8, 0x00, 0x0F,
  0x9C, 0x00, 0x0F, 0x8E, 0x00, 0x3F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xC0, 0x3C, 0x07, 0xE0, 0x00,
  0x81, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x04,
  0x07, 0xF0, 0x03, 0x80, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xE0, 0x01, 0xFC, 0x0E, 0x00,
  0x07, 0xE0, 0xE0, 0x00, 0x3F, 0x0E, 0x00, 0x01, 0xF0, 0xE0, 0x00, 0x0F,
  0x8E, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x07, 0xCE, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xCE, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x03, 0xCE, 0x00, 0x00, 0x7C, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00,
  0xF8, 0xE0, 0x00, 0x1F, 0x0E, 0x00, 0x03, 0xE0, 0xE0, 0x00, 0x7E, 0x0E,
  0x00, 0x1F, 0xC0, 0xE0, 0x1F, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEE, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEE, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0, 0x0F,
  0xC0, 0x7E, 0x00, 0x03, 0x81, 0xF8, 0x00, 0x01, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x03,
  0x9F, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x0E, 0x3E, 0x00, 0x00, 0x1C,
  0x3E, 0x00, 0x00, 0x38, 0x3E, 0x00, 0x00, 0x70, 0x3F, 0x00, 0x00, 0xE0,
  0x3F, 0x80, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xFE, 0xFF, 0xFF,
  0xFF, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0xC3, 0xF7, 0xFF, 0x3F,
  0xF1, 0xFF, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xB8, 0x00, 0x07,
  0x9C, 0x00, 0x07, 0x8E, 0x00, 0x07, 0xC7, 0x00, 0x03, 0xC3, 0x80, 0x03,
  0xC1, 0xC0, 0x03, 0xE0, 0xE0, 0x01, 0xE0, 0x70, 0x01, 0xE0, 0x38, 0x01,
  0xF0, 0x1C, 0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x03, 0x80,
  0xF8, 0x01, 0xC0, 0x78, 0x00, 0xE0, 0x78, 0x00, 0x70, 0x7C, 0x00, 0x38,
  0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x0E, 0x3E, 0x00, 0x07, 0x1F, 0x00, 0x03,
  0x9F, 0x80, 0x01, 0xDF, 0xE0, 0x00, 0xEE, 0xF0, 0x00, 0x7F, 0x3C, 0x00,
  0x3F, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x00, 0xF0,
  0x03, 0x80, 0x7C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x80, 0x70, 0x03,
  0xC0, 0x38, 0x00, 0xF0, 0x1C, 0x00, 0x78, 0x0E, 0x00, 0x1E, 0x07, 0x00,
  0x0F, 0x03, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0x78, 0x70,
  0x00, 0x3E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x07, 0x7F, 0xE0, 0x00, 0x00, 0x1D, 0xFB, 0x80, 0x00, 0x00, 0xF7, 0xEF,
  0x00, 0x00, 0x03, 0x9F, 0xBC, 0x00, 0x00, 0x0E, 0x7E, 0x70, 0x00, 0x00,
  0x79, 0xF9, 0xE0, 0x00, 0x01, 0xCF, 0xE7, 0x80, 0x00, 0x07, 0x3F, 0x8E,
  0x00, 0x00, 0x3C, 0xFE, 0x3C, 0x00, 0x00, 0xE3, 0xF8, 0xF0, 0x00, 0x03,
  0x8F, 0xE1, 0xC0, 0x00, 0x1E, 0x3F, 0x87, 0x80, 0x00, 0x70, 0xFE, 0x1E,
  0x00, 0x01, 0xC3, 0xF8, 0x38, 0x00, 0x0F, 0x0F, 0xE0, 0xF0, 0x00, 0x38,
  0x3F, 0x83, 0xC0, 0x00, 0xE0, 0xFE, 0x07, 0x00, 0x07, 0x83, 0xF8, 0x1E,
  0x00, 0x1E, 0x0F, 0xE0, 0x78, 0x00, 0x70, 0x3F, 0x80, 0xE0, 0x03, 0xC0,
  0xFE, 0x03, 0xC0, 0x0F, 0x03, 0xF8, 0x0F, 0x00, 0x38, 0x0F, 0xE0, 0x1C,
  0x01, 0xE0, 0x3F, 0x80, 0x78, 0x07, 0x80, 0xFE, 0x01, 0xE0, 0x1C, 0x03,
  0xF8, 0x03, 0x80, 0xF0, 0x0F, 0xE0, 0x0F, 0x03, 0xC0, 0x3F, 0x80, 0x3C,
  0x0E, 0x00, 0xFE, 0x00, 0x70, 0x78, 0x03, 0xF8, 0x01, 0xC1, 0xE0, 0x0F,
  0xE0, 0x07, 0x87, 0x00, 0x3F, 0x80, 0x0E, 0x3C, 0x00, 0xFE, 0x00, 0x38,
  0xF0, 0x03, 0xF8, 0x00, 0xF3, 0x80, 0x0F, 0xE0, 0x03, 0xCE, 0x00, 0x3F,
  0x80, 0x07, 0x78, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7E, 0xF0, 0x00,
  0x07, 0xEF, 0x00, 0x00, 0x7E, 0x78, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7E,
  0x3C, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x7E, 0x1E, 0x00, 0x07, 0xE1, 0xE0,
  0x00, 0x7E, 0x0F, 0x00, 0x07, 0xE0, 0xF0, 0x00, 0x7E, 0x07, 0x80, 0x07,
  0xE0, 0x78, 0x00, 0x7E, 0x03, 0xC0, 0x07, 0xE0, 0x3C, 0x00, 0x7E, 0x01,
  0xE0, 0x07, 0xE0, 0x1E, 0x00, 0x7E, 0x00, 0xF0, 0x07, 0xE0, 0x0F, 0x00,
  0x7E, 0x00, 0x78, 0x07, 0xE0, 0x07, 0x80, 0x7E, 0x00, 0x3C, 0x07, 0xE0,
  0x03, 0xC0, 0x7E, 0x00, 0x1E, 0x07, 0xE0, 0x01, 0xE0, 0x7E, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0xF0, 0x7E, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x78, 0x7E,
  0x00, 0x03, 0xC7, 0xE0, 0x00, 0x3C, 0x7E, 0x00, 0x01, 0xE7, 0xE0, 0x00,
  0x1E, 0x7E, 0x00, 0x00, 0xF7, 0xE0, 0x00, 0x0F, 0x7E, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xE0,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x00, 0x78, 0x78, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0E,
  0x00, 0x3F, 0x1C, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x70, 0x00, 0x1E, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00, 0x03,
  0xDC, 0x00, 0x0F, 0x38, 0x00, 0x3E, 0x70, 0x00, 0xF8, 0xE0, 0x07, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x3E,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x77, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0F, 0x78, 0x00,
  0x00, 0x07, 0x9C, 0x00, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFE, 0x0E, 0x00, 0x3F, 0x07, 0x00, 0x07, 0xC3, 0x80, 0x01, 0xF1,
  0xC0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x07,
  0x9C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xF3, 0x80, 0x00,
  0x79, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x38, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0x8E, 0x00, 0x07, 0x87, 0x00, 0x07, 0xC3, 0x80,
  0x07, 0xC1, 0xC0, 0x0F, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0x1C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x3C, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x80, 0x70, 0x01, 0xE0,
  0x38, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x07, 0x00, 0x07,
  0x83, 0x80, 0x03, 0xC1, 0xC0, 0x00, 0xF0, 0xE0, 0x00, 0x78, 0x70, 0x00,
  0x1E, 0x38, 0x00, 0x0F, 0x1C, 0x00, 0x03, 0xCE, 0x00, 0x01, 0xE7, 0x00,
  0x00, 0x7B, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0x0F, 0x00, 0x04, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xC0, 0x7C, 0x3F,
  0x00, 0x04, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0xC0, 0x00, 0xFC, 0xF8,
  0x01, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x0F, 0xC0, 0x3F, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x79, 0xE0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0xF0, 0x38, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x3C,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xC0, 0x0F, 0x00, 0x03, 0xC0, 0x1E, 0x00, 0x07,
  0x80, 0x38, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x0E, 0x01, 0xE0, 0x00, 0x1E,
  0x03, 0xC0, 0x00, 0x3C, 0x07, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x78,
  0x3C, 0x00, 0x00, 0xF0, 0x70, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x07, 0x3C,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3C, 0x38, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x07, 0x38, 0x00,
  0x1E, 0x0F, 0x00, 0x03, 0x9C, 0x00, 0x0F, 0x07, 0x80, 0x01, 0xCE, 0x00,
  0x07, 0x83, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xC0, 0xE0, 0x00, 0xF3, 0xC0,
  0x01, 0xC0, 0x78, 0x00, 0x70, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x38, 0x70,
  0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x1E,
  0x00, 0x3C, 0x03, 0xC0, 0x0E, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x03,
  0x80, 0x1E, 0x00, 0xF0, 0x03, 0x81, 0xC0, 0x0F, 0x00, 0x38, 0x03, 0xC0,
  0xF0, 0x07, 0x80, 0x1E, 0x01, 0xE0, 0x78, 0x03, 0x80, 0x0F, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x03, 0xC0, 0x78,
  0x07, 0x00, 0xF0, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x70, 0x00, 0x78, 0x1C,
  0x00, 0xE0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0x1E, 0x07,
  0x00, 0x38, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x03, 0xC3,
  0xC0, 0x0F, 0x07, 0x00, 0x01, 0xE1, 0xC0, 0x03, 0x87, 0x80, 0x00, 0xF0,
  0xE0, 0x01, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0xE1, 0xE0, 0x00, 0x1C,
  0x78, 0x00, 0x78, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0x9C, 0x00, 0x0E, 0x78, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0xEF, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x80, 0x01, 0xEE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1E, 0x1E, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x01, 0xC0, 0x1C, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x39, 0xE0, 0x00,
  0x07, 0x8E, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0,
  0x78, 0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0xF0,
  0x00, 0xF0, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x3D, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x0F, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x38, 0x1E, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x03, 0x80, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0F, 0x00, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x1E, 0x03, 0xC0,
  0x01, 0xC0, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x78,
  0x78, 0x00, 0x0F, 0x0E, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x1E, 0x70, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00,
  0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xE0, 0xF0,
  0x00, 0x1C, 0x07, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x70, 0x3C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0x38, 0x78, 0x00, 0x03, 0xC7, 0x00, 0x00, 0x1C, 0xF0, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x0F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E,
  0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0xFF, 0x00, 0x7F, 0xFE, 0x0F,
  0xFF, 0xF8, 0x3C, 0x07, 0xE1, 0x80, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x03, 0xFF,
  0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xF8, 0x0E, 0x7C, 0x00, 0x77, 0xC0,
  0x03, 0xBC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x37, 0x7C, 0x03, 0xB9, 0xFC, 0xF9, 0xC7,
  0xFF, 0x8E, 0x1F, 0xF0, 0x30, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0xFF, 0x00, 0xF1, 0xFF,
  0xE0, 0x79, 0xFF, 0xF8, 0x3D, 0xE0, 0x7E, 0x1E, 0xE0, 0x0F, 0x8F, 0xE0,
  0x03, 0xC7, 0x60, 0x00, 0xF3, 0xE0, 0x00, 0x79, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1D, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00,
  0x03, 0xCF, 0xC0, 0x01, 0xE7, 0x60, 0x01, 0xE3, 0xB8, 0x01, 0xF1, 0xCE,
  0x01, 0xF0, 0xE3, 0xFF, 0xF0, 0x70, 0xFF, 0xF0, 0x38, 0x3F, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E,
  0x07, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x10, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x01,
  0xFE, 0x0F, 0x03, 0xFF, 0xC7, 0x83, 0xFF, 0xF3, 0xC3, 0xF0, 0x3D, 0xE3,
  0xE0, 0x0E, 0xF1, 0xE0, 0x03, 0xF9, 0xE0, 0x00, 0xFC, 0xF0, 0x00, 0x3E,
  0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xEE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xE7, 0x00, 0x01, 0xF3, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0xDC,
  0x78, 0x00, 0xEE, 0x3F, 0x01, 0xE7, 0x0F, 0xFF, 0xE3, 0x83, 0xFF, 0xE1,
  0xC0, 0x7F, 0xE0, 0xE0, 0x07, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x07, 0xFF, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00, 0x04, 0x0F, 0xC0, 0x1C, 0x07, 0xFF,
  0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0x81, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0xF8, 0xFF, 0xFE,
  0x3F, 0xFF, 0x80, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x03, 0x81, 0xFF, 0xE1, 0xC1,
  0xFF, 0xF8, 0xE1, 0xF8, 0x1E, 0x71, 0xF0, 0x07, 0xF8, 0xF0, 0x01, 0xFC,
  0xF0, 0x00, 0x7E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07,
  0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF3, 0x80, 0x00, 0xF9,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x3C, 0x00, 0x6F, 0x0F, 0x80, 0xF7,
  0x87, 0xFF, 0xF3, 0xC1, 0xFF, 0xF1, 0xE0, 0x3F, 0xF0, 0xF0, 0x03, 0x80,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF1, 0x00, 0x00, 0xF8, 0x60, 0x00, 0xF8, 0x3F,
  0x01, 0xF8, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x1F, 0xE0, 0xF1, 0xFF, 0xE3, 0xCF,
  0xFF, 0xCF, 0x78, 0x1F, 0xBF, 0xC0, 0x1E, 0xEE, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xC0, 0x73, 0xFF, 0xF7,
  0xBC, 0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF,
  0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE,
  0xF7, 0xBD, 0xEF, 0x78, 0x03, 0x80, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x0E, 0x07, 0xA3, 0xEF, 0xF3, 0xF8,
  0xFC, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0xF0, 0x00,
  0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0x83,
  0xC0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3C, 0x03, 0xC0,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF1, 0xE0, 0x03, 0xC7, 0x80,
  0x0F, 0x3E, 0x00, 0x3D, 0xFC, 0x00, 0xE7, 0xF0, 0x03, 0xB9, 0xE0, 0x0F,
  0xC7, 0x80, 0x3F, 0x0F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x1E, 0x0F, 0x00, 0x78,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x00, 0x1E, 0x3C,
  0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0xFF, 0x00, 0x7F, 0xC3, 0x87, 0xFF, 0x03, 0xFF, 0x8E, 0x3F,
  0xFE, 0x1F, 0xFF, 0x39, 0xE0, 0xF8, 0xF0, 0x7E, 0xEE, 0x01, 0xF7, 0x00,
  0x7B, 0xB0, 0x03, 0xD8, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x03, 0xFE, 0x00,
  0x1F, 0x00, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0xC0, 0x01, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00,
  0x78, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x01,
  0xFC, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01,
  0xE0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x07,
  0xF0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07,
  0x80, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1F,
  0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0xF0, 0x00, 0x78, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0x78,
  0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x80, 0x01, 0xFC,
  0x00, 0x1E, 0x00, 0x07, 0xE0, 0x7F, 0x83, 0x87, 0xFF, 0x8E, 0x3F, 0xFF,
  0x39, 0xE0, 0x7E, 0xEF, 0x00, 0x7B, 0xB0, 0x01, 0xFE, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0x03, 0xF0, 0x1F, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x70, 0x00,
  0x07, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x1E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0,
  0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x01, 0xE0,
  0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x7F, 0x80, 0x70,
  0xFF, 0xF0, 0x38, 0xFF, 0xFC, 0x1C, 0xF0, 0x3F, 0x0E, 0x70, 0x07, 0xC7,
  0x70, 0x01, 0xE3, 0xB0, 0x00, 0x79, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F,
  0x7C, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1D, 0xE0, 0x00, 0x0E, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xCF,
  0x80, 0x01, 0xE7, 0xE0, 0x00, 0xF3, 0xB0, 0x00, 0xF1, 0xDC, 0x00, 0xF8,
  0xF7, 0x80, 0xF8, 0x79, 0xFF, 0xF8, 0x3C, 0x7F, 0xF8, 0x1E, 0x1F, 0xF8,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x03, 0x81, 0xFF, 0xE1, 0xC1, 0xFF, 0xF8,
  0xE1, 0xF8, 0x1E, 0x71, 0xF0, 0x07, 0x38, 0xF0, 0x01, 0xFC, 0xF0, 0x00,
  0x7E, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xBC, 0x00, 0x03,
  0xDE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0x80, 0x00, 0xF9, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0x7E, 0x3C, 0x00, 0x6F, 0x0F, 0x80, 0xF7, 0x87, 0xFF,
  0xF3, 0xC1, 0xFF, 0xF1, 0xE0, 0x3F, 0xE0, 0xF0, 0x03, 0x80, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0xE0, 0x7F,
  0xC3, 0xFF, 0x8F, 0xFF, 0x3F, 0x3E, 0x70, 0x1D, 0xC0, 0x3B, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x07, 0xFF, 0x03, 0xFF, 0xF8, 0xFF,
  0xFF, 0xBF, 0x01, 0xE7, 0x80, 0x05, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x1E, 0xE0, 0x07,
  0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x1F, 0xFE, 0x00, 0x7C, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x1F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0xFF, 0x03, 0xFF,
  0x01, 0xFF, 0x00, 0x38, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xF7, 0x80, 0x0D, 0xDE, 0x00, 0x77, 0x7C, 0x03, 0x9C, 0xFF,
  0xFE, 0x71, 0xFF, 0xF1, 0xC3, 0xFF, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0xB8, 0x00, 0x03, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x1C,
  0x00, 0x1C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x80,
  0xE0, 0x03, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x00, 0x70, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x70, 0x1C,
  0x00, 0x3C, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x1C,
  0xF0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xEE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xE0, 0x00, 0xF7, 0x00,
  0x07, 0xE0, 0x01, 0xCF, 0x00, 0x1D, 0xC0, 0x07, 0x9E, 0x00, 0x3B, 0x80,
  0x0F, 0x3C, 0x00, 0x77, 0x00, 0x1E, 0x38, 0x00, 0xEF, 0x00, 0x38, 0x78,
  0x03, 0xCE, 0x00, 0x70, 0xF0, 0x07, 0x9C, 0x01, 0xE1, 0xE0, 0x0E, 0x38,
  0x03, 0xC1, 0xC0, 0x1C, 0x78, 0x07, 0x03, 0x80, 0x78, 0x70, 0x0E, 0x07,
  0x80, 0xF0, 0xE0, 0x3C, 0x0F, 0x01, 0xC1, 0xC0, 0x78, 0x0E, 0x03, 0x83,
  0xC0, 0xE0, 0x1C, 0x0F, 0x07, 0x81, 0xC0, 0x3C, 0x1E, 0x07, 0x03, 0x80,
  0x78, 0x38, 0x0E, 0x0F, 0x00, 0xF0, 0x70, 0x1E, 0x1E, 0x00, 0xE1, 0xE0,
  0x3C, 0x38, 0x01, 0xE3, 0xC0, 0x38, 0x70, 0x03, 0xC7, 0x00, 0x71, 0xE0,
  0x07, 0x8E, 0x00, 0xE3, 0xC0, 0x07, 0x1C, 0x01, 0xE7, 0x00, 0x0E, 0x78,
  0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x03, 0x9C, 0x00, 0x3D, 0xC0, 0x07, 0x78,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07,
  0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xE3, 0xC0, 0x01,
  0xE7, 0x80, 0x00, 0xF7, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xF7, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0x80, 0x03,
  0xC3, 0xC0, 0x03, 0xC1, 0xC0, 0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x38, 0x00, 0x3C, 0x3C,
  0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1E,
  0x00, 0x78, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x03,
  0x81, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x8F,
  0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xF0,
  0x03, 0xFC, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x0C, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x17,
  0xFF, 0xE0, 0x0F, 0xE0, 0xFF, 0x9F, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF,
  0xC8, 0x00, 0x07, 0xC0,
};

const GFXglyph NotoSans_Condensed_Light67pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 49, 15, 5, -48 },
  { 32, 15, 17, 23, 4, -48 },
  { 64, 31, 48, 34, 1, -48 },
  { 250, 25, 55, 31, 3, -51 },
  { 422, 39, 50, 45, 3, -49 },
  { 666, 31, 50, 35, 3, -49 },
  { 860, 4, 17, 13, 4, -48 },
  { 869, 13, 59, 19, 3, -48 },
  { 965, 13, 59, 19, 2, -48 },
  { 1061, 22, 22, 28, 3, -51 },
  { 1122, 26, 31, 31, 2, -39 },
  { 1223, 7, 16, 14, 3, -7 },
  { 1237, 15, 4, 19, 2, -20 },
  { 1245, 6, 7, 14, 4, -6 },
  { 1251, 21, 48, 23, 1, -48 },
  { 1377, 25, 50, 31, 3, -49 },
  { 1534, 14, 48, 31, 5, -48 },
  { 1618, 24, 49, 31, 3, -49 },
  { 1765, 24, 50, 31, 3, -49 },
  { 1915, 29, 48, 31, 1, -48 },
  { 2089, 23, 49, 31, 4, -48 },
  { 2230, 25, 49, 31, 3, -48 },
  { 2384, 25, 48, 31, 3, -48 },
  { 2534, 25, 50, 31, 3, -49 },
  { 2691, 24, 50, 31, 3, -49 },
  { 2841, 6, 37, 14, 4, -36 },
  { 2869, 8, 45, 14, 2, -36 },
  { 2914, 26, 30, 31, 2, -39 },
  { 3012, 26, 17, 31, 2, -32 },
  { 3068, 26, 30, 31, 2, -39 },
  { 3166, 19, 50, 22, 1, -49 },
  { 3285, 41, 54, 47, 3, -48 },
  { 3562, 32, 48, 32, 0, -48 },
  { 3754, 25, 48, 34, 6, -48 },
  { 3904, 27, 50, 33, 4, -49 },
  { 4073, 28, 48, 37, 6, -48 },
  { 4241, 20, 48, 29, 6, -48 },
  { 4361, 20, 48, 27, 6, -48 },
  { 4481, 31, 50, 40, 4, -49 },
  { 4675, 27, 48, 38, 6, -48 },
  { 4837, 12, 48, 18, 3, -48 },
  { 4909, 13, 60, 15, -4, -48 },
  { 5007, 25, 48, 31, 6, -48 },
  { 5157, 20, 48, 27, 6, -48 },
  { 5277, 38, 48, 50, 6, -48 },
  { 5505, 28, 48, 40, 6, -48 },
  { 5673, 33, 50, 40, 4, -49 },
  { 5880, 23, 48, 31, 6, -48 },
  { 6018, 33, 60, 40, 4, -49 },
  { 6266, 25, 48, 32, 6, -48 },
  { 6416, 24, 50, 30, 3, -49 },
  { 6566, 26, 48, 27, 1, -48 },
  { 6722, 28, 49, 38, 5, -48 },
  { 6894, 31, 48, 31, 0, -48 },
  { 7080, 49, 48, 50, 1, -48 },
  { 7374, 28, 48, 28, 0, -48 },
  { 7542, 27, 48, 27, 0, -48 },
  { 7704, 24, 48, 28, 2, -48 },
  { 7848, 14, 59, 21, 5, -48 },
  { 7952, 21, 48, 23, 1, -48 },
  { 8078, 14, 59, 21, 2, -48 },
  { 8182, 28, 26, 31, 2, -48 },
  { 8273, 28, 3, 28, 0, 6 },
  { 8284, 11, 10, 17, 3, -51 },
  { 8298, 21, 37, 29, 3, -36 },
  { 8396, 25, 52, 33, 5, -51 },
  { 8559, 20, 37, 25, 3, -36 },
  { 8652, 25, 52, 33, 3, -51 },
  { 8815, 24, 37, 30, 3, -36 },
  { 8926, 18, 51, 17, 1, -51 },
  { 9041, 25, 52, 33, 3, -36 },
  { 9204, 22, 51, 32, 5, -51 },
  { 9345, 5, 49, 14, 4, -49 },
  { 9376, 10, 65, 14, -1, -49 },
  { 9458, 22, 51, 27, 5, -51 },
  { 9599, 4, 51, 14, 5, -51 },
  { 9625, 38, 36, 48, 5, -36 },
  { 9796, 22, 36, 32, 5, -36 },
  { 9895, 26, 37, 32, 3, -36 },
  { 10016, 25, 52, 33, 5, -36 },
  { 10179, 25, 52, 33, 3, -36 },
  { 10342, 15, 36, 21, 5, -36 },
  { 10410, 19, 37, 25, 3, -36 },
  { 10498, 16, 45, 18, 1, -44 },
  { 10588, 22, 37, 32, 5, -36 },
  { 10690, 25, 36, 25, 0, -36 },
  { 10803, 39, 36, 41, 1, -36 },
  { 10979, 24, 36, 26, 1, -36 },
  { 11087, 24, 52, 26, 1, -36 },
  { 11243, 19, 36, 22, 2, -36 },
  { 11329, 18, 59, 24, 3, -48 },
  { 11462, 3, 67, 29, 13, -51 },
  { 11488, 18, 59, 24, 3, -48 },
  { 11621, 26, 7, 31, 2, -27 },
};

const GFXfont NotoSans_Condensed_Light67pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light67pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light67pt7bGlyphs,
  0x20, 0x7E, 91
};

#endif // _NOTOSANS_CONDENSED_LIGHT67PT7B_H_
