#ifndef _NOTOSANS_CONDENSED_LIGHT9PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xE0, 0x5F, 0x5F, 0x66, 0x2E, 0xA4, 0x33, 0xE2, 0x4A, 0xCB,
  0x2A, 0x74, 0xD4, 0x80, 0x23, 0x18, 0x8A, 0xCB, 0xE0, 0xC0, 0x6A, 0xA4,
  0xD5, 0x5C, 0x5D, 0x80, 0x2F, 0x22, 0xC0, 0xC0, 0x80, 0x25, 0x29, 0x00,
  0x25, 0x99, 0x99, 0x60, 0xD5, 0x50, 0x69, 0x12, 0x24, 0xF0, 0x69, 0x16,
  0x11, 0xE0, 0x26, 0x6A, 0x72, 0xE8, 0x61, 0x1E, 0x24, 0x8E, 0x99, 0x60,
  0xF2, 0x22, 0x44, 0x69, 0x96, 0x99, 0x70, 0x69, 0x99, 0x71, 0x60, 0x88,
  0x8C, 0x3C, 0x61, 0xFF, 0xC3, 0x68, 0xC4, 0xA4, 0x10, 0x7A, 0x5A, 0xED,
  0xBD, 0x03, 0x00, 0x26, 0x67, 0x99, 0xF7, 0x5B, 0xC0, 0x34, 0x88, 0x84,
  0x70, 0xE9, 0x99, 0xAE, 0xF3, 0x49, 0xC0, 0xF3, 0x49, 0x00, 0x32, 0x61,
  0x28, 0xA5, 0xE0, 0xB7, 0xDB, 0x40, 0xD5, 0x70, 0x55, 0x57, 0xBA, 0x6B,
  0x40, 0xAA, 0xB0, 0x8C, 0x67, 0xBE, 0xD4, 0x99, 0xDB, 0xB9, 0x32, 0x63,
  0x18, 0xC5, 0xC0, 0xF6, 0xE9, 0x00, 0x32, 0x63, 0x18, 0xC5, 0xC2, 0x08,
  0xF6, 0xEB, 0x40, 0x78, 0x86, 0x11, 0xE0, 0xF4, 0x44, 0x44, 0xB6, 0xDB,
  0xC0, 0x99, 0x56, 0x62, 0x93, 0x69, 0xB3, 0x64, 0xC9, 0x00, 0xB6, 0x46,
  0x69, 0x96, 0x44, 0x44, 0xE5, 0x25, 0xC0, 0xEA, 0xAC, 0x89, 0x22, 0x40,
  0xD5, 0x5C, 0x66, 0x90, 0xF0, 0x90, 0x65, 0xDE, 0x93, 0x5B, 0x78, 0x72,
  0x46, 0x11, 0x79, 0x99, 0x70, 0x69, 0xF8, 0x70, 0x6B, 0x24, 0x90, 0x79,
  0x99, 0x71, 0xF0, 0x93, 0x5B, 0x68, 0xBE, 0xBF, 0x80, 0x93, 0x69, 0xA8,
  0xFE, 0xDD, 0x6B, 0x5A, 0x80, 0xD6, 0xDA, 0x69, 0x99, 0x70, 0xD6, 0xDF,
  0x20, 0x79, 0x99, 0x71, 0x10, 0xEA, 0x80, 0x71, 0x1E, 0xBA, 0x90, 0xB6,
  0xDE, 0xB6, 0xA4, 0xAD, 0x6E, 0xB4, 0x80, 0xAD, 0x3A, 0xB5, 0xA4, 0xB0,
  0xE5, 0x2E, 0x69, 0x44, 0x98, 0xFF, 0x80, 0xC9, 0x14, 0xB0, 0xF0,
};

const GFXglyph NotoSans_Condensed_Light9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 1, 6, 2, 1, -6 },
  { 2, 2, 2, 3, 1, -6 },
  { 3, 4, 6, 5, 0, -6 },
  { 6, 4, 8, 4, 0, -7 },
  { 10, 6, 7, 6, 0, -7 },
  { 16, 5, 7, 5, 0, -7 },
  { 21, 1, 2, 2, 0, -6 },
  { 22, 2, 7, 3, 0, -6 },
  { 24, 2, 7, 3, 0, -6 },
  { 26, 3, 3, 4, 0, -7 },
  { 28, 4, 4, 4, 0, -5 },
  { 30, 1, 2, 2, 0, -1 },
  { 31, 2, 1, 3, 0, -3 },
  { 32, 1, 1, 2, 0, -1 },
  { 33, 3, 6, 3, 0, -6 },
  { 36, 4, 7, 4, 0, -7 },
  { 40, 2, 6, 4, 1, -6 },
  { 42, 4, 7, 4, 0, -7 },
  { 46, 4, 7, 4, 0, -7 },
  { 50, 4, 6, 4, 0, -6 },
  { 53, 4, 6, 4, 0, -6 },
  { 56, 4, 7, 4, 0, -7 },
  { 60, 4, 6, 4, 0, -6 },
  { 63, 4, 7, 4, 0, -7 },
  { 67, 4, 7, 4, 0, -7 },
  { 71, 1, 5, 2, 0, -5 },
  { 72, 1, 6, 2, 0, -5 },
  { 73, 4, 4, 4, 0, -5 },
  { 75, 4, 2, 4, 0, -4 },
  { 76, 4, 4, 4, 0, -5 },
  { 78, 3, 7, 3, 0, -7 },
  { 81, 6, 7, 6, 0, -6 },
  { 87, 4, 6, 4, 0, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 4, 7, 4, 0, -7 },
  { 97, 4, 6, 5, 1, -6 },
  { 100, 3, 6, 4, 1, -6 },
  { 103, 3, 6, 4, 1, -6 },
  { 106, 5, 7, 5, 0, -7 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 2, 6, 2, 0, -6 },
  { 116, 2, 8, 2, -1, -6 },
  { 118, 3, 6, 4, 1, -6 },
  { 121, 2, 6, 4, 1, -6 },
  { 123, 5, 6, 7, 1, -6 },
  { 127, 4, 6, 5, 1, -6 },
  { 130, 5, 7, 5, 0, -7 },
  { 135, 3, 6, 4, 1, -6 },
  { 138, 5, 9, 5, 0, -7 },
  { 144, 3, 6, 4, 1, -6 },
  { 147, 4, 7, 4, 0, -7 },
  { 151, 4, 6, 4, 0, -6 },
  { 154, 3, 6, 5, 1, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 7, 6, 7, 0, -6 },
  { 166, 4, 6, 4, 0, -6 },
  { 169, 4, 6, 4, 0, -6 },
  { 172, 3, 6, 4, 0, -6 },
  { 175, 2, 7, 3, 1, -6 },
  { 177, 3, 6, 3, 0, -6 },
  { 180, 2, 7, 3, 0, -6 },
  { 182, 4, 3, 4, 0, -6 },
  { 184, 4, 1, 4, 0, 0 },
  { 185, 2, 2, 2, 0, -7 },
  { 186, 3, 5, 4, 0, -5 },
  { 188, 3, 7, 4, 1, -7 },
  { 191, 3, 5, 3, 0, -5 },
  { 193, 4, 7, 4, 0, -7 },
  { 197, 4, 5, 4, 0, -5 },
  { 200, 3, 7, 2, 0, -7 },
  { 203, 4, 7, 4, 0, -5 },
  { 207, 3, 7, 4, 1, -7 },
  { 210, 1, 7, 2, 0, -7 },
  { 211, 1, 9, 2, 0, -7 },
  { 213, 3, 7, 4, 1, -7 },
  { 216, 1, 7, 2, 0, -7 },
  { 217, 5, 5, 6, 1, -5 },
  { 221, 3, 5, 4, 1, -5 },
  { 223, 4, 5, 4, 0, -5 },
  { 226, 3, 7, 4, 1, -5 },
  { 229, 4, 7, 4, 0, -5 },
  { 233, 2, 5, 3, 1, -5 },
  { 235, 3, 5, 3, 0, -5 },
  { 237, 2, 6, 2, 0, -6 },
  { 239, 3, 5, 4, 1, -5 },
  { 241, 3, 5, 3, 0, -5 },
  { 243, 5, 5, 6, 0, -5 },
  { 247, 3, 5, 4, 0, -5 },
  { 249, 3, 7, 3, 0, -5 },
  { 252, 3, 5, 3, 0, -5 },
  { 254, 3, 7, 3, 0, -6 },
  { 257, 1, 9, 4, 1, -7 },
  { 259, 3, 7, 3, 0, -6 },
  { 262, 4, 1, 4, 0, -4 },
};

const GFXfont NotoSans_Condensed_Light9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light9pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_CONDENSED_LIGHT9PT7B_H_
