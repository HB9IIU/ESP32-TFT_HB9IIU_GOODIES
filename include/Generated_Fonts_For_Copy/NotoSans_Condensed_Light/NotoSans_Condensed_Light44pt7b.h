#ifndef _NOTOSANS_CONDENSED_LIGHT44PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light44pt7bBitmaps[] PROGMEM = {
  0x00, 0xE6, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x60, 0x00, 0x06, 0xFF, 0xE0, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x60, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01,
  0x81, 0x80, 0x18, 0x18, 0x01, 0x83, 0x00, 0x18, 0x30, 0x03, 0x03, 0x00,
  0x30, 0x30, 0x03, 0x03, 0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xF0, 0x30, 0x60,
  0x03, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06, 0x00, 0x60, 0x60, 0x06, 0x06,
  0x00, 0x60, 0x60, 0x06, 0x0C, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0xC0,
  0xC0, 0x0C, 0x0C, 0x00, 0xC0, 0xC0, 0x0C, 0x0C, 0x00, 0xC1, 0x80, 0x0C,
  0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x01, 0x81, 0x80, 0x18, 0x18, 0x00,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x0F, 0xFC, 0x3F, 0xFE, 0x79, 0x86,
  0x61, 0x80, 0xE1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80, 0xC1, 0x80,
  0xE1, 0x80, 0x71, 0x80, 0x79, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x03, 0xF0,
  0x01, 0xF8, 0x01, 0x9C, 0x01, 0x8E, 0x01, 0x87, 0x01, 0x83, 0x01, 0x83,
  0x01, 0x83, 0x01, 0x83, 0x01, 0x87, 0x01, 0x86, 0xC1, 0x9E, 0xFF, 0xFC,
  0x7F, 0xF0, 0x03, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x0E, 0x00, 0x00, 0x0F, 0xC0, 0x0C, 0x07, 0x18, 0x07, 0x01, 0x86, 0x01,
  0x80, 0x60, 0xC0, 0x60, 0x30, 0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x03, 0x03,
  0x06, 0x00, 0xC0, 0xC1, 0x80, 0x30, 0x30, 0x60, 0x0C, 0x0C, 0x30, 0x03,
  0x03, 0x0C, 0x00, 0xC0, 0xC6, 0x00, 0x30, 0x31, 0x8F, 0x8C, 0x0C, 0x67,
  0xF1, 0x83, 0x31, 0x8E, 0x61, 0x8C, 0xC1, 0x9C, 0xE6, 0x30, 0x63, 0xF1,
  0x8C, 0x18, 0x38, 0x63, 0x07, 0x00, 0x31, 0xC0, 0xC0, 0x0C, 0x70, 0x30,
  0x06, 0x18, 0x0C, 0x01, 0x86, 0x03, 0x00, 0xE1, 0xC0, 0xC0, 0x30, 0x30,
  0x70, 0x0C, 0x0C, 0x18, 0x06, 0x03, 0x06, 0x01, 0x80, 0xC1, 0x80, 0xE0,
  0x18, 0xE0, 0x30, 0x07, 0x70, 0x1C, 0x00, 0xF8, 0x03, 0xC0, 0x00, 0x7F,
  0x80, 0x07, 0x1C, 0x00, 0x30, 0x70, 0x03, 0x81, 0x80, 0x1C, 0x0C, 0x00,
  0xE0, 0x60, 0x07, 0x03, 0x00, 0x38, 0x18, 0x00, 0xC0, 0xC0, 0x06, 0x0E,
  0x00, 0x38, 0xE0, 0x00, 0xE6, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x80, 0x01, 0xCE, 0x00, 0x1C, 0x38, 0x18, 0xC0, 0xC0,
  0xCE, 0x07, 0x06, 0x60, 0x1C, 0x73, 0x00, 0x73, 0x18, 0x01, 0xB8, 0xC0,
  0x0F, 0xC6, 0x00, 0x3C, 0x30, 0x01, 0xE1, 0xC0, 0x0F, 0x06, 0x00, 0xFC,
  0x3C, 0x1E, 0x70, 0xFF, 0xE1, 0x83, 0xFC, 0x0F, 0xFB, 0x6D, 0xB6, 0xDB,
  0x00, 0x03, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18,
  0x1C, 0x0E, 0x06, 0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18, 0x0C, 0x07, 0x03, 0x80, 0xC0,
  0x70, 0x38, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0xE0, 0x38, 0x0C,
  0x07, 0x01, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x81, 0xC0, 0x60, 0x30,
  0x1C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x07,
  0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x0E, 0x06, 0x07,
  0x03, 0x03, 0x81, 0x81, 0x80, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x0C, 0x30, 0x5F, 0x67, 0xBF, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x0D, 0x80,
  0x33, 0x80, 0xC3, 0x83, 0x83, 0x82, 0x06, 0x00, 0x01, 0x80, 0x00, 0xC0,
  0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03,
  0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60,
  0x00, 0x30, 0x00, 0x18, 0x00, 0x39, 0x9C, 0xE7, 0x31, 0x9C, 0xC6, 0x30,
  0xFF, 0xFF, 0xF0, 0xEE, 0xFE, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C,
  0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x00,
  0x03, 0xC0, 0x0F, 0xF0, 0x1E, 0x78, 0x38, 0x1C, 0x38, 0x0C, 0x30, 0x0E,
  0x70, 0x06, 0x60, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07,
  0x60, 0x06, 0x70, 0x06, 0x70, 0x0E, 0x30, 0x0C, 0x38, 0x1C, 0x1C, 0x38,
  0x0F, 0xF8, 0x07, 0xF0, 0x03, 0xC1, 0xF0, 0xFC, 0x77, 0x39, 0xFC, 0x76,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0xC0, 0x3F, 0xF0, 0xFC,
  0xF8, 0x60, 0x1C, 0x40, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xC0, 0x3F, 0xF0, 0xFC, 0xF8, 0xE0, 0x1C, 0x40, 0x0E, 0x00, 0x0E, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x38, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0xC0, 0x3C, 0xFF,
  0xF8, 0x7F, 0xE0, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xDC, 0x00, 0x1B, 0x80, 0x06, 0x70, 0x01, 0xCE,
  0x00, 0x31, 0xC0, 0x0E, 0x38, 0x01, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x1C,
  0x03, 0x03, 0x80, 0x60, 0x70, 0x18, 0x0E, 0x03, 0x01, 0xC0, 0xC0, 0x38,
  0x38, 0x07, 0x06, 0x00, 0xE1, 0xC0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x3F, 0xFC, 0x3F, 0xFC, 0x30,
  0x00, 0x30, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x6F, 0xE0, 0x7F, 0xF8, 0x70,
  0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x1C, 0xC0, 0x3C, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0xFC, 0x03,
  0xFE, 0x07, 0xC6, 0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x80, 0xE7,
  0xF8, 0xEF, 0xFC, 0xF8, 0x1E, 0xF0, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x60,
  0x07, 0x70, 0x07, 0x30, 0x06, 0x38, 0x0E, 0x1C, 0x1C, 0x1F, 0xF8, 0x07,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x06, 0x00,
  0x0E, 0x00, 0x0C, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xC0, 0x00, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x01, 0x80, 0x03, 0x80, 0x03,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x03, 0xE0, 0x1F, 0xF8, 0x3E, 0x3C, 0x38, 0x0E, 0x70,
  0x0E, 0x60, 0x06, 0x60, 0x07, 0x60, 0x07, 0x60, 0x07, 0x60, 0x06, 0x70,
  0x0E, 0x38, 0x0C, 0x3C, 0x1C, 0x1E, 0x78, 0x07, 0xE0, 0x03, 0xC0, 0x0F,
  0xF0, 0x1C, 0x78, 0x38, 0x1C, 0x70, 0x0E, 0x60, 0x07, 0xE0, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x70,
  0x0E, 0x78, 0x1E, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x3C,
  0x78, 0x38, 0x1C, 0x70, 0x0C, 0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x06, 0xC0,
  0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0x60, 0x0F, 0x70, 0x1F, 0x38, 0x37, 0x1F, 0xF7, 0x0F, 0xC7, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x6E,
  0xFE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEE, 0xFE, 0x33,
  0x9E, 0xF3, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73,
  0x39, 0xCE, 0x63, 0x39, 0x8C, 0x60, 0x00, 0x01, 0x80, 0x03, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x60,
  0x00, 0x20, 0x00, 0x00, 0x1F, 0x0F, 0xFC, 0xFB, 0xE8, 0x07, 0x00, 0x70,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xE7, 0xE0, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x00, 0xE0, 0xC0, 0x00, 0x0C, 0x38, 0x00, 0x01, 0x86, 0x00,
  0xF0, 0x18, 0xC0, 0x7F, 0x83, 0x38, 0x1C, 0x30, 0x66, 0x06, 0x06, 0x0E,
  0xC0, 0xC0, 0xC0, 0xD8, 0x30, 0x18, 0x1F, 0x06, 0x03, 0x03, 0xE0, 0xC0,
  0x60, 0x78, 0x18, 0x1C, 0x0F, 0x07, 0x03, 0x81, 0xE0, 0xE0, 0x70, 0x3C,
  0x0C, 0x0E, 0x0F, 0x81, 0x81, 0xC1, 0xB8, 0x30, 0x38, 0x33, 0x06, 0x0F,
  0x06, 0x60, 0xE1, 0x21, 0x8C, 0x0F, 0xE7, 0xF1, 0x80, 0xF8, 0x78, 0x38,
  0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x06, 0x00, 0x00,
  0x00, 0x60, 0x00, 0x00, 0x0F, 0x00, 0x10, 0x00, 0xF8, 0x0E, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0xEE, 0x00, 0x06, 0x70,
  0x00, 0x31, 0x80, 0x03, 0x8C, 0x00, 0x18, 0x70, 0x00, 0xC1, 0x80, 0x06,
  0x0C, 0x00, 0x70, 0x70, 0x03, 0x03, 0x80, 0x18, 0x0C, 0x01, 0xC0, 0x60,
  0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xC0,
  0x1C, 0x0C, 0x00, 0x60, 0xE0, 0x03, 0x07, 0x00, 0x1C, 0x30, 0x00, 0xE1,
  0x80, 0x03, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE6, 0x00, 0x07, 0x70, 0x00,
  0x1B, 0x80, 0x00, 0xE0, 0xFF, 0xF0, 0xFF, 0xFC, 0xC0, 0x1C, 0xC0, 0x0E,
  0xC0, 0x06, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF, 0xF8,
  0xC0, 0x1E, 0xC0, 0x0E, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0E,
  0xC0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x7E,
  0x7C, 0x3C, 0x01, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x30, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x18,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x30, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x30, 0x3F, 0xFC, 0x07, 0xFE, 0xFF, 0xE0, 0x3F, 0xFE, 0x0C, 0x03,
  0xC3, 0x00, 0x38, 0xC0, 0x07, 0x30, 0x00, 0xCC, 0x00, 0x3B, 0x00, 0x06,
  0xC0, 0x01, 0xB0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x6C, 0x00, 0x1B, 0x00, 0x0E,
  0xC0, 0x03, 0xB0, 0x01, 0xCC, 0x00, 0xE3, 0x00, 0x78, 0xC0, 0xFC, 0x3F,
  0xFC, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x0F, 0xFF, 0x80, 0xFC, 0x7E, 0x0F, 0x00, 0x20, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x06,
  0xC0, 0x00, 0x36, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0xC0, 0x00, 0x6E, 0x00,
  0x03, 0x30, 0x00, 0x19, 0xC0, 0x00, 0xC7, 0x00, 0x06, 0x38, 0x00, 0x30,
  0xE0, 0x01, 0x83, 0xC0, 0x1C, 0x0F, 0xFF, 0xE0, 0x1F, 0xFC, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1C, 0xFF, 0x3C, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x78, 0x77, 0xF3, 0xF0, 0xC0,
  0x07, 0x60, 0x07, 0x30, 0x07, 0x18, 0x03, 0x0C, 0x03, 0x86, 0x03, 0x83,
  0x01, 0x81, 0x81, 0xC0, 0xC1, 0xC0, 0x61, 0xC0, 0x30, 0xE0, 0x18, 0xE0,
  0x0C, 0xE0, 0x06, 0x70, 0x03, 0x78, 0x01, 0xFE, 0x00, 0xF3, 0x00, 0x71,
  0xC0, 0x30, 0x70, 0x18, 0x38, 0x0C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0xC1,
  0x80, 0x60, 0xC0, 0x38, 0x60, 0x0C, 0x30, 0x07, 0x18, 0x01, 0xCC, 0x00,
  0xE6, 0x00, 0x3B, 0x00, 0x1E, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xBF, 0x80, 0x00, 0xDE,
  0xC0, 0x00, 0xEF, 0x60, 0x00, 0x67, 0xB8, 0x00, 0x33, 0xCC, 0x00, 0x39,
  0xE6, 0x00, 0x18, 0xF3, 0x80, 0x0C, 0x78, 0xC0, 0x06, 0x3C, 0x60, 0x06,
  0x1E, 0x38, 0x03, 0x0F, 0x0C, 0x01, 0x87, 0x86, 0x01, 0x83, 0xC3, 0x80,
  0xC1, 0xE0, 0xC0, 0x60, 0xF0, 0x60, 0x70, 0x78, 0x38, 0x30, 0x3C, 0x0C,
  0x18, 0x1E, 0x06, 0x1C, 0x0F, 0x03, 0x8C, 0x07, 0x80, 0xC6, 0x03, 0xC0,
  0x67, 0x01, 0xE0, 0x3B, 0x00, 0xF0, 0x0D, 0x80, 0x78, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x06, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xB8, 0x01, 0xF7,
  0x00, 0x3E, 0x70, 0x07, 0xCE, 0x00, 0xF8, 0xE0, 0x1F, 0x1C, 0x03, 0xE1,
  0xC0, 0x7C, 0x38, 0x0F, 0x83, 0x81, 0xF0, 0x70, 0x3E, 0x07, 0x07, 0xC0,
  0xE0, 0xF8, 0x0E, 0x1F, 0x01, 0xC3, 0xE0, 0x1C, 0x7C, 0x03, 0x8F, 0x80,
  0x39, 0xF0, 0x07, 0x3E, 0x00, 0x77, 0xC0, 0x0E, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0xFC, 0x03, 0x80, 0x78, 0x1C, 0x00,
  0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0E, 0x70, 0x00, 0x39,
  0xC0, 0x00, 0x66, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77,
  0x00, 0x01, 0x9C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80,
  0x07, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x3C, 0x0F, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0xE1, 0xFF, 0xE3, 0x01, 0xE6, 0x00, 0xEC, 0x00,
  0xD8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB0, 0x0F, 0x60, 0x7C, 0xFF, 0xF1, 0xFF,
  0x83, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x7E, 0xFC, 0x03, 0x80,
  0x78, 0x1C, 0x00, 0xE0, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0x0C, 0x00, 0x0E,
  0x70, 0x00, 0x39, 0xC0, 0x00, 0x66, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xD8, 0x00, 0x07, 0x60, 0x00, 0x1D,
  0x80, 0x00, 0x77, 0x00, 0x01, 0x9C, 0x00, 0x06, 0x30, 0x00, 0x38, 0xE0,
  0x00, 0xE3, 0x80, 0x07, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0xE0, 0x3C, 0x0F,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0xFF, 0xE0, 0xFF, 0xF0, 0xC0, 0x78, 0xC0, 0x1C, 0xC0, 0x0C,
  0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x0E, 0xC0, 0x0C, 0xC0, 0x1C, 0xC0, 0x78, 0xFF, 0xF0, 0xFF, 0xC0,
  0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xC0, 0x60, 0xC0, 0x70, 0xC0, 0x30,
  0xC0, 0x38, 0xC0, 0x38, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x0E,
  0xC0, 0x07, 0xC0, 0x07, 0x03, 0xF0, 0x0F, 0xFE, 0x3F, 0x7E, 0x78, 0x02,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x1C, 0xC0, 0x3C, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0x60, 0x00, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x01,
  0xC3, 0xC0, 0x78, 0x3F, 0xFE, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x30,
  0x00, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0x80, 0x18, 0x18, 0x01, 0x81,
  0xC0, 0x38, 0x0C, 0x03, 0x80, 0xC0, 0x30, 0x0E, 0x03, 0x00, 0xE0, 0x70,
  0x06, 0x06, 0x00, 0x60, 0x60, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x0C,
  0x00, 0x30, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0x80, 0x01, 0x98, 0x00, 0x19,
  0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xB0, 0x00, 0xE0, 0x01, 0x9C, 0x00,
  0x70, 0x01, 0xCE, 0x00, 0x78, 0x00, 0xE3, 0x00, 0x36, 0x00, 0x61, 0x80,
  0x1B, 0x00, 0x30, 0xE0, 0x0D, 0x80, 0x38, 0x70, 0x0E, 0xC0, 0x1C, 0x38,
  0x06, 0x70, 0x0C, 0x0C, 0x03, 0x18, 0x06, 0x06, 0x01, 0x8C, 0x07, 0x03,
  0x80, 0xC6, 0x03, 0x81, 0xC0, 0xE3, 0x01, 0xC0, 0x60, 0x61, 0xC0, 0xC0,
  0x30, 0x30, 0x60, 0x60, 0x1C, 0x18, 0x30, 0x70, 0x0E, 0x1C, 0x18, 0x38,
  0x07, 0x0C, 0x0E, 0x18, 0x01, 0x86, 0x03, 0x0C, 0x00, 0xC3, 0x01, 0x8E,
  0x00, 0x71, 0x80, 0xC7, 0x00, 0x39, 0xC0, 0x73, 0x00, 0x0C, 0xC0, 0x19,
  0x80, 0x06, 0x60, 0x0C, 0xC0, 0x03, 0x30, 0x06, 0xE0, 0x01, 0xF8, 0x03,
  0x70, 0x00, 0x78, 0x01, 0xB0, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x0E, 0x00, 0x70, 0x01,
  0xCE, 0x00, 0xE1, 0x80, 0x38, 0x70, 0x1C, 0x1C, 0x07, 0x03, 0x01, 0x80,
  0xE0, 0xE0, 0x18, 0x30, 0x07, 0x1C, 0x00, 0xC6, 0x00, 0x3B, 0x80, 0x06,
  0xC0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xF0,
  0x00, 0x6C, 0x00, 0x3B, 0x80, 0x0C, 0x60, 0x07, 0x1C, 0x01, 0x87, 0x00,
  0xE0, 0xC0, 0x30, 0x38, 0x1C, 0x06, 0x06, 0x01, 0xC3, 0x80, 0x30, 0xC0,
  0x0E, 0x70, 0x03, 0x9C, 0x00, 0x7E, 0x00, 0x1C, 0xE0, 0x01, 0xD8, 0x00,
  0x67, 0x00, 0x38, 0xC0, 0x0C, 0x38, 0x07, 0x0E, 0x01, 0xC1, 0x80, 0x60,
  0x70, 0x38, 0x0C, 0x0C, 0x03, 0x07, 0x00, 0xE1, 0xC0, 0x18, 0x60, 0x07,
  0x38, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x30,
  0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0,
  0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x18, 0x00,
  0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0,
  0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F,
  0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x06, 0xC0, 0x03,
  0x38, 0x00, 0xC6, 0x00, 0x61, 0x80, 0x18, 0x30, 0x0C, 0x0C, 0x03, 0x01,
  0x81, 0x80, 0x60, 0x60, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0x66, 0x00, 0x19,
  0x80, 0x07, 0xC0, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC1,
  0xC1, 0xC1, 0x81, 0x81, 0x80, 0x07, 0xC0, 0xFF, 0xC3, 0xC7, 0x88, 0x0E,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x0F,
  0xC3, 0xFF, 0x3E, 0x0D, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x3D, 0x81, 0xB7, 0xFC, 0xCF, 0xE3, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE1, 0xE0, 0xE7, 0xF8, 0xEE, 0x3C, 0xF8,
  0x0E, 0xF0, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x06, 0xF0, 0x0E, 0xD8,
  0x1C, 0xCF, 0xFC, 0xC7, 0xF0, 0x03, 0xF0, 0x7F, 0xC7, 0xC6, 0x78, 0x03,
  0x80, 0x38, 0x01, 0x80, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x03, 0x80, 0x1E, 0x04, 0x7F, 0xE0, 0xFF, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x03, 0xC3, 0x0F, 0xF3, 0x1E, 0x3B, 0x38, 0x0F, 0x70, 0x0F,
  0x70, 0x07, 0x60, 0x07, 0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0x60, 0x07, 0x60, 0x07, 0x70, 0x07, 0x30, 0x0F, 0x38, 0x1B, 0x1F, 0xF3,
  0x0F, 0xE3, 0x03, 0xC0, 0x0F, 0xF0, 0x1E, 0x38, 0x38, 0x1C, 0x30, 0x0C,
  0x70, 0x0E, 0x60, 0x06, 0x60, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x06, 0x1F, 0xFE,
  0x07, 0xFC, 0x00, 0xE0, 0x1F, 0xC1, 0xEC, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x01, 0xFF, 0x8F, 0xFC, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x03, 0xC0,
  0x0F, 0xF3, 0x1E, 0x3B, 0x38, 0x0F, 0x70, 0x07, 0x70, 0x07, 0x60, 0x07,
  0x60, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60, 0x07, 0x60, 0x07,
  0x70, 0x07, 0x30, 0x0F, 0x38, 0x1B, 0x1F, 0xF3, 0x0F, 0xE3, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E,
  0x60, 0x1E, 0x7F, 0xFC, 0x3F, 0xF0, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC3, 0xC3, 0x9F, 0xE7, 0x73, 0xEF, 0x81, 0xDE, 0x01, 0xFC, 0x03,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xFF, 0xA0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x1C,
  0x38, 0x20, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87,
  0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x86, 0xFD, 0xF1, 0x80,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x01, 0xB8, 0x0E, 0xE0, 0x73, 0x83,
  0x8E, 0x0C, 0x38, 0x70, 0xE3, 0x83, 0x8C, 0x0E, 0x60, 0x3B, 0xC0, 0xEF,
  0x03, 0xEE, 0x0F, 0x18, 0x38, 0x70, 0xE0, 0xC3, 0x83, 0x8E, 0x06, 0x38,
  0x1C, 0xE0, 0x33, 0x80, 0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x0C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x3C, 0x31, 0xFC, 0x3F, 0xCC, 0xC7, 0x9C, 0xF3, 0x60, 0x6C, 0x0E,
  0xF0, 0x1E, 0x01, 0xB8, 0x07, 0x80, 0x6E, 0x00, 0xC0, 0x1B, 0x80, 0x30,
  0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00, 0xC0, 0x1F, 0x80,
  0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00, 0xC0, 0x1F,
  0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00, 0xC0,
  0x1F, 0x80, 0x30, 0x07, 0xE0, 0x0C, 0x01, 0xF8, 0x03, 0x00, 0x7E, 0x00,
  0xC0, 0x1F, 0x80, 0x30, 0x07, 0x01, 0xE1, 0x8F, 0xF3, 0x38, 0xF6, 0xC0,
  0xED, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0x8F, 0x07, 0x01, 0xC3, 0x00,
  0x63, 0x80, 0x39, 0x80, 0x0C, 0xC0, 0x06, 0xE0, 0x03, 0x70, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0x30, 0x01, 0x98, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0xE1, 0xE0,
  0xE0, 0x7F, 0xF0, 0x0F, 0xE0, 0x01, 0xE0, 0xC7, 0xF8, 0xCE, 0x3C, 0xD8,
  0x0E, 0xD0, 0x0E, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x06, 0xF8, 0x0E, 0xFC,
  0x1C, 0xEF, 0xF8, 0xE7, 0xF0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x0F, 0xF3, 0x1E, 0x3B, 0x38, 0x0B, 0x70, 0x0F, 0x70,
  0x07, 0x60, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0x60,
  0x07, 0x60, 0x07, 0x70, 0x07, 0x30, 0x0F, 0x38, 0x1B, 0x1F, 0xF3, 0x0F,
  0xE3, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00,
  0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x03, 0xF1, 0xFC,
  0xFF, 0x70, 0xD8, 0x3C, 0x0F, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0x0F, 0xC1, 0xFF, 0x9E, 0x1D, 0xC0, 0x2C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x60, 0x3B, 0xFF, 0x8F, 0xF8, 0x18, 0x06, 0x01, 0x80, 0x60, 0x38,
  0x0E, 0x0F, 0xFF, 0xFF, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x01, 0x80, 0x7F, 0x0F, 0xC0, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7B, 0x00, 0xB7, 0x03, 0x67, 0xFC,
  0xC7, 0xF1, 0x80, 0xE0, 0x07, 0x60, 0x07, 0x60, 0x06, 0x70, 0x06, 0x30,
  0x0E, 0x30, 0x0E, 0x38, 0x0C, 0x38, 0x0C, 0x18, 0x1C, 0x18, 0x18, 0x1C,
  0x18, 0x0C, 0x38, 0x0C, 0x38, 0x0C, 0x30, 0x0E, 0x30, 0x06, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0xE0, 0x0E, 0x00, 0xD8, 0x03, 0x80, 0x37, 0x00, 0xF0, 0x1D, 0xC0,
  0x6C, 0x07, 0x30, 0x1B, 0x01, 0x8C, 0x06, 0xC0, 0x63, 0x81, 0xB8, 0x38,
  0xE0, 0xC6, 0x0E, 0x18, 0x31, 0x83, 0x06, 0x0C, 0x60, 0xC1, 0x83, 0x1C,
  0x30, 0x71, 0xC3, 0x1C, 0x0C, 0x60, 0xC6, 0x03, 0x18, 0x31, 0x80, 0xC6,
  0x0C, 0x60, 0x3B, 0x83, 0xB8, 0x0E, 0xC0, 0x6C, 0x01, 0xB0, 0x1B, 0x00,
  0x6C, 0x06, 0xC0, 0x1B, 0x01, 0xB0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x0E,
  0x00, 0x38, 0x03, 0x80, 0xE0, 0x0E, 0xE0, 0x18, 0xC0, 0x71, 0xC0, 0xC1,
  0x83, 0x83, 0x8E, 0x03, 0x18, 0x07, 0x70, 0x06, 0xC0, 0x0F, 0x80, 0x0E,
  0x00, 0x1C, 0x00, 0x7C, 0x00, 0xD8, 0x03, 0xB8, 0x06, 0x30, 0x1C, 0x70,
  0x30, 0x70, 0xE0, 0x61, 0x80, 0xE7, 0x00, 0xCC, 0x01, 0xF8, 0x01, 0x80,
  0xE0, 0x03, 0xB0, 0x01, 0x9C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0x61, 0xC0,
  0x70, 0xE0, 0x38, 0x30, 0x18, 0x18, 0x0C, 0x0E, 0x0E, 0x03, 0x06, 0x01,
  0x83, 0x00, 0xE3, 0x80, 0x31, 0x80, 0x18, 0xC0, 0x0C, 0x60, 0x07, 0x70,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00,
  0x30, 0x00, 0x38, 0x00, 0x38, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x30, 0x00,
  0x00, 0x7F, 0xF3, 0xFF, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x3F, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0C, 0x03, 0xC0, 0xF0, 0x0F, 0x80, 0x1C, 0x00, 0xC0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x78, 0x03, 0xF0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0x03,
  0x80, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xF8,
  0x0E, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0xF8, 0xF8, 0xF0, 0x1F, 0xE8, 0x01,
  0xC0,
};

const GFXglyph NotoSans_Condensed_Light44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 31, 10, 3, -31 },
  { 17, 9, 11, 15, 3, -31 },
  { 30, 20, 31, 22, 1, -31 },
  { 108, 16, 36, 20, 2, -33 },
  { 180, 26, 32, 30, 2, -32 },
  { 284, 21, 32, 23, 2, -32 },
  { 368, 3, 11, 8, 3, -31 },
  { 373, 9, 39, 12, 2, -32 },
  { 417, 9, 39, 12, 1, -32 },
  { 461, 15, 14, 19, 2, -33 },
  { 488, 17, 21, 20, 2, -26 },
  { 533, 5, 11, 9, 2, -5 },
  { 540, 10, 2, 13, 1, -13 },
  { 543, 4, 4, 9, 3, -4 },
  { 545, 14, 31, 15, 1, -31 },
  { 600, 16, 32, 20, 2, -32 },
  { 664, 10, 31, 20, 3, -31 },
  { 703, 16, 32, 20, 2, -32 },
  { 767, 16, 32, 20, 2, -32 },
  { 831, 19, 32, 20, 1, -32 },
  { 907, 16, 31, 20, 2, -31 },
  { 969, 16, 32, 20, 2, -32 },
  { 1033, 16, 31, 20, 2, -31 },
  { 1095, 16, 32, 20, 2, -32 },
  { 1159, 16, 32, 20, 2, -32 },
  { 1223, 4, 24, 10, 3, -24 },
  { 1235, 5, 30, 9, 2, -24 },
  { 1254, 17, 19, 20, 2, -25 },
  { 1295, 17, 11, 20, 2, -21 },
  { 1319, 17, 19, 20, 2, -25 },
  { 1360, 12, 32, 15, 1, -32 },
  { 1408, 27, 36, 31, 2, -32 },
  { 1530, 21, 31, 21, 0, -31 },
  { 1612, 16, 31, 22, 4, -31 },
  { 1674, 18, 32, 21, 2, -32 },
  { 1746, 18, 31, 25, 4, -31 },
  { 1816, 13, 31, 19, 4, -31 },
  { 1867, 13, 31, 18, 4, -31 },
  { 1918, 21, 32, 26, 2, -32 },
  { 2002, 18, 31, 25, 4, -31 },
  { 2072, 8, 31, 12, 2, -31 },
  { 2103, 9, 39, 10, -3, -31 },
  { 2147, 17, 31, 21, 4, -31 },
  { 2213, 13, 31, 18, 4, -31 },
  { 2264, 25, 31, 33, 4, -31 },
  { 2361, 19, 31, 26, 4, -31 },
  { 2435, 22, 32, 26, 2, -32 },
  { 2523, 15, 31, 21, 4, -31 },
  { 2582, 22, 39, 26, 2, -32 },
  { 2690, 16, 31, 21, 4, -31 },
  { 2752, 16, 32, 20, 2, -32 },
  { 2816, 18, 31, 18, 0, -31 },
  { 2886, 19, 31, 25, 3, -31 },
  { 2960, 20, 31, 20, 0, -31 },
  { 3038, 33, 31, 33, 0, -31 },
  { 3166, 18, 31, 18, 0, -31 },
  { 3236, 18, 31, 18, 0, -31 },
  { 3306, 16, 31, 18, 1, -31 },
  { 3368, 8, 39, 14, 4, -32 },
  { 3407, 14, 31, 15, 1, -31 },
  { 3462, 9, 39, 14, 1, -32 },
  { 3506, 18, 17, 20, 1, -31 },
  { 3545, 18, 2, 18, 0, 4 },
  { 3550, 7, 7, 11, 2, -34 },
  { 3557, 14, 24, 19, 2, -24 },
  { 3599, 16, 33, 22, 3, -33 },
  { 3665, 13, 24, 16, 2, -24 },
  { 3704, 16, 33, 22, 2, -33 },
  { 3770, 16, 24, 20, 2, -24 },
  { 3818, 13, 34, 11, 0, -34 },
  { 3874, 16, 35, 22, 2, -24 },
  { 3944, 15, 33, 21, 3, -33 },
  { 4006, 3, 32, 9, 3, -32 },
  { 4018, 7, 43, 9, -1, -32 },
  { 4056, 14, 33, 18, 3, -33 },
  { 4114, 3, 33, 9, 3, -33 },
  { 4127, 26, 24, 32, 3, -24 },
  { 4205, 15, 24, 21, 3, -24 },
  { 4250, 17, 24, 21, 2, -24 },
  { 4301, 16, 34, 22, 3, -24 },
  { 4369, 16, 34, 22, 2, -24 },
  { 4437, 10, 24, 14, 3, -24 },
  { 4467, 13, 24, 16, 2, -24 },
  { 4506, 10, 29, 12, 1, -29 },
  { 4543, 15, 23, 21, 3, -23 },
  { 4587, 16, 23, 16, 0, -23 },
  { 4633, 26, 23, 27, 0, -23 },
  { 4708, 15, 23, 17, 1, -23 },
  { 4752, 17, 34, 17, 0, -23 },
  { 4825, 13, 23, 15, 1, -23 },
  { 4863, 12, 38, 16, 2, -31 },
  { 4920, 3, 45, 19, 8, -34 },
  { 4937, 12, 38, 16, 2, -31 },
  { 4994, 17, 5, 20, 2, -18 },
};

const GFXfont NotoSans_Condensed_Light44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light44pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_CONDENSED_LIGHT44PT7B_H_
