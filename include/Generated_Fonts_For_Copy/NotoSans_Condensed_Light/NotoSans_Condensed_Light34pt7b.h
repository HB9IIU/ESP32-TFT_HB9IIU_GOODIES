#ifndef _NOTOSANS_CONDENSED_LIGHT34PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT34PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light34pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x00, 0xFB, 0xC7, 0xC6,
  0xC2, 0xC2, 0xC2, 0xC2, 0xC2, 0x42, 0x42, 0x06, 0x18, 0x0C, 0x30, 0x18,
  0x60, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x0C, 0x3F, 0xFF, 0x0C, 0x30,
  0x18, 0x60, 0x20, 0x80, 0x41, 0x00, 0x82, 0x01, 0x04, 0x06, 0x18, 0x7F,
  0xFE, 0x18, 0x60, 0x30, 0xC0, 0x41, 0x00, 0x82, 0x01, 0x04, 0x06, 0x18,
  0x0C, 0x30, 0x18, 0x60, 0x02, 0x00, 0x10, 0x00, 0x80, 0x3F, 0xE3, 0xA7,
  0x31, 0x01, 0x88, 0x08, 0x40, 0xC2, 0x02, 0x10, 0x18, 0x80, 0x64, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x4E, 0x02, 0x30, 0x10, 0xC0, 0x86, 0x04,
  0x30, 0x21, 0x81, 0x19, 0x09, 0xCF, 0xFC, 0x1F, 0x80, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x10, 0x00, 0x0F, 0x80, 0xC3, 0x18, 0x18, 0x63, 0x06, 0x08,
  0x20, 0xC1, 0x04, 0x10, 0x20, 0x86, 0x04, 0x18, 0x80, 0x83, 0x30, 0x10,
  0x46, 0x02, 0x08, 0x8E, 0x41, 0x33, 0xEC, 0x64, 0xC7, 0x8D, 0x90, 0xDF,
  0x32, 0x08, 0x84, 0x41, 0x01, 0x98, 0x20, 0x23, 0x04, 0x0C, 0x60, 0x81,
  0x84, 0x10, 0x20, 0x82, 0x0C, 0x10, 0xC1, 0x03, 0x18, 0x60, 0x26, 0x0C,
  0x07, 0xC0, 0x03, 0x00, 0x0F, 0xC0, 0x18, 0xC0, 0x10, 0x60, 0x30, 0x60,
  0x30, 0x60, 0x30, 0x60, 0x10, 0x60, 0x18, 0xC0, 0x18, 0xC0, 0x0D, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1B, 0x01, 0x31, 0x82, 0x61, 0xC6, 0x60, 0xC6,
  0xC0, 0x66, 0xC0, 0x3C, 0xC0, 0x3C, 0xC0, 0x18, 0x60, 0x3C, 0x60, 0x7E,
  0x39, 0xE6, 0x1F, 0x83, 0xFF, 0xFD, 0x40, 0x0C, 0x61, 0x0C, 0x21, 0x86,
  0x10, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x06,
  0x18, 0x20, 0xC1, 0x06, 0x0C, 0xE0, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x06,
  0x0C, 0x18, 0x10, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x60, 0xC1,
  0x83, 0x0C, 0x18, 0x60, 0xC3, 0x0E, 0x00, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x62, 0x7F, 0xFE, 0x06, 0x00, 0xF0, 0x09, 0x81, 0x8C, 0x30, 0xC1,
  0x08, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x1F, 0xFF, 0xFF, 0xF8, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x33, 0x36, 0x66, 0x4C, 0xFF, 0xFF, 0x7F, 0x80, 0x00,
  0xC0, 0x30, 0x08, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x0C, 0x06, 0x01, 0x80,
  0x40, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30, 0x0C, 0x03, 0x01, 0x80,
  0x60, 0x10, 0x0C, 0x03, 0x00, 0x04, 0x01, 0xF8, 0x31, 0xC6, 0x0C, 0x60,
  0x6C, 0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xC0,
  0x66, 0x06, 0x70, 0xC3, 0xFC, 0x1F, 0x80, 0x0E, 0x3C, 0xDB, 0x3C, 0x70,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x01, 0xFE, 0x1C, 0x38, 0x80, 0xE0, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x06, 0x01, 0xFE,
  0x3C, 0x38, 0x80, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30,
  0x03, 0x80, 0x18, 0x07, 0x81, 0xF0, 0x00, 0xF0, 0x01, 0xC0, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x80, 0x1A, 0x01, 0xDE, 0x3C,
  0x7F, 0xC0, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x60, 0x09,
  0x80, 0x66, 0x01, 0x18, 0x0C, 0x60, 0x21, 0x81, 0x86, 0x0C, 0x18, 0x30,
  0x61, 0x81, 0x86, 0x06, 0x30, 0x18, 0xC0, 0x63, 0xFF, 0xF0, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x7F, 0xE6, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x04, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x0D, 0xE0, 0xFF,
  0x84, 0x0C, 0x00, 0x60, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x07, 0x00, 0x68, 0x0E, 0xF3, 0xCF, 0xF0, 0x01, 0x80, 0xFE, 0x1C,
  0x23, 0x00, 0x30, 0x06, 0x00, 0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xCF,
  0x8D, 0xFC, 0xE0, 0x6E, 0x06, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x36, 0x06, 0x60, 0x63, 0x9C, 0x1F, 0x80, 0xFF, 0xF8,
  0x00, 0xC0, 0x06, 0x00, 0x60, 0x03, 0x00, 0x10, 0x01, 0x80, 0x0C, 0x00,
  0x40, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x03, 0x00, 0xFF, 0x0E, 0x1C, 0x60, 0x66, 0x03, 0x30, 0x0D, 0x80,
  0x6C, 0x06, 0x30, 0x31, 0x83, 0x07, 0x38, 0x1F, 0x00, 0x78, 0x0E, 0xE0,
  0xC1, 0x8C, 0x06, 0x60, 0x1A, 0x00, 0xF0, 0x07, 0x80, 0x34, 0x01, 0xB0,
  0x0D, 0xC0, 0xC7, 0x9E, 0x1F, 0xC0, 0x02, 0x00, 0xFE, 0x0E, 0x38, 0xE0,
  0xC6, 0x03, 0x30, 0x19, 0x00, 0x58, 0x03, 0xC0, 0x1A, 0x00, 0xD8, 0x06,
  0xC0, 0x76, 0x03, 0x98, 0x2C, 0xFF, 0x61, 0xE3, 0x00, 0x10, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x04, 0x70, 0x3F, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x77, 0x30, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x33, 0x36, 0x66, 0x4C, 0x00, 0x08, 0x00, 0xC0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x00, 0xE0, 0x1C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x20, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x00, 0x38, 0x07, 0x00,
  0xE0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0x00, 0x00, 0x18, 0x7F, 0xB0, 0xE0,
  0x30, 0x18, 0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x60,
  0x60, 0x20, 0x10, 0x08, 0x04, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x70, 0x38,
  0x00, 0x03, 0xFE, 0x00, 0x70, 0x70, 0x0C, 0x01, 0x81, 0x80, 0x0C, 0x30,
  0x00, 0x62, 0x00, 0x06, 0x60, 0x30, 0x24, 0x0F, 0xC3, 0xC1, 0x84, 0x3C,
  0x30, 0xC1, 0xC3, 0x0C, 0x1C, 0x20, 0xC1, 0x86, 0x0C, 0x18, 0x60, 0xC1,
  0x86, 0x0C, 0x18, 0x60, 0xC3, 0xC2, 0x0C, 0x3C, 0x31, 0xC2, 0xC3, 0xB6,
  0x6C, 0x1E, 0x3C, 0x40, 0x00, 0x06, 0x00, 0x00, 0x20, 0x00, 0x03, 0x00,
  0x00, 0x1C, 0x02, 0x00, 0xFB, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x02, 0x60, 0x06, 0x60, 0x06, 0x60, 0x06,
  0x20, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x08, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x1F, 0xF8, 0x3F, 0xFC, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x60,
  0x06, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0x86, 0x1F,
  0x30, 0x1D, 0x80, 0x6C, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0, 0x36,
  0x03, 0x3F, 0xF1, 0xFF, 0x0C, 0x0E, 0x60, 0x1B, 0x00, 0xD8, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x6C, 0x03, 0x60, 0x3B, 0xFF, 0x9F, 0xF0,
  0x00, 0xE0, 0x1F, 0xF1, 0xE1, 0x8E, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xCE, 0x07, 0xF8, 0xFF, 0x83, 0x1F, 0x8C,
  0x07, 0x30, 0x0C, 0xC0, 0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x6C, 0x01, 0xB0, 0x0E, 0xC0, 0x33, 0x03, 0x8F, 0xFC,
  0x3F, 0xC0, 0xFF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF,
  0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x00, 0x60, 0x07, 0xFE, 0x0E, 0x07, 0x18, 0x02, 0x30, 0x00,
  0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00,
  0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x7F, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0x60, 0x03, 0x60, 0x03, 0x70, 0x03, 0x30, 0x03, 0x1C, 0x03,
  0x0F, 0x9F, 0x07, 0xFE, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFE, 0x30,
  0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x7F, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x6F, 0xDF, 0x00, 0xC0, 0x3E,
  0x03, 0x30, 0x39, 0x81, 0x8C, 0x18, 0x61, 0xC3, 0x0C, 0x18, 0xC0, 0xCE,
  0x06, 0x60, 0x36, 0x01, 0xF8, 0x0E, 0xC0, 0x73, 0x03, 0x1C, 0x18, 0x60,
  0xC1, 0x86, 0x0C, 0x30, 0x31, 0x81, 0x8C, 0x06, 0x60, 0x33, 0x00, 0xD8,
  0x07, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x02, 0xF8, 0x00, 0xDF, 0x00, 0x1B, 0xA0, 0x02, 0x76, 0x00, 0xCE,
  0xC0, 0x19, 0xC8, 0x03, 0x39, 0x80, 0xC7, 0x30, 0x18, 0xE2, 0x03, 0x1C,
  0x60, 0xC3, 0x8C, 0x18, 0x70, 0x83, 0x0E, 0x18, 0xC1, 0xC3, 0x18, 0x38,
  0x23, 0x07, 0x06, 0xC0, 0xE0, 0xD8, 0x1C, 0x1B, 0x03, 0x81, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0x60, 0x1D, 0x80, 0x73, 0x01, 0xCC, 0x07, 0x18, 0x1C, 0x60, 0x70,
  0xC1, 0xC3, 0x07, 0x06, 0x1C, 0x18, 0x70, 0x31, 0xC0, 0xC7, 0x01, 0x9C,
  0x06, 0x70, 0x0D, 0xC0, 0x37, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x00, 0x80,
  0x07, 0xF8, 0x07, 0x0F, 0x07, 0x01, 0x87, 0x00, 0x63, 0x00, 0x31, 0x80,
  0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01,
  0x98, 0x00, 0xCC, 0x00, 0x66, 0x00, 0x61, 0x80, 0x30, 0xE0, 0x30, 0x3E,
  0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x8C, 0x7C, 0xC0, 0xEC, 0x06, 0xC0, 0x6C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x0C, 0xFF, 0xCF,
  0xF0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0x00, 0x80, 0x07, 0xF8, 0x07, 0x0F, 0x07, 0x01,
  0x87, 0x00, 0x63, 0x00, 0x31, 0x80, 0x0D, 0x80, 0x06, 0xC0, 0x03, 0x60,
  0x01, 0xB0, 0x00, 0xD8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x00, 0xCC, 0x00, 0x66, 0x00,
  0x61, 0x80, 0x30, 0xE0, 0x30, 0x3E, 0xF0, 0x07, 0xF0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00, 0x38, 0xFF, 0x86,
  0x3E, 0x30, 0x39, 0x80, 0xCC, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x06, 0xC0,
  0x66, 0x03, 0x30, 0x39, 0x83, 0x8F, 0xF0, 0x61, 0x83, 0x0C, 0x18, 0x30,
  0xC1, 0x86, 0x0E, 0x30, 0x31, 0x81, 0xCC, 0x06, 0x60, 0x3B, 0x00, 0xD8,
  0x07, 0x03, 0x00, 0xFF, 0x8E, 0x0C, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0x80, 0x06, 0x00, 0x30, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x03, 0x00,
  0x1A, 0x01, 0xDF, 0x3C, 0x7F, 0x80, 0xFF, 0xFC, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x06, 0xC0,
  0x19, 0x80, 0xE3, 0xCF, 0x07, 0xF0, 0xC0, 0x07, 0xC0, 0x06, 0x60, 0x06,
  0x60, 0x04, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x30, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x30, 0x18, 0x30, 0x0C, 0x30, 0x0C, 0x20,
  0x0C, 0x60, 0x04, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x01, 0x80, 0xC0, 0x0C, 0x01, 0xB0, 0x0E, 0x00,
  0xD8, 0x07, 0x00, 0x4C, 0x03, 0x80, 0x66, 0x01, 0x60, 0x31, 0x81, 0xB0,
  0x18, 0xC0, 0xD8, 0x0C, 0x60, 0x64, 0x0C, 0x30, 0x33, 0x06, 0x08, 0x11,
  0x83, 0x06, 0x18, 0xC1, 0x83, 0x0C, 0x21, 0x81, 0x86, 0x10, 0xC0, 0xC2,
  0x0C, 0x60, 0x33, 0x06, 0x30, 0x19, 0x83, 0x10, 0x0C, 0xC0, 0x98, 0x06,
  0x60, 0x6C, 0x01, 0x20, 0x36, 0x00, 0xF0, 0x1B, 0x00, 0x78, 0x05, 0x00,
  0x3C, 0x03, 0x80, 0x0C, 0x01, 0xC0, 0x06, 0x00, 0xE0, 0x60, 0x1C, 0xC0,
  0x63, 0x01, 0x86, 0x0C, 0x18, 0x30, 0x21, 0x80, 0xC6, 0x03, 0x30, 0x06,
  0xC0, 0x1E, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x80, 0x1E, 0x00, 0x6C, 0x03,
  0x30, 0x0C, 0x60, 0x61, 0x81, 0x83, 0x0C, 0x0C, 0x30, 0x39, 0x80, 0x66,
  0x01, 0xB0, 0x03, 0xC0, 0x0D, 0x80, 0x66, 0x01, 0x88, 0x0C, 0x30, 0x30,
  0xC0, 0xC1, 0x86, 0x06, 0x18, 0x08, 0xC0, 0x33, 0x00, 0xCC, 0x01, 0xE0,
  0x07, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xFF, 0xF0, 0x03,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x30,
  0x03, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00,
  0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81,
  0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x0F, 0xE0, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00,
  0x80, 0x30, 0x0C, 0x01, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x20, 0x0C, 0x03, 0xFE, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x78,
  0x03, 0x20, 0x0C, 0xC0, 0x61, 0x01, 0x86, 0x0C, 0x08, 0x30, 0x31, 0x80,
  0x46, 0x01, 0xB0, 0x06, 0xC0, 0x0C, 0xFF, 0xFF, 0xFF, 0xF0, 0xE1, 0xC3,
  0x06, 0x0C, 0x3F, 0xC6, 0x18, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x0F, 0x1F, 0xE7, 0x05, 0x80, 0xB0, 0x3C, 0x07, 0x80, 0xF0, 0x1B, 0x05,
  0x71, 0xA7, 0xE4, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00,
  0x80, 0x08, 0x00, 0x9F, 0x8B, 0x1C, 0xA0, 0x6C, 0x06, 0xC0, 0x3C, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x6A, 0x0E, 0xB9, 0xC9, 0xF8, 0x1F, 0xCE, 0x36, 0x01, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06,
  0x01, 0x80, 0x38, 0xC7, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x1F, 0xB3, 0x9F, 0x60, 0x7E, 0x07, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x76, 0x07, 0x79, 0x91, 0xF1, 0x1F, 0x83, 0x1C, 0x60,
  0xC4, 0x06, 0xC0, 0x6C, 0x02, 0xC0, 0x2C, 0x03, 0xFF, 0xFC, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x02, 0x3C, 0xE1, 0xFC, 0x07,
  0xC3, 0xE1, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0xFF, 0x06, 0x01,
  0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x00, 0x1F, 0x93, 0x1F, 0x60,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x76, 0x07, 0x79, 0xB1, 0xF3, 0x00,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x78, 0x06, 0xFF, 0xC7, 0xF8, 0x80,
  0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x9F, 0x96,
  0x3A, 0x83, 0x60, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x5F,
  0x80, 0x02, 0x49, 0x24, 0x92, 0x49, 0x24, 0x92, 0x40, 0x08, 0x71, 0xC0,
  0x00, 0x00, 0x02, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x61, 0xBE, 0xF0, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04, 0x00, 0x80, 0xD0, 0x32,
  0x0C, 0x43, 0x08, 0x61, 0x18, 0x26, 0x04, 0xC0, 0xBC, 0x1D, 0x83, 0x18,
  0x43, 0x08, 0x31, 0x06, 0x20, 0x64, 0x0C, 0x80, 0xD0, 0x1C, 0xFF, 0xFF,
  0xFF, 0xC0, 0x9F, 0x0F, 0x96, 0x73, 0x3B, 0x83, 0x83, 0xE0, 0x70, 0x3C,
  0x0E, 0x07, 0x81, 0x80, 0xE0, 0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70,
  0x18, 0x0E, 0x03, 0x01, 0xC0, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80, 0xE0,
  0x30, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0C, 0x9F, 0x96, 0x3A,
  0x83, 0x60, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0C, 0x1F, 0x83,
  0x8C, 0x60, 0x6C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x60, 0x36, 0x06, 0x39, 0xC1,
  0xF8, 0x9F, 0x8B, 0x1C, 0xA0, 0x6C, 0x06, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x6A,
  0x06, 0xB9, 0xC9, 0xF8, 0x80, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x08,
  0x00, 0x80, 0x08, 0x00, 0x1F, 0x93, 0x9F, 0x60, 0x7E, 0x07, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x76, 0x07, 0x79, 0xB1, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x9F, 0x76, 0x86, 0x0C, 0x18,
  0x30, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x00, 0x3F,
  0xDC, 0x36, 0x03, 0x00, 0xC0, 0x18, 0x06, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0xC0, 0x30, 0x0E, 0x03, 0xF3, 0x9F, 0xC0, 0x20, 0x40,
  0x81, 0x0F, 0xE4, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x83, 0xA3, 0xC0, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x60, 0x76, 0x0F, 0x79, 0xB3, 0xF3, 0xC0, 0x3A, 0x01,
  0x98, 0x0C, 0xC0, 0x66, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x08, 0x10, 0xC0,
  0xC6, 0x06, 0x30, 0x33, 0x00, 0x98, 0x06, 0xC0, 0x34, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0xC0, 0x70, 0x36, 0x07, 0x03, 0x60, 0x50, 0x36, 0x05,
  0x03, 0x60, 0xD8, 0x23, 0x0D, 0x86, 0x30, 0xD8, 0x63, 0x08, 0x86, 0x31,
  0x8C, 0x41, 0x18, 0xCC, 0x19, 0x8C, 0xC1, 0x90, 0x4C, 0x1B, 0x06, 0x80,
  0xB0, 0x68, 0x0F, 0x07, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x30,
  0xC0, 0x66, 0x06, 0x60, 0xC3, 0x0C, 0x31, 0x81, 0x98, 0x1B, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0x01, 0xB0, 0x11, 0x83, 0x18, 0x60, 0xC6, 0x0C,
  0xC0, 0x6C, 0x07, 0xC0, 0x1B, 0x01, 0x98, 0x0C, 0xC0, 0x63, 0x02, 0x18,
  0x30, 0xC1, 0x82, 0x0C, 0x18, 0xC0, 0xC6, 0x06, 0x30, 0x19, 0x00, 0xD8,
  0x06, 0xC0, 0x16, 0x00, 0xE0, 0x07, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x02, 0x00, 0x30, 0x01, 0x80, 0xB8, 0x07, 0x80, 0x00, 0x7F, 0xBF,
  0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06, 0x06, 0x03,
  0x01, 0x81, 0x80, 0xC0, 0xFF, 0xFF, 0xC0, 0x03, 0xC1, 0xC0, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x18, 0x0E,
  0x0E, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x1C, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF0, 0x0E, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x06, 0x01, 0xC0, 0x1C, 0x1C, 0x06, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0xE0,
  0xF0, 0x00, 0x3C, 0x0B, 0xF8, 0x70, 0xFF, 0x01, 0xC0,
};

const GFXglyph NotoSans_Condensed_Light34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 24, 8, 2, -24 },
  { 10, 8, 9, 12, 2, -24 },
  { 19, 15, 24, 17, 1, -24 },
  { 64, 13, 28, 16, 1, -26 },
  { 110, 19, 25, 23, 2, -25 },
  { 170, 16, 25, 18, 1, -25 },
  { 220, 2, 9, 6, 2, -24 },
  { 223, 6, 29, 9, 2, -24 },
  { 245, 7, 29, 9, 1, -24 },
  { 271, 12, 12, 14, 1, -26 },
  { 289, 13, 16, 16, 1, -20 },
  { 315, 4, 8, 7, 1, -4 },
  { 319, 8, 2, 10, 1, -10 },
  { 321, 3, 3, 7, 2, -3 },
  { 323, 10, 24, 12, 1, -24 },
  { 353, 12, 25, 16, 2, -25 },
  { 391, 7, 24, 16, 3, -24 },
  { 412, 13, 25, 16, 1, -25 },
  { 453, 13, 25, 16, 1, -25 },
  { 494, 14, 24, 16, 1, -24 },
  { 536, 12, 24, 16, 2, -24 },
  { 572, 12, 25, 16, 2, -25 },
  { 610, 13, 24, 16, 1, -24 },
  { 649, 13, 25, 16, 1, -25 },
  { 690, 13, 25, 16, 1, -25 },
  { 731, 3, 18, 7, 2, -18 },
  { 738, 4, 22, 7, 1, -18 },
  { 749, 13, 15, 16, 1, -20 },
  { 774, 13, 8, 16, 1, -16 },
  { 787, 13, 15, 16, 1, -20 },
  { 812, 9, 25, 11, 1, -25 },
  { 841, 20, 27, 24, 2, -24 },
  { 909, 16, 24, 16, 0, -24 },
  { 957, 13, 24, 17, 3, -24 },
  { 996, 14, 25, 17, 2, -25 },
  { 1040, 14, 24, 19, 3, -24 },
  { 1082, 10, 24, 15, 3, -24 },
  { 1112, 10, 24, 14, 3, -24 },
  { 1142, 16, 25, 20, 2, -25 },
  { 1192, 14, 24, 20, 3, -24 },
  { 1234, 7, 24, 9, 1, -24 },
  { 1255, 7, 30, 7, -2, -24 },
  { 1282, 13, 24, 16, 3, -24 },
  { 1321, 10, 24, 14, 3, -24 },
  { 1351, 19, 24, 25, 3, -24 },
  { 1408, 14, 24, 20, 3, -24 },
  { 1450, 17, 25, 20, 2, -25 },
  { 1504, 12, 24, 16, 3, -24 },
  { 1540, 17, 31, 20, 2, -25 },
  { 1606, 13, 24, 16, 3, -24 },
  { 1645, 13, 25, 15, 1, -25 },
  { 1686, 14, 24, 14, 0, -24 },
  { 1728, 14, 24, 19, 3, -24 },
  { 1770, 16, 24, 16, 0, -24 },
  { 1818, 25, 24, 25, 0, -24 },
  { 1893, 14, 24, 14, 0, -24 },
  { 1935, 14, 24, 14, 0, -24 },
  { 1977, 12, 24, 14, 1, -24 },
  { 2013, 7, 29, 11, 3, -24 },
  { 2039, 10, 24, 12, 1, -24 },
  { 2069, 7, 29, 11, 1, -24 },
  { 2095, 14, 13, 16, 1, -24 },
  { 2118, 14, 2, 14, 0, 3 },
  { 2122, 6, 5, 9, 1, -26 },
  { 2126, 11, 18, 15, 1, -18 },
  { 2151, 12, 26, 17, 3, -26 },
  { 2190, 10, 18, 13, 2, -18 },
  { 2213, 12, 26, 17, 2, -26 },
  { 2252, 12, 18, 15, 2, -18 },
  { 2279, 10, 26, 9, 0, -26 },
  { 2312, 12, 26, 17, 2, -18 },
  { 2351, 11, 26, 16, 3, -26 },
  { 2387, 3, 25, 7, 2, -25 },
  { 2397, 6, 33, 7, -1, -25 },
  { 2422, 11, 26, 14, 3, -26 },
  { 2458, 1, 26, 7, 3, -26 },
  { 2462, 19, 18, 24, 3, -18 },
  { 2505, 11, 18, 16, 3, -18 },
  { 2530, 12, 18, 16, 2, -18 },
  { 2557, 12, 26, 17, 3, -18 },
  { 2596, 12, 26, 17, 2, -18 },
  { 2635, 7, 18, 11, 3, -18 },
  { 2651, 10, 18, 13, 1, -18 },
  { 2674, 7, 22, 9, 1, -22 },
  { 2694, 12, 18, 16, 2, -18 },
  { 2721, 13, 18, 13, 0, -18 },
  { 2751, 20, 18, 21, 0, -18 },
  { 2796, 12, 18, 13, 1, -18 },
  { 2823, 13, 26, 13, 0, -18 },
  { 2866, 9, 18, 11, 1, -18 },
  { 2887, 10, 29, 12, 1, -24 },
  { 2924, 1, 34, 15, 7, -26 },
  { 2929, 10, 29, 12, 1, -24 },
  { 2966, 13, 4, 16, 1, -14 },
};

const GFXfont NotoSans_Condensed_Light34pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light34pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light34pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _NOTOSANS_CONDENSED_LIGHT34PT7B_H_
