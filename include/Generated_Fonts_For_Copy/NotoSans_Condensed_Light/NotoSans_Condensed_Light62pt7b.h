#ifndef _NOTOSANS_CONDENSED_LIGHT62PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light62pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xCE, 0x73, 0x8C, 0x63, 0x18, 0xC6, 0x00, 0x00, 0x00,
  0x00, 0xCF, 0xFF, 0xFE, 0xF2, 0x00, 0xF0, 0x3F, 0x81, 0xFC, 0x0F, 0xE0,
  0x7F, 0x03, 0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x76, 0x03, 0xB0, 0x1D, 0x80, 0xEC, 0x07, 0x00, 0x1C, 0x03, 0x00,
  0x00, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03,
  0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x07, 0x00,
  0xC0, 0x00, 0x30, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x0C, 0x00, 0x03, 0x00, 0x60, 0x00, 0x38, 0x07, 0x00, 0x01,
  0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x01, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00,
  0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x30, 0x06, 0x00, 0x01, 0x80,
  0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x03, 0x80, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0xFE, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xFF, 0x8F, 0xCC, 0x7E, 0x3C, 0x30,
  0x31, 0xE0, 0xC0, 0x0F, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03,
  0x80, 0xC0, 0x0E, 0x03, 0x00, 0x38, 0x0C, 0x00, 0xE0, 0x30, 0x03, 0x80,
  0xC0, 0x0F, 0x03, 0x00, 0x1E, 0x0C, 0x00, 0x3C, 0x30, 0x00, 0xFC, 0xC0,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0C, 0xFC, 0x00, 0x30, 0xF8, 0x00, 0xC1, 0xE0, 0x03,
  0x03, 0xC0, 0x0C, 0x07, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x01,
  0xC0, 0x0C, 0x07, 0x00, 0x30, 0x1C, 0x00, 0xC0, 0x70, 0x03, 0x03, 0xE0,
  0x0C, 0x1E, 0xC0, 0x30, 0xFB, 0xF0, 0xDF, 0xCF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0x00, 0x3F, 0xF0, 0x00, 0x70, 0x03, 0x87,
  0x00, 0x0E, 0x00, 0x70, 0x38, 0x00, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x1C, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0x1C, 0x0E, 0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x1C, 0x1C,
  0x00, 0x0E, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x1C, 0x38, 0x3F, 0x0E, 0x01,
  0xC3, 0x87, 0xF8, 0xE0, 0x1C, 0x70, 0xF7, 0xC7, 0x01, 0xC7, 0x1C, 0x1C,
  0x70, 0x38, 0x71, 0xC0, 0xE7, 0x03, 0x8E, 0x38, 0x0E, 0x38, 0x70, 0xE3,
  0x80, 0xE3, 0xFF, 0x1C, 0x38, 0x07, 0x1F, 0xE1, 0xC3, 0x80, 0x70, 0x78,
  0x1C, 0x38, 0x07, 0x00, 0x03, 0x83, 0x80, 0x70, 0x00, 0x38, 0x38, 0x07,
  0x00, 0x07, 0x03, 0x00, 0x70, 0x00, 0x70, 0x30, 0x07, 0x00, 0x07, 0x03,
  0x00, 0x70, 0x00, 0xE0, 0x30, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x70, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0x1C, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0x38, 0x03, 0x80, 0x60, 0x03, 0x80, 0x38, 0x0E, 0x00, 0x70, 0x01,
  0xC0, 0xE0, 0x07, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x00, 0xE3, 0xC0, 0x0E,
  0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xF0, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x38, 0x03,
  0xC0, 0x00, 0xE0, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x1C, 0x03, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x03, 0x83, 0xC0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x78, 0x3C,
  0x01, 0xC3, 0xC0, 0xF0, 0x07, 0x0F, 0x01, 0xE0, 0x3C, 0x78, 0x03, 0xC0,
  0xE1, 0xE0, 0x07, 0x03, 0x87, 0x00, 0x1E, 0x0E, 0x1C, 0x00, 0x3C, 0x78,
  0xF0, 0x00, 0x79, 0xC3, 0xC0, 0x01, 0xEF, 0x0F, 0x00, 0x03, 0xF8, 0x3C,
  0x00, 0x07, 0xE0, 0x70, 0x00, 0x0F, 0x01, 0xC0, 0x00, 0x3C, 0x07, 0x80,
  0x01, 0xF8, 0x1E, 0x00, 0x0F, 0xF0, 0x3C, 0x00, 0x79, 0xC0, 0xF8, 0x07,
  0xC7, 0x81, 0xFF, 0xFE, 0x0F, 0x03, 0xFF, 0xF0, 0x1E, 0x03, 0xFF, 0x00,
  0x7C, 0x00, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0x66,
  0x66, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x80, 0x78, 0x03,
  0x80, 0x38, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xF0, 0x07,
  0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x1E, 0x01,
  0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x80, 0x60,
  0x1F, 0x06, 0x0F, 0xFE, 0x67, 0xFF, 0xFF, 0xFF, 0x07, 0xFE, 0x00, 0x0F,
  0x00, 0x01, 0xF8, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x70, 0xE0, 0x0F,
  0x0F, 0x01, 0xE0, 0x78, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x04, 0x01, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1C, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x38, 0x70,
  0xE3, 0x87, 0x0E, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x23,
  0xFF, 0xFF, 0xBC, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xF1, 0xF0, 0x1F, 0x01, 0xE0, 0x78, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x1C, 0x38, 0x00, 0x79, 0xE0, 0x00, 0xE7, 0x80, 0x03,
  0x9C, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00,
  0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9E, 0x00, 0x0E, 0x78, 0x00, 0x38,
  0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x07, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x3C,
  0x0F, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x78, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0xFB, 0x8F, 0xBC, 0xF9,
  0xEF, 0x8F, 0xF0, 0x7B, 0x03, 0xD0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0xC3, 0xF0,
  0x78, 0x03, 0xE1, 0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x03, 0xFF,
  0xFC, 0x3F, 0x81, 0xF8, 0xF0, 0x01, 0xF3, 0x80, 0x03, 0xC4, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x80, 0x00, 0xF3, 0x80, 0x0F,
  0x8F, 0xF3, 0xFE, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F, 0x40, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38,
  0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00,
  0x0E, 0x0E, 0x00, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38,
  0x03, 0xC0, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0x80,
  0x03, 0x80, 0xF0, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC7, 0xE0, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF0, 0x3C, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x20, 0x00, 0x7C, 0xE0, 0x03,
  0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x1F, 0xC1, 0x80,
  0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x10, 0x01, 0xC3, 0xFE, 0x07, 0x9F, 0xFE, 0x0F, 0x7F, 0xFE,
  0x1E, 0xE0, 0x1E, 0x3F, 0x80, 0x1E, 0x7E, 0x00, 0x1C, 0xF8, 0x00, 0x3D,
  0xF0, 0x00, 0x7B, 0xC0, 0x00, 0x77, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0,
  0x00, 0x3D, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x80, 0x01, 0xC7, 0x00,
  0x07, 0x8F, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1E, 0x01,
  0xE0, 0x3F, 0x9F, 0x80, 0x3F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xE0, 0x0F, 0x07, 0x80,
  0x0F, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0xE0, 0x00,
  0x79, 0xC0, 0x00, 0xF3, 0x80, 0x01, 0xE7, 0x00, 0x03, 0xCF, 0x00, 0x07,
  0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3E, 0x03, 0xC0,
  0x3E, 0x0F, 0x00, 0x3E, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x80, 0x03, 0xEF, 0xC0, 0x0F, 0x87, 0xC0, 0x3C, 0x07, 0xC0, 0xF0,
  0x03, 0xC3, 0xC0, 0x03, 0xC7, 0x80, 0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00,
  0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xBC, 0x00, 0x0F,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0x7F, 0x1F, 0xC0,
  0x7F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xE1, 0xF0, 0x3E, 0x01, 0xE0, 0xF0,
  0x03, 0x87, 0x80, 0x0F, 0x1C, 0x00, 0x1C, 0xF0, 0x00, 0x7B, 0xC0, 0x00,
  0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0, 0x01, 0xF7, 0x80, 0x0F,
  0xCF, 0x00, 0x77, 0x3E, 0x03, 0x9C, 0x7F, 0xFE, 0x70, 0xFF, 0xF1, 0xC0,
  0xFF, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7E, 0x03, 0xDF, 0xF0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x1C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x67, 0xFF, 0xFF,
  0x79, 0x00, 0x1E, 0x7C, 0xF9, 0xF1, 0xE3, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x0E, 0x3C, 0x78, 0xE1, 0xC7, 0x8E, 0x1C,
  0x38, 0xE0, 0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x0F, 0xFF, 0x0F, 0xFF, 0xE1, 0xF0, 0xFC, 0x60,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x00, 0x40, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x03, 0x81, 0xE0, 0x00,
  0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x3C, 0x00, 0x7F, 0x80, 0x70,
  0xE0, 0x07, 0xFF, 0x80, 0xE3, 0x80, 0x3F, 0xFE, 0x03, 0x8E, 0x01, 0xE0,
  0x70, 0x0E, 0x70, 0x07, 0x01, 0xC0, 0x39, 0xC0, 0x38, 0x07, 0x00, 0xE7,
  0x00, 0xE0, 0x1C, 0x01, 0x9C, 0x07, 0x00, 0x70, 0x07, 0x70, 0x1C, 0x01,
  0xC0, 0x1F, 0x80, 0x70, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x1C, 0x01, 0xF8,
  0x0F, 0x00, 0x70, 0x07, 0xE0, 0x38, 0x01, 0xC0, 0x1F, 0x80, 0xE0, 0x07,
  0x00, 0x7E, 0x03, 0x80, 0x1C, 0x03, 0xB8, 0x0E, 0x00, 0x70, 0x0E, 0xE0,
  0x3C, 0x01, 0xC0, 0x3B, 0x80, 0x70, 0x0F, 0x00, 0xEE, 0x01, 0xC0, 0x3C,
  0x03, 0x9C, 0x07, 0x00, 0xF0, 0x1C, 0x70, 0x1E, 0x06, 0xE0, 0x71, 0xC0,
  0x3C, 0x39, 0x83, 0x87, 0x00, 0xFF, 0xC7, 0xFE, 0x1C, 0x01, 0xFF, 0x0F,
  0xF0, 0x38, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x80,
  0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x07, 0x9C,
  0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x0E, 0x3C, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00, 0x38, 0x3C, 0x00, 0x03,
  0xC0, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x38, 0x00, 0x07, 0x01,
  0xE0, 0x00, 0x78, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xE0,
  0x01, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03,
  0x80, 0x0F, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x0E,
  0x01, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0E, 0x07,
  0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0E, 0x1C, 0x00,
  0x00, 0x70, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xF0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF0, 0x01, 0xF8,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1C,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x01, 0xF0, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0xF0, 0xF0, 0x00, 0xF8,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78,
  0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x07, 0xF8,
  0x7E, 0x03, 0xF0, 0x01, 0x81, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x60, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xC0, 0x0F, 0xC0, 0xF0, 0x00, 0xF8, 0x3C, 0x00,
  0x1F, 0x0F, 0x00, 0x03, 0xE3, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x3C,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xCF, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x07,
  0xC3, 0xC0, 0x07, 0xE0, 0xF0, 0x07, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBC, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xFE, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x3F,
  0xC0, 0xFE, 0x01, 0xF8, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x40, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF7, 0x00, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D,
  0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0xF0, 0xF8, 0x00,
  0x03, 0xC1, 0xF0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x3C, 0x07, 0xE0, 0x01,
  0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x70, 0xFF, 0xFF,
  0xFF, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x01,
  0xFC, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x80, 0x3D, 0x03, 0xCF, 0xFE, 0x7F, 0xE3, 0xFC, 0x00, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0,
  0x00, 0xF1, 0xE0, 0x00, 0xF1, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0xF7, 0xE0,
  0x00, 0xF7, 0xE0, 0x00, 0xFE, 0xF0, 0x00, 0xFC, 0x78, 0x00, 0xF8, 0x78,
  0x00, 0xF8, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03,
  0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x00, 0x77, 0xEE, 0x00,
  0x00, 0x07, 0x7E, 0xF0, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0x0E, 0x7E,
  0x70, 0x00, 0x00, 0xEF, 0xE7, 0x80, 0x00, 0x1C, 0xFE, 0x38, 0x00, 0x01,
  0xCF, 0xE3, 0x80, 0x00, 0x1C, 0xFE, 0x3C, 0x00, 0x03, 0x8F, 0xE1, 0xC0,
  0x00, 0x38, 0xFE, 0x1C, 0x00, 0x03, 0x8F, 0xE1, 0xE0, 0x00, 0x78, 0xFE,
  0x0E, 0x00, 0x07, 0x0F, 0xE0, 0xE0, 0x00, 0x70, 0xFE, 0x0F, 0x00, 0x0F,
  0x0F, 0xE0, 0x70, 0x00, 0xE0, 0xFE, 0x07, 0x00, 0x0E, 0x0F, 0xE0, 0x78,
  0x01, 0xE0, 0xFE, 0x03, 0x80, 0x1C, 0x0F, 0xE0, 0x38, 0x01, 0xC0, 0xFE,
  0x03, 0xC0, 0x3C, 0x0F, 0xE0, 0x1C, 0x03, 0x80, 0xFE, 0x01, 0xC0, 0x38,
  0x0F, 0xE0, 0x1E, 0x07, 0x80, 0xFE, 0x00, 0xE0, 0x70, 0x0F, 0xE0, 0x0E,
  0x07, 0x00, 0xFE, 0x00, 0xF0, 0xF0, 0x0F, 0xE0, 0x0F, 0x0E, 0x00, 0xFE,
  0x00, 0x70, 0xE0, 0x0F, 0xE0, 0x07, 0x1E, 0x00, 0xFE, 0x00, 0x79, 0xC0,
  0x0F, 0xE0, 0x03, 0x9C, 0x00, 0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFB, 0xC0, 0x00,
  0x7F, 0x78, 0x00, 0x0F, 0xE7, 0x80, 0x01, 0xFC, 0xF0, 0x00, 0x3F, 0x8F,
  0x00, 0x07, 0xF1, 0xE0, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0xC3, 0xC0, 0x03,
  0xF8, 0x3C, 0x00, 0x7F, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x01, 0xFC, 0x0F,
  0x00, 0x3F, 0x80, 0xF0, 0x07, 0xF0, 0x1E, 0x00, 0xFE, 0x01, 0xE0, 0x1F,
  0xC0, 0x3C, 0x03, 0xF8, 0x03, 0xC0, 0x7F, 0x00, 0x78, 0x0F, 0xE0, 0x07,
  0x81, 0xFC, 0x00, 0xF0, 0x3F, 0x80, 0x0F, 0x07, 0xF0, 0x01, 0xE0, 0xFE,
  0x00, 0x1E, 0x1F, 0xC0, 0x03, 0xC3, 0xF8, 0x00, 0x3C, 0x7F, 0x00, 0x07,
  0x8F, 0xE0, 0x00, 0x79, 0xFC, 0x00, 0x0F, 0x3F, 0x80, 0x00, 0xF7, 0xF0,
  0x00, 0x1E, 0x7E, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0x3D, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1C,
  0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0xB0, 0x00, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFC, 0x3C, 0x01, 0xF8, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07,
  0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x0F, 0x8F, 0x01, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x03, 0xFF, 0xE0, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01,
  0xE1, 0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x07,
  0x9E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x1E,
  0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3D, 0xC0,
  0x00, 0x00, 0x7B, 0x80, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x01, 0xEE, 0x00,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1E, 0x78, 0x00,
  0x00, 0x3C, 0x70, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00,
  0x3C, 0x07, 0xC0, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF8, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xC0, 0xF0, 0x07, 0xE0, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0x38, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x70, 0xF0, 0x00, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x0F,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xF0, 0x1E,
  0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01,
  0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x00, 0x7F, 0x00, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x87, 0xF1, 0xFE, 0x3E, 0x00, 0x31, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x80, 0x01, 0xF3,
  0x80, 0x0F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xEF, 0x00,
  0x00, 0x3B, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC7,
  0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x7E, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x0E, 0x78, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x3C, 0x1C, 0x00,
  0x03, 0x81, 0xE0, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x07, 0x00, 0xF0, 0x00, 0xF0, 0x07, 0x00, 0x0F, 0x00, 0x70,
  0x00, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x38, 0x01, 0xC0, 0x03, 0xC0, 0x1C, 0x00, 0x1C, 0x03, 0xC0, 0x01,
  0xC0, 0x38, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x78, 0x00, 0x0E, 0x07,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x0F, 0x07, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x07, 0x0F, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x39,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x03, 0xDC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xBC, 0x00, 0x03, 0xC0,
  0x00, 0x1D, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xE7, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7E, 0x00, 0x03,
  0x8F, 0x00, 0x03, 0xB8, 0x00, 0x3C, 0x38, 0x00, 0x3D, 0xC0, 0x01, 0xE1,
  0xC0, 0x01, 0xCE, 0x00, 0x0F, 0x0F, 0x00, 0x0E, 0x70, 0x00, 0x70, 0x78,
  0x00, 0x73, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0x0E, 0x00,
  0x3C, 0x70, 0x01, 0xE0, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x03, 0xC0, 0x0E,
  0x1C, 0x00, 0x70, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x80, 0x70, 0x07, 0x83,
  0x80, 0x3C, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0xE0,
  0x0E, 0x00, 0xF0, 0x0E, 0x07, 0x00, 0x70, 0x03, 0x80, 0x70, 0x1C, 0x07,
  0x80, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x00, 0xF0, 0x38, 0x07, 0x01, 0xC0,
  0x07, 0x81, 0xC0, 0x38, 0x0E, 0x00, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x00,
  0xE0, 0xF0, 0x07, 0x07, 0x80, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0x3C,
  0x38, 0x01, 0xC1, 0xC0, 0x01, 0xE1, 0xC0, 0x0F, 0x1E, 0x00, 0x07, 0x0E,
  0x00, 0x38, 0xF0, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x01, 0xC7, 0x00,
  0x0E, 0x38, 0x00, 0x0F, 0x38, 0x00, 0x71, 0xC0, 0x00, 0x79, 0xC0, 0x03,
  0xDE, 0x00, 0x01, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x77,
  0x00, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x03, 0xF8, 0x00, 0x1D, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xC1,
  0xE0, 0x00, 0xF0, 0x78, 0x00, 0x38, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0x80, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0xF0,
  0x1E, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0, 0x00,
  0x38, 0x78, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7B, 0x80,
  0x00, 0x0E, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x3C, 0x00, 0x03, 0xC7, 0x00,
  0x00, 0xE1, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C, 0x0F, 0x00, 0x0F, 0x03,
  0xC0, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x00, 0xE0,
  0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xB8, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0x70,
  0x00, 0x78, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x03,
  0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x00, 0x1C, 0x07, 0x80,
  0x0E, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x00, 0xF0, 0xE0,
  0x00, 0x38, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03, 0xBC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF,
  0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1E, 0xE0, 0x00, 0x07, 0x1C, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xE0, 0xE0,
  0x00, 0x78, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x03, 0x80,
  0x38, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x1C, 0x00, 0x70, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x00, 0xF0, 0x70, 0x00, 0x1C,
  0x38, 0x00, 0x07, 0x8E, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x1F, 0xFC, 0x07, 0xFF, 0xF0, 0x3F, 0x0F, 0xC0, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x03, 0xFF, 0xF8, 0x7F, 0xC3, 0xC7,
  0xC0, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xC0, 0x01,
  0xEE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3E, 0xE0,
  0x01, 0xF7, 0x00, 0x1F, 0xBC, 0x00, 0xDC, 0xF0, 0x0C, 0xE7, 0xE1, 0xE7,
  0x1F, 0xFE, 0x38, 0x7F, 0xC1, 0xC0, 0x38, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x60, 0x0E, 0x1F,
  0xF0, 0x38, 0xFF, 0xF0, 0xE7, 0xEF, 0xE3, 0xB8, 0x07, 0xCE, 0xC0, 0x0F,
  0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0xF0, 0x00,
  0x7B, 0xE0, 0x01, 0xEF, 0xC0, 0x0F, 0x3B, 0x80, 0x78, 0xE7, 0xCF, 0xE3,
  0x0F, 0xFF, 0x0C, 0x1F, 0xF0, 0x00, 0x06, 0x00, 0x00, 0x18, 0x00, 0x3F,
  0xF8, 0x0F, 0xFF, 0x83, 0xFB, 0xE0, 0xF8, 0x04, 0x3C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x08, 0x7F, 0xBE,
  0x07, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x06, 0x03,
  0xC0, 0xFF, 0x87, 0x83, 0xFF, 0xCF, 0x0F, 0xEF, 0xDE, 0x3E, 0x03, 0xDC,
  0xF8, 0x01, 0xB9, 0xE0, 0x03, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE,
  0x00, 0x07, 0xB8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0x78, 0x00, 0xDC, 0xF0, 0x01, 0xB8,
  0xF0, 0x0E, 0x70, 0xFC, 0x7C, 0xE0, 0xFF, 0xF1, 0xC0, 0xFF, 0x83, 0x80,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xF8, 0x03, 0xF3,
  0xF0, 0x1E, 0x01, 0xE0, 0x70, 0x03, 0xC3, 0xC0, 0x07, 0x0E, 0x00, 0x1C,
  0x78, 0x00, 0x39, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x21, 0xF0, 0x03, 0x83, 0xF8, 0x7E, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x03, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0xC0, 0xF0, 0x00,
  0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0xFF, 0xF1, 0xFF,
  0xF8, 0xFF, 0xFC, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0xFE,
  0x1C, 0x1F, 0xFE, 0x38, 0x7F, 0x7E, 0x71, 0xF0, 0x1E, 0xE7, 0xC0, 0x0D,
  0xCF, 0x00, 0x1F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xE0, 0x00, 0x3D,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xF3, 0xC0, 0x06, 0xE7, 0x80, 0x0D, 0xC7, 0x80, 0x77,
  0x87, 0xE3, 0xEF, 0x07, 0xFF, 0x9E, 0x07, 0xFC, 0x3C, 0x00, 0x80, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC2, 0x00, 0x0F, 0x07, 0xC0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x03, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x01, 0x00, 0xE1, 0xFF, 0x0E, 0x3F, 0xFC, 0xE7, 0xEF, 0xCE, 0xE0,
  0x1E, 0xFC, 0x00, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x03, 0x81, 0xF0, 0x7C, 0x1F,
  0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1E, 0x8F, 0x3F, 0xCF, 0xE3, 0xE0, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xEE,
  0x00, 0x3C, 0xE0, 0x07, 0x8E, 0x00, 0x70, 0xE0, 0x0F, 0x0E, 0x01, 0xE0,
  0xE0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x78, 0x0E, 0x0F, 0x00, 0xE0, 0xE0,
  0x0E, 0x1E, 0x00, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xE7, 0xC0, 0x0E, 0xFE,
  0x00, 0xEE, 0xE0, 0x0F, 0xCF, 0x00, 0xF8, 0x70, 0x0F, 0x07, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0xE0, 0x1C, 0x0E, 0x01, 0xE0, 0xE0, 0x0E, 0x0E,
  0x00, 0xF0, 0xE0, 0x07, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00, 0x3C,
  0xE0, 0x01, 0xCE, 0x00, 0x1E, 0xE0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x70, 0x00, 0x78, 0x18, 0x3F, 0xC0, 0x3F, 0xC3, 0x1F,
  0xFC, 0x1F, 0xFE, 0x67, 0xCF, 0xC7, 0xCF, 0xCE, 0xE0, 0x7C, 0xE0, 0x3D,
  0xF8, 0x07, 0xB0, 0x07, 0xBE, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x0F, 0x80,
  0x0F, 0xF0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x03,
  0x80, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0,
  0x01, 0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07,
  0xE0, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80,
  0x03, 0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01,
  0xC0, 0x01, 0xF8, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0,
  0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x03,
  0xF0, 0x00, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x00, 0x0F, 0xC0, 0x01, 0xC0,
  0x01, 0xF8, 0x00, 0x38, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x07, 0xE0, 0x00,
  0xE0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x0C, 0x1F, 0xF0,
  0xC3, 0xFF, 0xCC, 0x7C, 0xFE, 0xCE, 0x01, 0xEF, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03,
  0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x3F, 0x01, 0xF0, 0x0F, 0x03, 0x80,
  0x0F, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xE0,
  0x00, 0x71, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0xC0,
  0x3C, 0x07, 0xF3, 0xF0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x18, 0x03, 0x07, 0xFC, 0x0C, 0x3F, 0xFC, 0x31, 0xF3, 0xF8,
  0xEE, 0x01, 0xF3, 0xB0, 0x03, 0xCF, 0x80, 0x07, 0xBE, 0x00, 0x1E, 0xF0,
  0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xBE, 0x00, 0x1E, 0xF8, 0x00, 0x73, 0xF0, 0x03, 0xCE,
  0xE0, 0x1E, 0x39, 0xF3, 0xF8, 0xE3, 0xFF, 0xC3, 0x87, 0xFC, 0x0E, 0x03,
  0x80, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFC, 0x1C, 0x1F, 0xFE,
  0x38, 0x7F, 0x7E, 0x71, 0xF0, 0x1C, 0xE7, 0xC0, 0x1D, 0xCF, 0x00, 0x1F,
  0xBC, 0x00, 0x1F, 0x78, 0x00, 0x3E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xC0, 0x01,
  0xF3, 0xC0, 0x06, 0xE7, 0x80, 0x1D, 0xC7, 0x80, 0x77, 0x87, 0xE7, 0xCF,
  0x07, 0xFF, 0x1E, 0x07, 0xFC, 0x3C, 0x01, 0x80, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x23, 0x07, 0xFC, 0x3F, 0xF1, 0xFF, 0xEF, 0x03, 0xB8, 0x0F,
  0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0x1F, 0xC7, 0xE3, 0xC0,
  0x08, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1D, 0x00, 0x07,
  0xB8, 0x01, 0xE7, 0xFB, 0xFC, 0xFF, 0xFF, 0x07, 0xFF, 0x80, 0x0F, 0x00,
  0x00, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x7C, 0xC1, 0xFF, 0x03,
  0xFC, 0x01, 0x80, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0xDC,
  0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x1B, 0x9E, 0x01, 0xDC, 0xFE, 0xFC,
  0xE3, 0xFF, 0xC7, 0x07, 0xFC, 0x38, 0x06, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x73, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xC7,
  0x00, 0x07, 0x0E, 0x00, 0x0E, 0x1E, 0x00, 0x3C, 0x1C, 0x00, 0x70, 0x38,
  0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07, 0x80, 0xE0, 0x0E, 0x01, 0xC0,
  0x1C, 0x03, 0xC0, 0x78, 0x03, 0x80, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x03,
  0x80, 0x1E, 0x0F, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x78, 0xF0,
  0x00, 0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x00, 0x03, 0xDE, 0x00,
  0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0xF7, 0x00, 0x1F,
  0x80, 0x0E, 0x70, 0x01, 0xF8, 0x00, 0xE7, 0x00, 0x1F, 0x80, 0x0E, 0x78,
  0x01, 0xDC, 0x01, 0xE7, 0x80, 0x39, 0xC0, 0x1E, 0x38, 0x03, 0x9C, 0x01,
  0xC3, 0x80, 0x39, 0xC0, 0x1C, 0x3C, 0x03, 0x9E, 0x01, 0xC3, 0xC0, 0x78,
  0xE0, 0x3C, 0x1C, 0x07, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0xE0, 0x38, 0x1C,
  0x07, 0x0E, 0x03, 0x81, 0xE0, 0xF0, 0x70, 0x78, 0x0E, 0x0E, 0x07, 0x07,
  0x00, 0xE0, 0xE0, 0x70, 0x70, 0x0E, 0x0E, 0x07, 0x07, 0x00, 0xF1, 0xE0,
  0x38, 0xF0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x38, 0xE0, 0x07,
  0x1C, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x3C, 0xE0, 0x07, 0xB8, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x1D, 0xC0, 0x03, 0xB0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x3D, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0xC0, 0xF0, 0x07,
  0x83, 0x80, 0x0E, 0x1E, 0x00, 0x3C, 0x70, 0x00, 0x73, 0xC0, 0x01, 0xEE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7B, 0x80, 0x01, 0xCF, 0x00, 0x0F,
  0x1C, 0x00, 0x38, 0x78, 0x01, 0xE0, 0xE0, 0x07, 0x03, 0xC0, 0x3C, 0x07,
  0x00, 0xE0, 0x1E, 0x07, 0x80, 0x38, 0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xC7,
  0x80, 0x07, 0x9E, 0x00, 0x0E, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xE0, 0x01,
  0xE3, 0x80, 0x07, 0x0E, 0x00, 0x1C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC1,
  0xC0, 0x0E, 0x07, 0x00, 0x38, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0xC0, 0xF0, 0x07, 0x03, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x38,
  0x01, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0E, 0x1C, 0x00, 0x38, 0xF0, 0x00,
  0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x8F, 0x80, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x7F, 0x00,
  0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0xFE, 0x00, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x1F,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x01, 0x3F, 0xF0,
  0x01, 0x7F, 0xFE, 0x07, 0xF0, 0x3F, 0xFF, 0xC0, 0x0F, 0xFE, 0x80, 0x03,
  0xFC,
};

const GFXglyph NotoSans_Condensed_Light62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 45, 14, 4, -44 },
  { 30, 13, 16, 21, 4, -44 },
  { 56, 29, 44, 31, 1, -44 },
  { 216, 22, 51, 28, 3, -47 },
  { 357, 36, 46, 42, 3, -45 },
  { 564, 30, 46, 32, 2, -45 },
  { 737, 4, 16, 12, 4, -44 },
  { 745, 12, 54, 17, 3, -44 },
  { 826, 12, 54, 17, 2, -44 },
  { 907, 20, 21, 26, 3, -47 },
  { 960, 24, 29, 29, 2, -36 },
  { 1047, 7, 15, 13, 2, -7 },
  { 1061, 14, 3, 18, 2, -18 },
  { 1067, 5, 7, 13, 4, -6 },
  { 1072, 20, 44, 22, 1, -44 },
  { 1182, 22, 46, 28, 3, -45 },
  { 1309, 13, 44, 28, 5, -44 },
  { 1381, 22, 45, 28, 3, -45 },
  { 1505, 22, 46, 28, 3, -45 },
  { 1632, 27, 45, 28, 1, -45 },
  { 1784, 22, 45, 28, 3, -44 },
  { 1908, 23, 46, 28, 3, -45 },
  { 2041, 23, 44, 28, 3, -44 },
  { 2168, 23, 46, 28, 3, -45 },
  { 2301, 22, 46, 28, 3, -45 },
  { 2428, 5, 34, 13, 4, -33 },
  { 2450, 7, 41, 13, 2, -33 },
  { 2486, 24, 28, 29, 2, -36 },
  { 2570, 24, 16, 29, 2, -30 },
  { 2618, 24, 28, 29, 2, -36 },
  { 2702, 18, 46, 20, 1, -45 },
  { 2806, 38, 50, 44, 3, -44 },
  { 3044, 29, 44, 29, 0, -44 },
  { 3204, 24, 44, 31, 5, -44 },
  { 3336, 26, 46, 30, 3, -45 },
  { 3486, 26, 44, 35, 5, -44 },
  { 3629, 19, 44, 27, 5, -44 },
  { 3734, 19, 44, 25, 5, -44 },
  { 3839, 30, 46, 37, 3, -45 },
  { 4012, 25, 44, 36, 5, -44 },
  { 4150, 12, 44, 17, 2, -44 },
  { 4216, 13, 55, 14, -4, -44 },
  { 4306, 24, 44, 29, 5, -44 },
  { 4438, 19, 44, 25, 5, -44 },
  { 4543, 36, 44, 46, 5, -44 },
  { 4741, 27, 44, 37, 5, -44 },
  { 4890, 31, 46, 37, 3, -45 },
  { 5069, 22, 44, 29, 5, -44 },
  { 5190, 31, 56, 37, 3, -45 },
  { 5407, 24, 44, 30, 5, -44 },
  { 5539, 22, 46, 28, 3, -45 },
  { 5666, 25, 44, 25, 0, -44 },
  { 5804, 26, 45, 35, 5, -44 },
  { 5951, 28, 44, 28, 0, -44 },
  { 6105, 45, 44, 46, 1, -44 },
  { 6353, 26, 44, 26, 0, -44 },
  { 6496, 25, 44, 25, 0, -44 },
  { 6634, 22, 44, 26, 2, -44 },
  { 6755, 12, 54, 19, 5, -44 },
  { 6836, 20, 44, 22, 1, -44 },
  { 6946, 12, 54, 19, 2, -44 },
  { 7027, 26, 24, 29, 1, -44 },
  { 7105, 26, 3, 26, 0, 5 },
  { 7115, 11, 9, 16, 2, -47 },
  { 7128, 21, 35, 27, 2, -34 },
  { 7220, 22, 48, 30, 5, -47 },
  { 7352, 19, 35, 23, 3, -34 },
  { 7436, 23, 48, 30, 3, -47 },
  { 7574, 22, 35, 28, 3, -34 },
  { 7671, 17, 47, 16, 1, -47 },
  { 7771, 23, 49, 30, 3, -34 },
  { 7912, 20, 47, 30, 5, -47 },
  { 8030, 5, 45, 13, 4, -45 },
  { 8059, 10, 60, 13, -1, -45 },
  { 8134, 20, 47, 25, 5, -47 },
  { 8252, 3, 47, 13, 5, -47 },
  { 8270, 35, 34, 45, 5, -34 },
  { 8419, 20, 34, 30, 5, -34 },
  { 8504, 23, 35, 29, 3, -34 },
  { 8605, 22, 49, 30, 5, -34 },
  { 8740, 23, 49, 30, 3, -34 },
  { 8881, 14, 34, 20, 5, -34 },
  { 8941, 19, 35, 23, 2, -34 },
  { 9025, 14, 42, 16, 1, -41 },
  { 9099, 21, 34, 30, 4, -33 },
  { 9189, 23, 33, 23, 0, -33 },
  { 9284, 36, 33, 38, 1, -33 },
  { 9433, 22, 33, 24, 1, -33 },
  { 9524, 22, 48, 24, 1, -33 },
  { 9656, 17, 33, 21, 2, -33 },
  { 9727, 16, 54, 22, 3, -44 },
  { 9835, 3, 62, 27, 12, -47 },
  { 9859, 16, 54, 22, 3, -44 },
  { 9967, 24, 6, 29, 2, -25 },
};

const GFXfont NotoSans_Condensed_Light62pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light62pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light62pt7bGlyphs,
  0x20, 0x7E, 84
};

#endif // _NOTOSANS_CONDENSED_LIGHT62PT7B_H_
