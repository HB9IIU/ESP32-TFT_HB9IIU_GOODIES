#ifndef _NOTOSANS_CONDENSED_LIGHT51PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT51PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light51pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0x66,
  0x66, 0x66, 0x60, 0x00, 0x06, 0xFF, 0xFE, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0E, 0xC1, 0xD8, 0x3B, 0x07, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36,
  0x06, 0x00, 0x60, 0x30, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xC0,
  0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0, 0x60, 0x00, 0xC0,
  0x60, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0x01, 0x80, 0xC0, 0x01, 0x80, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0x81, 0x80, 0x03, 0x01, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x01, 0x80, 0x03, 0x01, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x06, 0x03, 0x00, 0x06, 0x03, 0x00, 0x06, 0x03,
  0x00, 0x06, 0x03, 0x00, 0x06, 0x07, 0x00, 0x0E, 0x07, 0x00, 0x0E, 0x07,
  0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06, 0x00, 0x0C, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x18, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x8F, 0xB3, 0xE1, 0xC6, 0x04, 0x70, 0xC0, 0x0C, 0x18,
  0x03, 0x83, 0x00, 0x70, 0x60, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x38, 0x30,
  0x03, 0x86, 0x00, 0x78, 0xC0, 0x07, 0x98, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x37, 0xC0, 0x06, 0x3C, 0x00, 0xC3,
  0xC0, 0x18, 0x38, 0x03, 0x03, 0x80, 0x60, 0x70, 0x0C, 0x0E, 0x01, 0x81,
  0xC0, 0x30, 0x38, 0x06, 0x07, 0x00, 0xC1, 0xD8, 0x18, 0x73, 0xF3, 0x7E,
  0x7F, 0xFF, 0x01, 0xFF, 0x80, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00,
  0x00, 0xC0, 0x00, 0x18, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x7F, 0x00, 0x18,
  0x03, 0x9E, 0x00, 0x60, 0x0C, 0x38, 0x03, 0x80, 0x70, 0x60, 0x0C, 0x01,
  0x81, 0xC0, 0x70, 0x06, 0x03, 0x01, 0x80, 0x18, 0x0C, 0x06, 0x00, 0xE0,
  0x30, 0x38, 0x03, 0x80, 0xC0, 0xC0, 0x0E, 0x03, 0x07, 0x00, 0x38, 0x0C,
  0x18, 0x00, 0xE0, 0x30, 0x60, 0x03, 0x80, 0xC3, 0x80, 0x0E, 0x03, 0x0C,
  0x00, 0x18, 0x0C, 0x71, 0xF8, 0x60, 0x71, 0x8F, 0xF1, 0x81, 0xC6, 0x30,
  0xE7, 0x06, 0x39, 0xC1, 0x8C, 0x38, 0xC6, 0x06, 0x39, 0xC7, 0x18, 0x1C,
  0x7F, 0x18, 0xE0, 0x70, 0xF0, 0x63, 0x80, 0xC0, 0x03, 0x8E, 0x03, 0x00,
  0x0C, 0x38, 0x0C, 0x00, 0x70, 0xE0, 0x30, 0x01, 0x83, 0x80, 0xC0, 0x0E,
  0x0E, 0x03, 0x00, 0x38, 0x38, 0x0C, 0x00, 0xC0, 0xE0, 0x30, 0x07, 0x03,
  0x81, 0xC0, 0x18, 0x06, 0x07, 0x00, 0xE0, 0x18, 0x18, 0x03, 0x80, 0x70,
  0x60, 0x0C, 0x00, 0xC3, 0x80, 0x70, 0x03, 0xFC, 0x01, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xBC, 0x00, 0x0E, 0x0E, 0x00,
  0x1C, 0x06, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00,
  0x1C, 0x07, 0x00, 0x1C, 0x07, 0x00, 0x1C, 0x06, 0x00, 0x0C, 0x0E, 0x00,
  0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x07, 0x38, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x1C, 0x70, 0x0E, 0x38, 0x38, 0x0E, 0x70, 0x3C, 0x0C, 0x70, 0x1C, 0x1C,
  0xE0, 0x0E, 0x1C, 0xE0, 0x07, 0x1C, 0xE0, 0x07, 0x38, 0xE0, 0x03, 0xB8,
  0xE0, 0x01, 0xF8, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xF0,
  0x70, 0x03, 0xF8, 0x78, 0x07, 0xBC, 0x3C, 0x1F, 0x1C, 0x1F, 0xFE, 0x0E,
  0x0F, 0xF8, 0x0F, 0x01, 0x80, 0x00, 0xFF, 0xFE, 0xDB, 0x6D, 0xB6, 0x00,
  0xC0, 0x70, 0x38, 0x0C, 0x07, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07,
  0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x81, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E,
  0x07, 0x01, 0xC0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x0C, 0x04, 0x06, 0x05, 0xC3, 0x0F, 0xFD, 0xBF, 0x3F, 0xFE,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x6E, 0x00, 0x73, 0x80, 0x70, 0xC0, 0x70,
  0x70, 0x78, 0x1C, 0x18, 0x0C, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00,
  0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x38, 0xF3, 0x8E, 0x38, 0xE7, 0x1C,
  0x71, 0x8E, 0x38, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x23, 0xBF, 0xF7,
  0x00, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x06,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x07, 0x81, 0xC0,
  0x78, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x70, 0x01, 0xCE, 0x00,
  0x39, 0xC0, 0x03, 0x38, 0x00, 0x77, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x60, 0x03,
  0x8E, 0x00, 0x71, 0xC0, 0x1C, 0x1C, 0x03, 0x83, 0xC0, 0xE0, 0x3C, 0x7C,
  0x03, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x7C, 0x1F, 0x87, 0x71, 0xCE,
  0xF1, 0xFC, 0x3F, 0x07, 0x40, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x03, 0xF0, 0x03, 0xFF, 0x80,
  0xFF, 0xF8, 0x3C, 0x07, 0x82, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x07,
  0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x78, 0x07, 0x86, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x03, 0x90, 0x00, 0xF3, 0xC0, 0x7C, 0x7F, 0xFF,
  0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x33, 0x80, 0x01, 0xCE, 0x00, 0x0E, 0x38,
  0x00, 0x38, 0xE0, 0x01, 0xC3, 0x80, 0x06, 0x0E, 0x00, 0x38, 0x38, 0x00,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xE0, 0x0E, 0x03, 0x80, 0x38, 0x1C, 0x00, 0xE0,
  0x60, 0x03, 0x83, 0x80, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC7, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00,
  0x01, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E, 0xFF, 0x03, 0xFF, 0xF0,
  0x7E, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x80, 0x0F, 0x38, 0x0F, 0x8F, 0xFF, 0xC1, 0xFF, 0xC0, 0x03, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x7F, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x0E, 0x03, 0x8F, 0xF0,
  0xCF, 0xFE, 0x37, 0x03, 0xCD, 0x80, 0x7B, 0xC0, 0x0E, 0xE0, 0x03, 0xB8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x1D, 0xC0, 0x0E,
  0x38, 0x03, 0x8E, 0x01, 0xC1, 0xE0, 0xF0, 0x3F, 0xF8, 0x07, 0xF8, 0x00,
  0x10, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0x80, 0x00, 0x60,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x7F, 0xFC, 0x0E,
  0x03, 0xC3, 0x80, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70,
  0x00, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x18, 0x00, 0xE3, 0x80, 0x38, 0x38,
  0x07, 0x07, 0x81, 0xC0, 0x78, 0xF0, 0x07, 0xFC, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x03, 0xDF, 0x01, 0xE0, 0xF0, 0x78, 0x0F, 0x0E, 0x00, 0xF3, 0x80,
  0x0E, 0x70, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xC7, 0x00,
  0x78, 0xF8, 0x1E, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x80, 0x00, 0x03,
  0xF0, 0x01, 0xFF, 0x80, 0x7F, 0xF8, 0x1E, 0x07, 0x83, 0x80, 0x70, 0xE0,
  0x07, 0x1C, 0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80,
  0x03, 0x70, 0x00, 0x6E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0x70, 0x01, 0xEE, 0x00, 0x3D, 0xE0, 0x0F, 0x9C, 0x03, 0x71, 0xE1,
  0xEE, 0x3F, 0xF9, 0x81, 0xFC, 0x30, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x81, 0xF0, 0x1F, 0xFC,
  0x03, 0xFE, 0x00, 0x04, 0x00, 0x00, 0x77, 0xFE, 0xE2, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x8E, 0xFF, 0xDC, 0x38,
  0xF3, 0xCE, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE3, 0xCE, 0x38, 0xE3, 0x9C, 0x71, 0xC6, 0x38, 0xE3,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x00, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08,
  0x00, 0x00, 0x1F, 0xC0, 0xFF, 0xE3, 0xFF, 0xE3, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x78, 0x03, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x30, 0xE0, 0x00,
  0x00, 0xE3, 0x00, 0x00, 0x01, 0x9C, 0x01, 0xFE, 0x06, 0x70, 0x1F, 0xF8,
  0x1D, 0x80, 0xF0, 0x60, 0x7E, 0x03, 0x81, 0x80, 0xF8, 0x1C, 0x06, 0x03,
  0xE0, 0x60, 0x18, 0x0F, 0x01, 0x80, 0x60, 0x3C, 0x0E, 0x01, 0x80, 0xF0,
  0x38, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0F, 0x03, 0x80, 0xE0, 0x3C, 0x0E,
  0x03, 0x80, 0xF0, 0x38, 0x0E, 0x03, 0xC0, 0xE0, 0x38, 0x0F, 0x03, 0x80,
  0xE0, 0x7C, 0x0E, 0x07, 0x81, 0xB8, 0x1C, 0x1E, 0x0E, 0xE0, 0x70, 0xCC,
  0x73, 0x80, 0xFF, 0x3F, 0xC6, 0x01, 0xF8, 0x7E, 0x1C, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x66, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x00, 0x00, 0xE3, 0x00, 0x00, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x01,
  0xC3, 0x80, 0x01, 0x81, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0x70, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x0E,
  0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x0F, 0x8E, 0x00, 0x3C,
  0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00,
  0x3C, 0xE0, 0x07, 0x8E, 0x03, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xE0,
  0x0F, 0x8E, 0x00, 0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x07,
  0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x80, 0x0F,
  0xFF, 0xC0, 0xFF, 0xFC, 0x0F, 0x80, 0x60, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C,
  0x00, 0x81, 0xF8, 0x1C, 0x07, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x02, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x0E, 0x03, 0xF8, 0x38, 0x01, 0xF0, 0xE0,
  0x01, 0xE3, 0x80, 0x03, 0x8E, 0x00, 0x0F, 0x38, 0x00, 0x1C, 0xE0, 0x00,
  0x73, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x80, 0x00, 0x6E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE,
  0x00, 0x07, 0xB8, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x03, 0x8E, 0x00,
  0x1E, 0x38, 0x00, 0xF0, 0xE0, 0x0F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0,
  0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0x07, 0xC0, 0x0E, 0x0F, 0x00, 0x02, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x03, 0xFF,
  0xE0, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x70, 0x00, 0x07,
  0x70, 0x00, 0x07, 0x78, 0x00, 0x07, 0x38, 0x00, 0x07, 0x3C, 0x00, 0x07,
  0x1C, 0x00, 0x07, 0x1E, 0x00, 0x07, 0x0F, 0x80, 0x07, 0x07, 0xE0, 0x1F,
  0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x02, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x70, 0xFF, 0xDF, 0xE1, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x0F, 0xFF, 0xFF, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0xE8, 0x7B, 0xFC,
  0xFE, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0, 0x03, 0x8E, 0x00, 0x78,
  0xE0, 0x07, 0x0E, 0x00, 0xE0, 0xE0, 0x1E, 0x0E, 0x01, 0xC0, 0xE0, 0x38,
  0x0E, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0x70, 0x00, 0xEF, 0x80, 0x0E, 0xFC, 0x00, 0xFD,
  0xC0, 0x0F, 0x9E, 0x00, 0xF0, 0xE0, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xE0, 0x1E, 0x0E, 0x00, 0xE0,
  0xE0, 0x0F, 0x0E, 0x00, 0x70, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x01,
  0xCE, 0x00, 0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xDF, 0xB0, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x1D, 0xFB, 0x80,
  0x00, 0x67, 0xE6, 0x00, 0x01, 0x9F, 0x9C, 0x00, 0x0E, 0x7E, 0x70, 0x00,
  0x39, 0xF8, 0xC0, 0x00, 0xC7, 0xE3, 0x80, 0x07, 0x1F, 0x8E, 0x00, 0x1C,
  0x7E, 0x38, 0x00, 0x61, 0xF8, 0x70, 0x03, 0x87, 0xE1, 0xC0, 0x0E, 0x1F,
  0x87, 0x00, 0x30, 0x7E, 0x0E, 0x01, 0xC1, 0xF8, 0x38, 0x07, 0x07, 0xE0,
  0xE0, 0x18, 0x1F, 0x81, 0x80, 0xE0, 0x7E, 0x07, 0x03, 0x81, 0xF8, 0x1C,
  0x0C, 0x07, 0xE0, 0x30, 0x70, 0x1F, 0x80, 0xE1, 0xC0, 0x7E, 0x03, 0x86,
  0x01, 0xF8, 0x06, 0x38, 0x07, 0xE0, 0x1C, 0xE0, 0x1F, 0x80, 0x73, 0x00,
  0x7E, 0x00, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x1E, 0x00, 0x7E, 0x00, 0x78, 0x01, 0xF8, 0x01, 0xC0, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xB8, 0x00, 0x7E, 0xE0, 0x01, 0xF9, 0xC0, 0x07, 0xE7, 0x00, 0x1F,
  0x8E, 0x00, 0x7E, 0x38, 0x01, 0xF8, 0x70, 0x07, 0xE1, 0xC0, 0x1F, 0x83,
  0x80, 0x7E, 0x0E, 0x01, 0xF8, 0x1C, 0x07, 0xE0, 0x70, 0x1F, 0x80, 0xE0,
  0x7E, 0x03, 0x81, 0xF8, 0x07, 0x07, 0xE0, 0x1C, 0x1F, 0x80, 0x38, 0x7E,
  0x00, 0xE1, 0xF8, 0x01, 0xC7, 0xE0, 0x07, 0x1F, 0x80, 0x0E, 0x7E, 0x00,
  0x39, 0xF8, 0x00, 0x77, 0xE0, 0x01, 0xDF, 0x80, 0x03, 0xFE, 0x00, 0x0E,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xF0, 0x1F, 0x01, 0xE0, 0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x78,
  0x70, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x70,
  0xE0, 0x00, 0x38, 0x78, 0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x3C,
  0x01, 0xF0, 0x7C, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xC0,
  0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0x8E, 0x03, 0xF3, 0x80, 0x3C, 0xE0, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3B, 0x80,
  0x0E, 0xE0, 0x07, 0xB8, 0x03, 0xCE, 0x1F, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xE0,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x1C, 0x70,
  0x00, 0x0E, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x78,
  0x00, 0x38, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x7C, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x5C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xE0, 0x3F, 0x0E, 0x00, 0x78, 0xE0, 0x03, 0x8E, 0x00,
  0x3C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0, 0x03, 0x8E,
  0x00, 0x78, 0xE0, 0x0F, 0x0E, 0x07, 0xE0, 0xFF, 0xFC, 0x0F, 0xFE, 0x00,
  0xE0, 0x70, 0x0E, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C,
  0x0E, 0x01, 0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x03, 0x8E, 0x00, 0x38, 0xE0, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x00, 0xEE, 0x00, 0x0F, 0x01, 0xFC, 0x01, 0xFF, 0xE1, 0xFF, 0xFC, 0xF8,
  0x06, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xA0, 0x01, 0xEF, 0x81, 0xF3, 0xFF,
  0xF8, 0x7F, 0xF8, 0x00, 0x20, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xB8, 0x00, 0x39, 0xC0, 0x01, 0xCF, 0x00, 0x1E,
  0x3C, 0x01, 0xE0, 0xF8, 0x3E, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x06,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80,
  0x00, 0xE7, 0x00, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x38, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0, 0x03,
  0x80, 0xC0, 0x07, 0x01, 0xC0, 0x0C, 0x03, 0x80, 0x38, 0x07, 0x00, 0x70,
  0x07, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x1C, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0, 0x00, 0xC1, 0xC0, 0x01,
  0xC3, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x0E,
  0x60, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x36, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0x80, 0x03, 0xB8, 0x00, 0x3C, 0x00, 0x1D,
  0xC0, 0x01, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x80, 0x07, 0x38, 0x00, 0xFC,
  0x00, 0x71, 0xC0, 0x07, 0xE0, 0x03, 0x8E, 0x00, 0x33, 0x00, 0x1C, 0x30,
  0x01, 0x98, 0x00, 0xE1, 0xC0, 0x1C, 0xE0, 0x0E, 0x0E, 0x00, 0xE7, 0x00,
  0x70, 0x70, 0x07, 0x38, 0x03, 0x83, 0x80, 0x30, 0xC0, 0x1C, 0x0E, 0x03,
  0x87, 0x00, 0xC0, 0x70, 0x1C, 0x38, 0x0E, 0x03, 0x80, 0xE1, 0xC0, 0x70,
  0x1C, 0x06, 0x06, 0x03, 0x80, 0x60, 0x30, 0x30, 0x1C, 0x03, 0x83, 0x81,
  0xC1, 0xC0, 0x1C, 0x1C, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x30, 0x70, 0x07,
  0x06, 0x01, 0x83, 0x80, 0x1C, 0x70, 0x0E, 0x18, 0x00, 0xE3, 0x80, 0x71,
  0xC0, 0x07, 0x1C, 0x03, 0x8E, 0x00, 0x38, 0xC0, 0x0C, 0x70, 0x00, 0xC6,
  0x00, 0x63, 0x00, 0x07, 0x70, 0x03, 0xB8, 0x00, 0x3B, 0x80, 0x1D, 0xC0,
  0x01, 0xDC, 0x00, 0x6E, 0x00, 0x06, 0xC0, 0x03, 0x70, 0x00, 0x36, 0x00,
  0x1B, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x79,
  0xC0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x18, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x38, 0x00,
  0xE1, 0xC0, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01,
  0xF8, 0x00, 0x0D, 0xC0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x70, 0xE0,
  0x03, 0x87, 0x00, 0x38, 0x38, 0x01, 0xC0, 0xE0, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00, 0xF3,
  0x80, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x7B, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0xE0,
  0x70, 0x07, 0x03, 0x80, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x01, 0x87, 0x00, 0x0E, 0x38, 0x00,
  0x71, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF,
  0xC0, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18, 0x00,
  0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x30,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF8, 0x00, 0x0C, 0xC0, 0x00,
  0xE7, 0x00, 0x06, 0x18, 0x00, 0x70, 0xE0, 0x03, 0x03, 0x00, 0x38, 0x1C,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0x80, 0xC0, 0x1C, 0x0E, 0x00, 0x70, 0x60,
  0x03, 0x87, 0x00, 0x0E, 0x30, 0x00, 0x73, 0x80, 0x01, 0xF8, 0x00, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x38, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xE0, 0x07, 0xFE, 0x0F, 0xFF, 0x83,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x0F, 0xF8, 0x3F, 0xFC, 0x7E,
  0x0E, 0x78, 0x07, 0x70, 0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0x70, 0x0B, 0xBC, 0x1D,
  0xCF, 0xFC, 0xE3, 0xFC, 0x70, 0x20, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x30, 0x0E,
  0x3F, 0xC1, 0xDF, 0xFC, 0x3B, 0x03, 0xC6, 0xC0, 0x3C, 0xD0, 0x03, 0x9E,
  0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x01, 0xB8,
  0x00, 0x37, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0D, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x01, 0xDE, 0x00, 0x73, 0xC0, 0x0E, 0x6C, 0x03, 0x8C, 0xE0, 0xF1, 0x9F,
  0xFC, 0x30, 0xFF, 0x00, 0x02, 0x00, 0x00, 0x38, 0x03, 0xFF, 0x07, 0xFE,
  0x0F, 0x02, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x03, 0x0F, 0xFF,
  0x03, 0xFE, 0x00, 0x60, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x70, 0x7F, 0x8E, 0x1F,
  0xFD, 0xC7, 0x81, 0xD9, 0xE0, 0x1B, 0x38, 0x01, 0xE7, 0x00, 0x3D, 0xC0,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xD8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x76, 0x00,
  0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xE7, 0x00,
  0x3C, 0xE0, 0x05, 0x9E, 0x01, 0xB1, 0xE0, 0x66, 0x1F, 0xFC, 0xC1, 0xFE,
  0x18, 0x06, 0x00, 0x00, 0x60, 0x01, 0xFF, 0x00, 0xFF, 0xE0, 0x78, 0x3C,
  0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x19, 0xC0, 0x07, 0x70, 0x01, 0xDC,
  0x00, 0x77, 0x00, 0x0D, 0x80, 0x03, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFD, 0x80, 0x00, 0x60, 0x00, 0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x43,
  0xC0, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x30, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x7D, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xFF, 0xE3, 0xFF, 0x81, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0xFF, 0x8C, 0x3F,
  0xF9, 0x8F, 0x03, 0xB3, 0xC0, 0x36, 0x70, 0x03, 0xCE, 0x00, 0x7B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEC, 0x00,
  0x1D, 0x80, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00,
  0x79, 0xC0, 0x0B, 0x3C, 0x03, 0x63, 0xC1, 0xDC, 0x3F, 0xF3, 0x83, 0xFC,
  0x70, 0x04, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE2, 0x00, 0x38, 0x7C, 0x3F,
  0x0F, 0xFF, 0xC0, 0x7F, 0xE0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x1C, 0x0E, 0x3F, 0xC7, 0x7F, 0xF3, 0xB0,
  0x3D, 0xB0, 0x0E, 0xF0, 0x07, 0x78, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0E, 0x7F, 0xF7, 0x00, 0x00, 0x00, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x70, 0x07,
  0x0F, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x06, 0x0E, 0x9E, 0xFC, 0xF8,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x01,
  0xE0, 0x0E, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x70,
  0xE0, 0xE0, 0xE1, 0xC0, 0xE3, 0x80, 0xE3, 0x80, 0xE7, 0x00, 0xEF, 0x00,
  0xCF, 0x80, 0xDB, 0x80, 0xF9, 0xC0, 0xF1, 0xC0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xC0, 0x07,
  0x06, 0x3F, 0xC1, 0xFE, 0x33, 0xFF, 0x1F, 0xF9, 0xB8, 0x3D, 0xC1, 0xED,
  0x80, 0xEC, 0x07, 0x78, 0x07, 0xC0, 0x1F, 0x80, 0x1E, 0x00, 0xFC, 0x00,
  0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0,
  0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xF0, 0x03, 0x80, 0x1F,
  0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x3F, 0x00,
  0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0, 0x0E, 0x00, 0x7E, 0x00, 0x70,
  0x03, 0xF0, 0x03, 0x80, 0x1F, 0x80, 0x1C, 0x00, 0xFC, 0x00, 0xE0, 0x07,
  0xE0, 0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x01, 0xC0, 0x0F, 0xC0,
  0x0E, 0x00, 0x70, 0x00, 0xE0, 0x61, 0xFE, 0x33, 0xFF, 0x99, 0x81, 0xED,
  0x80, 0x77, 0x80, 0x3B, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x3F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0,
  0x78, 0x1C, 0x03, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0x66, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x60, 0x00, 0x76, 0x00, 0x07,
  0x70, 0x00, 0x67, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x00,
  0xC3, 0x80, 0x1C, 0x1C, 0x03, 0x81, 0xF0, 0x78, 0x0F, 0xFF, 0x00, 0x3F,
  0xC0, 0x00, 0x20, 0x00, 0x00, 0xE0, 0x18, 0x7F, 0x83, 0x1F, 0xF8, 0x66,
  0x07, 0x8D, 0x80, 0x79, 0xA0, 0x07, 0x3C, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x01, 0xDC, 0x00, 0x3B, 0x80, 0x03, 0x70, 0x00, 0x6E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1B, 0x80,
  0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xBC, 0x00, 0xE6, 0x80,
  0x1C, 0xD8, 0x07, 0x1D, 0xC1, 0xE3, 0x9F, 0xF8, 0x71, 0xFE, 0x0E, 0x04,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x60, 0x00, 0xFF, 0x8C, 0x3F, 0xF9, 0x8F, 0x03,
  0x31, 0xC0, 0x36, 0x70, 0x03, 0xCE, 0x00, 0x7B, 0x80, 0x07, 0x70, 0x00,
  0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xB0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1D, 0x80, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDE, 0x00, 0x79, 0xC0, 0x0B,
  0x3C, 0x03, 0xE3, 0xC1, 0xDC, 0x3F, 0xF3, 0x83, 0xFC, 0x70, 0x04, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0xCC, 0x3F, 0xC7, 0xEC, 0xE2, 0xDC, 0x0D, 0x80, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x01, 0x80, 0x3F, 0xF8,
  0xFF, 0xFB, 0xC0, 0x67, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x01, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x1D, 0xC0, 0x7B, 0xFF, 0xE3, 0xFF,
  0x00, 0x70, 0x00, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x0F, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xE1, 0x0F, 0xF0, 0x7F, 0x01, 0x80, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x37, 0x78,
  0x3B, 0x9F, 0xF9, 0xC7, 0xF8, 0xE0, 0x60, 0x00, 0xE0, 0x00, 0xEE, 0x00,
  0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x70, 0x07, 0x0E, 0x00,
  0xE1, 0xC0, 0x1C, 0x18, 0x03, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x0E, 0x03,
  0x80, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x30, 0x60, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x1C, 0x60, 0x01, 0x8C, 0x00, 0x3B, 0x80, 0x07, 0x70,
  0x00, 0x6C, 0x00, 0x0D, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x07, 0x00, 0x1F, 0x80, 0x1E, 0x00, 0x6E, 0x00, 0x78, 0x03,
  0xB8, 0x03, 0xE0, 0x0E, 0x60, 0x0D, 0x80, 0x39, 0xC0, 0x37, 0x00, 0xC7,
  0x00, 0xDC, 0x07, 0x1C, 0x07, 0x30, 0x1C, 0x30, 0x1C, 0xC0, 0x70, 0xE0,
  0x63, 0x81, 0x83, 0x81, 0x8E, 0x0E, 0x0E, 0x0E, 0x18, 0x38, 0x18, 0x38,
  0x60, 0xE0, 0x70, 0xC1, 0xC3, 0x01, 0xC3, 0x07, 0x0C, 0x07, 0x1C, 0x1C,
  0x70, 0x1C, 0x70, 0x31, 0xC0, 0x31, 0x80, 0xE6, 0x00, 0xE6, 0x03, 0x98,
  0x03, 0xB8, 0x0E, 0xE0, 0x0E, 0xE0, 0x1B, 0x80, 0x1B, 0x00, 0x6E, 0x00,
  0x6C, 0x01, 0xB0, 0x01, 0xF0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x00, 0x0E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0xE0, 0x00, 0xF0, 0x03, 0xDC, 0x00, 0xE3,
  0x80, 0x70, 0xE0, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x80, 0xE1, 0xC0, 0x38,
  0x70, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xC0, 0x07, 0x30, 0x01, 0xCE, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0x80, 0x70, 0xE0,
  0x1C, 0x70, 0x03, 0x9C, 0x00, 0xEE, 0x00, 0x1C, 0x70, 0x00, 0xEE, 0x00,
  0x1D, 0xC0, 0x03, 0x18, 0x00, 0xE3, 0x80, 0x1C, 0x70, 0x03, 0x8E, 0x00,
  0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x60, 0x30, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x60, 0x0C, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x70, 0x07, 0x0C,
  0x00, 0x63, 0x80, 0x0E, 0x70, 0x01, 0xCC, 0x00, 0x1B, 0x80, 0x03, 0x70,
  0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x08, 0xF0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0xFB, 0xFF, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x07, 0xF0, 0x1E, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x03, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0xC0, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0xF8,
  0x0F, 0xC0, 0x3C, 0x00, 0x1C, 0x00, 0x17, 0xFC, 0x01, 0xFF, 0xF0, 0x7C,
  0x0F, 0xFE, 0x80, 0x3F, 0xC8, 0x00, 0x30,
};

const GFXglyph NotoSans_Condensed_Light51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 36, 11, 4, -36 },
  { 19, 11, 13, 18, 3, -36 },
  { 37, 24, 36, 26, 1, -36 },
  { 145, 19, 42, 23, 2, -39 },
  { 245, 30, 37, 34, 2, -37 },
  { 384, 24, 38, 26, 2, -37 },
  { 498, 3, 13, 10, 3, -36 },
  { 503, 10, 45, 14, 2, -37 },
  { 560, 10, 45, 14, 2, -37 },
  { 617, 17, 17, 22, 2, -39 },
  { 654, 20, 24, 24, 2, -30 },
  { 714, 6, 13, 11, 2, -6 },
  { 724, 11, 3, 15, 2, -15 },
  { 729, 5, 5, 11, 3, -5 },
  { 733, 16, 36, 18, 1, -36 },
  { 805, 19, 37, 23, 2, -37 },
  { 893, 11, 36, 23, 4, -36 },
  { 943, 19, 37, 23, 2, -37 },
  { 1031, 19, 38, 23, 2, -37 },
  { 1122, 22, 37, 23, 1, -37 },
  { 1224, 18, 37, 23, 3, -36 },
  { 1308, 18, 38, 23, 3, -37 },
  { 1394, 19, 36, 23, 2, -36 },
  { 1480, 19, 38, 23, 2, -37 },
  { 1571, 19, 38, 23, 2, -37 },
  { 1662, 5, 27, 11, 3, -27 },
  { 1679, 6, 34, 11, 2, -27 },
  { 1705, 20, 22, 24, 2, -29 },
  { 1760, 20, 14, 24, 2, -25 },
  { 1795, 20, 22, 24, 2, -29 },
  { 1850, 15, 37, 17, 1, -37 },
  { 1920, 30, 42, 36, 3, -37 },
  { 2078, 24, 36, 24, 0, -36 },
  { 2186, 20, 36, 26, 4, -36 },
  { 2276, 21, 38, 25, 3, -37 },
  { 2376, 22, 36, 29, 4, -36 },
  { 2475, 16, 36, 22, 4, -36 },
  { 2547, 16, 36, 21, 4, -36 },
  { 2619, 24, 38, 30, 3, -37 },
  { 2733, 21, 36, 29, 4, -36 },
  { 2828, 10, 36, 14, 2, -36 },
  { 2873, 10, 45, 11, -3, -36 },
  { 2930, 20, 36, 24, 4, -36 },
  { 3020, 16, 36, 21, 4, -36 },
  { 3092, 30, 36, 38, 4, -36 },
  { 3227, 22, 36, 30, 4, -36 },
  { 3326, 25, 38, 31, 3, -37 },
  { 3445, 18, 36, 24, 4, -36 },
  { 3526, 25, 46, 31, 3, -37 },
  { 3670, 20, 36, 25, 4, -36 },
  { 3760, 18, 38, 23, 2, -37 },
  { 3846, 20, 36, 21, 0, -36 },
  { 3936, 21, 37, 29, 4, -36 },
  { 4034, 23, 36, 23, 0, -36 },
  { 4138, 37, 36, 38, 1, -36 },
  { 4305, 21, 36, 21, 0, -36 },
  { 4400, 21, 36, 21, 0, -36 },
  { 4495, 18, 36, 21, 2, -36 },
  { 4576, 10, 45, 16, 4, -37 },
  { 4633, 16, 36, 18, 1, -36 },
  { 4705, 10, 45, 16, 2, -37 },
  { 4762, 21, 19, 24, 1, -36 },
  { 4812, 21, 3, 21, 0, 4 },
  { 4820, 9, 8, 13, 2, -39 },
  { 4829, 17, 29, 22, 2, -28 },
  { 4891, 19, 40, 25, 4, -39 },
  { 4986, 16, 29, 19, 2, -28 },
  { 5044, 19, 40, 25, 2, -39 },
  { 5139, 18, 29, 23, 2, -28 },
  { 5205, 14, 39, 13, 1, -39 },
  { 5274, 19, 40, 25, 2, -28 },
  { 5369, 17, 39, 25, 4, -39 },
  { 5452, 4, 37, 11, 3, -37 },
  { 5471, 8, 49, 11, -1, -37 },
  { 5520, 16, 39, 20, 4, -39 },
  { 5598, 3, 39, 10, 4, -39 },
  { 5613, 29, 28, 37, 4, -28 },
  { 5715, 17, 28, 25, 4, -28 },
  { 5775, 20, 29, 24, 2, -28 },
  { 5848, 19, 40, 25, 4, -28 },
  { 5943, 19, 40, 25, 2, -28 },
  { 6038, 12, 28, 16, 4, -28 },
  { 6080, 15, 29, 19, 2, -28 },
  { 6135, 12, 35, 14, 1, -34 },
  { 6188, 17, 28, 25, 4, -27 },
  { 6248, 19, 27, 19, 0, -27 },
  { 6313, 30, 27, 31, 1, -27 },
  { 6415, 18, 27, 20, 1, -27 },
  { 6476, 19, 39, 19, 0, -27 },
  { 6569, 14, 27, 17, 2, -27 },
  { 6617, 14, 44, 18, 2, -36 },
  { 6694, 2, 51, 22, 10, -39 },
  { 6707, 14, 44, 18, 2, -36 },
  { 6784, 20, 6, 24, 2, -21 },
};

const GFXfont NotoSans_Condensed_Light51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light51pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_CONDENSED_LIGHT51PT7B_H_
