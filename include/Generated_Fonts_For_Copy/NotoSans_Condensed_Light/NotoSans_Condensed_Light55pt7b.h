#ifndef _NOTOSANS_CONDENSED_LIGHT55PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT55PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light55pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x76,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x7F, 0xFF, 0xF2, 0xE0, 0xFC, 0x1F,
  0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x03,
  0xE0, 0x3C, 0x07, 0x80, 0xC0, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x06, 0x00,
  0x07, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00, 0x18, 0x0E,
  0x00, 0x06, 0x03, 0x80, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00, 0x38,
  0x0C, 0x00, 0x0C, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xF0, 0x1C, 0x07, 0x00, 0x07, 0x01, 0x80, 0x01, 0xC0, 0x60,
  0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80, 0x01, 0x80,
  0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0C, 0x00, 0x0E, 0x03, 0x00, 0xFF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x07, 0x00,
  0x07, 0x01, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x06,
  0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x00, 0x60, 0x38, 0x00, 0x38,
  0x0E, 0x00, 0x0E, 0x03, 0x00, 0x03, 0x80, 0xC0, 0x00, 0xE0, 0x30, 0x00,
  0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0x87, 0x8C, 0x1C, 0x38, 0x60, 0x23,
  0x83, 0x00, 0x1C, 0x18, 0x00, 0xC0, 0xC0, 0x0E, 0x06, 0x00, 0x70, 0x30,
  0x03, 0x81, 0x80, 0x0E, 0x0C, 0x00, 0x70, 0x60, 0x03, 0xC3, 0x00, 0x0F,
  0x18, 0x00, 0x3E, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x67, 0xC0, 0x03, 0x1F, 0x00, 0x18, 0x3C, 0x00,
  0xC0, 0xE0, 0x06, 0x07, 0x00, 0x30, 0x1C, 0x01, 0x80, 0xE0, 0x0C, 0x07,
  0x00, 0x60, 0x30, 0x03, 0x03, 0x80, 0x18, 0x1D, 0x00, 0xC1, 0xCF, 0x06,
  0x3E, 0x7F, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x60, 0x00,
  0x03, 0x00, 0x00, 0x18, 0x00, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x03, 0x80, 0x3F, 0xC0, 0x07, 0x00, 0x70,
  0xE0, 0x07, 0x00, 0x60, 0x60, 0x06, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0xE0,
  0x70, 0x0E, 0x00, 0xC0, 0x70, 0x1C, 0x00, 0xC0, 0x30, 0x1C, 0x00, 0xC0,
  0x30, 0x18, 0x00, 0xC0, 0x30, 0x38, 0x00, 0xC0, 0x30, 0x30, 0x00, 0xC0,
  0x30, 0x70, 0x00, 0xC0, 0x30, 0x70, 0x00, 0xC0, 0x30, 0x60, 0x00, 0xC0,
  0x30, 0xE0, 0x00, 0xC0, 0x30, 0xC1, 0xF0, 0xC0, 0x71, 0xC7, 0xF8, 0xE0,
  0x71, 0xC7, 0x3C, 0xE0, 0x71, 0x8E, 0x1C, 0x60, 0x63, 0x8C, 0x0E, 0x70,
  0xE3, 0x1C, 0x0E, 0x3F, 0xC7, 0x1C, 0x06, 0x3F, 0x87, 0x1C, 0x06, 0x0F,
  0x06, 0x1C, 0x07, 0x00, 0x0E, 0x18, 0x07, 0x00, 0x0C, 0x18, 0x07, 0x00,
  0x1C, 0x18, 0x07, 0x00, 0x1C, 0x18, 0x07, 0x00, 0x18, 0x18, 0x07, 0x00,
  0x38, 0x18, 0x07, 0x00, 0x30, 0x18, 0x07, 0x00, 0x70, 0x1C, 0x06, 0x00,
  0x70, 0x1C, 0x06, 0x00, 0x60, 0x1C, 0x0E, 0x00, 0xE0, 0x0C, 0x0E, 0x00,
  0xC0, 0x0E, 0x0C, 0x01, 0xC0, 0x06, 0x1C, 0x01, 0xC0, 0x07, 0xF8, 0x03,
  0x80, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x80, 0x03,
  0x80, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80,
  0x07, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x07,
  0x00, 0x03, 0xC1, 0xC0, 0x00, 0x70, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x03,
  0xBC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xC3, 0xC0, 0x38, 0xE0, 0x70,
  0x0E, 0x78, 0x0E, 0x07, 0x1C, 0x03, 0xC1, 0xC7, 0x00, 0x70, 0x73, 0x80,
  0x0E, 0x1C, 0xE0, 0x03, 0xCE, 0x38, 0x00, 0x73, 0x8E, 0x00, 0x0F, 0xC3,
  0x80, 0x03, 0xF0, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x0F,
  0xC1, 0xE0, 0x07, 0xF8, 0x3C, 0x03, 0xCF, 0x0F, 0xC3, 0xE1, 0xC1, 0xFF,
  0xF0, 0x78, 0x1F, 0xF0, 0x0F, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xED, 0x80, 0x01, 0xC0, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x38, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x01, 0xC0,
  0x78, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00,
  0xE0, 0x1C, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x78, 0x0E, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xC0, 0x78, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x18,
  0x18, 0x33, 0xE3, 0x3F, 0xFF, 0xFF, 0xE1, 0xFF, 0xC0, 0x03, 0x80, 0x00,
  0xF8, 0x00, 0x3B, 0x80, 0x0E, 0x38, 0x01, 0xC7, 0x80, 0x70, 0x70, 0x1E,
  0x07, 0x01, 0x80, 0xE0, 0x10, 0x10, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0x9C, 0x71, 0xC6, 0x18, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xFF, 0xF4, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x0F,
  0xFE, 0x01, 0xE0, 0xF0, 0x3C, 0x07, 0x83, 0x80, 0x38, 0x38, 0x01, 0xC7,
  0x00, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00,
  0xEE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x00, 0xE7,
  0x00, 0x1E, 0x70, 0x01, 0xC7, 0x00, 0x1C, 0x38, 0x03, 0xC3, 0xC0, 0x38,
  0x1C, 0x07, 0x81, 0xF1, 0xF0, 0x0F, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x40,
  0x00, 0x00, 0xF0, 0x1F, 0x03, 0xF0, 0x7F, 0x0F, 0x71, 0xE7, 0x7C, 0x7F,
  0x07, 0x60, 0x72, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x07, 0xC0, 0x78, 0x30, 0x03,
  0xC2, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0xFF, 0xE0, 0x3F, 0xFF, 0x8F,
  0xC0, 0x7C, 0x70, 0x03, 0xC4, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0xC0, 0x03,
  0xCF, 0x81, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xE0, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00,
  0x06, 0xC0, 0x00, 0x0E, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1D, 0xC0, 0x00,
  0x1D, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x39, 0xC0, 0x00, 0x71, 0xC0, 0x00,
  0x61, 0xC0, 0x00, 0xE1, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03,
  0x81, 0xC0, 0x03, 0x81, 0xC0, 0x07, 0x01, 0xC0, 0x07, 0x01, 0xC0, 0x0E,
  0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0xC0, 0x38,
  0x01, 0xC0, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x3F,
  0xFF, 0x83, 0xFF, 0xF8, 0x3F, 0xFF, 0x83, 0x00, 0x00, 0x30, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x3E, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x70, 0x0F, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xCC, 0x00, 0xF8, 0xF8, 0x3F, 0x0F, 0xFF, 0xE0, 0x3F, 0xF8,
  0x00, 0x10, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xC0, 0x7C,
  0x04, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE1, 0xFE, 0x0E, 0x7F, 0xF0,
  0xEF, 0x0F, 0x8E, 0xC0, 0x3C, 0xF8, 0x01, 0xCF, 0x00, 0x1E, 0xF0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x77, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xE3, 0x80, 0x1C, 0x1C, 0x03, 0xC1,
  0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0x70, 0x00,
  0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x70, 0x07, 0x83, 0xC0, 0x78, 0x0F,
  0x87, 0x80, 0x3E, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xE0,
  0x03, 0xC7, 0x80, 0x3C, 0x1F, 0x03, 0x80, 0x38, 0x38, 0x00, 0xE3, 0xC0,
  0x07, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00,
  0x1C, 0xF0, 0x01, 0xE3, 0xC0, 0x1E, 0x0F, 0x83, 0xE0, 0x3F, 0xFE, 0x00,
  0xFF, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0x01, 0xF0, 0x78, 0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0x70, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0xF7, 0x80, 0x0F, 0x38, 0x01, 0xF3, 0xC0, 0x37,
  0x1F, 0xFF, 0x70, 0xFF, 0xE7, 0x03, 0xF8, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x1F, 0x03, 0x07, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x02, 0x00, 0x00,
  0x4F, 0xFF, 0xF6, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0E, 0xFF, 0xFF, 0x18, 0xF3, 0xCF, 0x3C, 0x60, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x73, 0xCF,
  0x38, 0xE3, 0x9C, 0x71, 0xC6, 0x38, 0xE0, 0x00, 0x00, 0x08, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x00, 0x00,
  0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x03,
  0xC0, 0x00, 0x18, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0xF0,
  0xFF, 0xFC, 0x70, 0x3C, 0x40, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x02, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x70, 0x1C,
  0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x0E, 0x0C, 0x00, 0x00, 0x03, 0x0E,
  0x00, 0x00, 0x01, 0xC7, 0x00, 0x7F, 0xC0, 0xE7, 0x00, 0xFF, 0xE0, 0x33,
  0x80, 0x70, 0x30, 0x19, 0xC0, 0x70, 0x38, 0x0E, 0xC0, 0x70, 0x1C, 0x07,
  0xE0, 0x38, 0x0E, 0x03, 0xF0, 0x18, 0x07, 0x01, 0xF8, 0x1C, 0x03, 0x80,
  0xFC, 0x0E, 0x01, 0xC0, 0x7E, 0x07, 0x00, 0xE0, 0x3F, 0x03, 0x80, 0x70,
  0x1F, 0x81, 0xC0, 0x38, 0x0F, 0xC0, 0xE0, 0x1C, 0x07, 0xE0, 0x70, 0x0E,
  0x03, 0xF0, 0x38, 0x07, 0x01, 0xF8, 0x1C, 0x07, 0x80, 0xDC, 0x0E, 0x03,
  0xC0, 0xEE, 0x03, 0x81, 0xE0, 0x77, 0x01, 0xC1, 0xB8, 0x71, 0x80, 0x7F,
  0xCF, 0xF0, 0xE0, 0x1F, 0xC7, 0xF8, 0x70, 0x07, 0x80, 0xF0, 0x38, 0x00,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x03, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0C, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73,
  0x80, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00,
  0xC1, 0xC0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x03, 0x80,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x0E, 0x01,
  0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0x78, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83, 0xC0, 0x00,
  0xF0, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x79, 0xC0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0xBC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1C, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x7F, 0x8E, 0x00,
  0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0E, 0xE0, 0x01, 0xCE, 0x00, 0x3C, 0xE0, 0x0F, 0x8F, 0xFF, 0xE0,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xE0, 0x07, 0xCE, 0x00, 0x1E, 0xE0, 0x00,
  0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0xFE, 0x00, 0x0E, 0xE0, 0x01, 0xEE, 0x00, 0x7C, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0xE0, 0x1F,
  0xFF, 0xC0, 0xF8, 0x0F, 0x07, 0x80, 0x04, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x04, 0x0F,
  0xE1, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x02, 0x00, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x03, 0x83, 0xFE, 0x07, 0x00, 0x3E, 0x0E, 0x00, 0x3E,
  0x1C, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC,
  0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00,
  0x3B, 0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x03, 0xDC, 0x00, 0x07,
  0x38, 0x00, 0x1E, 0x70, 0x00, 0x38, 0xE0, 0x00, 0xF1, 0xC0, 0x03, 0xC3,
  0x80, 0x0F, 0x07, 0x00, 0x7C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0xFC, 0x0F, 0xC0, 0x3E, 0x07, 0xC0, 0x01, 0x83, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x3C,
  0x00, 0x01, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00, 0x1C, 0x3E, 0x00, 0x07,
  0x07, 0xC0, 0x01, 0xC0, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x01, 0x40, 0x00, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xC0, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE1, 0xFF, 0xFF, 0xF8, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x07, 0xBF, 0xE7, 0xF8, 0xFE, 0x00, 0xE0, 0x00, 0xF7, 0x00, 0x0F,
  0x38, 0x00, 0x71, 0xC0, 0x07, 0x8E, 0x00, 0x78, 0x70, 0x03, 0x83, 0x80,
  0x3C, 0x1C, 0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x01, 0xC0, 0x38, 0x1E, 0x01,
  0xC0, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0xF0, 0x03, 0x8F, 0x00, 0x1C, 0x70,
  0x00, 0xE7, 0x80, 0x07, 0x7C, 0x00, 0x3B, 0xE0, 0x01, 0xFF, 0x80, 0x0F,
  0x9C, 0x00, 0x78, 0xF0, 0x03, 0xC3, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x78,
  0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01, 0xC0, 0x38, 0x0E, 0x01, 0xE0, 0x70,
  0x07, 0x03, 0x80, 0x3C, 0x1C, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x00, 0x1E,
  0x38, 0x00, 0x71, 0xC0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0x80,
  0x01, 0xE0, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFD,
  0xC0, 0x00, 0x07, 0xFB, 0x80, 0x00, 0x0F, 0xF7, 0x00, 0x00, 0x1B, 0xE7,
  0x00, 0x00, 0x77, 0xCE, 0x00, 0x00, 0xEF, 0x9C, 0x00, 0x01, 0x9F, 0x1C,
  0x00, 0x07, 0x3E, 0x38, 0x00, 0x0E, 0x7C, 0x70, 0x00, 0x18, 0xF8, 0x70,
  0x00, 0x71, 0xF0, 0xE0, 0x00, 0xE3, 0xE1, 0xC0, 0x01, 0x87, 0xC1, 0x80,
  0x07, 0x0F, 0x83, 0x80, 0x0E, 0x1F, 0x07, 0x00, 0x18, 0x3E, 0x0E, 0x00,
  0x70, 0x7C, 0x0E, 0x00, 0xE0, 0xF8, 0x1C, 0x01, 0x81, 0xF0, 0x38, 0x07,
  0x03, 0xE0, 0x38, 0x0E, 0x07, 0xC0, 0x70, 0x1C, 0x0F, 0x80, 0xE0, 0x70,
  0x1F, 0x00, 0xE0, 0xE0, 0x3E, 0x01, 0xC1, 0xC0, 0x7C, 0x03, 0x87, 0x00,
  0xF8, 0x03, 0x8E, 0x01, 0xF0, 0x07, 0x1C, 0x03, 0xE0, 0x0E, 0x70, 0x07,
  0xC0, 0x0E, 0xE0, 0x0F, 0x80, 0x1D, 0xC0, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0,
  0x00, 0xE0, 0x03, 0x80, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0xFB, 0x80, 0x01, 0xF7, 0x80, 0x03,
  0xE7, 0x00, 0x07, 0xCF, 0x00, 0x0F, 0x8E, 0x00, 0x1F, 0x1E, 0x00, 0x3E,
  0x1C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x38, 0x01, 0xF0, 0x78, 0x03, 0xE0,
  0x70, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0xE0, 0x1F, 0x01, 0xE0, 0x3E, 0x01,
  0xC0, 0x7C, 0x03, 0xC0, 0xF8, 0x03, 0x81, 0xF0, 0x07, 0x83, 0xE0, 0x07,
  0x07, 0xC0, 0x0F, 0x0F, 0x80, 0x0E, 0x1F, 0x00, 0x1E, 0x3E, 0x00, 0x1C,
  0x7C, 0x00, 0x3C, 0xF8, 0x00, 0x39, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0x77,
  0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC1, 0xE0, 0x00, 0x3C,
  0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x07, 0x38, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0,
  0x00, 0x03, 0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0x83, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x04, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0xC3, 0x87, 0xFC, 0x70,
  0x07, 0xCE, 0x00, 0x79, 0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x03, 0xDC, 0x00, 0x73, 0x80,
  0x1E, 0x70, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xF8, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x00, 0x01,
  0xC1, 0xE0, 0x00, 0x3C, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xB8, 0x00, 0x00, 0xF7,
  0x00, 0x00, 0x1C, 0xE0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF1, 0xC0, 0x00,
  0x1C, 0x38, 0x00, 0x03, 0x83, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x3C, 0x07,
  0x80, 0x07, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xC0, 0x1F, 0x0E, 0x00, 0x3C,
  0x70, 0x01, 0xE3, 0x80, 0x07, 0x1C, 0x00, 0x3C, 0xE0, 0x01, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1E, 0x70, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x03,
  0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0xF8, 0x03, 0x81, 0xC0, 0x1C,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x1C,
  0x0E, 0x00, 0xE0, 0x70, 0x07, 0x83, 0x80, 0x1C, 0x1C, 0x00, 0xF0, 0xE0,
  0x03, 0x87, 0x00, 0x1E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0xCE, 0x00, 0x0E,
  0x70, 0x00, 0x7B, 0x80, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x0F,
  0xFF, 0xE1, 0xF0, 0x1E, 0x3C, 0x00, 0x23, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0xC0, 0x03, 0xCF, 0xC1, 0xF8, 0xFF, 0xFF, 0x03, 0xFF, 0xC0, 0x00, 0x80,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x1C,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xE0, 0xF0, 0x07, 0xC1, 0xF8, 0x3F, 0x00,
  0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xDC, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x78, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x3C, 0x00, 0x0E,
  0x0E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x03,
  0xC0, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x38,
  0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0x70, 0x00, 0x1C, 0x70, 0x00,
  0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x00, 0xEE, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0D, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0F, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x7C, 0x00,
  0x0E, 0xF0, 0x00, 0x7C, 0x00, 0x0E, 0x70, 0x00, 0x7C, 0x00, 0x1E, 0x70,
  0x00, 0x6C, 0x00, 0x1C, 0x70, 0x00, 0xEE, 0x00, 0x1C, 0x70, 0x00, 0xEE,
  0x00, 0x1C, 0x38, 0x00, 0xEE, 0x00, 0x3C, 0x38, 0x00, 0xEE, 0x00, 0x38,
  0x38, 0x00, 0xC6, 0x00, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x38, 0x3C, 0x01,
  0xC7, 0x00, 0x38, 0x1C, 0x01, 0xC7, 0x00, 0x70, 0x1C, 0x01, 0xC3, 0x00,
  0x70, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x1C, 0x03, 0x83, 0x80, 0x70, 0x0E,
  0x03, 0x83, 0x80, 0xF0, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0x0E, 0x03, 0x01,
  0x80, 0xE0, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x0F, 0x07, 0x01, 0xC1, 0xE0,
  0x07, 0x07, 0x01, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0xC1, 0xC0, 0x07, 0x0E,
  0x00, 0xE1, 0xC0, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x03, 0x8E, 0x00, 0xE3,
  0x80, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x03, 0x8C, 0x00, 0x63, 0x80, 0x03,
  0x9C, 0x00, 0x73, 0x80, 0x01, 0xDC, 0x00, 0x77, 0x80, 0x01, 0xDC, 0x00,
  0x77, 0x00, 0x01, 0xDC, 0x00, 0x37, 0x00, 0x01, 0xD8, 0x00, 0x37, 0x00,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x78, 0x70, 0x00, 0xE0, 0xE0, 0x03,
  0xC0, 0xE0, 0x07, 0x01, 0xC0, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70,
  0x07, 0x81, 0xC0, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x0E, 0x1C, 0x00,
  0x1C, 0x70, 0x00, 0x1C, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x73, 0x80, 0x01, 0xC7,
  0x00, 0x03, 0x87, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x70, 0x1C,
  0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x1E, 0x00, 0x70,
  0x38, 0x00, 0xE0, 0xF0, 0x01, 0xE1, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0xCE,
  0x00, 0x03, 0xBC, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xF7,
  0x00, 0x03, 0x8E, 0x00, 0x0E, 0x38, 0x00, 0x78, 0xF0, 0x01, 0xC1, 0xC0,
  0x07, 0x07, 0x00, 0x38, 0x0E, 0x00, 0xE0, 0x38, 0x07, 0x80, 0xE0, 0x1C,
  0x01, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x0E, 0x0E, 0x00, 0x38, 0x78, 0x00,
  0xE1, 0xC0, 0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x0E, 0xE0, 0x00, 0x3B,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x00, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x71, 0xC0, 0x00, 0xE1, 0xC0, 0x03, 0x83, 0x80, 0x07, 0x03,
  0x80, 0x1C, 0x07, 0x00, 0x38, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x0E,
  0x07, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x18, 0x00, 0x38, 0x70, 0x00, 0x38,
  0xE0, 0x00, 0x73, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70,
  0x0E, 0x01, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x83, 0xFF, 0xF0, 0x70, 0x1E,
  0x10, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x3F, 0xF0, 0x7F,
  0xFC, 0x7F, 0x07, 0x3E, 0x01, 0xDE, 0x00, 0x77, 0x00, 0x1F, 0xC0, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xDC,
  0x01, 0xF7, 0x00, 0xFC, 0xF0, 0x77, 0x3F, 0xF8, 0xC3, 0xFC, 0x30, 0x18,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0xF8, 0x0E, 0x3F, 0xF0,
  0xE7, 0xFF, 0x8E, 0xE0, 0x7C, 0xEC, 0x03, 0xCF, 0x80, 0x1E, 0xF0, 0x00,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF8, 0x00, 0xEF, 0x80, 0x1C,
  0xEC, 0x03, 0xCE, 0xF0, 0xF8, 0xE7, 0xFF, 0x0E, 0x3F, 0xE0, 0x00, 0x60,
  0x00, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0xFF, 0x1F, 0x03, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x07, 0x0F, 0xFF, 0x03,
  0xFF, 0x00, 0x30, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x01, 0xF0, 0x70,
  0x7F, 0xC7, 0x1F, 0xFE, 0x71, 0xE0, 0x77, 0x3C, 0x03, 0x77, 0x80, 0x1F,
  0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x01, 0xF7,
  0x80, 0x1F, 0x3C, 0x03, 0x71, 0xE0, 0xF7, 0x0F, 0xFE, 0x70, 0x7F, 0x87,
  0x00, 0x40, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x07,
  0x83, 0xC0, 0x38, 0x70, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0xE0, 0x00,
  0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x01, 0x0F, 0x81, 0xE0, 0xFF, 0xFC,
  0x07, 0xFE, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x07, 0xFC, 0x1F, 0xF0, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xFE, 0x3F, 0xFC, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x01, 0xF0, 0x00, 0x7F, 0xC7, 0x1F, 0xFE, 0x71, 0xE0, 0x77, 0x3C, 0x03,
  0xF7, 0x80, 0x1F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x0F,
  0x70, 0x01, 0xF7, 0x80, 0x1F, 0x3C, 0x03, 0x71, 0xE0, 0xE7, 0x0F, 0xFE,
  0x70, 0x7F, 0x87, 0x00, 0x40, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC6, 0x00, 0x7C, 0x7F, 0x3F, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x0F, 0x81, 0xC7, 0xFC, 0x39, 0xFF, 0xC7,
  0x70, 0x3C, 0xEC, 0x03, 0xDF, 0x00, 0x3B, 0xC0, 0x07, 0x78, 0x00, 0xEF,
  0x00, 0x1D, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1C, 0xEF, 0xFF, 0x60, 0x00, 0x00, 0x0E, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0x07, 0x03, 0xC1, 0xE0, 0xE0, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x07, 0xBF, 0x9F, 0xCF, 0x80,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x01, 0xEE, 0x00, 0x73, 0x80, 0x38,
  0xE0, 0x1C, 0x38, 0x0F, 0x0E, 0x03, 0x83, 0x81, 0xC0, 0xE0, 0xF0, 0x38,
  0x38, 0x0E, 0x1C, 0x03, 0x8E, 0x00, 0xE3, 0x80, 0x39, 0xE0, 0x0E, 0xFC,
  0x03, 0xF7, 0x00, 0xF8, 0xE0, 0x3E, 0x38, 0x0F, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x38, 0x38, 0x0F, 0x0E, 0x01, 0xC3, 0x80, 0x78, 0xE0, 0x0E, 0x38,
  0x03, 0xCE, 0x00, 0x73, 0x80, 0x1E, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xE0, 0xE3, 0xFC, 0x0F, 0xF8, 0xE7,
  0xFE, 0x1F, 0xFC, 0xEE, 0x0F, 0x38, 0x3C, 0xFC, 0x07, 0x70, 0x1E, 0xF8,
  0x03, 0xE0, 0x0E, 0xF0, 0x03, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0x0F, 0xF0,
  0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0, 0x03, 0x80, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0x00, 0xF8, 0x18, 0x7F, 0xC3, 0x9F, 0xFE, 0x77, 0x03,
  0xCE, 0xC0, 0x3D, 0xF0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01,
  0xDC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0,
  0x78, 0x3C, 0x03, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xF0,
  0xF8, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x0E,
  0x3F, 0xF0, 0xE7, 0xFF, 0x8E, 0xE0, 0x7C, 0xEC, 0x01, 0xCF, 0x80, 0x1E,
  0xF8, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0E, 0xF8, 0x00, 0xEF,
  0x80, 0x1C, 0xEC, 0x03, 0xCE, 0xF0, 0xF8, 0xE7, 0xFF, 0x0E, 0x1F, 0xE0,
  0xE0, 0x20, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x7F, 0xC7, 0x0F, 0xFE, 0x71, 0xE0, 0x77, 0x3C, 0x03, 0x77, 0x80, 0x1F,
  0x70, 0x01, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x01, 0xF7,
  0x80, 0x1F, 0x3C, 0x03, 0x71, 0xE0, 0xE7, 0x0F, 0xFC, 0x70, 0x7F, 0x87,
  0x00, 0x80, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0xF7, 0x1F,
  0xF9, 0xFF, 0xDE, 0x2E, 0xC0, 0x7E, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x0F, 0xFE, 0x3F, 0xFF, 0x7C, 0x06, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0xC0, 0x0E, 0xF8, 0x3E, 0xFF, 0xFC, 0x3F, 0xF0, 0x01, 0x00,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1F,
  0xFE, 0xFF, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x43, 0xFE, 0x0F, 0xF0, 0x08,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x06, 0xDE, 0x03, 0xB7,
  0xC1, 0xCC, 0xFF, 0xE3, 0x1F, 0xF0, 0xC0, 0xC0, 0x00, 0xF0, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0E, 0x38, 0x00, 0xE3, 0x80, 0x0E,
  0x38, 0x01, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03,
  0x80, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x70,
  0x70, 0x07, 0x07, 0x00, 0x70, 0xE0, 0x03, 0x0E, 0x00, 0x38, 0xE0, 0x03,
  0x9C, 0x00, 0x39, 0xC0, 0x01, 0x9C, 0x00, 0x1D, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x0E, 0xF0, 0x07,
  0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x06,
  0x60, 0x0C, 0x70, 0x0E, 0x60, 0x1C, 0x38, 0x0E, 0x70, 0x1C, 0x38, 0x0E,
  0x70, 0x1C, 0x38, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x30, 0x38, 0x1C, 0x1C,
  0x38, 0x38, 0x1C, 0x1C, 0x38, 0x38, 0x1C, 0x18, 0x38, 0x38, 0x1C, 0x38,
  0x18, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0E, 0x38, 0x1C, 0x70, 0x0E, 0x30,
  0x1C, 0x70, 0x0E, 0x70, 0x0C, 0x60, 0x06, 0x70, 0x0E, 0xE0, 0x07, 0x70,
  0x0E, 0xE0, 0x07, 0x60, 0x0E, 0xE0, 0x07, 0x60, 0x06, 0xC0, 0x07, 0xE0,
  0x06, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0x80, 0xF0, 0x00, 0xE7, 0x80, 0x1C, 0x38,
  0x03, 0xC3, 0xC0, 0x38, 0x1C, 0x07, 0x80, 0xE0, 0x70, 0x0E, 0x0F, 0x00,
  0x70, 0xE0, 0x07, 0x1E, 0x00, 0x39, 0xC0, 0x03, 0xB8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x3B, 0x80, 0x03, 0x9C, 0x00, 0x71, 0xE0, 0x0F, 0x0E, 0x00, 0xE0,
  0xF0, 0x1E, 0x07, 0x01, 0xC0, 0x78, 0x3C, 0x03, 0x83, 0x80, 0x3C, 0x78,
  0x01, 0xC7, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0x70, 0x00, 0x7B, 0x80, 0x03,
  0x9C, 0x00, 0x1C, 0x70, 0x00, 0xE3, 0x80, 0x0E, 0x1C, 0x00, 0x70, 0x70,
  0x03, 0x83, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x07, 0x00, 0xE0, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1C, 0x00, 0xE0,
  0xE0, 0x03, 0x07, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x07, 0x1C, 0x00,
  0x1C, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1B, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x1B, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFE,
  0xFF, 0xFC, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01,
  0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x01, 0xFC, 0x07, 0xE0, 0x0F,
  0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x3F, 0x80,
  0x7C, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x3F, 0x80, 0x1F, 0x00, 0x7E,
  0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xF0, 0x1F, 0xE0, 0x3F, 0x00, 0x70, 0x00, 0x3F, 0x80, 0x0B, 0xFF, 0x80,
  0x7C, 0x7F, 0x0F, 0x80, 0x7F, 0xF8, 0x00, 0xFE, 0x00,
};

const GFXglyph NotoSans_Condensed_Light55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 40, 12, 4, -39 },
  { 21, 11, 14, 19, 4, -39 },
  { 41, 26, 39, 28, 1, -39 },
  { 168, 21, 45, 25, 2, -42 },
  { 287, 32, 41, 37, 3, -40 },
  { 451, 26, 41, 28, 2, -40 },
  { 585, 3, 14, 10, 4, -39 },
  { 591, 10, 48, 15, 3, -39 },
  { 651, 11, 48, 15, 2, -39 },
  { 717, 19, 19, 23, 2, -42 },
  { 763, 21, 25, 25, 2, -32 },
  { 829, 6, 13, 11, 2, -6 },
  { 839, 12, 3, 16, 2, -16 },
  { 844, 4, 6, 12, 4, -5 },
  { 847, 17, 39, 19, 1, -39 },
  { 930, 20, 41, 25, 3, -40 },
  { 1033, 12, 39, 25, 4, -39 },
  { 1092, 20, 40, 25, 2, -40 },
  { 1192, 20, 41, 25, 2, -40 },
  { 1295, 24, 40, 25, 1, -40 },
  { 1415, 20, 40, 25, 3, -39 },
  { 1515, 20, 41, 25, 3, -40 },
  { 1618, 21, 39, 25, 2, -39 },
  { 1721, 21, 41, 25, 2, -40 },
  { 1829, 20, 41, 25, 2, -40 },
  { 1932, 4, 30, 12, 4, -30 },
  { 1947, 6, 37, 12, 2, -30 },
  { 1975, 21, 25, 25, 2, -32 },
  { 2041, 21, 14, 25, 2, -26 },
  { 2078, 21, 25, 25, 2, -32 },
  { 2144, 16, 41, 18, 1, -40 },
  { 2226, 33, 44, 39, 3, -39 },
  { 2408, 26, 39, 26, 0, -39 },
  { 2535, 20, 39, 28, 5, -39 },
  { 2633, 22, 41, 27, 3, -40 },
  { 2746, 23, 39, 31, 5, -39 },
  { 2859, 16, 39, 24, 5, -39 },
  { 2937, 16, 39, 22, 5, -39 },
  { 3015, 26, 41, 32, 3, -40 },
  { 3149, 22, 39, 32, 5, -39 },
  { 3257, 11, 39, 15, 2, -39 },
  { 3311, 11, 49, 12, -3, -39 },
  { 3379, 21, 39, 26, 5, -39 },
  { 3482, 16, 39, 22, 5, -39 },
  { 3560, 31, 39, 41, 5, -39 },
  { 3712, 23, 39, 33, 5, -39 },
  { 3825, 27, 41, 33, 3, -40 },
  { 3964, 19, 39, 26, 5, -39 },
  { 4057, 27, 49, 33, 3, -40 },
  { 4223, 21, 39, 27, 5, -39 },
  { 4326, 20, 41, 24, 2, -40 },
  { 4429, 22, 39, 23, 0, -39 },
  { 4537, 23, 40, 31, 4, -39 },
  { 4652, 25, 39, 25, 0, -39 },
  { 4774, 40, 39, 41, 1, -39 },
  { 4969, 23, 39, 23, 0, -39 },
  { 5082, 22, 39, 22, 0, -39 },
  { 5190, 19, 39, 23, 2, -39 },
  { 5283, 12, 48, 17, 4, -39 },
  { 5355, 17, 39, 19, 1, -39 },
  { 5438, 11, 48, 17, 2, -39 },
  { 5504, 23, 21, 26, 1, -39 },
  { 5565, 23, 2, 23, 0, 5 },
  { 5571, 10, 9, 14, 2, -42 },
  { 5583, 18, 31, 24, 2, -30 },
  { 5653, 20, 43, 27, 4, -42 },
  { 5761, 16, 31, 21, 3, -30 },
  { 5823, 20, 43, 27, 3, -42 },
  { 5931, 19, 31, 24, 3, -30 },
  { 6005, 15, 42, 14, 1, -42 },
  { 6084, 20, 43, 27, 3, -30 },
  { 6192, 19, 42, 26, 4, -42 },
  { 6292, 4, 40, 11, 4, -40 },
  { 6312, 9, 53, 11, -1, -40 },
  { 6372, 18, 42, 22, 4, -42 },
  { 6467, 3, 42, 11, 4, -42 },
  { 6483, 32, 30, 40, 4, -30 },
  { 6603, 19, 30, 26, 4, -30 },
  { 6675, 20, 31, 26, 3, -30 },
  { 6753, 20, 43, 27, 4, -30 },
  { 6861, 20, 43, 27, 3, -30 },
  { 6969, 13, 30, 17, 4, -30 },
  { 7018, 16, 31, 20, 2, -30 },
  { 7080, 13, 37, 15, 1, -36 },
  { 7141, 18, 30, 26, 4, -29 },
  { 7209, 20, 29, 21, 0, -29 },
  { 7282, 32, 29, 34, 1, -29 },
  { 7398, 20, 29, 22, 1, -29 },
  { 7471, 21, 42, 21, 0, -29 },
  { 7582, 15, 29, 18, 2, -29 },
  { 7637, 15, 48, 20, 2, -39 },
  { 7727, 2, 55, 24, 11, -42 },
  { 7741, 15, 48, 20, 2, -39 },
  { 7831, 21, 5, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Light55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light55pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_CONDENSED_LIGHT55PT7B_H_
