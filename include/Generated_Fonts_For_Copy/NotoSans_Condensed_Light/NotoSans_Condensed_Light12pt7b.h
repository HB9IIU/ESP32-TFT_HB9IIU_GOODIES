#ifndef _NOTOSANS_CONDENSED_LIGHT12PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT12PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 12pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light12pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xFF, 0x28, 0xA2, 0x9F, 0x49, 0x4F, 0x94, 0x50, 0x4F,
  0xCC, 0x47, 0x55, 0xE4, 0xC9, 0x92, 0xC5, 0x8D, 0xDD, 0x4A, 0xA5, 0x4C,
  0x21, 0x45, 0x14, 0x21, 0x59, 0x62, 0x74, 0xF0, 0x6A, 0xAA, 0xA4, 0x89,
  0x12, 0x49, 0x4B, 0x00, 0x4F, 0x4A, 0x21, 0x3E, 0x42, 0x10, 0x58, 0xE0,
  0x80, 0x11, 0x22, 0x24, 0x44, 0x80, 0x69, 0x99, 0x99, 0x99, 0xE0, 0x5D,
  0x55, 0x40, 0x74, 0x42, 0x11, 0x08, 0x88, 0xF8, 0x74, 0x42, 0x13, 0x04,
  0x21, 0xF0, 0x10, 0x8C, 0x65, 0x2B, 0xE2, 0x10, 0xE8, 0x88, 0xE1, 0x11,
  0xE0, 0x78, 0x88, 0xF9, 0x99, 0xE0, 0xF8, 0x42, 0x21, 0x10, 0x84, 0x40,
  0x32, 0x52, 0x93, 0x26, 0x31, 0x70, 0x69, 0x99, 0x9F, 0x12, 0xE0, 0x84,
  0x40, 0x16, 0x09, 0xB0, 0x41, 0x80, 0xF8, 0x3E, 0xC1, 0x82, 0x6C, 0x00,
  0xE1, 0x11, 0x24, 0x40, 0x40, 0x38, 0x8A, 0x0D, 0xDC, 0xB9, 0x72, 0xDA,
  0x80, 0xF0, 0x20, 0xC3, 0x14, 0x49, 0xE4, 0xA2, 0x84, 0xE4, 0xA3, 0x2E,
  0x4A, 0x31, 0xF0, 0x3E, 0x21, 0x08, 0x42, 0x10, 0x70, 0xE4, 0xA3, 0x18,
  0xC6, 0x31, 0xF0, 0xF8, 0x88, 0xF8, 0x88, 0xF0, 0xF8, 0x88, 0xF8, 0x88,
  0x80, 0x3A, 0x21, 0x09, 0x46, 0x31, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31,
  0x88, 0xE9, 0x24, 0x92, 0xE0, 0x24, 0x92, 0x49, 0x27, 0x00, 0x8C, 0xA9,
  0x8C, 0x52, 0x92, 0x98, 0x88, 0x88, 0x88, 0x88, 0xF0, 0x83, 0x07, 0x1E,
  0x3C, 0xB5, 0x6A, 0xD9, 0x92, 0x8C, 0x73, 0x9A, 0xD6, 0x73, 0x88, 0x72,
  0x28, 0xA1, 0x86, 0x18, 0x62, 0x70, 0xE9, 0x99, 0x9E, 0x88, 0x80, 0x72,
  0x28, 0xA1, 0x86, 0x18, 0x62, 0x70, 0x40, 0x80, 0xE4, 0xA5, 0x2D, 0x52,
  0x92, 0x98, 0x78, 0x88, 0x43, 0x11, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x84,
  0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0x8C, 0x62, 0x94, 0xA9, 0x46,
  0x20, 0x88, 0xC4, 0x66, 0x2A, 0xA5, 0x52, 0xA9, 0x54, 0x44, 0x22, 0x00,
  0x8A, 0x54, 0x42, 0x11, 0x4A, 0x88, 0x8C, 0x54, 0xA6, 0x10, 0x84, 0x20,
  0xF8, 0x84, 0x42, 0x11, 0x08, 0xF8, 0xEA, 0xAA, 0xAC, 0x88, 0x44, 0x22,
  0x21, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x21, 0x94, 0x98, 0x80, 0xF8,
  0xC4, 0x25, 0x17, 0x99, 0x70, 0x88, 0xE9, 0x99, 0x99, 0xF0, 0x72, 0x49,
  0x38, 0x11, 0x79, 0x99, 0x99, 0xF0, 0x69, 0x9F, 0x88, 0xF0, 0x6B, 0xA4,
  0x92, 0x40, 0x69, 0x99, 0x99, 0xF1, 0x1E, 0x88, 0xE9, 0x99, 0x99, 0x90,
  0x9F, 0x80, 0x41, 0x55, 0x56, 0x88, 0x9A, 0xCC, 0xAA, 0x90, 0xFF, 0x80,
  0x6D, 0x26, 0x4C, 0x99, 0x32, 0x64, 0x80, 0x69, 0x99, 0x99, 0x90, 0x69,
  0x99, 0x99, 0xE0, 0x69, 0x99, 0x99, 0xF8, 0x88, 0x69, 0x99, 0x99, 0xF1,
  0x11, 0xF2, 0x49, 0x00, 0x69, 0x86, 0x11, 0xF0, 0x5D, 0x24, 0x93, 0x99,
  0x99, 0x9F, 0x99, 0x56, 0x62, 0x93, 0x35, 0xAB, 0x66, 0x44, 0x80, 0xD5,
  0x22, 0x59, 0x9C, 0x94, 0xA2, 0x10, 0x88, 0xC0, 0x72, 0x24, 0x4F, 0x12,
  0x22, 0x2C, 0x42, 0x22, 0x30, 0xFF, 0xF0, 0xC2, 0x22, 0x23, 0x22, 0x22,
  0xC0, 0xF8,
};

const GFXglyph NotoSans_Condensed_Light12pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 9, 3, 1, -9 },
  { 3, 2, 4, 4, 1, -9 },
  { 4, 6, 9, 6, 0, -9 },
  { 11, 4, 10, 6, 1, -9 },
  { 16, 7, 9, 8, 1, -9 },
  { 24, 6, 9, 6, 0, -9 },
  { 31, 1, 4, 2, 1, -9 },
  { 32, 2, 11, 3, 1, -9 },
  { 35, 3, 11, 3, 0, -9 },
  { 40, 4, 4, 5, 1, -9 },
  { 42, 5, 6, 6, 0, -7 },
  { 46, 2, 3, 3, 0, -1 },
  { 47, 3, 1, 3, 0, -4 },
  { 48, 1, 1, 3, 1, -1 },
  { 49, 4, 9, 4, 0, -9 },
  { 54, 4, 9, 6, 1, -9 },
  { 59, 2, 9, 6, 1, -9 },
  { 62, 5, 9, 6, 0, -9 },
  { 68, 5, 9, 6, 0, -9 },
  { 74, 5, 9, 6, 0, -9 },
  { 80, 4, 9, 6, 1, -9 },
  { 85, 4, 9, 6, 1, -9 },
  { 90, 5, 9, 6, 0, -9 },
  { 96, 5, 9, 6, 0, -9 },
  { 102, 4, 9, 6, 1, -9 },
  { 107, 1, 6, 3, 1, -6 },
  { 108, 2, 8, 3, 0, -6 },
  { 110, 5, 5, 6, 0, -7 },
  { 114, 5, 3, 6, 0, -6 },
  { 116, 5, 5, 6, 0, -7 },
  { 120, 4, 9, 4, 0, -9 },
  { 125, 7, 10, 8, 1, -9 },
  { 134, 6, 9, 6, 0, -9 },
  { 141, 5, 9, 6, 1, -9 },
  { 147, 5, 9, 6, 1, -9 },
  { 153, 5, 9, 7, 1, -9 },
  { 159, 4, 9, 5, 1, -9 },
  { 164, 4, 9, 5, 1, -9 },
  { 169, 5, 9, 7, 1, -9 },
  { 175, 5, 9, 7, 1, -9 },
  { 181, 3, 9, 3, 0, -9 },
  { 185, 3, 11, 3, -1, -9 },
  { 190, 5, 9, 6, 1, -9 },
  { 196, 4, 9, 5, 1, -9 },
  { 201, 7, 9, 9, 1, -9 },
  { 209, 5, 9, 7, 1, -9 },
  { 215, 6, 9, 7, 1, -9 },
  { 222, 4, 9, 6, 1, -9 },
  { 227, 6, 11, 7, 1, -9 },
  { 236, 5, 9, 6, 1, -9 },
  { 242, 4, 9, 5, 1, -9 },
  { 247, 5, 9, 5, 0, -9 },
  { 253, 5, 9, 7, 1, -9 },
  { 259, 5, 9, 5, 0, -9 },
  { 265, 9, 9, 9, 0, -9 },
  { 276, 5, 9, 5, 0, -9 },
  { 282, 5, 9, 5, 0, -9 },
  { 288, 5, 9, 5, 0, -9 },
  { 294, 2, 11, 4, 1, -9 },
  { 297, 4, 9, 4, 0, -9 },
  { 302, 3, 11, 4, 0, -9 },
  { 307, 5, 5, 6, 0, -9 },
  { 311, 5, 1, 5, 0, 1 },
  { 312, 3, 2, 3, 0, -9 },
  { 313, 4, 7, 5, 0, -7 },
  { 317, 4, 9, 6, 1, -9 },
  { 322, 3, 7, 4, 1, -7 },
  { 325, 4, 9, 6, 1, -9 },
  { 330, 4, 7, 5, 1, -7 },
  { 334, 3, 9, 3, 0, -9 },
  { 338, 4, 10, 6, 1, -7 },
  { 343, 4, 9, 6, 1, -9 },
  { 348, 1, 9, 2, 1, -9 },
  { 350, 2, 12, 2, 0, -9 },
  { 353, 4, 9, 5, 1, -9 },
  { 358, 1, 9, 2, 1, -9 },
  { 360, 7, 7, 9, 1, -7 },
  { 367, 4, 7, 6, 1, -7 },
  { 371, 4, 7, 6, 1, -7 },
  { 375, 4, 10, 6, 1, -7 },
  { 380, 4, 10, 6, 1, -7 },
  { 385, 3, 6, 4, 1, -6 },
  { 388, 4, 7, 4, 0, -7 },
  { 392, 3, 8, 3, 0, -8 },
  { 395, 4, 6, 6, 1, -6 },
  { 398, 4, 6, 4, 0, -6 },
  { 401, 7, 6, 7, 0, -6 },
  { 407, 4, 6, 5, 0, -6 },
  { 410, 5, 9, 5, 0, -6 },
  { 416, 4, 6, 4, 0, -6 },
  { 419, 4, 11, 4, 0, -9 },
  { 425, 1, 12, 5, 2, -9 },
  { 427, 4, 11, 4, 0, -9 },
  { 433, 5, 1, 6, 0, -5 },
};

const GFXfont NotoSans_Condensed_Light12pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light12pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light12pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _NOTOSANS_CONDENSED_LIGHT12PT7B_H_
