#ifndef _NOTOSANS_CONDENSED_LIGHT31PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT31PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light31pt7bBitmaps[] PROGMEM = {
  0x00, 0xF9, 0x24, 0x92, 0x49, 0x24, 0x92, 0x00, 0x2F, 0xC0, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xB1, 0x62, 0x04, 0x30, 0x10, 0x80, 0x42, 0x03, 0x08,
  0x0C, 0x20, 0x30, 0x8F, 0xFF, 0xFF, 0xFF, 0x08, 0x60, 0x21, 0x01, 0x84,
  0x06, 0x10, 0x18, 0x40, 0x43, 0x0F, 0xFF, 0x84, 0x30, 0x10, 0x80, 0xC2,
  0x03, 0x08, 0x0C, 0x20, 0x21, 0x80, 0x86, 0x00, 0x06, 0x00, 0x60, 0x06,
  0x01, 0xFE, 0x76, 0x66, 0x60, 0xC6, 0x0C, 0x60, 0xC6, 0x04, 0x60, 0x66,
  0x03, 0xE0, 0x1E, 0x00, 0x78, 0x06, 0xE0, 0x66, 0x06, 0x30, 0x63, 0x06,
  0x30, 0x62, 0x86, 0x6F, 0xFC, 0x3F, 0x00, 0x60, 0x06, 0x00, 0x60, 0x3C,
  0x06, 0x0C, 0xC0, 0x81, 0x08, 0x30, 0x21, 0x04, 0x0C, 0x31, 0x81, 0x86,
  0x20, 0x30, 0xC4, 0x06, 0x19, 0x80, 0x43, 0x22, 0x08, 0x4C, 0xF1, 0x09,
  0x33, 0x33, 0x64, 0x23, 0xCD, 0x84, 0x01, 0x30, 0x80, 0x66, 0x18, 0x08,
  0xC3, 0x03, 0x18, 0x60, 0x63, 0x08, 0x08, 0x21, 0x03, 0x04, 0x20, 0x40,
  0xCC, 0x18, 0x0F, 0x00, 0x1F, 0x80, 0x33, 0x00, 0xC3, 0x01, 0x86, 0x03,
  0x0C, 0x06, 0x18, 0x0C, 0x20, 0x0C, 0xC0, 0x1B, 0x00, 0x1C, 0x00, 0x78,
  0x01, 0xB0, 0x06, 0x30, 0xCC, 0x31, 0xB0, 0x63, 0x60, 0x64, 0xC0, 0x79,
  0x80, 0x63, 0x00, 0xC3, 0x03, 0xC7, 0x1C, 0xC7, 0xF1, 0xC0, 0xFF, 0xFF,
  0x0E, 0x10, 0x60, 0x83, 0x06, 0x18, 0x30, 0x60, 0x81, 0x02, 0x0C, 0x18,
  0x30, 0x20, 0x40, 0xC1, 0x83, 0x06, 0x06, 0x0C, 0x08, 0x18, 0x18, 0x18,
  0xC1, 0x82, 0x0C, 0x10, 0x61, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC2, 0x18, 0x61, 0x0C, 0x21, 0x8C, 0x00, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x0E, 0x4E, 0xFF, 0x03, 0x80, 0x58, 0x11, 0x06, 0x30, 0x82,
  0x00, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0xFF, 0xFF,
  0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x36, 0x66,
  0x44, 0xC0, 0xFE, 0xDF, 0x00, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x10,
  0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x80, 0x80, 0xC0, 0x60, 0x20,
  0x30, 0x18, 0x18, 0x0C, 0x04, 0x00, 0x1F, 0x83, 0x8C, 0x30, 0x46, 0x06,
  0x60, 0x66, 0x02, 0x40, 0x24, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x34, 0x03, 0x40, 0x34, 0x02, 0x60, 0x26, 0x06, 0x60, 0x63, 0x0C,
  0x19, 0xC0, 0xF8, 0x06, 0x1C, 0xFB, 0xBC, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x3F,
  0x87, 0x1C, 0x40, 0xC0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0x8E, 0x1C, 0x40,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x38, 0x1E,
  0x00, 0x3C, 0x00, 0xE0, 0x06, 0x00, 0x20, 0x03, 0x00, 0x30, 0x02, 0x00,
  0x60, 0x06, 0xE1, 0xC7, 0xF8, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x6C, 0x03, 0x60, 0x33, 0x01, 0x18, 0x18, 0xC0, 0x86, 0x0C, 0x30, 0x41,
  0x86, 0x0C, 0x20, 0x63, 0x03, 0x1F, 0xFF, 0xFF, 0xF8, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x7F, 0x88, 0x01, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x1F, 0xE1, 0x06, 0x00, 0x60, 0x0C, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0xEC, 0x39, 0xFC, 0x00,
  0x0F, 0xC7, 0x08, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x30, 0x06, 0x00, 0x8E,
  0x17, 0xF2, 0x83, 0x60, 0x6C, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0x30, 0x67, 0x18, 0x3E, 0x00, 0xFF, 0xF0, 0x03, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x00,
  0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x0C, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1F, 0x83, 0x0C, 0x60, 0x66, 0x02, 0x60, 0x26,
  0x02, 0x60, 0x63, 0x06, 0x38, 0xC1, 0xF8, 0x0F, 0x01, 0x98, 0x30, 0xC6,
  0x06, 0x40, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x40, 0x36, 0x06, 0x30, 0xE1,
  0xF8, 0x1F, 0x83, 0x1C, 0x60, 0xC6, 0x06, 0x40, 0x6C, 0x02, 0xC0, 0x2C,
  0x03, 0xC0, 0x34, 0x07, 0x60, 0x77, 0x0B, 0x3F, 0xA0, 0xC2, 0x00, 0x20,
  0x06, 0x00, 0x60, 0x04, 0x00, 0xC0, 0x18, 0x43, 0x87, 0xE0, 0x5F, 0x80,
  0x00, 0x00, 0x00, 0x37, 0xC0, 0x27, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x36, 0x66, 0x44, 0xC0, 0x00, 0x10, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x08, 0x00, 0xFE, 0xC7,
  0x03, 0x01, 0x01, 0x01, 0x01, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x30,
  0x30, 0x30, 0x00, 0x00, 0x00, 0x30, 0x30, 0x30, 0x03, 0xF8, 0x03, 0x83,
  0x81, 0x80, 0x30, 0xC0, 0x04, 0x20, 0x01, 0x98, 0x00, 0x24, 0x0F, 0x8F,
  0x0E, 0x63, 0xC2, 0x18, 0x61, 0x86, 0x18, 0x41, 0x86, 0x10, 0x61, 0x84,
  0x18, 0x61, 0x06, 0x18, 0x41, 0x86, 0x18, 0xE3, 0x86, 0x28, 0xB0, 0xFB,
  0xEC, 0x18, 0x21, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x40,
  0x3F, 0xE0, 0x03, 0xE0, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x34,
  0x00, 0x6C, 0x00, 0x98, 0x03, 0x10, 0x06, 0x30, 0x0C, 0x60, 0x10, 0xC0,
  0x60, 0x80, 0xC1, 0x81, 0x03, 0x07, 0xFE, 0x0C, 0x04, 0x18, 0x0C, 0x20,
  0x18, 0xC0, 0x11, 0x80, 0x33, 0x00, 0x6C, 0x00, 0xD8, 0x00, 0xC0, 0xFF,
  0x10, 0xFA, 0x03, 0x40, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x02, 0x80, 0xD0,
  0x73, 0xFC, 0x40, 0xE8, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x6F, 0xFD, 0xFE, 0x00, 0x0F, 0xF1, 0xC3, 0x30, 0x06, 0x00,
  0x60, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00,
  0x1E, 0x30, 0xFF, 0xFF, 0x04, 0x3C, 0x20, 0x31, 0x00, 0xC8, 0x03, 0x40,
  0x1A, 0x00, 0xD0, 0x02, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0A, 0x00, 0xD0, 0x06, 0x80, 0x34, 0x03, 0x20, 0x19, 0x01, 0x8F,
  0xF8, 0x7F, 0x00, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x3F, 0xF0, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x0F, 0xFF, 0xFC, 0xFF, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x1F, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x04, 0x00, 0x07, 0xF8, 0x70, 0x73, 0x80, 0x1C, 0x00,
  0x60, 0x01, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x3F, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x40, 0x05, 0x80,
  0x17, 0x00, 0x4E, 0x01, 0x1E, 0x1C, 0x1F, 0xF0, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0xFF,
  0xF8, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x38, 0x03, 0x80, 0x38, 0x03, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x33, 0xF0, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x0C, 0x3F, 0x9C, 0x80, 0x70, 0x1A, 0x06, 0x40,
  0xC8, 0x31, 0x0C, 0x21, 0x84, 0x60, 0x98, 0x13, 0x02, 0xE0, 0x76, 0x0C,
  0xC1, 0x0C, 0x21, 0x84, 0x18, 0x83, 0x10, 0x32, 0x03, 0x40, 0x68, 0x07,
  0x00, 0xC0, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10,
  0x0F, 0xFF, 0xFC, 0xC0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF4, 0x00, 0x5B,
  0x00, 0x6D, 0x80, 0x36, 0x40, 0x13, 0x30, 0x19, 0x98, 0x0C, 0xC4, 0x04,
  0x63, 0x06, 0x31, 0x83, 0x18, 0x41, 0x0C, 0x31, 0x86, 0x18, 0xC3, 0x0C,
  0x41, 0x83, 0x60, 0xC1, 0xB0, 0x60, 0xD0, 0x30, 0x38, 0x18, 0x1C, 0x0C,
  0x0C, 0x04, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0x40, 0x3B, 0x01, 0xC8, 0x0E,
  0x60, 0x71, 0x03, 0x8C, 0x1C, 0x20, 0xE1, 0x87, 0x04, 0x38, 0x31, 0xC0,
  0x8E, 0x06, 0x70, 0x13, 0x80, 0xDC, 0x02, 0xE0, 0x1F, 0x00, 0x78, 0x03,
  0xC0, 0x0C, 0x0F, 0xE0, 0x70, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xD8,
  0x01, 0xB0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0C, 0xC0, 0x19,
  0x80, 0x61, 0x80, 0xC1, 0xC7, 0x01, 0xFC, 0x00, 0xFE, 0x23, 0xE8, 0x1E,
  0x03, 0x80, 0xE0, 0x38, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x1B, 0xFC, 0xFE,
  0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x00,
  0x0F, 0xE0, 0x70, 0xE0, 0xC0, 0x63, 0x00, 0x66, 0x00, 0xD8, 0x01, 0xB0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0C, 0xC0, 0x19, 0x80, 0x61,
  0x80, 0xC1, 0xC7, 0x01, 0xFC, 0x00, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x60, 0xFE, 0x11, 0xF2, 0x07, 0x40, 0x68, 0x0D, 0x00, 0xA0,
  0x14, 0x06, 0x80, 0xD0, 0x1A, 0x0E, 0x7F, 0x08, 0x61, 0x0C, 0x20, 0xC4,
  0x18, 0x81, 0x90, 0x32, 0x03, 0x40, 0x68, 0x07, 0x00, 0xC0, 0x1F, 0xE7,
  0x0D, 0x80, 0x30, 0x04, 0x00, 0x80, 0x10, 0x03, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x18, 0x01, 0x00, 0x20, 0x04, 0x01,
  0x80, 0x7F, 0x1C, 0xFF, 0x00, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x1A, 0x00, 0xD8, 0x06, 0xE0, 0x63, 0xCF,
  0x0F, 0xE0, 0xC0, 0x0F, 0x00, 0x36, 0x00, 0x98, 0x06, 0x60, 0x18, 0x80,
  0x63, 0x01, 0x0C, 0x0C, 0x30, 0x30, 0x40, 0xC1, 0x86, 0x06, 0x18, 0x18,
  0x60, 0x21, 0x00, 0xCC, 0x03, 0x30, 0x04, 0xC0, 0x1A, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x00, 0x0C, 0x00, 0xC0, 0x18, 0x06, 0x80, 0x70, 0x0D, 0x80,
  0xE0, 0x13, 0x01, 0x40, 0x66, 0x02, 0x80, 0xC4, 0x0D, 0x81, 0x8C, 0x1B,
  0x02, 0x18, 0x32, 0x0C, 0x30, 0x44, 0x18, 0x20, 0x8C, 0x30, 0x43, 0x18,
  0x40, 0xC6, 0x31, 0x81, 0x88, 0x23, 0x03, 0x10, 0x46, 0x02, 0x60, 0xCC,
  0x06, 0xC1, 0x90, 0x0D, 0x81, 0x60, 0x1A, 0x02, 0xC0, 0x14, 0x05, 0x80,
  0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xC0, 0x18, 0x00, 0x60, 0x39, 0x01,
  0x8C, 0x08, 0x20, 0xC1, 0x84, 0x0C, 0x60, 0x33, 0x01, 0xB0, 0x05, 0x80,
  0x38, 0x00, 0xC0, 0x0E, 0x00, 0x58, 0x06, 0xC0, 0x32, 0x03, 0x18, 0x18,
  0x41, 0x83, 0x0C, 0x18, 0xC0, 0x66, 0x03, 0x60, 0x0C, 0xC0, 0x1A, 0x01,
  0x98, 0x0C, 0xC0, 0xC3, 0x06, 0x18, 0x20, 0x43, 0x03, 0x18, 0x19, 0x80,
  0x6C, 0x03, 0x40, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0xFF, 0xE0, 0x0C,
  0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x18, 0x02, 0x00, 0xC0, 0x10,
  0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x60,
  0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0xFF, 0xF8, 0x80, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0,
  0x60, 0x10, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x02, 0x01,
  0x80, 0xC0, 0x20, 0x18, 0x0C, 0xFC, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04,
  0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x07,
  0xFF, 0xC0, 0x06, 0x00, 0x38, 0x03, 0x40, 0x13, 0x01, 0x98, 0x0C, 0x60,
  0xC3, 0x06, 0x0C, 0x60, 0x63, 0x01, 0xB0, 0x0D, 0x80, 0x30, 0xFF, 0xF8,
  0xC1, 0x83, 0x04, 0x0C, 0x0F, 0x0F, 0xE2, 0x0C, 0x03, 0x00, 0xC0, 0x10,
  0x04, 0x0F, 0x3F, 0xDC, 0x14, 0x07, 0x01, 0xC0, 0xF0, 0x3C, 0x0D, 0x8D,
  0x3E, 0x40, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x70, 0xDF, 0xCF, 0x0C, 0xE0, 0x6C, 0x06, 0xC0, 0x2C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x02, 0xE0, 0x6E, 0x06, 0xD9,
  0xCC, 0xF8, 0x0F, 0x1F, 0xD8, 0x08, 0x0C, 0x06, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x0C, 0x06, 0x01, 0x80, 0xE1, 0x3F, 0x80, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xE3, 0x1F, 0xB3,
  0x0F, 0x60, 0x76, 0x03, 0x60, 0x34, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34,
  0x03, 0x40, 0x36, 0x03, 0x60, 0x36, 0x07, 0x38, 0xF1, 0xF9, 0x1E, 0x0F,
  0xC6, 0x1B, 0x03, 0xC0, 0xE0, 0x18, 0x07, 0xFF, 0xFF, 0xE0, 0x08, 0x02,
  0x00, 0xC0, 0x30, 0x06, 0x01, 0xC3, 0x1F, 0x80, 0x07, 0x07, 0xC6, 0x03,
  0x01, 0x00, 0x80, 0x40, 0x60, 0xFE, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80,
  0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x0F,
  0x01, 0xFB, 0x30, 0x76, 0x07, 0x60, 0x36, 0x03, 0x40, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0x40, 0x34, 0x03, 0x60, 0x36, 0x03, 0x60, 0x73, 0x9B, 0x1F,
  0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x60, 0xE7, 0xF8, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x38, 0xDF, 0xDE,
  0x1B, 0x81, 0x60, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFC, 0x08, 0xC6, 0x00, 0x00, 0x03, 0x18, 0xC6, 0x31, 0x8C, 0x63,
  0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0xF8, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC1, 0xB0, 0x4C, 0x33, 0x18,
  0xCC, 0x33, 0x0D, 0x83, 0xF0, 0xE4, 0x31, 0x8C, 0x33, 0x0C, 0xC1, 0xB0,
  0x6C, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0x0F, 0x37,
  0xE7, 0xEF, 0x1B, 0x1F, 0x83, 0x83, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C,
  0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03,
  0xC0, 0xC0, 0xF0, 0x30, 0x3C, 0x0C, 0x0F, 0x03, 0x03, 0xC0, 0xC0, 0xC0,
  0x07, 0x1B, 0xFB, 0xC3, 0x70, 0x2C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60,
  0x0F, 0x01, 0xFC, 0x30, 0x66, 0x06, 0x60, 0x36, 0x03, 0x40, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0x40, 0x34, 0x03, 0x60, 0x36, 0x02, 0x30, 0x63, 0x8C,
  0x1F, 0x80, 0x07, 0x0D, 0xFC, 0xF0, 0xCE, 0x06, 0xE0, 0x6C, 0x02, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x2E, 0x06, 0xE0,
  0x6D, 0x9C, 0xCF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0x0F, 0x01, 0xFB, 0x30, 0xF6, 0x07, 0x60, 0x36, 0x03, 0x40,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x60, 0x36, 0x07, 0x60,
  0x73, 0x8B, 0x1F, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00,
  0x30, 0x03, 0x0F, 0xBF, 0x47, 0x0E, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0x1E, 0x3F, 0xD8, 0x38, 0x0C, 0x06, 0x01,
  0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x30, 0x08, 0x04, 0x07, 0x87, 0x7E,
  0x00, 0x20, 0x41, 0x83, 0x0F, 0xEC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC0, 0xC9, 0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x0E, 0x81, 0xDC, 0xD9, 0xF3, 0xC0, 0x68, 0x0D, 0x81, 0xB0, 0x22, 0x0C,
  0x41, 0x8C, 0x21, 0x8C, 0x11, 0x83, 0x30, 0x64, 0x05, 0x80, 0xB0, 0x1C,
  0x03, 0x80, 0x30, 0xC0, 0xE0, 0x6C, 0x1C, 0x19, 0x82, 0x83, 0x30, 0x50,
  0x62, 0x1B, 0x08, 0x43, 0x61, 0x0C, 0x44, 0x61, 0x88, 0x8C, 0x33, 0x19,
  0x82, 0x63, 0x20, 0x68, 0x2C, 0x0D, 0x05, 0x81, 0xA0, 0xF0, 0x1C, 0x1C,
  0x03, 0x81, 0x80, 0x60, 0x30, 0xC0, 0xCC, 0x11, 0x86, 0x19, 0x83, 0x30,
  0x3C, 0x03, 0x80, 0x60, 0x0E, 0x03, 0xC0, 0xCC, 0x19, 0x86, 0x18, 0xC3,
  0x30, 0x36, 0x07, 0xC0, 0x36, 0x06, 0x60, 0x66, 0x06, 0x20, 0xC3, 0x0C,
  0x30, 0xC1, 0x08, 0x19, 0x81, 0x98, 0x09, 0x00, 0x90, 0x0F, 0x00, 0xF0,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01, 0x80,
  0xF0, 0x00, 0xFF, 0x01, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18,
  0x18, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0xFF, 0x07, 0x87, 0x03, 0x01,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x07, 0x07, 0x00,
  0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C,
  0x07, 0xC0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xE0,
  0x1C, 0x06, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x03, 0x01,
  0x80, 0x70, 0x1C, 0x38, 0x18, 0x0C, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x18, 0x7C, 0x38, 0x00, 0x30, 0x07, 0xE1, 0x87, 0xF8, 0x0C,
};

const GFXglyph NotoSans_Condensed_Light31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 3, 22, 7, 2, -22 },
  { 10, 7, 8, 11, 2, -22 },
  { 17, 14, 22, 16, 1, -22 },
  { 56, 12, 26, 14, 1, -24 },
  { 95, 19, 22, 21, 1, -22 },
  { 148, 15, 22, 16, 1, -22 },
  { 190, 2, 8, 6, 2, -22 },
  { 192, 7, 27, 9, 1, -22 },
  { 216, 6, 27, 9, 1, -22 },
  { 237, 11, 11, 13, 1, -24 },
  { 253, 12, 14, 14, 1, -18 },
  { 274, 4, 7, 6, 1, -3 },
  { 278, 7, 1, 9, 1, -9 },
  { 279, 3, 3, 7, 2, -3 },
  { 281, 9, 22, 11, 1, -22 },
  { 306, 12, 22, 14, 1, -22 },
  { 339, 7, 22, 14, 2, -22 },
  { 359, 12, 22, 14, 1, -22 },
  { 392, 12, 22, 14, 1, -22 },
  { 425, 13, 22, 14, 1, -22 },
  { 461, 11, 22, 14, 2, -22 },
  { 492, 11, 22, 14, 2, -22 },
  { 523, 12, 22, 14, 1, -22 },
  { 556, 12, 22, 14, 1, -22 },
  { 589, 12, 22, 14, 1, -22 },
  { 622, 3, 17, 7, 2, -17 },
  { 629, 4, 21, 7, 1, -17 },
  { 640, 12, 14, 14, 1, -18 },
  { 661, 12, 8, 14, 1, -15 },
  { 673, 12, 14, 14, 1, -18 },
  { 694, 8, 22, 10, 1, -22 },
  { 716, 18, 25, 22, 2, -22 },
  { 773, 15, 22, 15, 0, -22 },
  { 815, 11, 22, 16, 3, -22 },
  { 846, 12, 22, 15, 2, -22 },
  { 879, 13, 22, 17, 3, -22 },
  { 915, 9, 22, 14, 3, -22 },
  { 940, 9, 22, 13, 3, -22 },
  { 965, 14, 22, 18, 2, -22 },
  { 1004, 12, 22, 18, 3, -22 },
  { 1037, 6, 22, 8, 1, -22 },
  { 1054, 6, 28, 7, -2, -22 },
  { 1075, 11, 22, 14, 3, -22 },
  { 1106, 9, 22, 13, 3, -22 },
  { 1131, 17, 22, 23, 3, -22 },
  { 1178, 13, 22, 18, 3, -22 },
  { 1214, 15, 22, 19, 2, -22 },
  { 1256, 10, 22, 15, 3, -22 },
  { 1284, 15, 27, 19, 2, -22 },
  { 1335, 11, 22, 15, 3, -22 },
  { 1366, 11, 22, 14, 1, -22 },
  { 1397, 12, 22, 13, 0, -22 },
  { 1430, 13, 22, 18, 2, -22 },
  { 1466, 14, 22, 14, 0, -22 },
  { 1505, 23, 22, 23, 0, -22 },
  { 1569, 13, 22, 13, 0, -22 },
  { 1605, 13, 22, 13, 0, -22 },
  { 1641, 11, 22, 13, 1, -22 },
  { 1672, 7, 27, 10, 2, -22 },
  { 1696, 9, 22, 11, 1, -22 },
  { 1721, 6, 27, 10, 1, -22 },
  { 1742, 13, 12, 14, 1, -22 },
  { 1762, 13, 1, 13, 0, 3 },
  { 1764, 6, 5, 8, 1, -24 },
  { 1768, 10, 17, 13, 1, -17 },
  { 1790, 12, 24, 15, 2, -24 },
  { 1826, 9, 17, 12, 2, -17 },
  { 1846, 12, 24, 15, 1, -24 },
  { 1882, 10, 17, 14, 2, -17 },
  { 1904, 9, 24, 8, 0, -24 },
  { 1931, 12, 24, 15, 1, -17 },
  { 1967, 11, 24, 15, 2, -24 },
  { 2000, 2, 23, 6, 2, -23 },
  { 2006, 5, 30, 6, -1, -23 },
  { 2025, 10, 24, 12, 2, -24 },
  { 2055, 2, 24, 6, 2, -24 },
  { 2061, 18, 17, 22, 2, -17 },
  { 2100, 11, 17, 15, 2, -17 },
  { 2124, 12, 17, 15, 1, -17 },
  { 2150, 12, 24, 15, 2, -17 },
  { 2186, 12, 24, 15, 1, -17 },
  { 2222, 7, 17, 10, 2, -17 },
  { 2237, 9, 17, 11, 1, -17 },
  { 2257, 7, 20, 8, 1, -20 },
  { 2275, 11, 16, 15, 2, -16 },
  { 2297, 11, 16, 12, 0, -16 },
  { 2319, 19, 16, 19, 0, -16 },
  { 2357, 11, 16, 12, 1, -16 },
  { 2379, 12, 23, 12, 0, -16 },
  { 2414, 9, 16, 10, 1, -16 },
  { 2432, 9, 27, 11, 1, -22 },
  { 2463, 2, 31, 14, 6, -24 },
  { 2471, 9, 27, 11, 1, -22 },
  { 2502, 12, 4, 14, 1, -13 },
};

const GFXfont NotoSans_Condensed_Light31pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light31pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light31pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _NOTOSANS_CONDENSED_LIGHT31PT7B_H_
