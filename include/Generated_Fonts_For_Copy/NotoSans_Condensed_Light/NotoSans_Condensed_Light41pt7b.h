#ifndef _NOTOSANS_CONDENSED_LIGHT41PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT41PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light41pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xB6, 0xDB, 0x6D, 0xB4, 0x00, 0x0F, 0xFE,
  0xC3, 0xE1, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0x80,
  0x01, 0x83, 0x00, 0x20, 0x60, 0x0C, 0x08, 0x01, 0x83, 0x00, 0x30, 0x60,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x30, 0x7F, 0xFF, 0xEF, 0xFF, 0xFC,
  0x18, 0x10, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00,
  0x20, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x03, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0,
  0xC1, 0x80, 0x18, 0x30, 0x02, 0x06, 0x00, 0xC0, 0xC0, 0x18, 0x10, 0x03,
  0x06, 0x00, 0x60, 0xC0, 0x0C, 0x18, 0x01, 0x83, 0x00, 0x03, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0xFF, 0x83, 0xFF, 0xCE, 0x61, 0x38, 0xC0, 0x61, 0x80,
  0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0E, 0x30, 0x0E, 0x60, 0x0F,
  0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x0C, 0xE0, 0x18, 0xE0, 0x30,
  0xE0, 0x60, 0xC0, 0xC1, 0x81, 0x83, 0x03, 0x0E, 0x06, 0x1A, 0x0C, 0x77,
  0xDF, 0xCF, 0xFE, 0x00, 0xE0, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x1C,
  0x00, 0x00, 0x3E, 0x00, 0xE0, 0x63, 0x00, 0xC0, 0x61, 0x80, 0xC0, 0xC1,
  0x81, 0x80, 0xC1, 0x81, 0x80, 0xC1, 0x83, 0x00, 0xC1, 0x83, 0x00, 0xC0,
  0x83, 0x00, 0xC0, 0xC6, 0x00, 0xC0, 0x86, 0x00, 0xC1, 0x8C, 0x00, 0xC1,
  0x8C, 0x78, 0xC1, 0x8C, 0xFC, 0xC1, 0x99, 0xC6, 0x61, 0x99, 0x86, 0x73,
  0x31, 0x86, 0x3E, 0x33, 0x03, 0x1C, 0x33, 0x03, 0x00, 0x63, 0x03, 0x00,
  0x63, 0x03, 0x00, 0xC3, 0x03, 0x00, 0xC3, 0x03, 0x00, 0xC3, 0x03, 0x01,
  0x83, 0x03, 0x01, 0x81, 0x82, 0x03, 0x01, 0x86, 0x03, 0x01, 0x86, 0x03,
  0x00, 0xFC, 0x06, 0x00, 0x7C, 0x03, 0x80, 0x01, 0xFC, 0x00, 0x73, 0x80,
  0x1C, 0x18, 0x03, 0x03, 0x00, 0x60, 0x60, 0x0C, 0x0C, 0x01, 0x81, 0x80,
  0x30, 0x30, 0x03, 0x06, 0x00, 0x61, 0x80, 0x0E, 0x70, 0x00, 0xDC, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFC, 0x00, 0x39, 0x80, 0x0E, 0x38, 0x1B,
  0x83, 0x87, 0x60, 0x30, 0xCC, 0x03, 0x19, 0x80, 0x77, 0x30, 0x07, 0xC6,
  0x00, 0x78, 0xC0, 0x0E, 0x18, 0x01, 0xE3, 0x80, 0x7C, 0x38, 0x1C, 0xC3,
  0xFF, 0x1C, 0x3F, 0x81, 0xC0, 0xFF, 0xFF, 0xF0, 0x07, 0x0E, 0x0C, 0x1C,
  0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x60, 0x70,
  0x30, 0x38, 0x18, 0x18, 0x0C, 0x0E, 0x07, 0xE0, 0x30, 0x30, 0x18, 0x1C,
  0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x07, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0E,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0xC2, 0x0B, 0xE9, 0xE7, 0xFF, 0x41, 0xC0, 0x05, 0x80, 0x37, 0x01,
  0x8C, 0x0E, 0x18, 0x30, 0x70, 0x41, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x37, 0x77, 0x66,
  0xEC, 0xCC, 0xFF, 0xFF, 0xC0, 0x5F, 0xF0, 0x00, 0x38, 0x01, 0x80, 0x0C,
  0x00, 0xC0, 0x06, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x30, 0x03, 0x80, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x03, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x06, 0x00, 0x70, 0x03,
  0x00, 0x18, 0x01, 0xC0, 0x0C, 0x00, 0x00, 0x03, 0x00, 0x1F, 0xC0, 0x7B,
  0xC1, 0xC1, 0xC3, 0x01, 0x8E, 0x03, 0x98, 0x03, 0x30, 0x06, 0xE0, 0x0D,
  0xC0, 0x1B, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xB8, 0x03, 0x30, 0x06, 0x60, 0x0C, 0xE0, 0x30, 0xC0, 0x61, 0xC1, 0xC1,
  0xFF, 0x01, 0xFC, 0x00, 0x03, 0x83, 0xC3, 0xE3, 0xB7, 0x1F, 0x0D, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x07, 0x80, 0x7F, 0xC3, 0xE7, 0xC3, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x07, 0x00, 0x06, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00,
  0x60, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00,
  0x7F, 0xC3, 0xE3, 0xC6, 0x01, 0xC8, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00,
  0x06, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x1C,
  0x07, 0xE0, 0x0F, 0xF0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x74, 0x01, 0xCF, 0xFF, 0x0F, 0xFC, 0x00, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x30,
  0x03, 0x18, 0x01, 0x8C, 0x01, 0x86, 0x01, 0xC3, 0x00, 0xC1, 0x80, 0xE0,
  0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x18,
  0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x3F, 0xF8, 0x7F,
  0xF1, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x3C, 0x07, 0xFF, 0x0E, 0x1F, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x33, 0x01, 0xE7,
  0xFF, 0x87, 0xFC, 0x00, 0x00, 0xF0, 0x07, 0xF0, 0x3E, 0x20, 0xE0, 0x01,
  0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x07, 0x00, 0x0E, 0x7E, 0x19, 0xFF, 0x36, 0x0E, 0x78, 0x0E, 0xE0, 0x0D,
  0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB0,
  0x07, 0x60, 0x0E, 0xE0, 0x18, 0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x81, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x38, 0x00, 0x60, 0x00, 0xC0, 0x03,
  0x00, 0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00,
  0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x00, 0x03, 0x80, 0x3F, 0xE0,
  0xF1, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xB8, 0x03, 0x70, 0x06, 0x60,
  0x0C, 0xC0, 0x19, 0xC0, 0x71, 0xC1, 0xC1, 0xC7, 0x01, 0xFC, 0x01, 0xE0,
  0x07, 0xF0, 0x1C, 0x70, 0x60, 0x71, 0x80, 0x77, 0x00, 0x6C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x33, 0x80,
  0xE3, 0xFF, 0x83, 0xFC, 0x00, 0x03, 0x80, 0x3F, 0xC0, 0xF3, 0xC3, 0x81,
  0xC6, 0x01, 0x9C, 0x03, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1B,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xB0, 0x0F, 0x78,
  0x6E, 0x7F, 0xD8, 0x3E, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07, 0x07, 0xFC, 0x0F,
  0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0x7F, 0xC0, 0x39,
  0xCE, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xCE, 0x73,
  0x98, 0xCE, 0x63, 0x38, 0x00, 0x01, 0x00, 0x03, 0x00, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x78, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xF8, 0x80, 0x01, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x01, 0x00, 0x00, 0x0C,
  0x0F, 0xF8, 0xF3, 0xC8, 0x0E, 0x00, 0x60, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x18, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xF9, 0xF0, 0x01, 0xE0, 0x0E, 0x01, 0xC0, 0x03, 0x80, 0xC0, 0x00, 0xC0,
  0xC0, 0x00, 0x30, 0xE0, 0x00, 0x18, 0x60, 0x00, 0x06, 0x70, 0x1F, 0x83,
  0x30, 0x3F, 0xE1, 0x98, 0x38, 0x60, 0x6C, 0x18, 0x30, 0x3C, 0x1C, 0x18,
  0x1E, 0x0C, 0x0C, 0x0F, 0x06, 0x06, 0x07, 0x83, 0x03, 0x03, 0xC1, 0x81,
  0x81, 0xE0, 0xC0, 0xC0, 0xF0, 0x60, 0x60, 0x78, 0x30, 0x30, 0x6C, 0x18,
  0x38, 0x36, 0x06, 0x16, 0x19, 0x83, 0xBB, 0xB8, 0xC0, 0xF8, 0xF8, 0x60,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x70, 0x01, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0xD8, 0x00, 0x1B, 0x00, 0x03, 0x30, 0x00, 0xE6, 0x00, 0x18, 0xC0, 0x03,
  0x1C, 0x00, 0x61, 0x80, 0x18, 0x30, 0x03, 0x06, 0x00, 0x60, 0xE0, 0x1C,
  0x0C, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x03, 0xFF, 0xE0, 0x7F,
  0xFC, 0x0C, 0x01, 0xC3, 0x80, 0x18, 0x70, 0x03, 0x0C, 0x00, 0x71, 0x80,
  0x0E, 0x70, 0x00, 0xCC, 0x00, 0x19, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x06, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0,
  0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x78, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0x1C, 0xE0, 0x0E, 0xE0,
  0x06, 0xE0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x00,
  0x38, 0x01, 0xFF, 0xC1, 0xF3, 0xE1, 0xC0, 0x21, 0xC0, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x18, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x20, 0x7F,
  0xF0, 0x0F, 0xF8, 0xFF, 0xE0, 0x3F, 0xFE, 0x0E, 0x03, 0xC3, 0x80, 0x38,
  0xE0, 0x07, 0x38, 0x01, 0xCE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xB8,
  0x00, 0x6E, 0x00, 0x1B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x6E, 0x00, 0x1B, 0x80, 0x06,
  0xE0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x33, 0x80, 0x1C, 0xE0, 0x0E, 0x38,
  0x07, 0x8E, 0x07, 0xC3, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x7F, 0xFB, 0xFF, 0xDC, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xDF, 0xFE, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x1F, 0xFC, 0x07, 0xE7, 0xE0, 0xF0, 0x06, 0x1C, 0x00, 0x01, 0x80, 0x00,
  0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00,
  0x06, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x01,
  0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60,
  0x00, 0x76, 0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x07, 0x38, 0x00, 0x71,
  0x80, 0x07, 0x1E, 0x00, 0x70, 0xF0, 0x07, 0x07, 0xFF, 0xF0, 0x1F, 0xFC,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x18, 0xFE, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE7, 0xFF, 0xE0, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x06, 0x0E, 0xFE, 0xFC, 0x20, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x1C, 0xE0,
  0x18, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0xE0, 0xE0, 0xC0, 0xE1, 0xC0, 0xE3,
  0x80, 0xE3, 0x00, 0xE7, 0x00, 0xEE, 0x00, 0xEF, 0x00, 0xFF, 0x00, 0xF3,
  0x80, 0xF1, 0x80, 0xE1, 0xC0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0,
  0x70, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0,
  0x06, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xD8, 0x00, 0x1F, 0xF8, 0x00, 0x1B, 0xFC, 0x00, 0x1B, 0xEC, 0x00, 0x3B,
  0xEC, 0x00, 0x33, 0xEE, 0x00, 0x33, 0xE6, 0x00, 0x73, 0xE6, 0x00, 0x63,
  0xE7, 0x00, 0x63, 0xE3, 0x00, 0xE3, 0xE3, 0x00, 0xC3, 0xE3, 0x80, 0xC3,
  0xE1, 0x80, 0xC3, 0xE1, 0x81, 0x83, 0xE1, 0x81, 0x83, 0xE0, 0xC1, 0x83,
  0xE0, 0xC3, 0x03, 0xE0, 0xC3, 0x03, 0xE0, 0x63, 0x03, 0xE0, 0x66, 0x03,
  0xE0, 0x66, 0x03, 0xE0, 0x36, 0x03, 0xE0, 0x3C, 0x03, 0xE0, 0x3C, 0x03,
  0xE0, 0x1C, 0x03, 0xE0, 0x18, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0x60, 0x03, 0xD8, 0x00, 0xFB, 0x00, 0x3E, 0xC0, 0x0F, 0x98, 0x03,
  0xE6, 0x00, 0xF8, 0xC0, 0x3E, 0x30, 0x0F, 0x86, 0x03, 0xE1, 0x80, 0xF8,
  0x30, 0x3E, 0x0E, 0x0F, 0x81, 0x83, 0xE0, 0x70, 0xF8, 0x0C, 0x3E, 0x03,
  0x8F, 0x80, 0x63, 0xE0, 0x1C, 0xF8, 0x03, 0x3E, 0x00, 0xEF, 0x80, 0x1B,
  0xE0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x0F, 0xDF, 0x01, 0xE0, 0x38, 0x1C, 0x01,
  0xC3, 0x80, 0x0E, 0x30, 0x00, 0x67, 0x00, 0x06, 0x60, 0x00, 0x76, 0x00,
  0x07, 0x60, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36,
  0x00, 0x03, 0x60, 0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06,
  0x30, 0x00, 0xE3, 0x80, 0x0C, 0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0xFF,
  0x00, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0x80, 0xE7, 0x00, 0xEE, 0x00,
  0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x37,
  0x00, 0x6E, 0x01, 0xDC, 0x03, 0x38, 0x1E, 0x7F, 0xF8, 0xFF, 0xC1, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0xE0, 0x0F, 0xDF, 0x01, 0xE0, 0x38, 0x1C, 0x01, 0xC3, 0x80,
  0x0E, 0x30, 0x00, 0xE7, 0x00, 0x06, 0x60, 0x00, 0x76, 0x00, 0x07, 0x60,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x36, 0x00, 0x03,
  0x60, 0x00, 0x36, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x06, 0x30, 0x00,
  0xE3, 0x80, 0x0C, 0x1C, 0x01, 0xC0, 0xE0, 0x38, 0x07, 0xFF, 0x00, 0x3F,
  0xE0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x18, 0x00, 0x01, 0xC0, 0xFF, 0xE0, 0xFF, 0xF0, 0xE0,
  0x38, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x38, 0xFF,
  0xF0, 0xFF, 0xC0, 0xE1, 0xC0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0,
  0x70, 0xE0, 0x30, 0xE0, 0x38, 0xE0, 0x18, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0,
  0x0E, 0xE0, 0x06, 0xE0, 0x07, 0x03, 0xC0, 0x7F, 0xF3, 0xEF, 0xDC, 0x01,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01,
  0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x70, 0x01, 0xB0, 0x1E, 0xFF, 0xF3, 0xFF, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x06, 0xC0, 0x07, 0x60,
  0x03, 0x38, 0x03, 0x8E, 0x03, 0x83, 0xFF, 0x80, 0xFF, 0x80, 0xE0, 0x00,
  0xFC, 0x00, 0x19, 0x80, 0x03, 0x30, 0x00, 0xE7, 0x00, 0x18, 0x60, 0x03,
  0x0C, 0x00, 0x61, 0x80, 0x1C, 0x38, 0x03, 0x03, 0x00, 0x60, 0x60, 0x1C,
  0x0E, 0x03, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x03, 0x03, 0x80, 0x70, 0x60,
  0x06, 0x0C, 0x00, 0xC1, 0x80, 0x18, 0x70, 0x03, 0x8C, 0x00, 0x31, 0x80,
  0x06, 0x70, 0x00, 0xCC, 0x00, 0x0D, 0x80, 0x01, 0xB0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x0D, 0x80,
  0x0E, 0x00, 0x76, 0x00, 0x38, 0x01, 0xDC, 0x01, 0xE0, 0x06, 0x70, 0x07,
  0x80, 0x18, 0xC0, 0x1B, 0x00, 0x63, 0x00, 0x6C, 0x03, 0x8C, 0x03, 0xB0,
  0x0E, 0x38, 0x0C, 0xC0, 0x30, 0x60, 0x33, 0x80, 0xC1, 0x80, 0xC6, 0x07,
  0x06, 0x03, 0x18, 0x1C, 0x1C, 0x18, 0x60, 0x60, 0x30, 0x61, 0x81, 0x80,
  0xC1, 0x83, 0x06, 0x03, 0x06, 0x0C, 0x38, 0x0E, 0x38, 0x30, 0xC0, 0x38,
  0xC0, 0xC3, 0x00, 0x63, 0x01, 0x8C, 0x01, 0x8C, 0x06, 0x70, 0x06, 0x70,
  0x19, 0xC0, 0x1D, 0x80, 0x66, 0x00, 0x36, 0x01, 0x98, 0x00, 0xD8, 0x03,
  0x60, 0x03, 0x60, 0x0F, 0x80, 0x0D, 0x80, 0x3C, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x07, 0x00, 0x70, 0x03, 0x98, 0x03,
  0x8E, 0x01, 0x83, 0x00, 0xC1, 0xC0, 0xC0, 0x60, 0x60, 0x38, 0x70, 0x0C,
  0x30, 0x06, 0x38, 0x01, 0x98, 0x00, 0xDC, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0x60, 0x01, 0x98, 0x01, 0xCC,
  0x00, 0xC7, 0x00, 0xE1, 0x80, 0x60, 0xE0, 0x70, 0x30, 0x30, 0x1C, 0x38,
  0x06, 0x18, 0x03, 0x1C, 0x01, 0xCC, 0x00, 0x6E, 0x00, 0x38, 0xE0, 0x03,
  0xB0, 0x01, 0x9C, 0x01, 0xC6, 0x00, 0xC3, 0x00, 0xE1, 0xC0, 0x60, 0x60,
  0x30, 0x30, 0x38, 0x0C, 0x18, 0x06, 0x0C, 0x03, 0x8C, 0x00, 0xC6, 0x00,
  0x67, 0x00, 0x1B, 0x00, 0x0D, 0x80, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x7F, 0xFE, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00,
  0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18,
  0x00, 0x30, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0,
  0x01, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F, 0xFF, 0xF0,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x03,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0x60,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xFF, 0xFF, 0xF0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF8, 0x00,
  0x6C, 0x00, 0x73, 0x00, 0x31, 0x80, 0x38, 0x60, 0x18, 0x30, 0x1C, 0x1C,
  0x0C, 0x06, 0x0E, 0x03, 0x86, 0x00, 0xC7, 0x00, 0x73, 0x00, 0x1B, 0x80,
  0x0F, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0xE0, 0xC0, 0xC1, 0xC1, 0xC1, 0xC0,
  0x1F, 0xC3, 0xFF, 0x08, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x1F, 0xC7, 0xFE, 0xF0, 0x36, 0x01, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xC0, 0xB7, 0xBD, 0x9F, 0x8C,
  0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x8F, 0xC3, 0x3F, 0xC6, 0xC1, 0xCF, 0x01,
  0xDC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x37, 0x80, 0xED, 0x83, 0x99, 0xFE, 0x31, 0xF8, 0x00, 0x07,
  0xF1, 0xFF, 0x3C, 0x13, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60,
  0x06, 0x00, 0x70, 0x03, 0x81, 0x1F, 0xF0, 0xFF, 0x00, 0x06, 0x00, 0x0C,
  0x00, 0x18, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00,
  0x06, 0x1F, 0x8C, 0x7F, 0x99, 0xC1, 0xB7, 0x01, 0xEC, 0x01, 0xD8, 0x03,
  0xF0, 0x07, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x3B, 0x80,
  0xF3, 0x83, 0x67, 0xFE, 0xC3, 0xF1, 0x80, 0x0F, 0xC0, 0x7F, 0xC3, 0x83,
  0x8C, 0x06, 0x60, 0x1D, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0x80, 0x07, 0x00, 0x0E, 0x03, 0x1F, 0xFC, 0x3F, 0xE0, 0x03, 0xF0,
  0x7E, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x03,
  0xFC, 0xFF, 0xC0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xC6, 0x3F,
  0xCC, 0xE0, 0xDB, 0x80, 0xF6, 0x00, 0xEC, 0x01, 0xF8, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xF0, 0x03, 0x60, 0x0E, 0xC0, 0x1D, 0xC0, 0x79, 0xC1, 0xB3, 0xFE,
  0x61, 0xF8, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x64, 0x01, 0xCE, 0x0F, 0x1F, 0xFC, 0x07, 0xE0, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x1F, 0x8C, 0xFF, 0x36, 0x0E, 0xF0, 0x1B, 0x80, 0x7E, 0x01, 0xF8,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xC0, 0xDF, 0xA0, 0x00, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0x80, 0x0C, 0x1C, 0x38, 0x20, 0x00, 0x00, 0x00, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xD3, 0xBE, 0x78, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x01, 0xF0, 0x1D, 0x80, 0xCC, 0x0C,
  0x60, 0xE3, 0x06, 0x18, 0x60, 0xC7, 0x06, 0x70, 0x33, 0x81, 0xBC, 0x0F,
  0x30, 0x71, 0x83, 0x86, 0x18, 0x30, 0xC0, 0xC6, 0x06, 0x30, 0x19, 0x80,
  0xEC, 0x03, 0x60, 0x1F, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xC7, 0xC1, 0xF8, 0xCF, 0xE3, 0xFC, 0xD8, 0x76, 0x0E, 0xF0,
  0x34, 0x06, 0xE0, 0x3C, 0x06, 0xE0, 0x18, 0x07, 0xE0, 0x18, 0x07, 0xC0,
  0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0,
  0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0,
  0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0,
  0x18, 0x07, 0xC0, 0x18, 0x07, 0xC0, 0x18, 0x07, 0xC7, 0xE3, 0x3F, 0xCD,
  0x83, 0xBC, 0x06, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x30, 0x0F,
  0xE0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xE6, 0x00, 0xCC, 0x01, 0xF8, 0x01,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xF0, 0x03, 0x60, 0x0E, 0xC0, 0x19, 0xC0, 0x31, 0xC0,
  0xC1, 0xFF, 0x81, 0xFC, 0x00, 0xC7, 0xE1, 0x9F, 0xE3, 0x60, 0xE6, 0x80,
  0xEE, 0x00, 0xDC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1B, 0xC0, 0x76, 0xC1, 0xCC, 0xFF, 0x18, 0xFC, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x0F, 0xC6, 0x3F, 0xCC, 0xE0, 0xDB, 0x80,
  0xF6, 0x00, 0xEC, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x07, 0xE0,
  0x0E, 0xC0, 0x1D, 0xC0, 0x79, 0xC1, 0xB3, 0xFE, 0x61, 0xF8, 0xC0, 0x01,
  0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x60,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0xC7, 0xF3, 0xED, 0x83, 0x40, 0xF0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0xC7, 0xFE,
  0xE0, 0x2C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x68, 0x0E, 0xFF, 0xCF, 0xF8, 0x10, 0x08, 0x0C, 0x06, 0x03, 0x03,
  0xFF, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x0F, 0xC3,
  0xE0, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x02, 0xDC, 0x1B,
  0x7F, 0xCC, 0xFE, 0x30, 0xE0, 0x06, 0xC0, 0x1D, 0x80, 0x3B, 0x00, 0x67,
  0x00, 0xC6, 0x03, 0x8C, 0x06, 0x18, 0x0C, 0x18, 0x18, 0x30, 0x60, 0x60,
  0xC0, 0xE1, 0x80, 0xC7, 0x01, 0x8C, 0x03, 0x18, 0x03, 0x30, 0x06, 0xC0,
  0x0D, 0x80, 0x1B, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x1C,
  0x03, 0xB0, 0x0E, 0x01, 0x98, 0x07, 0x00, 0xCC, 0x03, 0xC0, 0x67, 0x03,
  0x60, 0x71, 0x81, 0xB0, 0x30, 0xC0, 0xD8, 0x18, 0x60, 0x66, 0x0C, 0x38,
  0x63, 0x06, 0x0C, 0x31, 0x86, 0x06, 0x18, 0xC3, 0x03, 0x0C, 0x31, 0x81,
  0xCC, 0x18, 0xC0, 0x66, 0x0C, 0xC0, 0x33, 0x06, 0x60, 0x19, 0x83, 0xB0,
  0x0D, 0x80, 0xD8, 0x03, 0xC0, 0x6C, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0x00, 0x38, 0x03, 0x80, 0xE0, 0x1D, 0x80, 0x67, 0x03,
  0x8C, 0x0C, 0x38, 0x70, 0x61, 0x81, 0xCE, 0x03, 0x30, 0x0F, 0xC0, 0x1E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x3F, 0x00, 0xCC, 0x07, 0x18, 0x18,
  0x60, 0xE0, 0xC3, 0x03, 0x18, 0x06, 0xE0, 0x1F, 0x00, 0x30, 0xE0, 0x06,
  0xC0, 0x0D, 0x80, 0x3B, 0x80, 0x63, 0x00, 0xC6, 0x01, 0x8E, 0x07, 0x0C,
  0x0C, 0x18, 0x18, 0x30, 0x70, 0x70, 0xC0, 0x61, 0x80, 0xC3, 0x01, 0xCE,
  0x01, 0x98, 0x03, 0x30, 0x06, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0x30, 0x00, 0x60, 0x01, 0xC0, 0x03, 0x00, 0x06, 0x00, 0x1C,
  0x00, 0x30, 0x00, 0xE0, 0x13, 0x80, 0x3F, 0x00, 0x78, 0x00, 0x7F, 0xE7,
  0xFE, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x00,
  0x70, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x30, 0x03,
  0x00, 0x70, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0xFC, 0x18, 0x07,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xE0, 0x78, 0x1C, 0x03, 0xE0, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x06, 0x00, 0xF8, 0x0F, 0x80, 0x10, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x1F, 0x00, 0x70,
  0x06, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x30, 0x03, 0xC0, 0x3C, 0x0F, 0x83, 0x80,
  0x60, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x60, 0x1C, 0x0F, 0x03, 0xC0, 0x40, 0x00, 0x38, 0x01,
  0xFE, 0x07, 0x1F, 0x1C, 0x0F, 0xF8, 0x03, 0x80,
};

const GFXglyph NotoSans_Condensed_Light41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 9, 10, 14, 3, -29 },
  { 24, 19, 29, 21, 1, -29 },
  { 93, 15, 33, 19, 2, -31 },
  { 155, 24, 30, 28, 2, -30 },
  { 245, 19, 30, 21, 2, -30 },
  { 317, 2, 10, 8, 3, -29 },
  { 320, 8, 35, 11, 2, -29 },
  { 355, 8, 35, 11, 1, -29 },
  { 390, 14, 14, 17, 2, -31 },
  { 415, 16, 19, 19, 1, -24 },
  { 453, 4, 10, 9, 2, -5 },
  { 458, 9, 2, 12, 1, -12 },
  { 461, 3, 4, 9, 3, -4 },
  { 463, 13, 29, 14, 1, -29 },
  { 511, 15, 30, 19, 2, -30 },
  { 568, 9, 29, 19, 3, -29 },
  { 601, 15, 30, 19, 2, -30 },
  { 658, 15, 30, 19, 2, -30 },
  { 715, 17, 29, 19, 1, -29 },
  { 777, 15, 29, 19, 2, -29 },
  { 832, 15, 30, 19, 2, -30 },
  { 889, 15, 29, 19, 2, -29 },
  { 944, 15, 30, 19, 2, -30 },
  { 1001, 15, 30, 19, 2, -30 },
  { 1058, 3, 22, 9, 3, -22 },
  { 1067, 5, 27, 9, 1, -22 },
  { 1084, 16, 18, 19, 1, -24 },
  { 1120, 15, 11, 19, 2, -20 },
  { 1141, 15, 18, 19, 2, -24 },
  { 1175, 12, 30, 14, 1, -30 },
  { 1220, 25, 33, 29, 2, -29 },
  { 1324, 19, 29, 19, 0, -29 },
  { 1393, 16, 29, 21, 3, -29 },
  { 1451, 17, 30, 20, 2, -30 },
  { 1515, 18, 29, 23, 3, -29 },
  { 1581, 13, 29, 18, 3, -29 },
  { 1629, 13, 29, 17, 3, -29 },
  { 1677, 20, 30, 24, 2, -30 },
  { 1752, 17, 29, 24, 3, -29 },
  { 1814, 7, 29, 11, 2, -29 },
  { 1840, 8, 37, 9, -2, -29 },
  { 1877, 16, 29, 19, 3, -29 },
  { 1935, 13, 29, 17, 3, -29 },
  { 1983, 24, 29, 30, 3, -29 },
  { 2070, 18, 29, 24, 3, -29 },
  { 2136, 20, 30, 25, 2, -30 },
  { 2211, 15, 29, 19, 3, -29 },
  { 2266, 20, 37, 25, 2, -30 },
  { 2359, 16, 29, 20, 3, -29 },
  { 2417, 14, 30, 18, 2, -30 },
  { 2470, 16, 29, 17, 0, -29 },
  { 2528, 17, 29, 23, 3, -29 },
  { 2590, 19, 29, 19, 0, -29 },
  { 2659, 30, 29, 31, 0, -29 },
  { 2768, 17, 29, 17, 0, -29 },
  { 2830, 17, 29, 17, 0, -29 },
  { 2892, 15, 29, 17, 1, -29 },
  { 2947, 9, 36, 13, 3, -29 },
  { 2988, 13, 29, 14, 1, -29 },
  { 3036, 9, 36, 13, 1, -29 },
  { 3077, 17, 16, 19, 1, -29 },
  { 3111, 17, 1, 17, 0, 4 },
  { 3114, 7, 6, 10, 2, -31 },
  { 3120, 13, 22, 18, 2, -22 },
  { 3156, 15, 31, 20, 3, -31 },
  { 3215, 12, 22, 15, 2, -22 },
  { 3248, 15, 31, 20, 2, -31 },
  { 3307, 14, 22, 18, 2, -22 },
  { 3346, 12, 31, 10, 0, -31 },
  { 3393, 15, 32, 20, 2, -22 },
  { 3453, 14, 31, 20, 3, -31 },
  { 3508, 3, 30, 8, 3, -30 },
  { 3520, 7, 40, 8, -1, -30 },
  { 3555, 13, 31, 16, 3, -31 },
  { 3606, 2, 31, 8, 3, -31 },
  { 3614, 24, 22, 30, 3, -22 },
  { 3680, 14, 22, 20, 3, -22 },
  { 3719, 15, 22, 19, 2, -22 },
  { 3761, 15, 32, 20, 3, -22 },
  { 3821, 15, 32, 20, 2, -22 },
  { 3881, 10, 22, 13, 3, -22 },
  { 3909, 12, 22, 15, 2, -22 },
  { 3942, 9, 27, 11, 1, -27 },
  { 3973, 14, 22, 20, 3, -22 },
  { 4012, 15, 22, 15, 0, -22 },
  { 4054, 25, 22, 25, 0, -22 },
  { 4123, 14, 22, 16, 1, -22 },
  { 4162, 15, 32, 16, 0, -22 },
  { 4222, 12, 22, 14, 1, -22 },
  { 4255, 11, 36, 15, 2, -29 },
  { 4305, 2, 41, 18, 8, -31 },
  { 4316, 11, 36, 15, 2, -29 },
  { 4366, 15, 5, 19, 2, -17 },
};

const GFXfont NotoSans_Condensed_Light41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light41pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_CONDENSED_LIGHT41PT7B_H_
