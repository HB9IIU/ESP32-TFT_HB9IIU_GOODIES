#ifndef _NOTOSANS_CONDENSED_LIGHT59PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFB, 0xC8, 0xE0, 0x7F, 0x03, 0xF8, 0x1D, 0xC0, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D, 0xC0, 0xEE,
  0x07, 0x70, 0x3B, 0x80, 0xC0, 0x00, 0x38, 0x06, 0x00, 0x07, 0x01, 0xC0,
  0x00, 0xE0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0,
  0x18, 0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00,
  0x0E, 0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0E, 0x03, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x07, 0x01, 0xC0, 0x00,
  0xE0, 0x38, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0xE0, 0x1C,
  0x00, 0x1C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E,
  0x03, 0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0E, 0x03, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x18, 0x07, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x60, 0x1C, 0x00,
  0x1C, 0x03, 0x00, 0x03, 0x80, 0x60, 0x00, 0x70, 0x1C, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0x80, 0x70, 0x00, 0x30, 0x0E, 0x00, 0x06, 0x01, 0xC0, 0x01,
  0xC0, 0x30, 0x00, 0x00, 0x60, 0x00, 0x03, 0x00, 0x00, 0x18, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0x7F, 0xFF, 0xC7, 0xCC, 0x7C,
  0x78, 0x60, 0x23, 0x83, 0x00, 0x38, 0x18, 0x01, 0xC0, 0xC0, 0x0E, 0x06,
  0x00, 0x70, 0x30, 0x03, 0x81, 0x80, 0x1C, 0x0C, 0x00, 0xE0, 0x60, 0x07,
  0x03, 0x00, 0x1C, 0x18, 0x00, 0xF0, 0xC0, 0x03, 0xE6, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x19, 0xF8, 0x00, 0xC3, 0xC0, 0x06, 0x0F, 0x00, 0x30, 0x3C, 0x01, 0x80,
  0xE0, 0x0C, 0x07, 0x00, 0x60, 0x38, 0x03, 0x01, 0xC0, 0x18, 0x0E, 0x00,
  0xC0, 0x70, 0x06, 0x07, 0x80, 0x30, 0x3A, 0x01, 0x83, 0xDF, 0x0C, 0x7C,
  0xFF, 0xFF, 0xC3, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x06,
  0x00, 0x00, 0x30, 0x00, 0x01, 0x80, 0x00, 0x0C, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x38, 0x03, 0xFE, 0x00, 0x1C, 0x00, 0xE1, 0xC0,
  0x07, 0x00, 0x70, 0x70, 0x01, 0x80, 0x18, 0x0E, 0x00, 0xE0, 0x0E, 0x03,
  0x80, 0x38, 0x03, 0x80, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x07, 0x00, 0x38,
  0x06, 0x01, 0x80, 0x0E, 0x01, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x38, 0x00,
  0xC0, 0x1C, 0x1C, 0x00, 0x30, 0x07, 0x07, 0x00, 0x0C, 0x01, 0xC1, 0x80,
  0x03, 0x80, 0x70, 0xE0, 0x00, 0xE0, 0x18, 0x38, 0x00, 0x38, 0x06, 0x1C,
  0x1E, 0x0E, 0x03, 0x87, 0x0F, 0xE3, 0x80, 0xE3, 0x87, 0xFC, 0xE0, 0x38,
  0xE3, 0x87, 0x1C, 0x0E, 0x38, 0xC0, 0xE7, 0x07, 0x1C, 0x70, 0x38, 0xE3,
  0xC7, 0x1C, 0x07, 0x3F, 0xE3, 0x87, 0x01, 0xC7, 0xF0, 0xE1, 0x80, 0x70,
  0x70, 0x38, 0x60, 0x1C, 0x00, 0x1C, 0x38, 0x07, 0x00, 0x07, 0x0E, 0x01,
  0xC0, 0x03, 0x83, 0x80, 0x70, 0x00, 0xE0, 0xE0, 0x1C, 0x00, 0x38, 0x38,
  0x07, 0x00, 0x1C, 0x0E, 0x01, 0xC0, 0x07, 0x03, 0x80, 0x70, 0x03, 0x80,
  0x60, 0x1C, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x38, 0x07, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x60, 0x07, 0x00, 0x70, 0x38, 0x03, 0x80, 0x0E, 0x0E, 0x00,
  0xE0, 0x03, 0xC7, 0x00, 0x30, 0x00, 0x7F, 0xC0, 0x1C, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x78, 0x78, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0x1C,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0xE0, 0x1E, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01,
  0xC0, 0x00, 0xF0, 0x1C, 0x00, 0x07, 0x03, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x03, 0x87, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xB8, 0x00,
  0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x1E, 0x01, 0xE3, 0xC0, 0xF0, 0x1C, 0x38,
  0x07, 0x01, 0xC7, 0x80, 0x78, 0x1C, 0x70, 0x03, 0xC1, 0xC7, 0x00, 0x1C,
  0x38, 0xF0, 0x01, 0xE3, 0x8F, 0x00, 0x0F, 0x78, 0xF0, 0x00, 0x7F, 0x0F,
  0x00, 0x03, 0xF0, 0xF0, 0x00, 0x3E, 0x07, 0x00, 0x01, 0xE0, 0x70, 0x00,
  0x3E, 0x07, 0x80, 0x07, 0xF0, 0x38, 0x00, 0xF7, 0x83, 0xE0, 0x1E, 0x3C,
  0x1F, 0x9F, 0xC1, 0xC0, 0xFF, 0xF8, 0x1E, 0x07, 0xFE, 0x00, 0xF0, 0x06,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x38, 0x0E,
  0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x1C,
  0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xC0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0x80, 0xF0, 0x07, 0x00, 0x38, 0x03,
  0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0,
  0x1E, 0x01, 0xC0, 0x1C, 0x03, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x20, 0x38, 0x0F, 0x87, 0x0F, 0xFE, 0xEF, 0xEF, 0xFF, 0xF8,
  0x1F, 0xE0, 0x00, 0xF8, 0x00, 0x3B, 0x00, 0x07, 0x70, 0x01, 0xC7, 0x00,
  0x70, 0xF0, 0x1E, 0x0F, 0x03, 0x80, 0xE0, 0xF0, 0x1E, 0x04, 0x01, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x3C, 0x70,
  0xE3, 0xC7, 0x8E, 0x1C, 0x38, 0xE1, 0xC3, 0x86, 0x1C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7, 0xFF, 0xFF, 0x10, 0x00, 0x01, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x1F, 0x1F, 0x01,
  0xE0, 0x3C, 0x0E, 0x00, 0xF0, 0xF0, 0x03, 0x87, 0x00, 0x1C, 0x78, 0x00,
  0xF3, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x01, 0xE3,
  0x80, 0x0E, 0x1E, 0x00, 0xF0, 0x70, 0x07, 0x03, 0xE0, 0x78, 0x0F, 0xDF,
  0x80, 0x3F, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x00, 0xF0, 0x1F,
  0x03, 0xF0, 0x7F, 0x0F, 0x71, 0xE7, 0x3C, 0x7F, 0x87, 0xF0, 0x76, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x78, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xC3, 0xF0, 0x38,
  0x01, 0xE0, 0xC0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFC, 0x1F, 0xC1, 0xF8, 0xF8, 0x01,
  0xE1, 0x80, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE8, 0x00, 0x0F, 0x38, 0x00,
  0x78, 0xFE, 0x0F, 0xE3, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x37, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x19, 0xC0, 0x00, 0x1C,
  0xE0, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x1C, 0x00, 0x07,
  0x0E, 0x00, 0x07, 0x07, 0x00, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x1C, 0x00,
  0xF0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x38, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x1C,
  0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xFF, 0xF0, 0x1F,
  0xFF, 0xE0, 0xFC, 0x3F, 0x82, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00,
  0x0E, 0x40, 0x00, 0xF3, 0x80, 0x1F, 0x1F, 0xC7, 0xF0, 0xFF, 0xFF, 0x01,
  0xFF, 0xE0, 0x00, 0x60, 0x00, 0x00, 0x07, 0x80, 0x03, 0xFF, 0x00, 0x7F,
  0xF8, 0x07, 0xE0, 0xC0, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x87, 0xF0, 0x38, 0xFF, 0xE1, 0xCF, 0xFF, 0x8E, 0xF0, 0x1E,
  0x76, 0x00, 0x7B, 0xE0, 0x01, 0xDF, 0x00, 0x0E, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00,
  0x0E, 0xF0, 0x00, 0xF3, 0x80, 0x07, 0x1E, 0x00, 0x38, 0x70, 0x03, 0xC3,
  0xC0, 0x3C, 0x0F, 0x87, 0xC0, 0x3F, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7C, 0x1F, 0x01, 0xE0, 0x0F, 0x07,
  0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x00, 0x78, 0xE0, 0x00, 0xF1, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00,
  0x07, 0x0F, 0x00, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x07,
  0x80, 0x0F, 0x1E, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0xE0, 0x03, 0xC3, 0xE0, 0x0F, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0xF0, 0x01, 0xE1, 0xC0, 0x01, 0xC7, 0x80, 0x03, 0xCE, 0x00, 0x03, 0x9C,
  0x00, 0x07, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCF, 0x00, 0x07, 0x8F, 0x00,
  0x1E, 0x1F, 0x00, 0x78, 0x1F, 0x83, 0xF0, 0x1F, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xC0,
  0x3E, 0x1F, 0x03, 0xC0, 0x3C, 0x3C, 0x00, 0xE1, 0xC0, 0x07, 0x9E, 0x00,
  0x1C, 0xF0, 0x00, 0xF7, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xB8,
  0x00, 0x7D, 0xE0, 0x06, 0xE7, 0xC0, 0xE7, 0x1F, 0xFF, 0x38, 0x7F, 0xF3,
  0xC0, 0xFE, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x30, 0xFE, 0x01, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x0C, 0x00, 0x00,
  0x67, 0xBF, 0xFF, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFE, 0x1C, 0x7C, 0xF9, 0xF3,
  0xE3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0xF1, 0xC7, 0x8F, 0x1C,
  0x38, 0x71, 0xE3, 0x87, 0x0E, 0x38, 0x70, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x04, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x00, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x1F,
  0xFC, 0x3F, 0xFF, 0x1F, 0x0F, 0xC6, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x70, 0x0E, 0x00, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0x00,
  0x1C, 0x38, 0x01, 0xFF, 0x80, 0xE3, 0x80, 0x3F, 0xF8, 0x0E, 0x70, 0x07,
  0x83, 0x80, 0xE7, 0x00, 0xE0, 0x38, 0x0E, 0x70, 0x1E, 0x03, 0x80, 0x67,
  0x01, 0xC0, 0x38, 0x07, 0x60, 0x1C, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x38,
  0x07, 0xE0, 0x38, 0x03, 0x80, 0x7E, 0x03, 0x80, 0x38, 0x07, 0xE0, 0x38,
  0x03, 0x80, 0x7E, 0x03, 0x80, 0x38, 0x07, 0xE0, 0x38, 0x03, 0x80, 0x7E,
  0x03, 0x80, 0x38, 0x06, 0xE0, 0x38, 0x07, 0x80, 0xEE, 0x03, 0x80, 0x78,
  0x0E, 0xE0, 0x38, 0x07, 0x80, 0xEE, 0x03, 0x80, 0x78, 0x0E, 0xE0, 0x3C,
  0x0D, 0x81, 0xC6, 0x01, 0xC0, 0xD8, 0x1C, 0x70, 0x1E, 0x39, 0xC7, 0x87,
  0x00, 0xFF, 0x8F, 0xF0, 0x70, 0x07, 0xF0, 0x7E, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0C,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0x98, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x07,
  0x1E, 0x00, 0x00, 0x70, 0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xF0, 0xE0,
  0x00, 0x0E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xC0, 0x78, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x3C, 0x03,
  0x80, 0x03, 0x80, 0x3C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70,
  0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x1C, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x38, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x01,
  0xC7, 0x80, 0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x38, 0x00, 0xFC, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xEE, 0x00,
  0x07, 0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03,
  0xB8, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x07, 0xB8,
  0x00, 0x1C, 0xE0, 0x00, 0xF3, 0x80, 0x0F, 0x8E, 0x03, 0xFC, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0x80, 0x3F, 0x8E, 0x00, 0x1F, 0x38, 0x00, 0x1E,
  0xE0, 0x00, 0x7B, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0xE0, 0x00, 0x7B,
  0x80, 0x03, 0xCE, 0x00, 0x3F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x83, 0xFF,
  0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x01,
  0xFC, 0x3F, 0x03, 0xE0, 0x02, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x02, 0x01, 0xFE, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0x80, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1C,
  0x00, 0xFC, 0x0E, 0x00, 0x1F, 0x07, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF1,
  0xC0, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x38, 0x00, 0x03,
  0x9C, 0x00, 0x01, 0xEE, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x3B, 0x80, 0x00,
  0x1D, 0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xB8,
  0x00, 0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x7B,
  0x80, 0x00, 0x3D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0E,
  0x38, 0x00, 0x0F, 0x1C, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x87, 0x00, 0x0F,
  0x83, 0x80, 0x3F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF,
  0xFF, 0xB8, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xE0, 0xFF, 0x03, 0xF0, 0x00, 0xE0, 0x7C, 0x00, 0x02, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x77, 0x00,
  0x00, 0x07, 0x70, 0x00, 0x00, 0x77, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x07, 0x38, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x1C,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x70, 0xF8, 0x00,
  0x07, 0x07, 0xC0, 0x00, 0x70, 0x3F, 0x00, 0x0F, 0x01, 0xFF, 0x3F, 0xF0,
  0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0xFC, 0xFF,
  0xFF, 0xFC, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x03, 0xD0, 0xFB, 0xFE,
  0x7F, 0x87, 0xC0, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xC7,
  0x00, 0x07, 0x8E, 0x00, 0x1E, 0x1C, 0x00, 0x78, 0x38, 0x00, 0xE0, 0x70,
  0x03, 0xC0, 0xE0, 0x0F, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x78, 0x07, 0x01,
  0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0x70, 0xF0,
  0x00, 0xE1, 0xE0, 0x01, 0xC7, 0x80, 0x03, 0x9F, 0x00, 0x07, 0x3E, 0x00,
  0x0E, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x3C, 0x00, 0x7C, 0x38, 0x00,
  0xF0, 0x78, 0x01, 0xC0, 0x70, 0x03, 0x80, 0xF0, 0x07, 0x00, 0xF0, 0x0E,
  0x01, 0xE0, 0x1C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x70, 0x03, 0xC0, 0xE0,
  0x03, 0x81, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x07, 0x00, 0x0F, 0x0E, 0x00,
  0x0F, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00,
  0x3D, 0xC0, 0x00, 0x3C, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x07, 0x7E, 0xE0, 0x00, 0x01, 0xDF, 0xB8, 0x00, 0x00,
  0x77, 0xEE, 0x00, 0x00, 0x39, 0xF9, 0xC0, 0x00, 0x0E, 0x7E, 0x70, 0x00,
  0x03, 0x9F, 0x9C, 0x00, 0x01, 0xC7, 0xE3, 0x80, 0x00, 0x71, 0xF8, 0xE0,
  0x00, 0x1C, 0x7E, 0x38, 0x00, 0x0E, 0x1F, 0x87, 0x00, 0x03, 0x87, 0xE1,
  0xC0, 0x00, 0xE1, 0xF8, 0x70, 0x00, 0x70, 0x7E, 0x0E, 0x00, 0x1C, 0x1F,
  0x83, 0x80, 0x07, 0x07, 0xE0, 0xE0, 0x03, 0x81, 0xF8, 0x1C, 0x00, 0xE0,
  0x7E, 0x07, 0x00, 0x38, 0x1F, 0x81, 0xC0, 0x1C, 0x07, 0xE0, 0x38, 0x07,
  0x01, 0xF8, 0x0E, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0xE0, 0x1F, 0x80, 0xF0,
  0x38, 0x07, 0xE0, 0x1C, 0x0E, 0x01, 0xF8, 0x07, 0x07, 0x00, 0x7E, 0x01,
  0xE1, 0xC0, 0x1F, 0x80, 0x38, 0x70, 0x07, 0xE0, 0x0E, 0x38, 0x01, 0xF8,
  0x03, 0xCE, 0x00, 0x7E, 0x00, 0x73, 0x80, 0x1F, 0x80, 0x1D, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78,
  0x00, 0x70, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xB8, 0x00, 0x0F,
  0xDE, 0x00, 0x07, 0xE7, 0x00, 0x03, 0xF3, 0xC0, 0x01, 0xF8, 0xE0, 0x00,
  0xFC, 0x78, 0x00, 0x7E, 0x1C, 0x00, 0x3F, 0x0F, 0x00, 0x1F, 0x83, 0x80,
  0x0F, 0xC1, 0xE0, 0x07, 0xE0, 0x70, 0x03, 0xF0, 0x3C, 0x01, 0xF8, 0x0E,
  0x00, 0xFC, 0x07, 0x80, 0x7E, 0x01, 0xC0, 0x3F, 0x00, 0xF0, 0x1F, 0x80,
  0x38, 0x0F, 0xC0, 0x1E, 0x07, 0xE0, 0x07, 0x03, 0xF0, 0x03, 0xC1, 0xF8,
  0x00, 0xE0, 0xFC, 0x00, 0x78, 0x7E, 0x00, 0x1C, 0x3F, 0x00, 0x0F, 0x1F,
  0x80, 0x03, 0x8F, 0xC0, 0x01, 0xE7, 0xE0, 0x00, 0x73, 0xF0, 0x00, 0x3D,
  0xF8, 0x00, 0x0E, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x7C, 0x00, 0xF0, 0x07, 0xC0, 0x03, 0xC0,
  0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0xE7, 0x80, 0x00,
  0x07, 0x38, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x38, 0x00,
  0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38, 0x38, 0x00, 0x03,
  0xC1, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x00,
  0xF8, 0x03, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x8E, 0x00, 0xFC, 0xE0, 0x03, 0xEE, 0x00, 0x1E, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xEE, 0x00, 0x1E, 0xE0, 0x07, 0xCE, 0x01,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xC0, 0xFF, 0xE0, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xE1,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x38, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x07,
  0xB8, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xF1, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x38, 0x38, 0x00,
  0x03, 0xC1, 0xE0, 0x00, 0x1C, 0x07, 0x80, 0x01, 0xE0, 0x3E, 0x00, 0x1E,
  0x00, 0xF8, 0x03, 0xE0, 0x03, 0xFC, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8,
  0x38, 0x03, 0xF0, 0xE0, 0x03, 0xE3, 0x80, 0x07, 0x8E, 0x00, 0x0F, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00,
  0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1C,
  0xE0, 0x00, 0xF3, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00, 0xF0, 0xE0,
  0x1F, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xE0, 0x3C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0, 0x38, 0x03, 0x80, 0xE0, 0x0F, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x78, 0x38, 0x00, 0xE0, 0xE0, 0x03, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x1E, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xF3, 0x80, 0x03,
  0xCE, 0x00, 0x07, 0xB8, 0x00, 0x1E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xFE, 0x03, 0xFF, 0xFC, 0x3F, 0x9F, 0xE3, 0xE0,
  0x06, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x72, 0x00, 0x07, 0x98, 0x00, 0xF8, 0xFF, 0xFF, 0x87,
  0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3C, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1D,
  0xC0, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x07, 0xB8, 0x00, 0x03,
  0xDE, 0x00, 0x01, 0xC7, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00,
  0xF0, 0x7C, 0x00, 0xF0, 0x1F, 0xE7, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3D,
  0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x3C, 0x70, 0x00,
  0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x83,
  0x80, 0x00, 0xE0, 0x70, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0xE0, 0x1C, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0x78, 0x00, 0xF0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x1E,
  0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x07, 0x83, 0xC0,
  0x00, 0x70, 0x70, 0x00, 0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x3C,
  0x70, 0x00, 0x03, 0x8E, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x78, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xC0,
  0x00, 0x3B, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE7, 0x00, 0x03, 0xF0, 0x00, 0x3C, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x1C,
  0x00, 0x0F, 0xC0, 0x00, 0xE3, 0xC0, 0x01, 0xF8, 0x00, 0x3C, 0x38, 0x00,
  0x73, 0x80, 0x07, 0x87, 0x00, 0x0E, 0x70, 0x00, 0xE0, 0xE0, 0x01, 0xCE,
  0x00, 0x1C, 0x1E, 0x00, 0x39, 0xC0, 0x03, 0x83, 0xC0, 0x07, 0x38, 0x00,
  0xF0, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x07, 0x00, 0x38, 0x70, 0x03, 0x80,
  0xE0, 0x07, 0x0E, 0x00, 0x70, 0x1E, 0x00, 0xE1, 0xC0, 0x1E, 0x01, 0xC0,
  0x38, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x70, 0x0E, 0x00, 0xF0, 0x1C, 0x0E, 0x03, 0xC0, 0x1E, 0x03, 0x81, 0xC0,
  0x78, 0x01, 0xC0, 0xE0, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x03, 0x81, 0xC0,
  0x07, 0x83, 0x80, 0x70, 0x38, 0x00, 0xF0, 0x70, 0x0E, 0x0F, 0x00, 0x0E,
  0x1C, 0x00, 0xE1, 0xC0, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x00, 0x38, 0x70,
  0x03, 0x87, 0x00, 0x07, 0x8E, 0x00, 0x71, 0xE0, 0x00, 0x71, 0xC0, 0x0E,
  0x3C, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00, 0x1C, 0xE0,
  0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x07, 0xB8, 0x00, 0x77, 0x80, 0x00,
  0x76, 0x00, 0x06, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x0F, 0x3C, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x1E, 0x00,
  0x1C, 0x0E, 0x00, 0x3C, 0x0F, 0x00, 0x38, 0x07, 0x00, 0x78, 0x07, 0x00,
  0x70, 0x03, 0x80, 0x70, 0x03, 0x80, 0xF0, 0x03, 0xC0, 0xE0, 0x01, 0xC1,
  0xE0, 0x01, 0xE1, 0xC0, 0x00, 0xE3, 0xC0, 0x00, 0xF3, 0x80, 0x00, 0x77,
  0x80, 0x00, 0x77, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x77, 0x80, 0x00, 0xE3, 0x80, 0x00, 0xE3, 0x80, 0x01, 0xE1,
  0xC0, 0x01, 0xC1, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x80,
  0xF0, 0x07, 0x00, 0x70, 0x0F, 0x00, 0x78, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x3C, 0x1C, 0x00, 0x3C, 0x3C, 0x00, 0x1C, 0x38, 0x00, 0x1E, 0x38, 0x00,
  0x0E, 0x78, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x70, 0x00,
  0x0E, 0x78, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x0E, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x81,
  0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xC0, 0x01, 0xC3, 0x80, 0x01, 0xC3,
  0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFC, 0x00, 0x01, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x03, 0x8E, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xE1, 0xC0, 0x00, 0xE0,
  0x70, 0x00, 0xF0, 0x38, 0x00, 0x70, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x3C, 0x00, 0xE0, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x0E,
  0x00, 0x0E, 0x0F, 0x00, 0x03, 0x87, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x73,
  0x80, 0x00, 0x3B, 0xC0, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0F,
  0x01, 0xE0, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x3F, 0xF8, 0x3F, 0xFF, 0x0F, 0xC0, 0xE7, 0xC0, 0x1C, 0xF0,
  0x03, 0xBC, 0x00, 0x77, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x01, 0xB7, 0x80,
  0x76, 0x7C, 0x3C, 0xC7, 0xFF, 0x18, 0x7F, 0xC3, 0x01, 0x80, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC1,
  0xF8, 0x0F, 0x1F, 0xF8, 0x3C, 0xFF, 0xF0, 0xF7, 0x03, 0xE3, 0xF8, 0x03,
  0xCE, 0xC0, 0x07, 0x3E, 0x00, 0x1E, 0xF8, 0x00, 0x3B, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3B, 0xE0, 0x00, 0xEF, 0x80, 0x07, 0xBE, 0x00,
  0x1C, 0xEC, 0x00, 0xF3, 0xB8, 0x07, 0x8E, 0x78, 0x7E, 0x38, 0xFF, 0xF0,
  0xE1, 0xFF, 0x00, 0x00, 0x40, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF0, 0x7F,
  0xF8, 0x3E, 0x06, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x43,
  0xF1, 0xE0, 0x7F, 0xF8, 0x0F, 0xFE, 0x00, 0x50, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x07, 0xE0, 0xF0,
  0x7F, 0xE3, 0xC3, 0xFF, 0xCF, 0x1F, 0x03, 0xBC, 0xF0, 0x07, 0xF3, 0xC0,
  0x0D, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0x7D, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3D, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x3C,
  0x00, 0xDC, 0xF8, 0x06, 0x71, 0xF8, 0x79, 0xC3, 0xFF, 0xC7, 0x03, 0xFC,
  0x1C, 0x01, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0x81,
  0xF0, 0x7C, 0x1C, 0x01, 0xC3, 0xC0, 0x1E, 0x38, 0x00, 0xE7, 0x00, 0x0F,
  0x70, 0x00, 0x77, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x20, 0xFC, 0x3E, 0x07, 0xFF, 0xE0, 0x3F, 0xFC,
  0x00, 0x3C, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x07, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x01, 0xF8, 0x00,
  0x1F, 0xF8, 0x70, 0xFF, 0xF1, 0xC7, 0xC0, 0xE7, 0x3C, 0x01, 0xDC, 0xF0,
  0x03, 0xF7, 0x80, 0x07, 0xDC, 0x00, 0x1F, 0x70, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0x70, 0x00, 0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x0F, 0xCF,
  0x00, 0x3F, 0x3E, 0x01, 0xBC, 0x7E, 0x1E, 0xF0, 0xFF, 0xF3, 0xC0, 0xFF,
  0x0F, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF1, 0x00, 0x03, 0xC7, 0x00, 0x3E, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x07, 0xE0, 0xF1, 0xFF, 0x8F, 0x3F, 0xFC, 0xF7, 0x03, 0xEE, 0xE0,
  0x1E, 0xEC, 0x00, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x70, 0x7F, 0xFF, 0x70,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83,
  0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0,
  0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x7B, 0xFD, 0xFC, 0xFC, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0xF7,
  0x80, 0x1C, 0xF0, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0x38, 0x78, 0x0E, 0x0F,
  0x03, 0xC1, 0xE0, 0x70, 0x3C, 0x1C, 0x07, 0x87, 0x80, 0xF1, 0xE0, 0x1E,
  0x38, 0x03, 0xCF, 0x00, 0x7B, 0xF0, 0x0E, 0x7E, 0x01, 0xDD, 0xE0, 0x3F,
  0x1C, 0x07, 0xC3, 0xC0, 0xF0, 0x38, 0x1E, 0x07, 0x83, 0xC0, 0x70, 0x78,
  0x0F, 0x0F, 0x00, 0xE1, 0xE0, 0x1E, 0x3C, 0x01, 0xC7, 0x80, 0x3C, 0xF0,
  0x03, 0x9E, 0x00, 0x7B, 0xC0, 0x07, 0x78, 0x00, 0xFF, 0x00, 0x0E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC,
  0x01, 0xF8, 0x38, 0x7F, 0xC0, 0xFF, 0x8E, 0x7F, 0xF8, 0xFF, 0xF3, 0x9C,
  0x1E, 0x38, 0x3E, 0xEC, 0x03, 0xDC, 0x07, 0xBB, 0x00, 0x76, 0x00, 0xFF,
  0x80, 0x1F, 0x00, 0x3F, 0xE0, 0x07, 0xC0, 0x07, 0xF0, 0x00, 0xE0, 0x01,
  0xFC, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x03, 0x80,
  0x07, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0E,
  0x00, 0x1F, 0xC0, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00,
  0x38, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x07, 0xF0,
  0x00, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x1F,
  0xC0, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x38, 0x00,
  0x7F, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0x07, 0xF0, 0x00, 0xE0,
  0x01, 0xFC, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x0E, 0x00, 0x1F, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x7E, 0x0E, 0x1F, 0xF8, 0xE3, 0xFF, 0xCE, 0x70, 0x3E,
  0xEE, 0x01, 0xEE, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x00, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xC0, 0xF8, 0x3C, 0x00, 0xE0,
  0xF0, 0x03, 0xC7, 0x80, 0x07, 0x1C, 0x00, 0x1E, 0x70, 0x00, 0x3B, 0xC0,
  0x00, 0xEF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x39, 0xE0, 0x01, 0xE3, 0x80, 0x07,
  0x0F, 0x00, 0x3C, 0x1E, 0x01, 0xE0, 0x3E, 0x1F, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xC0, 0x00, 0x30, 0x00, 0x00, 0x7E, 0x03, 0x87, 0xFE, 0x0E, 0x3F,
  0xFC, 0x39, 0xC0, 0xF8, 0xEE, 0x00, 0xF3, 0xB0, 0x01, 0xCF, 0x80, 0x07,
  0xBE, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0xF8,
  0x00, 0x3B, 0xE0, 0x01, 0xEF, 0xC0, 0x07, 0x3B, 0x00, 0x3C, 0xF6, 0x01,
  0xE3, 0xDF, 0x1F, 0x8F, 0x3F, 0xFC, 0x3C, 0x3F, 0xC0, 0xF0, 0x10, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x70, 0xFF, 0xF1, 0xC7, 0xC0, 0xE7, 0x3C,
  0x01, 0xDC, 0xF0, 0x03, 0xF7, 0x80, 0x07, 0xDE, 0x00, 0x1F, 0x70, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x7D, 0xE0, 0x01, 0xF7,
  0x80, 0x0D, 0xCF, 0x00, 0x3F, 0x3E, 0x01, 0xBC, 0x7E, 0x3E, 0xF0, 0xFF,
  0xF3, 0xC0, 0xFF, 0x0F, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x87, 0xFE, 0x3F,
  0xF9, 0xE2, 0xE6, 0x03, 0xB0, 0x0E, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0x03, 0xFC, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0xF0, 0x0E,
  0x78, 0x01, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x3A, 0x00, 0x1E, 0xC0, 0x0F, 0xBF, 0x0F, 0xCF, 0xFF,
  0xE0, 0xFF, 0xE0, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0xFF, 0xFB, 0xFF, 0xE1,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x8C, 0x1F,
  0xF0, 0x3F, 0xC0, 0x18, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x1F, 0x78, 0x03, 0x77,
  0xC0, 0x77, 0x3F, 0x1E, 0x71, 0xFF, 0xC7, 0x0F, 0xF8, 0x70, 0x0C, 0x00,
  0xF0, 0x00, 0x3D, 0xC0, 0x00, 0xE7, 0x00, 0x03, 0x9E, 0x00, 0x1E, 0x38,
  0x00, 0x70, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x0F, 0x00, 0x3C, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x81, 0xC0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x0F, 0x3C,
  0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xCE, 0x00, 0x03, 0x70, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0x00,
  0x1F, 0x00, 0x1D, 0xC0, 0x0F, 0xC0, 0x0F, 0x70, 0x03, 0xF0, 0x03, 0x9C,
  0x00, 0xEC, 0x00, 0xE7, 0x00, 0x3B, 0x80, 0x38, 0xE0, 0x0C, 0xE0, 0x1E,
  0x38, 0x07, 0x38, 0x07, 0x0E, 0x01, 0xCE, 0x01, 0xC3, 0x80, 0x71, 0xC0,
  0x70, 0xF0, 0x18, 0x70, 0x1C, 0x1C, 0x0E, 0x1C, 0x0E, 0x07, 0x03, 0x87,
  0x03, 0x81, 0xC0, 0xE0, 0xE0, 0xE0, 0x78, 0x30, 0x38, 0x38, 0x0E, 0x1C,
  0x0E, 0x1C, 0x03, 0x87, 0x03, 0x87, 0x00, 0xE1, 0xC0, 0x71, 0xC0, 0x3C,
  0x60, 0x1C, 0x70, 0x07, 0x38, 0x07, 0x1C, 0x01, 0xCE, 0x01, 0xCE, 0x00,
  0x73, 0x80, 0x33, 0x80, 0x1C, 0xE0, 0x0E, 0xE0, 0x03, 0xF0, 0x03, 0xB8,
  0x00, 0xFC, 0x00, 0xEC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0x79, 0xC0, 0x07, 0x8F, 0x00, 0x38, 0x38, 0x03,
  0xC1, 0xE0, 0x1C, 0x07, 0x01, 0xE0, 0x3C, 0x0E, 0x00, 0xE0, 0xE0, 0x07,
  0x87, 0x00, 0x1C, 0x70, 0x00, 0xF3, 0x80, 0x03, 0xB8, 0x00, 0x1F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x77, 0x00, 0x07, 0x9C, 0x00, 0x38, 0xE0, 0x03, 0x83, 0x80,
  0x1C, 0x1E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0xC0, 0xE0, 0x0E, 0x0F, 0x00,
  0x78, 0x70, 0x01, 0xC7, 0x80, 0x0F, 0x38, 0x00, 0x3B, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00,
  0x0F, 0x3C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x01, 0xE0,
  0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xC0, 0xF0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC1, 0xC0, 0x0F, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x0E, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x80,
  0x07, 0xC0, 0x0F, 0xE0, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x7F, 0xE0,
  0x05, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xD0, 0x00, 0xFE,
  0x00,
};

const GFXglyph NotoSans_Condensed_Light59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 43, 13, 4, -42 },
  { 28, 13, 15, 20, 4, -42 },
  { 53, 27, 42, 30, 1, -42 },
  { 195, 21, 48, 27, 3, -45 },
  { 321, 34, 44, 40, 3, -43 },
  { 508, 28, 44, 31, 2, -43 },
  { 662, 3, 15, 11, 4, -42 },
  { 668, 11, 51, 16, 3, -42 },
  { 739, 12, 51, 16, 2, -42 },
  { 816, 19, 20, 25, 3, -45 },
  { 864, 23, 28, 27, 2, -35 },
  { 945, 7, 14, 12, 2, -6 },
  { 958, 13, 4, 17, 2, -18 },
  { 965, 5, 6, 13, 4, -5 },
  { 969, 19, 42, 21, 1, -42 },
  { 1069, 21, 44, 27, 3, -43 },
  { 1185, 12, 42, 27, 5, -42 },
  { 1248, 22, 43, 27, 2, -43 },
  { 1367, 22, 44, 27, 2, -43 },
  { 1488, 25, 42, 27, 1, -42 },
  { 1620, 21, 43, 27, 3, -42 },
  { 1733, 21, 44, 27, 3, -43 },
  { 1849, 22, 42, 27, 2, -42 },
  { 1965, 23, 44, 27, 2, -43 },
  { 2092, 21, 44, 27, 3, -43 },
  { 2208, 5, 32, 13, 4, -32 },
  { 2228, 7, 40, 13, 2, -32 },
  { 2263, 23, 26, 27, 2, -34 },
  { 2338, 23, 15, 27, 2, -28 },
  { 2382, 23, 26, 27, 2, -34 },
  { 2457, 17, 44, 19, 1, -43 },
  { 2551, 36, 47, 42, 3, -42 },
  { 2763, 28, 42, 28, 0, -42 },
  { 2910, 22, 42, 30, 5, -42 },
  { 3026, 24, 44, 29, 3, -43 },
  { 3158, 25, 42, 33, 5, -42 },
  { 3290, 18, 42, 26, 5, -42 },
  { 3385, 18, 42, 24, 5, -42 },
  { 3480, 28, 44, 35, 3, -43 },
  { 3634, 24, 42, 34, 5, -42 },
  { 3760, 11, 42, 16, 2, -42 },
  { 3818, 11, 53, 13, -3, -42 },
  { 3891, 23, 42, 28, 5, -42 },
  { 4012, 18, 42, 24, 5, -42 },
  { 4107, 34, 42, 44, 5, -42 },
  { 4286, 25, 42, 35, 5, -42 },
  { 4418, 29, 44, 36, 3, -43 },
  { 4578, 20, 42, 28, 5, -42 },
  { 4683, 29, 53, 36, 3, -43 },
  { 4876, 22, 42, 29, 5, -42 },
  { 4992, 21, 44, 26, 3, -43 },
  { 5108, 24, 42, 24, 0, -42 },
  { 5234, 25, 43, 34, 4, -42 },
  { 5369, 27, 42, 27, 0, -42 },
  { 5511, 43, 42, 44, 1, -42 },
  { 5737, 24, 42, 25, 0, -42 },
  { 5863, 24, 42, 24, 0, -42 },
  { 5989, 21, 42, 24, 2, -42 },
  { 6100, 12, 51, 18, 5, -42 },
  { 6177, 19, 42, 21, 1, -42 },
  { 6277, 12, 51, 18, 2, -42 },
  { 6354, 25, 23, 27, 1, -42 },
  { 6426, 25, 3, 24, 0, 5 },
  { 6436, 10, 9, 15, 2, -45 },
  { 6448, 19, 33, 26, 2, -32 },
  { 6527, 22, 46, 29, 4, -45 },
  { 6654, 18, 33, 22, 3, -32 },
  { 6729, 22, 46, 29, 3, -45 },
  { 6856, 20, 33, 26, 3, -32 },
  { 6939, 16, 45, 15, 1, -45 },
  { 7029, 22, 46, 29, 3, -32 },
  { 7156, 20, 45, 28, 4, -45 },
  { 7269, 4, 43, 12, 4, -43 },
  { 7291, 9, 57, 12, -1, -43 },
  { 7356, 19, 45, 24, 4, -45 },
  { 7463, 4, 45, 12, 4, -45 },
  { 7486, 34, 32, 42, 4, -32 },
  { 7622, 20, 32, 28, 4, -32 },
  { 7702, 22, 33, 28, 3, -32 },
  { 7793, 22, 46, 29, 4, -32 },
  { 7920, 22, 46, 29, 3, -32 },
  { 8047, 14, 32, 19, 4, -32 },
  { 8103, 18, 33, 22, 2, -32 },
  { 8178, 14, 40, 16, 1, -39 },
  { 8248, 20, 32, 28, 4, -31 },
  { 8328, 22, 31, 22, 0, -31 },
  { 8414, 34, 31, 36, 1, -31 },
  { 8546, 21, 31, 23, 1, -31 },
  { 8628, 21, 45, 22, 1, -31 },
  { 8747, 16, 31, 20, 2, -31 },
  { 8809, 16, 51, 21, 2, -42 },
  { 8911, 3, 59, 26, 11, -45 },
  { 8934, 17, 51, 21, 2, -42 },
  { 9043, 23, 6, 27, 2, -24 },
};

const GFXfont NotoSans_Condensed_Light59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light59pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_CONDENSED_LIGHT59PT7B_H_
