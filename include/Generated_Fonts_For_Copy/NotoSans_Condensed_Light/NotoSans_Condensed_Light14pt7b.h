#ifndef _NOTOSANS_CONDENSED_LIGHT14PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x40, 0xB6, 0xD0, 0x24, 0x48, 0x93, 0xF2, 0x85, 0x3F, 0x24,
  0x48, 0x90, 0x23, 0xA9, 0x4A, 0x20, 0xC5, 0x2D, 0x90, 0x40, 0xC4, 0xA4,
  0xA8, 0xA8, 0xB6, 0xD9, 0x19, 0x29, 0x29, 0x46, 0x62, 0x49, 0x14, 0x62,
  0x99, 0x66, 0x8B, 0xD0, 0xF0, 0x5A, 0xAA, 0xA9, 0xC8, 0x92, 0x49, 0x25,
  0x60, 0x44, 0xF6, 0x90, 0x10, 0x41, 0x3F, 0x10, 0x40, 0xF0, 0xF0, 0x80,
  0x08, 0x84, 0x22, 0x11, 0x08, 0x44, 0x00, 0x74, 0xA3, 0x18, 0xC6, 0x31,
  0x93, 0x80, 0x2E, 0x92, 0x49, 0x24, 0xF0, 0x82, 0x21, 0x10, 0x88, 0x87,
  0xC0, 0xF0, 0x82, 0x26, 0x08, 0x21, 0x0F, 0x80, 0x08, 0x61, 0x8A, 0x49,
  0x28, 0xBF, 0x08, 0x20, 0xF4, 0x21, 0x0F, 0x04, 0x21, 0x17, 0x80, 0x74,
  0x21, 0x0F, 0x46, 0x31, 0x8B, 0x80, 0xF8, 0x44, 0x22, 0x10, 0x88, 0x42,
  0x00, 0xF4, 0x63, 0x26, 0x4A, 0x31, 0x8F, 0x80, 0xF4, 0xA3, 0x18, 0xFC,
  0x22, 0x17, 0x00, 0xC1, 0x50, 0x05, 0x60, 0x04, 0x6E, 0x18, 0x18, 0x10,
  0xF8, 0x01, 0xF0, 0x83, 0x06, 0x26, 0x40, 0xF1, 0x11, 0x22, 0x40, 0x04,
  0x3C, 0x42, 0x81, 0x9D, 0xA5, 0xA5, 0xA5, 0xAD, 0x92, 0x80, 0x7C, 0x10,
  0x60, 0xA1, 0x44, 0x89, 0x1F, 0x22, 0x85, 0x04, 0xF4, 0x63, 0x1F, 0x46,
  0x31, 0x8F, 0x80, 0x7A, 0x21, 0x08, 0x42, 0x10, 0x43, 0xC0, 0xF2, 0x28,
  0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0xF8, 0x88, 0xF8, 0x88, 0x8F, 0xF8,
  0x88, 0x8F, 0x88, 0x88, 0x3D, 0x08, 0x20, 0x82, 0x38, 0x61, 0x44, 0xF0,
  0x86, 0x18, 0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xEA, 0xAA, 0xB0, 0x24,
  0x92, 0x49, 0x24, 0x9C, 0x8A, 0x49, 0x28, 0xC2, 0x89, 0x24, 0x8A, 0x30,
  0x88, 0x88, 0x88, 0x88, 0x8F, 0x81, 0xC1, 0xC3, 0xA3, 0xA5, 0xA5, 0x95,
  0x99, 0x99, 0x89, 0x87, 0x1C, 0x69, 0xA6, 0x59, 0x63, 0x86, 0x10, 0x79,
  0x0A, 0x14, 0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0, 0xF4, 0x63, 0x18, 0xFA,
  0x10, 0x84, 0x00, 0x79, 0x0A, 0x14, 0x18, 0x30, 0x60, 0xC2, 0x84, 0xF0,
  0x20, 0x60, 0xF2, 0x28, 0xA2, 0x9B, 0x89, 0x24, 0x8A, 0x30, 0xF4, 0x21,
  0x04, 0x18, 0x21, 0x17, 0x80, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x80, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x85, 0xE0, 0x86, 0x14, 0x51,
  0x49, 0x22, 0x8C, 0x30, 0x40, 0x84, 0x61, 0x14, 0xC5, 0x29, 0x4A, 0x94,
  0xA5, 0x28, 0xCA, 0x31, 0x08, 0x40, 0xC5, 0x24, 0x8C, 0x30, 0xC3, 0x12,
  0x4A, 0x10, 0x85, 0x24, 0x94, 0x30, 0xC2, 0x08, 0x20, 0x80, 0x78, 0x42,
  0x21, 0x10, 0x88, 0x47, 0xC0, 0xF2, 0x49, 0x24, 0x92, 0x70, 0x82, 0x10,
  0x82, 0x10, 0x42, 0x10, 0x40, 0xE4, 0x92, 0x49, 0x24, 0xF0, 0x10, 0xC2,
  0x92, 0xC4, 0xFC, 0xA4, 0x69, 0x13, 0xD9, 0x9F, 0x84, 0x21, 0x6C, 0xC6,
  0x31, 0x8C, 0x7C, 0x78, 0x88, 0x88, 0x87, 0x08, 0x42, 0xD9, 0xC6, 0x31,
  0x8C, 0x5E, 0x64, 0xA3, 0x1F, 0x42, 0x0E, 0x34, 0x4E, 0x44, 0x44, 0x44,
  0x40, 0x64, 0xE3, 0x18, 0xC6, 0x2F, 0x08, 0x7C, 0x84, 0x21, 0x6C, 0xC6,
  0x31, 0x8C, 0x62, 0x9F, 0xC0, 0x41, 0x55, 0x55, 0xC0, 0x84, 0x21, 0x09,
  0x53, 0x14, 0xA4, 0xA6, 0xFF, 0xE0, 0x26, 0xD9, 0x89, 0x89, 0x89, 0x89,
  0x89, 0x89, 0x36, 0x63, 0x18, 0xC6, 0x31, 0x64, 0xA3, 0x18, 0xC6, 0x2E,
  0x36, 0x63, 0x18, 0xC6, 0x3E, 0x84, 0x20, 0x64, 0xE3, 0x18, 0xC6, 0x2F,
  0x08, 0x42, 0x3A, 0x49, 0x24, 0x78, 0x88, 0x61, 0x1E, 0x5D, 0x24, 0x92,
  0x60, 0x8C, 0x63, 0x18, 0xC7, 0xE0, 0x8C, 0x54, 0xA5, 0x10, 0x80, 0x89,
  0x99, 0x55, 0x55, 0x56, 0x26, 0x22, 0xCA, 0x8C, 0x45, 0x26, 0x20, 0x8A,
  0x52, 0xA5, 0x18, 0x84, 0x26, 0x00, 0x71, 0x22, 0x44, 0xF0, 0x29, 0x24,
  0xA2, 0x49, 0x30, 0xFF, 0xFC, 0x89, 0x24, 0x8A, 0x49, 0x60, 0xCD, 0xC0,
};

const GFXglyph NotoSans_Condensed_Light14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 10, 3, 1, -10 },
  { 3, 3, 4, 5, 1, -10 },
  { 5, 7, 10, 7, 0, -10 },
  { 14, 5, 12, 6, 1, -11 },
  { 22, 8, 10, 9, 1, -10 },
  { 32, 6, 10, 7, 1, -10 },
  { 40, 1, 4, 3, 1, -10 },
  { 41, 2, 12, 4, 1, -10 },
  { 44, 3, 12, 4, 0, -10 },
  { 49, 4, 5, 6, 1, -11 },
  { 52, 6, 6, 6, 0, -8 },
  { 57, 1, 4, 3, 1, -2 },
  { 58, 4, 1, 4, 0, -4 },
  { 59, 1, 1, 3, 1, -1 },
  { 60, 5, 10, 5, 0, -10 },
  { 67, 5, 10, 6, 1, -10 },
  { 74, 3, 10, 6, 1, -10 },
  { 78, 5, 10, 6, 1, -10 },
  { 85, 5, 10, 6, 1, -10 },
  { 92, 6, 10, 6, 0, -10 },
  { 100, 5, 10, 6, 1, -10 },
  { 107, 5, 10, 6, 1, -10 },
  { 114, 5, 10, 6, 1, -10 },
  { 121, 5, 10, 6, 1, -10 },
  { 128, 5, 10, 6, 1, -10 },
  { 135, 1, 8, 3, 1, -8 },
  { 136, 2, 10, 3, 0, -8 },
  { 139, 6, 6, 6, 0, -8 },
  { 144, 5, 4, 6, 1, -7 },
  { 147, 5, 6, 6, 1, -8 },
  { 151, 4, 10, 5, 0, -10 },
  { 156, 8, 11, 10, 1, -10 },
  { 167, 7, 10, 7, 0, -10 },
  { 176, 5, 10, 7, 1, -10 },
  { 183, 5, 10, 7, 1, -10 },
  { 190, 6, 10, 8, 1, -10 },
  { 198, 4, 10, 6, 1, -10 },
  { 203, 4, 10, 6, 1, -10 },
  { 208, 6, 10, 8, 1, -10 },
  { 216, 6, 10, 8, 1, -10 },
  { 224, 2, 10, 4, 1, -10 },
  { 227, 3, 13, 3, -1, -10 },
  { 232, 6, 10, 7, 1, -10 },
  { 240, 4, 10, 6, 1, -10 },
  { 245, 8, 10, 10, 1, -10 },
  { 255, 6, 10, 8, 1, -10 },
  { 263, 7, 10, 8, 1, -10 },
  { 272, 5, 10, 7, 1, -10 },
  { 279, 7, 12, 8, 1, -10 },
  { 290, 6, 10, 7, 1, -10 },
  { 298, 5, 10, 6, 1, -10 },
  { 305, 6, 10, 6, 0, -10 },
  { 313, 6, 10, 8, 1, -10 },
  { 321, 6, 10, 6, 0, -10 },
  { 329, 10, 10, 10, 0, -10 },
  { 342, 6, 10, 6, 0, -10 },
  { 350, 6, 10, 6, 0, -10 },
  { 358, 5, 10, 6, 0, -10 },
  { 365, 3, 12, 4, 1, -10 },
  { 370, 5, 10, 5, 0, -10 },
  { 377, 3, 12, 4, 0, -10 },
  { 382, 6, 5, 7, 0, -10 },
  { 386, 6, 1, 6, 0, 1 },
  { 387, 2, 3, 4, 1, -11 },
  { 388, 4, 8, 6, 1, -8 },
  { 392, 5, 11, 7, 1, -11 },
  { 399, 4, 8, 5, 1, -8 },
  { 403, 5, 11, 7, 1, -11 },
  { 410, 5, 8, 6, 1, -8 },
  { 415, 4, 11, 4, 0, -11 },
  { 421, 5, 11, 7, 1, -8 },
  { 428, 5, 11, 7, 1, -11 },
  { 435, 1, 10, 3, 1, -10 },
  { 437, 2, 13, 3, 0, -10 },
  { 441, 5, 11, 6, 1, -11 },
  { 448, 1, 11, 3, 1, -11 },
  { 450, 8, 8, 10, 1, -8 },
  { 458, 5, 8, 7, 1, -8 },
  { 463, 5, 8, 7, 1, -8 },
  { 468, 5, 11, 7, 1, -8 },
  { 475, 5, 11, 7, 1, -8 },
  { 482, 3, 8, 4, 1, -8 },
  { 485, 4, 8, 5, 1, -8 },
  { 489, 3, 9, 4, 0, -9 },
  { 493, 5, 7, 7, 1, -7 },
  { 498, 5, 7, 5, 0, -7 },
  { 503, 8, 7, 9, 0, -7 },
  { 510, 5, 7, 5, 0, -7 },
  { 515, 5, 10, 5, 0, -7 },
  { 522, 4, 7, 5, 0, -7 },
  { 526, 3, 12, 5, 1, -10 },
  { 531, 1, 14, 6, 3, -11 },
  { 533, 3, 12, 5, 1, -10 },
  { 538, 5, 2, 6, 1, -6 },
};

const GFXfont NotoSans_Condensed_Light14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light14pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_CONDENSED_LIGHT14PT7B_H_
