#ifndef _NOTOSANS_CONDENSED_LIGHT56PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT56PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light56pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBC, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x30, 0x00, 0x00, 0x00, 0xEF,
  0x7F, 0xFE, 0x20, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F,
  0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06, 0xE0, 0x6E, 0x06,
  0x00, 0x30, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0,
  0x60, 0x00, 0x70, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x01,
  0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80,
  0x03, 0x80, 0xC0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF0, 0x0C, 0x07,
  0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C,
  0x06, 0x00, 0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x38, 0x00,
  0x38, 0x0E, 0x00, 0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0xC0,
  0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01,
  0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x00, 0xE0, 0x38, 0x00, 0x38, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC3, 0xEE, 0x3C, 0x3C, 0x70, 0x23, 0xC3, 0x80,
  0x1C, 0x1C, 0x00, 0xE0, 0xE0, 0x06, 0x07, 0x00, 0x70, 0x38, 0x03, 0x81,
  0xC0, 0x0E, 0x0E, 0x00, 0x70, 0x70, 0x03, 0xC3, 0x80, 0x0E, 0x1C, 0x00,
  0x7C, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x80, 0x03, 0x9E, 0x00, 0x1C, 0x78, 0x00, 0xE0, 0xE0,
  0x07, 0x07, 0x80, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x0E, 0x07, 0x00, 0x70,
  0x38, 0x03, 0x81, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0xE8, 0x07, 0x0F, 0x38,
  0x39, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x06,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x3F, 0xC0, 0x03, 0x80, 0x70,
  0xE0, 0x03, 0x00, 0x70, 0x60, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x00, 0xE0,
  0x70, 0x0E, 0x00, 0xE0, 0x30, 0x0E, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0xC0,
  0x38, 0x1C, 0x00, 0xC0, 0x38, 0x1C, 0x00, 0xC0, 0x38, 0x38, 0x00, 0xC0,
  0x38, 0x38, 0x00, 0xC0, 0x38, 0x30, 0x00, 0xC0, 0x38, 0x70, 0x00, 0xC0,
  0x38, 0x70, 0x00, 0xC0, 0x38, 0xE0, 0x40, 0xC0, 0x30, 0xE1, 0xF8, 0xE0,
  0x30, 0xC3, 0xFC, 0xE0, 0x71, 0xC7, 0x1E, 0xE0, 0x71, 0x8E, 0x0E, 0x70,
  0x63, 0x8E, 0x06, 0x70, 0xE3, 0x8C, 0x07, 0x3F, 0xC3, 0x0C, 0x07, 0x1F,
  0x87, 0x1C, 0x07, 0x02, 0x06, 0x1C, 0x07, 0x00, 0x0E, 0x1C, 0x03, 0x00,
  0x0E, 0x1C, 0x03, 0x00, 0x0C, 0x1C, 0x03, 0x00, 0x1C, 0x1C, 0x03, 0x00,
  0x18, 0x1C, 0x03, 0x00, 0x38, 0x1C, 0x03, 0x00, 0x38, 0x1C, 0x07, 0x00,
  0x30, 0x1C, 0x07, 0x00, 0x70, 0x0C, 0x07, 0x00, 0x60, 0x0C, 0x07, 0x00,
  0xE0, 0x0E, 0x06, 0x00, 0xE0, 0x0E, 0x0E, 0x00, 0xC0, 0x07, 0x1E, 0x01,
  0xC0, 0x03, 0xFC, 0x01, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x30, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x60,
  0x0C, 0x00, 0x1C, 0x01, 0x80, 0x03, 0x80, 0x30, 0x00, 0x38, 0x0E, 0x00,
  0x07, 0x01, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x01, 0xC1,
  0xC0, 0x00, 0x38, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0x8E, 0x00, 0x00, 0xE0, 0xE0, 0x1C, 0x38, 0x1E, 0x03, 0x8F,
  0x01, 0xC0, 0x71, 0xC0, 0x1C, 0x0E, 0x38, 0x03, 0xC3, 0x8E, 0x00, 0x3C,
  0x71, 0xC0, 0x03, 0x9E, 0x38, 0x00, 0x7B, 0x87, 0x00, 0x07, 0xF0, 0xE0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x01, 0xF0, 0x38, 0x00, 0x7F,
  0x07, 0x80, 0x1E, 0xE0, 0x78, 0x07, 0x8E, 0x0F, 0xC3, 0xE1, 0xE0, 0xFF,
  0xF8, 0x1E, 0x07, 0xFC, 0x01, 0xE0, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x78, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x10, 0x18, 0x0B,
  0xC3, 0x0F, 0x7F, 0x6F, 0xF7, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x1B, 0x80, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x78, 0x70, 0x0E, 0x07, 0x03,
  0x80, 0xF0, 0x30, 0x08, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03,
  0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x30, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3, 0x8E, 0x71,
  0xC7, 0x18, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF4, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x3F, 0xC0, 0x0F, 0xFE,
  0x00, 0xF1, 0xF0, 0x1E, 0x07, 0x83, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x80,
  0x1C, 0x70, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xEF, 0x00, 0x0E, 0xE0,
  0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0E, 0xF0, 0x00, 0xE7, 0x00,
  0x0E, 0x70, 0x00, 0xE7, 0x00, 0x1E, 0x78, 0x01, 0xC3, 0x80, 0x1C, 0x3C,
  0x03, 0x81, 0xE0, 0x78, 0x0F, 0x9F, 0x00, 0xFF, 0xE0, 0x03, 0xFC, 0x00,
  0x04, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x7F, 0x0F, 0x71, 0xE7, 0x3C,
  0x77, 0x87, 0xF0, 0x72, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x40, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0xC0, 0xFE, 0x3F,
  0x07, 0x80, 0x3C, 0x10, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0xE0, 0xFC, 0x1F,
  0x8F, 0x80, 0x3C, 0x30, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x60, 0x01, 0xE3, 0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFE, 0x00, 0x06, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x0E, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x38, 0xE0, 0x00,
  0x30, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0xC0, 0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07,
  0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0xE0, 0x1C,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70,
  0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC3, 0x80, 0x00, 0x38, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x7F, 0xFC, 0x07,
  0xFF, 0xE0, 0x7F, 0xFF, 0x82, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0xC0,
  0x07, 0x8F, 0x83, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x40, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xF0, 0xC0, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x0F, 0xC0, 0xE3, 0xFF, 0x0E, 0x7F, 0xF8, 0xEE, 0x07, 0xCF,
  0xC0, 0x1C, 0xF8, 0x01, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xFE, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00,
  0x0E, 0x38, 0x00, 0xE3, 0xC0, 0x1E, 0x1E, 0x03, 0xC1, 0xF0, 0x78, 0x0F,
  0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x20, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x3F, 0x0F, 0x81, 0xE0, 0x1E, 0x1E, 0x00, 0x78, 0xE0, 0x01, 0xC7, 0x00,
  0x0E, 0x78, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xF0, 0x00, 0xE3,
  0x80, 0x07, 0x1C, 0x00, 0x78, 0x70, 0x03, 0x83, 0xC0, 0x3C, 0x0F, 0x03,
  0xC0, 0x3C, 0x7C, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xEF, 0x80, 0x3E, 0x3E, 0x03, 0xC0, 0x78, 0x3C, 0x01, 0xE1, 0xC0, 0x07,
  0x9E, 0x00, 0x1C, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xDC, 0x00, 0x0E,
  0xE0, 0x00, 0xF7, 0x80, 0x0F, 0x1E, 0x00, 0xF0, 0x7C, 0x1F, 0x81, 0xFF,
  0xF0, 0x03, 0xFF, 0x00, 0x01, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1F, 0xF0,
  0x03, 0xFF, 0xC0, 0x3E, 0x1F, 0x01, 0xE0, 0x3C, 0x1E, 0x00, 0xE0, 0xE0,
  0x03, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xF3, 0x80, 0x03, 0x9C, 0x00, 0x1D,
  0xE0, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xF0, 0x01, 0xF3,
  0x80, 0x0F, 0x9E, 0x00, 0xDC, 0x78, 0x1C, 0xE1, 0xFF, 0xEF, 0x07, 0xFC,
  0x70, 0x0F, 0xC3, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0xC1,
  0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0x1C, 0xF3, 0xCF, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x73, 0xCF, 0x38, 0xE3,
  0x9E, 0x71, 0xC7, 0x38, 0xE0, 0x00, 0x00, 0x0C, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0x80, 0x3F, 0xF0, 0xFF, 0xF8, 0xF8, 0x7C, 0x40, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x02, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00,
  0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xE0, 0x00, 0x0E,
  0x00, 0x70, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x00, 0x38, 0x1C, 0x00, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x00, 0x70, 0xE0, 0x07,
  0xF0, 0x0C, 0x30, 0x07, 0xFF, 0x03, 0x9C, 0x03, 0xE3, 0xC0, 0xE7, 0x01,
  0xE0, 0x70, 0x19, 0xC0, 0x70, 0x1C, 0x06, 0x60, 0x38, 0x07, 0x01, 0xF8,
  0x0E, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0x60, 0x1F, 0x81, 0xC0, 0x18, 0x07,
  0xE0, 0x70, 0x06, 0x01, 0xF8, 0x1C, 0x01, 0x80, 0x7E, 0x07, 0x00, 0xE0,
  0x1F, 0x81, 0xC0, 0x38, 0x07, 0xE0, 0x70, 0x0E, 0x01, 0xB8, 0x1C, 0x03,
  0x80, 0x6E, 0x07, 0x00, 0xE0, 0x3B, 0x81, 0xC0, 0x38, 0x0E, 0xE0, 0x30,
  0x1E, 0x03, 0xB8, 0x0E, 0x06, 0xC1, 0xCE, 0x03, 0xC3, 0x30, 0x71, 0x80,
  0x7F, 0xCF, 0xF8, 0x70, 0x0F, 0xE1, 0xFC, 0x1C, 0x00, 0xE0, 0x3C, 0x07,
  0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3B, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0x38, 0x00, 0x01, 0xCE,
  0x00, 0x00, 0x71, 0x80, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0x87, 0x00, 0x00, 0xE0, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xC0, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00,
  0xE0, 0x01, 0xE0, 0x38, 0x00, 0x38, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x1C, 0x38, 0x00, 0x07, 0x0E, 0x00,
  0x01, 0xE3, 0x80, 0x00, 0x39, 0xE0, 0x00, 0x0E, 0x70, 0x00, 0x03, 0x9C,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xC0, 0x0F, 0x8E, 0x00, 0x1E, 0x70, 0x00,
  0x73, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8,
  0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x73, 0x80, 0x03,
  0x9C, 0x00, 0x3C, 0xE0, 0x03, 0xC7, 0x01, 0xFC, 0x3F, 0xFF, 0x81, 0xFF,
  0xFC, 0x0E, 0x03, 0xF8, 0x70, 0x01, 0xF3, 0x80, 0x03, 0x9C, 0x00, 0x1E,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x3D, 0xC0, 0x03, 0xCE, 0x00, 0x3C, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0xF8, 0x1F, 0xE3, 0xE0, 0x7C, 0x00, 0x41, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x80, 0xFE, 0x1F, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x05, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFC,
  0x03, 0xFF, 0xFE, 0x07, 0x00, 0x7E, 0x0E, 0x00, 0x3E, 0x1C, 0x00, 0x1E,
  0x38, 0x00, 0x1C, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x39, 0xC0, 0x00, 0x7B,
  0x80, 0x00, 0x77, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x79, 0xC0, 0x01, 0xE3, 0x80, 0x07, 0xC7,
  0x00, 0x1F, 0x0E, 0x00, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x7F,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xDF, 0xFF, 0xEE, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7,
  0xFF, 0xFB, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x00, 0x01, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x03,
  0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3E, 0x00, 0x18, 0x0F, 0x00, 0x01,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x01, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xB8,
  0x00, 0x00, 0xF7, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0x79, 0xC0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0x87, 0x80, 0x00, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0xC0, 0x03,
  0xC0, 0xFF, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x30, 0x00, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFC,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x3F, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF7, 0xFC, 0xFF, 0x1F,
  0xC0, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xB8, 0x00, 0x79, 0xC0, 0x03, 0x8E,
  0x00, 0x3C, 0x70, 0x03, 0xC3, 0x80, 0x1C, 0x1C, 0x01, 0xC0, 0xE0, 0x1E,
  0x07, 0x00, 0xE0, 0x38, 0x0E, 0x01, 0xC0, 0xF0, 0x0E, 0x0F, 0x00, 0x70,
  0x70, 0x03, 0x87, 0x80, 0x1C, 0x78, 0x00, 0xE3, 0x80, 0x07, 0x3C, 0x00,
  0x3B, 0xE0, 0x01, 0xDF, 0x80, 0x0F, 0xDC, 0x00, 0x7C, 0xF0, 0x03, 0xC3,
  0x80, 0x1E, 0x1E, 0x00, 0xE0, 0x78, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x01,
  0xC0, 0x38, 0x0E, 0x01, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x3C, 0x1C, 0x00,
  0xE0, 0xE0, 0x07, 0x87, 0x00, 0x1E, 0x38, 0x00, 0x71, 0xC0, 0x03, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00, 0x3F, 0xDC, 0x00, 0x00, 0x37, 0xFC,
  0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x67, 0xEE,
  0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0xC7, 0xE7,
  0x00, 0x01, 0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE3, 0x80, 0x01, 0x87, 0xE3,
  0x80, 0x03, 0x87, 0xE1, 0xC0, 0x03, 0x87, 0xE1, 0xC0, 0x03, 0x87, 0xE1,
  0xC0, 0x07, 0x07, 0xE0, 0xE0, 0x07, 0x07, 0xE0, 0xE0, 0x07, 0x07, 0xE0,
  0xE0, 0x0E, 0x07, 0xE0, 0xE0, 0x0E, 0x07, 0xE0, 0x70, 0x0E, 0x07, 0xE0,
  0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0,
  0x38, 0x38, 0x07, 0xE0, 0x38, 0x38, 0x07, 0xE0, 0x1C, 0x38, 0x07, 0xE0,
  0x1C, 0x70, 0x07, 0xE0, 0x1C, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0,
  0x0E, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0,
  0x03, 0x80, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xDC, 0x00, 0x07, 0xDE, 0x00, 0x07,
  0xEE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE7, 0x80, 0x07,
  0xE3, 0x80, 0x07, 0xE3, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE1, 0xE0, 0x07,
  0xE0, 0xE0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x70, 0x07, 0xE0, 0x78, 0x07,
  0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1E, 0x07,
  0xE0, 0x0E, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x87,
  0xE0, 0x03, 0x87, 0xE0, 0x03, 0xC7, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xE7,
  0xE0, 0x00, 0xE7, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x00, 0xF0,
  0x1E, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03, 0x83, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x01,
  0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0xEE, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0E, 0xF0, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x3C, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x70, 0x0F, 0xCE, 0x00, 0x7D, 0xC0, 0x07, 0xB8, 0x00, 0x77, 0x00,
  0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x0F, 0x70, 0x03, 0xCE, 0x03, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE,
  0x07, 0xFC, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x00, 0xF0, 0x1E, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x38, 0x3C, 0x00, 0x03,
  0xC3, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x1E, 0x70,
  0x00, 0x01, 0xE7, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00,
  0x0E, 0xF0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0E,
  0xF0, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1C, 0x38, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1,
  0xC0, 0x3F, 0x0E, 0x00, 0x7C, 0x70, 0x01, 0xE3, 0x80, 0x07, 0x9C, 0x00,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE,
  0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x3C, 0xE0, 0x01,
  0xC7, 0x00, 0x1E, 0x38, 0x01, 0xE1, 0xC0, 0x3E, 0x0F, 0xFF, 0xE0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1C, 0x0F, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x3C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x83, 0x80,
  0x1C, 0x1C, 0x00, 0xF0, 0xE0, 0x03, 0x87, 0x00, 0x1E, 0x38, 0x00, 0x71,
  0xC0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00,
  0x0F, 0x00, 0x10, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF1, 0xFC, 0x7E, 0x1E,
  0x00, 0x63, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xEE, 0x00, 0x3C,
  0xFE, 0x1F, 0x8F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x0C, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0x70, 0x00, 0x0E,
  0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C,
  0x1E, 0x00, 0x78, 0x0F, 0xC3, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80,
  0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xC3, 0x80,
  0x00, 0x70, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x81,
  0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x07,
  0x00, 0xE0, 0x03, 0xC0, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x00,
  0xE0, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x03, 0x80, 0x01, 0xC0, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x1C, 0x1C, 0x00, 0x03, 0x87, 0x00, 0x00, 0xE1,
  0xC0, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xCE, 0x00, 0x00,
  0x73, 0x80, 0x00, 0x1D, 0xC0, 0x00, 0x07, 0x70, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x70, 0x00, 0x7C,
  0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x0E, 0x70, 0x00, 0x7E, 0x00, 0x0E,
  0x70, 0x00, 0x6E, 0x00, 0x1E, 0x78, 0x00, 0xEE, 0x00, 0x1C, 0x38, 0x00,
  0xE7, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x38, 0x00, 0xE7, 0x00,
  0x1C, 0x3C, 0x00, 0xC7, 0x00, 0x3C, 0x1C, 0x01, 0xC3, 0x00, 0x38, 0x1C,
  0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x1C, 0x01, 0xC3,
  0x80, 0x78, 0x0E, 0x03, 0x83, 0x80, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0x70,
  0x0E, 0x03, 0x81, 0xC0, 0x70, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x0F, 0x03,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0xE0,
  0xE0, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x07, 0x87, 0x00, 0xE1, 0xE0, 0x03,
  0x8E, 0x00, 0x61, 0xC0, 0x03, 0x8E, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00,
  0x71, 0xC0, 0x03, 0x8E, 0x00, 0x73, 0xC0, 0x03, 0xCC, 0x00, 0x73, 0x80,
  0x01, 0xDC, 0x00, 0x33, 0x80, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x01, 0xDC,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x3F, 0x00, 0x00, 0xD8, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x1E,
  0x78, 0x00, 0x38, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xC0, 0xE0, 0x07, 0x81,
  0xC0, 0x0E, 0x03, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x80, 0xE0, 0x07,
  0x03, 0x80, 0x0E, 0x07, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x1C,
  0xF0, 0x00, 0x39, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x03, 0x8F, 0x00,
  0x07, 0x0E, 0x00, 0x1C, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x38, 0x01,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x70,
  0x01, 0xE1, 0xE0, 0x01, 0xC3, 0x80, 0x03, 0xC7, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x07, 0x00, 0x1C,
  0x0E, 0x00, 0x38, 0x1E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0x38, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0xF0, 0x70, 0x00, 0xE0, 0xE0, 0x01,
  0xC1, 0xC0, 0x01, 0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0xB8, 0x00, 0x07,
  0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x18, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xE7, 0x00, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0x80, 0x03, 0x81,
  0xC0, 0x03, 0x81, 0xC0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x0E, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF0, 0x1E, 0x03, 0x80, 0xF0,
  0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x07, 0xFC, 0x07, 0xFF, 0xC1,
  0xF9, 0xF8, 0x60, 0x0E, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x7F, 0xF0, 0xFF, 0xFC, 0x7E, 0x07, 0x3C, 0x01, 0xDE, 0x00, 0x77,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xF0, 0x03, 0xDC, 0x01, 0xB7, 0x80, 0x6C, 0xF0, 0x73, 0x3F, 0xF8,
  0xC3, 0xFC, 0x30, 0x10, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0xFF, 0x03, 0x8F, 0xFE, 0x1C, 0xF9, 0xF8, 0xEE,
  0x03, 0xC7, 0x60, 0x0F, 0x3E, 0x00, 0x39, 0xE0, 0x01, 0xEF, 0x00, 0x07,
  0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xBC, 0x00,
  0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x0F, 0x7C, 0x00, 0x73, 0xE0, 0x07, 0x9D,
  0x80, 0x78, 0xE7, 0x07, 0xC7, 0x3F, 0xFC, 0x38, 0x7F, 0x80, 0x00, 0x40,
  0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xF3, 0xC3, 0xC0, 0x23, 0xC0, 0x01,
  0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0xE0, 0xFF, 0xF0, 0x1F, 0xF8, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x3F, 0x87, 0x0F, 0xFE, 0x71, 0xF9, 0xF7, 0x3E,
  0x03, 0xF3, 0x80, 0x1F, 0x78, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x78, 0x01, 0xB3, 0xC0, 0x3B, 0x1F,
  0x0F, 0x30, 0xFF, 0xE3, 0x07, 0xFC, 0x30, 0x06, 0x00, 0x03, 0xFC, 0x01,
  0xFF, 0xC0, 0x7C, 0x7C, 0x0E, 0x03, 0xC3, 0x80, 0x3C, 0xF0, 0x03, 0x9C,
  0x00, 0x73, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x01, 0x0F, 0xC1, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x0A, 0x00, 0x00,
  0xFC, 0x07, 0xFC, 0x0F, 0xF8, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x07,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x03, 0xF8, 0x30, 0xFF,
  0xE3, 0x1F, 0x9F, 0x33, 0xC0, 0x3F, 0x38, 0x01, 0xF7, 0x80, 0x0F, 0x70,
  0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x80,
  0x1F, 0x3C, 0x03, 0x71, 0xF0, 0xF7, 0x0F, 0xFE, 0x70, 0x7F, 0x87, 0x00,
  0x60, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE6, 0x00, 0x3C,
  0x7C, 0x1F, 0x87, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0x08, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC3, 0xFC, 0x38, 0xFF, 0xC7, 0x3E, 0xFC,
  0xEE, 0x03, 0xDF, 0x80, 0x3B, 0xE0, 0x07, 0x78, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0x80, 0x6F, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xE0, 0x07, 0x03, 0xC1, 0xE0, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x83, 0xD3,
  0xCF, 0xE7, 0xE0, 0x80, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0xFE,
  0x00, 0x7B, 0x80, 0x3C, 0xE0, 0x0E, 0x38, 0x07, 0x0E, 0x03, 0xC3, 0x80,
  0xE0, 0xE0, 0x70, 0x38, 0x3C, 0x0E, 0x0E, 0x03, 0x87, 0x00, 0xE3, 0x80,
  0x39, 0xE0, 0x0E, 0x7C, 0x03, 0xBF, 0x00, 0xFC, 0xE0, 0x3E, 0x38, 0x0F,
  0x87, 0x03, 0xC1, 0xC0, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xE0, 0x0E, 0x38, 0x03, 0x8E, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x03,
  0xB8, 0x00, 0xEE, 0x00, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE1, 0xFC,
  0x07, 0xF8, 0xE7, 0xFE, 0x0F, 0xFC, 0xE7, 0x9F, 0x1E, 0x7E, 0xEC, 0x07,
  0xB8, 0x1E, 0xF8, 0x03, 0xB0, 0x0F, 0xF8, 0x03, 0xE0, 0x07, 0xF0, 0x03,
  0xE0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01,
  0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0xE1, 0xFE,
  0x1C, 0x7F, 0xE3, 0x9E, 0x7E, 0x77, 0x01, 0xEF, 0xC0, 0x1D, 0xF0, 0x03,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xC0, 0x03, 0xFE,
  0x00, 0x7F, 0xF8, 0x07, 0xE7, 0xE0, 0x78, 0x07, 0x83, 0x80, 0x1E, 0x3C,
  0x00, 0x71, 0xC0, 0x03, 0xCE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x00, 0x03,
  0xB8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0x70, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00,
  0x1E, 0x78, 0x00, 0xE1, 0xC0, 0x0F, 0x0F, 0x00, 0xF0, 0x3E, 0x0F, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0xC0, 0x00, 0xE1, 0xFE, 0x07, 0x1F,
  0xFC, 0x39, 0xF3, 0xF1, 0xDC, 0x07, 0x8E, 0xC0, 0x1E, 0x7C, 0x00, 0x73,
  0xE0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xB8, 0x00,
  0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xFF, 0x00, 0x07, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xDE, 0x00, 0x1E, 0xF8,
  0x00, 0xE7, 0xE0, 0x0F, 0x3B, 0x80, 0xF1, 0xCE, 0x0F, 0x0E, 0x3F, 0xF8,
  0x70, 0xFF, 0x03, 0x80, 0x80, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x03, 0xF8, 0x30, 0xFF, 0xE3, 0x1F, 0x9F, 0x33, 0xC0, 0x33, 0x38,
  0x01, 0xF7, 0x80, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00,
  0x0F, 0x70, 0x00, 0xF7, 0x80, 0x1F, 0x3C, 0x03, 0x71, 0xF0, 0xF7, 0x0F,
  0xFE, 0x70, 0x7F, 0x87, 0x00, 0x40, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0xE1, 0xFF, 0x1F, 0xF9, 0xFF, 0xDC, 0x0E, 0xC0, 0x7C, 0x03, 0xE0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0x87, 0xCF, 0x00, 0x47, 0x00,
  0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xB0, 0x03, 0xDF,
  0x07, 0xCF, 0xFF, 0xC1, 0xFF, 0xC0, 0x0C, 0x00, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC7, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0xC2, 0x0F, 0xF0, 0x3F, 0x80, 0x20, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03, 0xEE, 0x00, 0x7D,
  0xE0, 0x1B, 0x9F, 0x0E, 0x73, 0xFF, 0x8E, 0x1F, 0xE1, 0xC0, 0xE0, 0x00,
  0xE0, 0x00, 0x7B, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x80,
  0x0E, 0x1C, 0x00, 0x70, 0xE0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x01, 0xC0,
  0xE0, 0x0E, 0x07, 0x00, 0x70, 0x38, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x00, 0xE0, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x01,
  0xC3, 0x80, 0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x06, 0x70,
  0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x0E, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0,
  0x01, 0xE0, 0x03, 0xB8, 0x00, 0xF0, 0x01, 0xDC, 0x00, 0x7C, 0x00, 0xE7,
  0x00, 0x3E, 0x00, 0x73, 0x80, 0x3B, 0x00, 0x71, 0xC0, 0x1D, 0x80, 0x38,
  0xE0, 0x0E, 0xE0, 0x1C, 0x38, 0x06, 0x70, 0x0E, 0x1C, 0x07, 0x38, 0x06,
  0x0E, 0x03, 0x8C, 0x07, 0x07, 0x01, 0xC7, 0x03, 0x81, 0xC0, 0xC3, 0x81,
  0xC0, 0xE0, 0xE1, 0xC0, 0xE0, 0x70, 0x70, 0x60, 0xE0, 0x38, 0x38, 0x38,
  0x70, 0x1C, 0x18, 0x1C, 0x38, 0x07, 0x1C, 0x0E, 0x1C, 0x03, 0x8E, 0x03,
  0x1C, 0x01, 0xC7, 0x01, 0xCE, 0x00, 0xE3, 0x00, 0xE7, 0x00, 0x3B, 0x80,
  0x73, 0x80, 0x1D, 0xC0, 0x39, 0x80, 0x0E, 0xE0, 0x0D, 0xC0, 0x07, 0x60,
  0x07, 0xE0, 0x01, 0xB0, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xF7, 0x80, 0x0E, 0x38, 0x01, 0xC3, 0xC0, 0x1C, 0x1C, 0x03, 0x81,
  0xE0, 0x38, 0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x07, 0x0E, 0x00, 0x79, 0xE0,
  0x03, 0x9C, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0x9C, 0x00, 0x39,
  0xC0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x0E, 0x07, 0x01, 0xE0, 0x70, 0x1C,
  0x03, 0x83, 0xC0, 0x3C, 0x38, 0x01, 0xC7, 0x80, 0x1E, 0x70, 0x00, 0xEF,
  0x00, 0x0F, 0x70, 0x00, 0x3B, 0x80, 0x01, 0xDC, 0x00, 0x1C, 0x70, 0x00,
  0xE3, 0x80, 0x07, 0x1C, 0x00, 0x78, 0xE0, 0x03, 0x83, 0x80, 0x1C, 0x1C,
  0x00, 0xE0, 0xE0, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38,
  0x03, 0x01, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x1C,
  0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x18, 0xE0, 0x00, 0xE7, 0x00,
  0x07, 0x38, 0x00, 0x3B, 0x80, 0x00, 0xDC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x8F,
  0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x7F, 0xFE,
  0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0xFC, 0x03,
  0xF8, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0xC0, 0x7F, 0x00, 0xF8, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x3F, 0x80,
  0x3F, 0x00, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7F, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x0F, 0x80, 0xFF, 0x00, 0xFE,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x04, 0xFF, 0x80, 0x17, 0xFF, 0x80, 0xF8,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFA, 0x00, 0x1F, 0x80,
};

const GFXglyph NotoSans_Condensed_Light56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 41, 13, 4, -40 },
  { 27, 12, 14, 19, 4, -40 },
  { 48, 26, 40, 28, 1, -40 },
  { 178, 21, 46, 26, 2, -43 },
  { 299, 32, 42, 38, 3, -41 },
  { 467, 27, 42, 29, 2, -41 },
  { 609, 3, 14, 11, 4, -40 },
  { 615, 11, 49, 16, 3, -40 },
  { 683, 11, 49, 16, 2, -40 },
  { 751, 19, 19, 24, 2, -43 },
  { 797, 22, 26, 26, 2, -33 },
  { 869, 6, 13, 12, 2, -6 },
  { 879, 12, 3, 16, 2, -17 },
  { 884, 4, 6, 12, 4, -5 },
  { 887, 18, 40, 20, 1, -40 },
  { 977, 20, 42, 26, 3, -41 },
  { 1082, 12, 40, 26, 4, -40 },
  { 1142, 21, 41, 26, 2, -41 },
  { 1250, 21, 42, 26, 2, -41 },
  { 1361, 24, 40, 26, 1, -40 },
  { 1481, 20, 41, 26, 3, -40 },
  { 1584, 20, 41, 26, 3, -40 },
  { 1687, 21, 40, 26, 2, -40 },
  { 1792, 21, 42, 26, 2, -41 },
  { 1903, 21, 42, 26, 2, -41 },
  { 2014, 4, 30, 12, 4, -30 },
  { 2029, 6, 37, 12, 2, -30 },
  { 2057, 22, 24, 26, 2, -32 },
  { 2123, 22, 15, 26, 2, -27 },
  { 2165, 22, 24, 26, 2, -32 },
  { 2231, 16, 42, 18, 1, -41 },
  { 2315, 34, 45, 39, 3, -40 },
  { 2507, 26, 40, 26, 0, -40 },
  { 2637, 21, 40, 28, 5, -40 },
  { 2742, 23, 42, 27, 3, -41 },
  { 2863, 23, 40, 31, 5, -40 },
  { 2978, 17, 40, 25, 5, -40 },
  { 3063, 17, 40, 23, 5, -40 },
  { 3148, 27, 42, 33, 3, -41 },
  { 3290, 23, 40, 32, 5, -40 },
  { 3405, 11, 40, 15, 2, -40 },
  { 3460, 11, 50, 12, -3, -40 },
  { 3529, 21, 40, 26, 5, -40 },
  { 3634, 17, 40, 23, 5, -40 },
  { 3719, 32, 40, 42, 5, -40 },
  { 3879, 24, 40, 33, 5, -40 },
  { 3999, 28, 42, 34, 3, -41 },
  { 4146, 19, 40, 26, 5, -40 },
  { 4241, 28, 51, 34, 3, -41 },
  { 4420, 21, 40, 27, 5, -40 },
  { 4525, 20, 42, 25, 2, -41 },
  { 4630, 22, 40, 23, 0, -40 },
  { 4740, 24, 41, 32, 4, -40 },
  { 4863, 26, 40, 26, 0, -40 },
  { 4993, 40, 40, 42, 1, -40 },
  { 5193, 23, 40, 24, 0, -40 },
  { 5308, 23, 40, 23, 0, -40 },
  { 5423, 20, 40, 23, 2, -40 },
  { 5523, 12, 49, 18, 4, -40 },
  { 5597, 18, 40, 19, 1, -40 },
  { 5687, 11, 49, 18, 2, -40 },
  { 5755, 24, 22, 26, 1, -40 },
  { 5821, 23, 2, 23, 0, 5 },
  { 5827, 10, 9, 14, 2, -43 },
  { 5839, 18, 31, 24, 2, -30 },
  { 5909, 21, 44, 27, 4, -43 },
  { 6025, 17, 31, 21, 3, -30 },
  { 6091, 20, 44, 27, 3, -43 },
  { 6201, 19, 31, 25, 3, -30 },
  { 6275, 15, 43, 14, 1, -43 },
  { 6356, 20, 44, 27, 3, -30 },
  { 6466, 19, 43, 27, 4, -43 },
  { 6569, 4, 41, 12, 4, -41 },
  { 6590, 9, 55, 12, -1, -41 },
  { 6652, 18, 43, 22, 4, -43 },
  { 6749, 3, 43, 11, 4, -43 },
  { 6766, 32, 30, 40, 4, -30 },
  { 6886, 19, 30, 27, 4, -30 },
  { 6958, 21, 31, 27, 3, -30 },
  { 7040, 21, 43, 27, 4, -30 },
  { 7153, 20, 43, 27, 3, -30 },
  { 7261, 13, 30, 18, 4, -30 },
  { 7310, 17, 31, 21, 2, -30 },
  { 7376, 13, 38, 15, 1, -37 },
  { 7438, 19, 31, 27, 4, -30 },
  { 7512, 21, 30, 21, 0, -30 },
  { 7591, 33, 30, 34, 1, -30 },
  { 7715, 20, 30, 22, 1, -30 },
  { 7790, 21, 44, 21, 0, -30 },
  { 7906, 15, 30, 19, 2, -30 },
  { 7963, 15, 49, 20, 2, -40 },
  { 8055, 3, 57, 24, 11, -43 },
  { 8077, 16, 49, 20, 2, -40 },
  { 8175, 22, 6, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Light56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light56pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_CONDENSED_LIGHT56PT7B_H_
