#ifndef _NOTOSANS_CONDENSED_LIGHT19PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT19PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light19pt7bBitmaps[] PROGMEM = {
  0x00, 0xD5, 0x55, 0x50, 0x70, 0x99, 0x99, 0x90, 0x09, 0x08, 0x84, 0x42,
  0x47, 0xF8, 0x90, 0x48, 0x24, 0x22, 0x7F, 0xC9, 0x04, 0x82, 0x41, 0x20,
  0x10, 0xFA, 0x44, 0x89, 0x12, 0x1C, 0x0C, 0x14, 0x24, 0x48, 0xBF, 0xC2,
  0x04, 0x00, 0x60, 0x92, 0x22, 0x44, 0x49, 0x09, 0x21, 0x24, 0x25, 0x74,
  0xA9, 0x69, 0x21, 0x44, 0x28, 0x88, 0x91, 0x12, 0x43, 0x80, 0x30, 0x24,
  0x11, 0x08, 0x84, 0x81, 0x40, 0xC0, 0xA0, 0x89, 0x44, 0xA1, 0xD0, 0x48,
  0x73, 0xCC, 0xF8, 0x12, 0x44, 0xC8, 0x88, 0x88, 0x88, 0x84, 0x42, 0x30,
  0x91, 0x22, 0x49, 0x24, 0x92, 0xD2, 0x80, 0x30, 0x4F, 0xCC, 0x49, 0x20,
  0x10, 0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x7A, 0xF0, 0xF0, 0x04,
  0x10, 0x42, 0x08, 0x41, 0x04, 0x20, 0x82, 0x10, 0x43, 0x00, 0x38, 0x99,
  0x14, 0x28, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x24, 0x47, 0x00, 0x13,
  0x7D, 0x11, 0x11, 0x11, 0x11, 0x11, 0x31, 0x98, 0x10, 0x20, 0x40, 0x81,
  0x04, 0x18, 0x20, 0x82, 0x08, 0x1F, 0xC0, 0x79, 0x18, 0x10, 0x20, 0x40,
  0x9E, 0x0C, 0x04, 0x04, 0x08, 0x30, 0x5F, 0x00, 0x02, 0x06, 0x0A, 0x0A,
  0x12, 0x12, 0x22, 0x22, 0x42, 0x42, 0xFF, 0x02, 0x02, 0x02, 0x7C, 0x81,
  0x04, 0x08, 0x10, 0x3E, 0x02, 0x02, 0x04, 0x08, 0x38, 0x5F, 0x00, 0x1C,
  0x41, 0x02, 0x08, 0x10, 0x2F, 0x62, 0x83, 0x06, 0x0C, 0x14, 0x47, 0x80,
  0xFE, 0x04, 0x10, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0xC1, 0x02, 0x0C,
  0x00, 0x38, 0x8A, 0x14, 0x18, 0x48, 0x8E, 0x34, 0xC5, 0x06, 0x0C, 0x18,
  0x4F, 0x80, 0x30, 0x9A, 0x14, 0x28, 0x30, 0x61, 0xE5, 0x72, 0x08, 0x10,
  0x20, 0x9E, 0x00, 0xD0, 0x00, 0xF0, 0xD0, 0x00, 0x7A, 0x02, 0x18, 0xC6,
  0x0C, 0x04, 0x06, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x60,
  0x20, 0x63, 0x18, 0x40, 0x72, 0x20, 0x41, 0x04, 0x21, 0x84, 0x20, 0x80,
  0x00, 0x20, 0x80, 0x06, 0x03, 0x30, 0x81, 0x20, 0x14, 0x73, 0x12, 0x64,
  0x4C, 0x89, 0x91, 0x32, 0x26, 0x4C, 0xC6, 0x64, 0x00, 0x80, 0x0C, 0x40,
  0x70, 0x08, 0x04, 0x05, 0x02, 0x81, 0x41, 0x10, 0x88, 0x44, 0x3E, 0x20,
  0x90, 0x48, 0x2C, 0x1C, 0x04, 0xF1, 0x1A, 0x14, 0x38, 0x50, 0xBE, 0x46,
  0x85, 0x06, 0x0C, 0x38, 0x5F, 0x00, 0x0E, 0x31, 0x40, 0x40, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0xC0, 0x40, 0x60, 0x1F, 0xE0, 0x9C, 0x86, 0x82,
  0x82, 0x82, 0x83, 0x83, 0x83, 0x82, 0x82, 0x86, 0x8C, 0xF8, 0xFC, 0x21,
  0x08, 0x43, 0xF0, 0x84, 0x21, 0x08, 0x7C, 0xFC, 0x21, 0x08, 0x42, 0x1F,
  0x84, 0x21, 0x08, 0x40, 0x0F, 0x18, 0xD8, 0x08, 0x08, 0x04, 0x02, 0x01,
  0x0F, 0x80, 0xC0, 0x50, 0x28, 0x12, 0x08, 0xFC, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x7F, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x40, 0xE9, 0x24, 0x92,
  0x49, 0x25, 0xC0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xE0,
  0x87, 0x0A, 0x24, 0xC9, 0x14, 0x38, 0x70, 0x91, 0x22, 0x24, 0x48, 0x50,
  0xC0, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0x80, 0x70,
  0x0F, 0x02, 0xE0, 0x7C, 0x0F, 0x42, 0xE8, 0x5D, 0x0B, 0x92, 0x72, 0x4E,
  0x49, 0xC6, 0x38, 0xC7, 0x18, 0xC0, 0x81, 0x81, 0xC1, 0xC1, 0xA1, 0xA1,
  0x91, 0x91, 0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x1C, 0x11, 0x90, 0x48,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x28, 0x36, 0x11, 0xF0,
  0xE2, 0x68, 0x61, 0x86, 0x18, 0x7E, 0x82, 0x08, 0x20, 0x82, 0x00, 0x1C,
  0x11, 0x90, 0x48, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x28,
  0x36, 0x11, 0xF0, 0x18, 0x04, 0x01, 0x00, 0xE1, 0x32, 0x14, 0x28, 0x50,
  0xA3, 0x7C, 0x91, 0x32, 0x24, 0x68, 0x50, 0xC0, 0x38, 0x8A, 0x04, 0x08,
  0x18, 0x18, 0x0C, 0x04, 0x0C, 0x08, 0x30, 0x5F, 0x00, 0xFF, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x43,
  0x3E, 0x80, 0xC0, 0x90, 0x48, 0x24, 0x32, 0x10, 0x88, 0x44, 0x24, 0x1A,
  0x05, 0x02, 0x81, 0x80, 0x40, 0x81, 0x07, 0x0C, 0x14, 0x30, 0xD0, 0xC2,
  0x42, 0x89, 0x12, 0x22, 0x48, 0x89, 0x24, 0x24, 0x90, 0x91, 0x43, 0x85,
  0x06, 0x18, 0x18, 0x60, 0x60, 0x80, 0x41, 0x42, 0x62, 0x24, 0x24, 0x18,
  0x18, 0x18, 0x18, 0x24, 0x24, 0x42, 0x42, 0x83, 0x81, 0xC2, 0x42, 0x46,
  0x24, 0x24, 0x28, 0x18, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0xFC, 0x10,
  0xC2, 0x08, 0x41, 0x08, 0x21, 0x04, 0x20, 0x83, 0xF0, 0xF2, 0x49, 0x24,
  0x92, 0x49, 0x24, 0xE0, 0x81, 0x04, 0x10, 0x20, 0x81, 0x04, 0x10, 0x20,
  0x82, 0x04, 0x10, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x49, 0xE0, 0x08, 0x08,
  0x14, 0x14, 0x22, 0x22, 0x41, 0xC1, 0xFF, 0x99, 0x80, 0x78, 0x10, 0x41,
  0x3F, 0x18, 0x61, 0x8F, 0xD0, 0x81, 0x02, 0x04, 0x0B, 0xD8, 0x70, 0xE1,
  0x83, 0x07, 0x0E, 0x1C, 0x37, 0x80, 0x7D, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x41, 0xF0, 0x02, 0x04, 0x08, 0x17, 0xA8, 0xE0, 0xC1, 0x83, 0x06, 0x0C,
  0x14, 0x6F, 0x40, 0x78, 0x8A, 0x14, 0x1F, 0xF0, 0x20, 0x40, 0x40, 0x78,
  0x09, 0xC8, 0x42, 0x7C, 0x84, 0x21, 0x08, 0x42, 0x10, 0x80, 0x7A, 0x8E,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0xF4, 0x08, 0x10, 0x79, 0x8C, 0x00,
  0x81, 0x02, 0x04, 0x0B, 0xD8, 0xF0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x40, 0xF0, 0xAA, 0xAA, 0xA0, 0x6C, 0x04, 0x92, 0x49, 0x24, 0x92, 0x5A,
  0x00, 0x81, 0x02, 0x04, 0x08, 0x51, 0x24, 0x48, 0xB1, 0xA2, 0x24, 0x48,
  0x50, 0xC0, 0xFF, 0xFC, 0xBD, 0xF8, 0xC7, 0x18, 0xC2, 0x18, 0x43, 0x08,
  0x61, 0x0C, 0x21, 0x84, 0x30, 0x84, 0xBD, 0x8F, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x04, 0x7C, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x44, 0xF8,
  0xBD, 0x87, 0x0E, 0x18, 0x30, 0x70, 0xE1, 0xC3, 0x7A, 0x04, 0x08, 0x10,
  0x00, 0x7A, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x46, 0xF4, 0x08, 0x10,
  0x20, 0x40, 0xBE, 0x31, 0x88, 0x42, 0x10, 0x84, 0x00, 0xFC, 0x21, 0x06,
  0x0C, 0x21, 0x0F, 0x80, 0x21, 0x11, 0xF4, 0x21, 0x08, 0x42, 0x10, 0x43,
  0x80, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0x46, 0xF4, 0x82, 0x85,
  0x12, 0x24, 0x45, 0x0A, 0x14, 0x28, 0x20, 0x86, 0x28, 0xC5, 0x18, 0xA5,
  0x14, 0x94, 0x52, 0x8A, 0x51, 0x8A, 0x30, 0x86, 0x10, 0xC2, 0x88, 0x91,
  0xC1, 0x83, 0x0A, 0x12, 0x45, 0x84, 0x82, 0x85, 0x12, 0x22, 0x45, 0x0A,
  0x14, 0x18, 0x20, 0x40, 0x82, 0x14, 0x30, 0x00, 0xF8, 0x84, 0x42, 0x21,
  0x18, 0x87, 0xC0, 0x09, 0x88, 0x42, 0x10, 0x84, 0xC2, 0x08, 0x42, 0x10,
  0x84, 0x18, 0xFF, 0xFF, 0xE0, 0x83, 0x08, 0x42, 0x10, 0x84, 0x19, 0x88,
  0x42, 0x10, 0x84, 0xC0, 0x63, 0x3C,
};

const GFXglyph NotoSans_Condensed_Light19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 4, 5, 7, 1, -14 },
  { 8, 9, 14, 10, 0, -14 },
  { 24, 7, 15, 9, 1, -14 },
  { 38, 11, 14, 13, 1, -14 },
  { 58, 9, 14, 10, 1, -14 },
  { 74, 1, 5, 4, 1, -14 },
  { 75, 4, 17, 5, 1, -14 },
  { 84, 3, 17, 5, 1, -14 },
  { 91, 6, 6, 8, 1, -14 },
  { 96, 7, 9, 9, 1, -11 },
  { 104, 2, 4, 4, 1, -2 },
  { 105, 4, 1, 5, 1, -6 },
  { 106, 2, 2, 4, 1, -2 },
  { 107, 6, 14, 7, 0, -14 },
  { 118, 7, 14, 9, 1, -14 },
  { 131, 4, 14, 9, 1, -14 },
  { 138, 7, 14, 9, 1, -14 },
  { 151, 7, 14, 9, 1, -14 },
  { 164, 8, 14, 9, 0, -14 },
  { 178, 7, 14, 9, 1, -14 },
  { 191, 7, 14, 9, 1, -14 },
  { 204, 7, 14, 9, 1, -14 },
  { 217, 7, 14, 9, 1, -14 },
  { 230, 7, 14, 9, 1, -14 },
  { 243, 2, 10, 4, 1, -10 },
  { 246, 2, 12, 4, 1, -10 },
  { 249, 7, 8, 9, 1, -11 },
  { 256, 7, 5, 9, 1, -9 },
  { 261, 7, 8, 9, 1, -11 },
  { 268, 6, 14, 6, 0, -14 },
  { 279, 11, 16, 13, 1, -14 },
  { 301, 9, 14, 9, 0, -14 },
  { 317, 7, 14, 10, 2, -14 },
  { 330, 8, 14, 9, 1, -14 },
  { 344, 8, 14, 11, 2, -14 },
  { 358, 5, 14, 8, 2, -14 },
  { 367, 5, 14, 8, 2, -14 },
  { 376, 9, 14, 11, 1, -14 },
  { 392, 7, 14, 11, 2, -14 },
  { 405, 3, 14, 5, 1, -14 },
  { 411, 4, 17, 4, -1, -14 },
  { 420, 7, 14, 9, 2, -14 },
  { 433, 5, 14, 8, 2, -14 },
  { 442, 11, 14, 14, 2, -14 },
  { 462, 8, 14, 11, 2, -14 },
  { 476, 9, 14, 11, 1, -14 },
  { 492, 6, 14, 9, 2, -14 },
  { 503, 9, 17, 11, 1, -14 },
  { 523, 7, 14, 9, 2, -14 },
  { 536, 7, 14, 8, 1, -14 },
  { 549, 8, 14, 8, 0, -14 },
  { 563, 8, 14, 11, 1, -14 },
  { 577, 9, 14, 9, 0, -14 },
  { 593, 14, 14, 14, 0, -14 },
  { 618, 8, 14, 8, 0, -14 },
  { 632, 8, 14, 8, 0, -14 },
  { 646, 6, 14, 8, 1, -14 },
  { 657, 3, 17, 6, 2, -14 },
  { 664, 6, 14, 7, 0, -14 },
  { 675, 3, 17, 6, 1, -14 },
  { 682, 8, 8, 9, 0, -14 },
  { 690, 8, 1, 8, 0, 2 },
  { 691, 3, 3, 5, 1, -15 },
  { 693, 6, 10, 8, 1, -10 },
  { 701, 7, 14, 9, 1, -14 },
  { 714, 6, 10, 7, 1, -10 },
  { 722, 7, 14, 9, 1, -14 },
  { 735, 7, 10, 8, 1, -10 },
  { 744, 5, 15, 5, 0, -15 },
  { 754, 7, 15, 9, 1, -10 },
  { 768, 7, 14, 9, 1, -14 },
  { 781, 2, 14, 4, 1, -14 },
  { 785, 3, 19, 4, 0, -14 },
  { 793, 7, 14, 8, 1, -14 },
  { 806, 1, 14, 4, 1, -14 },
  { 808, 11, 10, 14, 1, -10 },
  { 822, 7, 10, 9, 1, -10 },
  { 831, 7, 10, 9, 1, -10 },
  { 840, 7, 14, 9, 1, -10 },
  { 853, 7, 14, 9, 1, -10 },
  { 866, 5, 10, 6, 1, -10 },
  { 873, 5, 10, 7, 1, -10 },
  { 880, 5, 13, 5, 0, -13 },
  { 889, 7, 10, 9, 1, -10 },
  { 898, 7, 10, 7, 0, -10 },
  { 907, 11, 10, 12, 0, -10 },
  { 921, 7, 10, 7, 0, -10 },
  { 930, 7, 15, 7, 0, -10 },
  { 944, 5, 10, 6, 1, -10 },
  { 951, 5, 17, 7, 1, -14 },
  { 962, 1, 19, 8, 4, -14 },
  { 965, 5, 17, 7, 1, -14 },
  { 976, 7, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Light19pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light19pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light19pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _NOTOSANS_CONDENSED_LIGHT19PT7B_H_
