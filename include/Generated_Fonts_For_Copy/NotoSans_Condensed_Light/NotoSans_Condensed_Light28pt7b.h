#ifndef _NOTOSANS_CONDENSED_LIGHT28PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light28pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0x54, 0x1F, 0xCE, 0x38, 0xE3, 0x8E, 0x38, 0xC0,
  0x0C, 0x40, 0x42, 0x02, 0x10, 0x10, 0x80, 0x84, 0x04, 0x63, 0xFF, 0xE3,
  0x10, 0x10, 0x80, 0x84, 0x04, 0x20, 0x21, 0x0F, 0xFF, 0x7F, 0xF8, 0xC6,
  0x04, 0x20, 0x21, 0x01, 0x08, 0x08, 0x40, 0x46, 0x00, 0x04, 0x00, 0x80,
  0xFF, 0x32, 0x64, 0x41, 0x88, 0x31, 0x06, 0x20, 0x44, 0x0E, 0x80, 0x70,
  0x03, 0x80, 0x58, 0x09, 0x81, 0x10, 0x23, 0x04, 0x40, 0x9B, 0xDE, 0x3F,
  0x80, 0x40, 0x08, 0x01, 0x00, 0x38, 0x08, 0x22, 0x0C, 0x11, 0x04, 0x18,
  0xC6, 0x0C, 0x62, 0x06, 0x11, 0x03, 0x09, 0x81, 0x8C, 0x80, 0xC6, 0xDE,
  0x22, 0x49, 0x91, 0x2C, 0x47, 0x36, 0x20, 0x12, 0x18, 0x19, 0x0C, 0x08,
  0x86, 0x04, 0x43, 0x06, 0x31, 0x02, 0x18, 0x83, 0x04, 0xC1, 0x01, 0xC0,
  0x1F, 0x01, 0x88, 0x08, 0x60, 0x43, 0x02, 0x18, 0x10, 0xC0, 0xC4, 0x02,
  0x60, 0x1E, 0x00, 0xE0, 0x0D, 0x00, 0xCC, 0x34, 0x31, 0x60, 0xCB, 0x02,
  0xD8, 0x1C, 0xC0, 0x62, 0x07, 0x98, 0x6C, 0x7E, 0x30, 0xEA, 0xA8, 0x0C,
  0x61, 0x0C, 0x21, 0x86, 0x10, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x41,
  0x86, 0x08, 0x30, 0xC1, 0x83, 0xC3, 0x08, 0x63, 0x08, 0x63, 0x08, 0x42,
  0x10, 0x84, 0x21, 0x18, 0xC6, 0x23, 0x11, 0x98, 0x0C, 0x03, 0x00, 0xC3,
  0xA7, 0x3E, 0x03, 0x01, 0x20, 0xCC, 0x61, 0x00, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02,
  0x00, 0x40, 0x6D, 0xA5, 0xA0, 0xFC, 0xBC, 0x01, 0x03, 0x02, 0x02, 0x06,
  0x04, 0x0C, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x20, 0x20, 0x60, 0x40,
  0xC0, 0xC0, 0x80, 0x1F, 0x06, 0x31, 0x82, 0x30, 0x64, 0x0C, 0x80, 0xB0,
  0x16, 0x02, 0xC0, 0x58, 0x0F, 0x01, 0xE0, 0x2C, 0x05, 0x80, 0x90, 0x12,
  0x06, 0x60, 0xCC, 0x10, 0xC6, 0x0F, 0x80, 0x0C, 0x73, 0x59, 0xCC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x3F, 0x38,
  0x64, 0x08, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x30,
  0x08, 0x06, 0x03, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x03, 0xFF, 0x3F,
  0x38, 0x68, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x06, 0x03, 0x07, 0x00,
  0x78, 0x02, 0x00, 0xC0, 0x10, 0x04, 0x01, 0x00, 0xC0, 0x3C, 0x1B, 0xFC,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x3C, 0x02, 0xC0, 0x6C, 0x04, 0xC0, 0xCC,
  0x18, 0xC1, 0x0C, 0x30, 0xC2, 0x0C, 0x60, 0xC4, 0x0C, 0xFF, 0xF0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06,
  0x02, 0x01, 0x00, 0xFE, 0x63, 0x80, 0x60, 0x30, 0x08, 0x04, 0x02, 0x01,
  0x01, 0x80, 0xE1, 0xDF, 0xC0, 0x0F, 0xC3, 0x80, 0xC0, 0x10, 0x06, 0x00,
  0xC0, 0x10, 0x02, 0x00, 0x5F, 0x9E, 0x1B, 0x83, 0x60, 0x2C, 0x06, 0x80,
  0xD0, 0x1A, 0x02, 0x60, 0x4C, 0x18, 0xC6, 0x0F, 0x80, 0xFF, 0xE0, 0x08,
  0x01, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08,
  0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x60, 0x08, 0x03, 0x00, 0x40, 0x18,
  0x00, 0x1F, 0x06, 0x31, 0x83, 0x20, 0x24, 0x04, 0x81, 0x98, 0x31, 0x8C,
  0x1B, 0x01, 0xC0, 0xEC, 0x30, 0xC4, 0x0D, 0x80, 0xB0, 0x1E, 0x03, 0xC0,
  0x68, 0x19, 0xC7, 0x1F, 0x80, 0x1F, 0x0C, 0x66, 0x09, 0x03, 0xC0, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0xD0, 0x36, 0x14, 0xFD, 0x00, 0x40, 0x30, 0x0C,
  0x02, 0x01, 0x80, 0x60, 0x71, 0xF8, 0xFC, 0x00, 0x00, 0x7C, 0x6D, 0x80,
  0x00, 0x00, 0x06, 0xDA, 0x5A, 0x00, 0x00, 0x20, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x10, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x80,
  0x40, 0x00, 0xFE, 0x21, 0x80, 0x40, 0x20, 0x18, 0x08, 0x04, 0x06, 0x06,
  0x02, 0x02, 0x03, 0x01, 0x00, 0x80, 0x40, 0x00, 0x00, 0x08, 0x06, 0x03,
  0x00, 0x03, 0xF0, 0x03, 0x06, 0x06, 0x01, 0x82, 0x00, 0x63, 0x00, 0x11,
  0x00, 0x0D, 0x87, 0xC2, 0x86, 0x21, 0x42, 0x10, 0xA3, 0x08, 0x71, 0x84,
  0x38, 0x82, 0x1C, 0x41, 0x0E, 0x31, 0x85, 0x18, 0xC6, 0x86, 0xD6, 0x41,
  0xCE, 0x30, 0x00, 0x08, 0x00, 0x06, 0x00, 0x01, 0x80, 0x80, 0x7F, 0xC0,
  0x02, 0x00, 0x03, 0x00, 0x38, 0x01, 0x40, 0x0B, 0x00, 0xD8, 0x06, 0x40,
  0x22, 0x01, 0x18, 0x18, 0xC0, 0xC2, 0x04, 0x18, 0x60, 0xC3, 0xFE, 0x10,
  0x10, 0x80, 0xCC, 0x06, 0x60, 0x12, 0x00, 0xF0, 0x07, 0x80, 0x30, 0xFF,
  0x18, 0x73, 0x03, 0x60, 0x2C, 0x07, 0x80, 0xB0, 0x16, 0x06, 0xC1, 0x9F,
  0xC3, 0x07, 0x60, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x1B,
  0x0E, 0x7F, 0x80, 0x0F, 0xE7, 0x0C, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x30,
  0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x08, 0x01, 0x80, 0x30, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE1, 0x87, 0xF0, 0xFE, 0x0C, 0x78, 0xC0, 0xCC,
  0x06, 0xC0, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x06, 0xC0, 0x6C, 0x0C, 0xC7, 0x8F,
  0xE0, 0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x7F,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F, 0xF0,
  0xFF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x3F,
  0xF8, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x0F,
  0xF0, 0xE1, 0xCC, 0x00, 0xC0, 0x04, 0x00, 0x60, 0x03, 0x00, 0x10, 0x00,
  0x80, 0x04, 0x00, 0x20, 0x7F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0x60, 0x19, 0x80, 0xCE, 0x0E, 0x1F, 0xE0, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3F, 0xFF, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xF9, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8D, 0xF0, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xE6, 0xF0, 0xC0, 0x78,
  0x1B, 0x06, 0x60, 0x8C, 0x31, 0x8C, 0x31, 0x06, 0x60, 0xD8, 0x1B, 0x03,
  0xB0, 0x62, 0x0C, 0x61, 0x84, 0x30, 0xC6, 0x0C, 0xC1, 0x98, 0x1B, 0x03,
  0x60, 0x30, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x1F,
  0xF0, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xF0, 0x05, 0xD0, 0x05, 0xD0,
  0x0D, 0xD8, 0x09, 0xC8, 0x09, 0xC8, 0x19, 0xCC, 0x19, 0xC4, 0x11, 0xC4,
  0x31, 0xC6, 0x31, 0xC6, 0x21, 0xC2, 0x61, 0xC3, 0x61, 0xC3, 0x41, 0xC1,
  0xC1, 0xC1, 0xC1, 0xC1, 0x81, 0xC0, 0x1E, 0x01, 0xE0, 0x1F, 0x01, 0xD0,
  0x1D, 0x81, 0xC8, 0x1C, 0xC1, 0xC4, 0x1C, 0x61, 0xC2, 0x1C, 0x31, 0xC1,
  0x1C, 0x19, 0xC0, 0x9C, 0x0D, 0xC0, 0x5C, 0x07, 0xC0, 0x3C, 0x03, 0x1F,
  0xC1, 0xC7, 0x18, 0x0C, 0x80, 0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x03, 0x40, 0x33, 0x01, 0x8E, 0x38, 0x3F, 0x80, 0xFE, 0x31, 0xEC, 0x1B,
  0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x6F, 0xF3, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0xC1, 0xC7,
  0x18, 0x0C, 0x80, 0x6C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0x40,
  0x33, 0x01, 0x8E, 0x38, 0x3F, 0x80, 0x18, 0x00, 0x60, 0x01, 0x00, 0x0C,
  0x00, 0x30, 0xFE, 0x19, 0xF3, 0x06, 0x60, 0x6C, 0x0D, 0x81, 0xB0, 0x36,
  0x06, 0xC0, 0x98, 0x33, 0xF8, 0x63, 0x0C, 0x21, 0x86, 0x30, 0x46, 0x0C,
  0xC0, 0x98, 0x1B, 0x01, 0x60, 0x30, 0x1F, 0xDC, 0x36, 0x01, 0x00, 0xC0,
  0x30, 0x04, 0x01, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x30,
  0x04, 0x01, 0x00, 0xC0, 0x3C, 0x3B, 0xFC, 0xFF, 0xE0, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x26, 0x06, 0x30, 0xC1, 0xF8, 0xC0, 0x1E, 0x00, 0x90, 0x0C, 0xC0, 0x66,
  0x03, 0x10, 0x10, 0x81, 0x86, 0x0C, 0x30, 0x40, 0x82, 0x04, 0x30, 0x31,
  0x81, 0x88, 0x04, 0x40, 0x36, 0x01, 0xB0, 0x05, 0x00, 0x28, 0x01, 0xC0,
  0x0C, 0x00, 0xC0, 0x20, 0x1A, 0x03, 0x80, 0x90, 0x1C, 0x0C, 0xC0, 0xA0,
  0x66, 0x05, 0x03, 0x10, 0x68, 0x10, 0x83, 0x60, 0x86, 0x13, 0x0C, 0x30,
  0x88, 0x61, 0x84, 0x43, 0x04, 0x63, 0x10, 0x23, 0x19, 0x81, 0x90, 0x4C,
  0x0C, 0x82, 0x60, 0x2C, 0x12, 0x01, 0x60, 0xD0, 0x0E, 0x07, 0x80, 0x70,
  0x1C, 0x03, 0x80, 0xC0, 0x0C, 0x06, 0x00, 0x60, 0x66, 0x06, 0x30, 0x43,
  0x0C, 0x10, 0x81, 0x98, 0x09, 0x00, 0xF0, 0x06, 0x00, 0x60, 0x06, 0x00,
  0xF0, 0x09, 0x01, 0x98, 0x10, 0x83, 0x0C, 0x20, 0xC6, 0x04, 0x60, 0x6C,
  0x03, 0xC0, 0x28, 0x0D, 0x81, 0x30, 0x62, 0x0C, 0x61, 0x04, 0x60, 0xC8,
  0x1B, 0x01, 0x60, 0x38, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0xFF, 0xC0, 0x20, 0x18, 0x06, 0x03, 0x00,
  0xC0, 0x60, 0x18, 0x04, 0x03, 0x00, 0x80, 0x60, 0x10, 0x0C, 0x03, 0x01,
  0x80, 0x60, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x3F,
  0x80, 0xC0, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30, 0x10, 0x10, 0x18, 0x08,
  0x0C, 0x0C, 0x04, 0x06, 0x02, 0x02, 0x03, 0x01, 0xFC, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xFF, 0x04, 0x01, 0xC0, 0x28, 0x0D, 0x81, 0x10, 0x63, 0x08, 0x23,
  0x06, 0x40, 0x58, 0x0E, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xC3, 0x0C, 0x30,
  0x3F, 0x31, 0xC0, 0x60, 0x10, 0x08, 0x04, 0x3E, 0x79, 0x60, 0xE0, 0x70,
  0x38, 0x3C, 0x1B, 0x15, 0xF2, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0D, 0xF3, 0xCE, 0xE0, 0xF0, 0x3C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x3E, 0x0E, 0xC6, 0x9F, 0x00, 0x1F, 0x9C, 0x58, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x06, 0x01, 0x84,
  0x7E, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC7, 0xD9, 0x8F,
  0x60, 0xEC, 0x0D, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0x40,
  0x68, 0x0D, 0x83, 0x98, 0xF1, 0xF6, 0x1F, 0x0C, 0x66, 0x09, 0x03, 0x40,
  0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x30, 0x04, 0x01, 0x80, 0x60, 0x0C, 0x31,
  0xF8, 0x1F, 0x18, 0x10, 0x30, 0x30, 0x30, 0xFE, 0x30, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x66,
  0x3D, 0x83, 0xA0, 0x34, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D,
  0x01, 0xA0, 0x36, 0x0E, 0x63, 0xC7, 0xD8, 0x03, 0x00, 0x60, 0x08, 0x01,
  0x20, 0x67, 0xF8, 0x3C, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x7D, 0xE7, 0xE1, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x08, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x18, 0xC0,
  0x00, 0x0C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C,
  0x63, 0x17, 0xB8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x07, 0x86,
  0xC6, 0x62, 0x33, 0x1B, 0x0D, 0x87, 0x43, 0x31, 0x88, 0xC6, 0x61, 0x30,
  0xD8, 0x2C, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x9E, 0x3E, 0xA3,
  0x67, 0xA1, 0xC3, 0xC1, 0x83, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1,
  0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1, 0x81, 0xC1,
  0x81, 0xC1, 0x81, 0x9F, 0x58, 0xE8, 0x78, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x02, 0x1F, 0x06, 0x31, 0x83,
  0x20, 0x24, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01, 0xA0,
  0x26, 0x0C, 0x63, 0x07, 0xC0, 0x9F, 0x2C, 0x6A, 0x0F, 0x03, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xE0, 0xFC, 0x6D, 0xF3,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F, 0x66, 0x3D,
  0x83, 0xB0, 0x34, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0D, 0x01,
  0xA0, 0x36, 0x0E, 0x63, 0xC7, 0xD8, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x9F, 0x76, 0x86, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x00, 0x3F, 0x63, 0xC0, 0xC0, 0xC0, 0x60,
  0x70, 0x1C, 0x06, 0x03, 0x01, 0x01, 0x03, 0x83, 0xFE, 0x30, 0x60, 0xC7,
  0xF3, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x3C, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x3C, 0x1B, 0x15, 0xF2, 0xC0, 0x70, 0x34, 0x0D, 0x82, 0x60,
  0x88, 0x62, 0x18, 0xC4, 0x33, 0x04, 0xC1, 0xA0, 0x68, 0x0E, 0x03, 0x80,
  0xC0, 0xC0, 0xC1, 0xA0, 0xE0, 0xD0, 0x70, 0x4C, 0x28, 0x26, 0x16, 0x31,
  0x1B, 0x18, 0x8C, 0x88, 0x64, 0x44, 0x32, 0x26, 0x0B, 0x1B, 0x05, 0x85,
  0x02, 0x82, 0x81, 0xC1, 0x40, 0xE0, 0xE0, 0x30, 0x60, 0x60, 0xD8, 0x33,
  0x18, 0x44, 0x1B, 0x02, 0x80, 0xE0, 0x30, 0x0E, 0x06, 0xC1, 0xB0, 0xC6,
  0x21, 0x98, 0x3C, 0x04, 0xC0, 0x68, 0x09, 0x83, 0x30, 0x62, 0x08, 0x43,
  0x0C, 0x61, 0x88, 0x11, 0x03, 0x60, 0x6C, 0x05, 0x00, 0xE0, 0x1C, 0x01,
  0x00, 0x60, 0x0C, 0x01, 0x00, 0x20, 0x0C, 0x0F, 0x01, 0xC0, 0x00, 0xFE,
  0x02, 0x06, 0x04, 0x0C, 0x08, 0x18, 0x18, 0x30, 0x30, 0x60, 0x60, 0x40,
  0xC0, 0xFF, 0x07, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x10, 0x70, 0xE0, 0x30, 0x10, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x08, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0E, 0x07, 0x0C, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x10, 0xF0, 0x7C, 0x30, 0xFE,
  0x02, 0x00,
};

const GFXglyph NotoSans_Condensed_Light28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 2, 20, 6, 2, -20 },
  { 6, 6, 7, 10, 2, -20 },
  { 12, 13, 20, 14, 1, -20 },
  { 45, 11, 23, 13, 1, -21 },
  { 77, 17, 20, 19, 1, -20 },
  { 120, 13, 20, 14, 1, -20 },
  { 153, 2, 7, 5, 2, -20 },
  { 155, 6, 24, 8, 1, -20 },
  { 173, 5, 24, 8, 1, -20 },
  { 188, 10, 9, 12, 1, -21 },
  { 200, 11, 13, 13, 1, -16 },
  { 218, 3, 7, 6, 1, -3 },
  { 221, 6, 1, 8, 1, -8 },
  { 222, 2, 3, 6, 2, -3 },
  { 223, 8, 20, 10, 1, -20 },
  { 243, 11, 20, 13, 1, -20 },
  { 271, 6, 20, 13, 2, -20 },
  { 286, 10, 20, 13, 1, -20 },
  { 311, 10, 20, 13, 1, -20 },
  { 336, 12, 20, 13, 0, -20 },
  { 366, 9, 20, 13, 2, -20 },
  { 389, 11, 20, 13, 1, -20 },
  { 417, 11, 20, 13, 1, -20 },
  { 445, 11, 20, 13, 1, -20 },
  { 473, 10, 20, 13, 1, -20 },
  { 498, 2, 15, 6, 2, -15 },
  { 502, 3, 19, 6, 1, -15 },
  { 510, 11, 12, 13, 1, -16 },
  { 527, 11, 7, 13, 1, -13 },
  { 537, 11, 12, 13, 1, -16 },
  { 554, 9, 20, 9, 0, -20 },
  { 577, 17, 23, 20, 1, -20 },
  { 626, 13, 20, 13, 0, -20 },
  { 659, 11, 20, 14, 2, -20 },
  { 687, 11, 20, 14, 2, -20 },
  { 715, 12, 20, 16, 2, -20 },
  { 745, 9, 20, 12, 2, -20 },
  { 768, 9, 20, 11, 2, -20 },
  { 791, 13, 20, 17, 2, -20 },
  { 824, 12, 20, 16, 2, -20 },
  { 854, 5, 20, 8, 1, -20 },
  { 867, 6, 25, 6, -2, -20 },
  { 886, 11, 20, 13, 2, -20 },
  { 914, 9, 20, 11, 2, -20 },
  { 937, 16, 20, 21, 2, -20 },
  { 977, 12, 20, 17, 2, -20 },
  { 1007, 13, 20, 17, 2, -20 },
  { 1040, 10, 20, 13, 2, -20 },
  { 1065, 13, 25, 17, 2, -20 },
  { 1106, 11, 20, 14, 2, -20 },
  { 1134, 10, 20, 12, 1, -20 },
  { 1159, 11, 20, 11, 0, -20 },
  { 1187, 12, 20, 16, 2, -20 },
  { 1217, 13, 20, 13, 0, -20 },
  { 1250, 21, 20, 21, 0, -20 },
  { 1303, 12, 20, 12, 0, -20 },
  { 1333, 11, 20, 11, 0, -20 },
  { 1361, 10, 20, 12, 1, -20 },
  { 1386, 6, 24, 9, 2, -20 },
  { 1404, 8, 20, 10, 1, -20 },
  { 1424, 6, 24, 9, 1, -20 },
  { 1442, 11, 11, 13, 1, -20 },
  { 1458, 12, 2, 12, 0, 2 },
  { 1461, 5, 4, 7, 1, -21 },
  { 1464, 9, 15, 12, 1, -15 },
  { 1481, 10, 21, 14, 2, -21 },
  { 1508, 9, 15, 10, 1, -15 },
  { 1525, 11, 21, 14, 1, -21 },
  { 1554, 10, 15, 12, 1, -15 },
  { 1573, 8, 21, 7, 0, -21 },
  { 1594, 11, 22, 14, 1, -15 },
  { 1625, 9, 21, 13, 2, -21 },
  { 1649, 2, 20, 6, 2, -20 },
  { 1654, 5, 27, 6, -1, -20 },
  { 1671, 9, 21, 11, 2, -21 },
  { 1695, 2, 21, 6, 2, -21 },
  { 1701, 16, 15, 20, 2, -15 },
  { 1731, 9, 15, 13, 2, -15 },
  { 1748, 11, 15, 13, 1, -15 },
  { 1769, 10, 22, 14, 2, -15 },
  { 1797, 11, 22, 14, 1, -15 },
  { 1828, 7, 15, 9, 2, -15 },
  { 1842, 8, 15, 10, 1, -15 },
  { 1857, 7, 18, 7, 0, -18 },
  { 1873, 9, 15, 13, 2, -15 },
  { 1890, 10, 15, 10, 0, -15 },
  { 1909, 17, 15, 17, 0, -15 },
  { 1941, 10, 15, 11, 0, -15 },
  { 1960, 11, 22, 11, 0, -15 },
  { 1991, 8, 15, 9, 1, -15 },
  { 2006, 8, 24, 10, 1, -20 },
  { 2030, 2, 28, 12, 5, -21 },
  { 2037, 8, 24, 10, 1, -20 },
  { 2061, 11, 3, 13, 1, -11 },
};

const GFXfont NotoSans_Condensed_Light28pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light28pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light28pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _NOTOSANS_CONDENSED_LIGHT28PT7B_H_
