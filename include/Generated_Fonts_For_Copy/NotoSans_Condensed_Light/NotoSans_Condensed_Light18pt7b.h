#ifndef _NOTOSANS_CONDENSED_LIGHT18PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light18pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x55, 0x51, 0xC0, 0x99, 0x99, 0x90, 0x12, 0x09, 0x04, 0x82,
  0x47, 0xF8, 0x90, 0x88, 0x48, 0xFF, 0x12, 0x09, 0x04, 0x82, 0x40, 0x10,
  0x47, 0xE4, 0x92, 0x4D, 0x0C, 0x1C, 0x51, 0x45, 0xF8, 0x41, 0x00, 0x61,
  0x24, 0x49, 0x22, 0x48, 0x94, 0x25, 0x69, 0x65, 0xA9, 0x0A, 0x44, 0x91,
  0x24, 0x49, 0x21, 0xC0, 0x38, 0x48, 0x48, 0x48, 0x48, 0x30, 0x70, 0xD1,
  0x8A, 0x86, 0x86, 0x86, 0x79, 0xF8, 0x29, 0x29, 0x24, 0x92, 0x44, 0x99,
  0x91, 0x22, 0x49, 0x24, 0x94, 0xB4, 0x20, 0x8A, 0xDC, 0x31, 0x20, 0x10,
  0x20, 0x40, 0x8F, 0xE2, 0x04, 0x08, 0x10, 0x6A, 0xF0, 0xB0, 0x04, 0x10,
  0x82, 0x10, 0x41, 0x08, 0x20, 0x84, 0x10, 0xC0, 0x39, 0x38, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x51, 0x78, 0x13, 0xD1, 0x11, 0x11, 0x11, 0x11,
  0x10, 0x7A, 0x30, 0x41, 0x04, 0x10, 0x84, 0x10, 0x84, 0x20, 0xFC, 0x7A,
  0x30, 0x41, 0x04, 0x27, 0x03, 0x04, 0x10, 0x41, 0xF8, 0x04, 0x04, 0x0C,
  0x14, 0x14, 0x24, 0x24, 0x44, 0x44, 0xFF, 0x04, 0x04, 0x04, 0x7E, 0x08,
  0x20, 0x83, 0xC0, 0xC1, 0x04, 0x10, 0x43, 0xF8, 0x3D, 0x84, 0x20, 0x82,
  0xEC, 0x61, 0x86, 0x18, 0x51, 0x78, 0xFC, 0x10, 0x41, 0x08, 0x21, 0x04,
  0x10, 0x82, 0x08, 0x40, 0x79, 0x8A, 0x14, 0x2C, 0x4D, 0x0C, 0x26, 0x85,
  0x0E, 0x14, 0x27, 0x80, 0x7B, 0x28, 0x61, 0x86, 0x18, 0x5F, 0x04, 0x10,
  0x42, 0xF0, 0xB0, 0x00, 0xB0, 0xB0, 0x00, 0xEA, 0x06, 0x31, 0x84, 0x06,
  0x03, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0xC0, 0x60, 0x30,
  0x86, 0x30, 0x40, 0xF8, 0x42, 0x10, 0x84, 0x44, 0x21, 0x00, 0x42, 0x00,
  0x0F, 0x06, 0x11, 0x01, 0x20, 0x28, 0xF3, 0x22, 0x64, 0x4C, 0x91, 0x92,
  0x32, 0x6A, 0x37, 0x20, 0x04, 0x00, 0x62, 0x03, 0x80, 0x08, 0x0C, 0x05,
  0x02, 0x82, 0x41, 0x20, 0x88, 0x44, 0x7E, 0x21, 0x90, 0x50, 0x28, 0x18,
  0xF9, 0x8F, 0x0E, 0x1C, 0x38, 0xBF, 0x61, 0xC3, 0x87, 0x0E, 0x1F, 0xC0,
  0x1E, 0xC1, 0x06, 0x08, 0x10, 0x20, 0x40, 0x81, 0x01, 0x03, 0x03, 0xE0,
  0xF8, 0xC6, 0xC2, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC2, 0xC6,
  0xF8, 0xFF, 0x0C, 0x30, 0xC3, 0x0F, 0xF0, 0xC3, 0x0C, 0x30, 0xFC, 0xFF,
  0x0C, 0x30, 0xC3, 0x0F, 0xF0, 0xC3, 0x0C, 0x30, 0xC0, 0x1F, 0x10, 0x90,
  0x18, 0x08, 0x04, 0x02, 0x1F, 0x01, 0x80, 0xC0, 0x50, 0x2C, 0x13, 0xF8,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xFF, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xE9, 0x24, 0x92, 0x49, 0x2E, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x12, 0x2E, 0xC3, 0x8B, 0x36, 0x4D, 0x1E, 0x3C, 0x68, 0xC9, 0x93, 0x16,
  0x3C, 0x20, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC,
  0xC0, 0x78, 0x0E, 0x81, 0xD0, 0x5A, 0x0B, 0x21, 0x64, 0x4C, 0x89, 0x89,
  0x31, 0x46, 0x28, 0xC3, 0x18, 0x42, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91,
  0x89, 0x89, 0x85, 0x85, 0x83, 0x83, 0x81, 0x3E, 0x31, 0x90, 0x50, 0x28,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xD0, 0x48, 0x63, 0xE0, 0xF9, 0x8B,
  0x0E, 0x1C, 0x38, 0xF1, 0x7C, 0xC1, 0x83, 0x06, 0x0C, 0x00, 0x3E, 0x31,
  0x90, 0x50, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xD0, 0x48, 0x63,
  0xE0, 0x20, 0x08, 0x06, 0xF9, 0x8B, 0x0E, 0x1C, 0x38, 0xBF, 0x64, 0xC9,
  0x8B, 0x16, 0x3C, 0x20, 0x7F, 0x08, 0x20, 0x81, 0x03, 0x03, 0x04, 0x10,
  0x41, 0xF8, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x00, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x41, 0x42, 0x3C, 0x81, 0x81, 0x41, 0x42, 0x42, 0x42, 0x24, 0x24, 0x24,
  0x14, 0x18, 0x18, 0x18, 0x82, 0x0E, 0x18, 0x50, 0xC2, 0x8A, 0x34, 0x51,
  0x22, 0x88, 0x92, 0x44, 0x92, 0x28, 0xA1, 0x45, 0x06, 0x18, 0x30, 0xC1,
  0x04, 0x00, 0xC2, 0x84, 0x91, 0x22, 0x83, 0x06, 0x0C, 0x28, 0x49, 0x12,
  0x18, 0x20, 0x82, 0x85, 0x12, 0x22, 0x45, 0x06, 0x08, 0x10, 0x20, 0x40,
  0x81, 0x00, 0xFC, 0x30, 0x82, 0x10, 0x42, 0x08, 0x41, 0x08, 0x20, 0xFC,
  0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0x81, 0x04, 0x08, 0x20,
  0x81, 0x04, 0x10, 0x20, 0x82, 0x04, 0xE4, 0x92, 0x49, 0x24, 0x92, 0x4F,
  0x08, 0x18, 0x14, 0x24, 0x22, 0x42, 0xC1, 0xFF, 0x89, 0x80, 0x72, 0x20,
  0x81, 0x3F, 0x18, 0x63, 0x8F, 0xD0, 0x81, 0x02, 0x04, 0x09, 0x94, 0xB0,
  0xC1, 0x83, 0x06, 0x0E, 0x1C, 0x57, 0x80, 0x3A, 0x21, 0x08, 0x42, 0x10,
  0x43, 0xC0, 0x02, 0x04, 0x08, 0x13, 0x29, 0x61, 0xC3, 0x83, 0x06, 0x1C,
  0x3C, 0x6F, 0x40, 0x31, 0x28, 0x61, 0xFE, 0x08, 0x20, 0x41, 0xF0, 0x19,
  0x08, 0x4F, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x35, 0x38, 0x61, 0x86,
  0x18, 0x61, 0xC5, 0xF0, 0x41, 0x07, 0xE0, 0x82, 0x08, 0x20, 0x9A, 0x9C,
  0x61, 0x86, 0x18, 0x61, 0x86, 0x10, 0xC2, 0xAA, 0xAA, 0x80, 0x60, 0x24,
  0x92, 0x49, 0x24, 0x92, 0xC0, 0x82, 0x08, 0x20, 0x86, 0x29, 0x24, 0xA3,
  0x49, 0x22, 0x8A, 0x10, 0xFF, 0xFC, 0xB9, 0x99, 0xCB, 0x10, 0xC2, 0x18,
  0x43, 0x08, 0x61, 0x0C, 0x21, 0x84, 0x30, 0x84, 0x9B, 0x9C, 0x61, 0x86,
  0x18, 0x61, 0x86, 0x10, 0x38, 0x8A, 0x14, 0x18, 0x30, 0x60, 0xC2, 0x44,
  0xF0, 0x99, 0x4B, 0x0C, 0x18, 0x30, 0x60, 0xE1, 0xC5, 0x7A, 0x04, 0x08,
  0x10, 0x00, 0x35, 0x38, 0x61, 0x86, 0x18, 0x61, 0xC5, 0xF0, 0x41, 0x04,
  0x10, 0x9A, 0xC8, 0x88, 0x88, 0x88, 0x74, 0x61, 0x04, 0x18, 0x21, 0x0F,
  0x80, 0x44, 0xF4, 0x44, 0x44, 0x44, 0x43, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0xC5, 0xF0, 0x83, 0x09, 0x12, 0x24, 0x89, 0x0A, 0x14, 0x30, 0x20,
  0x84, 0x30, 0x85, 0x29, 0x25, 0x24, 0xA4, 0x94, 0x8C, 0x61, 0x8C, 0x31,
  0x86, 0x30, 0xC2, 0x88, 0xB1, 0x41, 0x02, 0x0A, 0x14, 0x45, 0x8C, 0x83,
  0x09, 0x12, 0x24, 0x45, 0x0A, 0x14, 0x30, 0x20, 0x40, 0x82, 0x1C, 0x00,
  0xF0, 0x84, 0x42, 0x21, 0x10, 0x87, 0xC0, 0x19, 0x08, 0x42, 0x10, 0x98,
  0x41, 0x08, 0x42, 0x10, 0x83, 0xFF, 0xFF, 0xC0, 0xC3, 0x08, 0x42, 0x10,
  0x87, 0x31, 0x08, 0x42, 0x11, 0x98, 0xF3, 0x18,
};

const GFXglyph NotoSans_Condensed_Light18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 13, 4, 1, -13 },
  { 5, 4, 5, 6, 1, -13 },
  { 8, 9, 13, 9, 0, -13 },
  { 23, 6, 15, 8, 1, -14 },
  { 35, 10, 13, 12, 1, -13 },
  { 52, 8, 13, 9, 1, -13 },
  { 65, 1, 5, 3, 1, -13 },
  { 66, 3, 16, 5, 1, -13 },
  { 72, 3, 16, 5, 1, -13 },
  { 78, 6, 6, 8, 1, -14 },
  { 83, 7, 9, 8, 1, -11 },
  { 91, 2, 4, 4, 1, -2 },
  { 92, 4, 1, 5, 1, -5 },
  { 93, 2, 2, 4, 1, -2 },
  { 94, 6, 13, 6, 0, -13 },
  { 104, 6, 13, 8, 1, -13 },
  { 114, 4, 13, 8, 1, -13 },
  { 121, 6, 13, 8, 1, -13 },
  { 131, 6, 13, 8, 1, -13 },
  { 141, 8, 13, 8, 0, -13 },
  { 154, 6, 13, 8, 1, -13 },
  { 164, 6, 13, 8, 1, -13 },
  { 174, 6, 13, 8, 1, -13 },
  { 184, 7, 13, 8, 1, -13 },
  { 196, 6, 13, 8, 1, -13 },
  { 206, 2, 10, 4, 1, -10 },
  { 209, 2, 12, 4, 1, -10 },
  { 212, 7, 8, 8, 1, -10 },
  { 219, 7, 5, 8, 1, -9 },
  { 224, 7, 8, 8, 1, -10 },
  { 231, 5, 13, 6, 0, -13 },
  { 240, 11, 15, 13, 1, -13 },
  { 261, 9, 13, 9, 0, -13 },
  { 276, 7, 13, 9, 1, -13 },
  { 288, 7, 13, 9, 1, -13 },
  { 300, 8, 13, 10, 1, -13 },
  { 313, 6, 13, 8, 1, -13 },
  { 323, 6, 13, 7, 1, -13 },
  { 333, 9, 13, 11, 1, -13 },
  { 348, 8, 13, 10, 1, -13 },
  { 361, 3, 13, 5, 1, -13 },
  { 366, 4, 16, 4, -1, -13 },
  { 374, 7, 13, 8, 1, -13 },
  { 386, 6, 13, 7, 1, -13 },
  { 396, 11, 13, 13, 1, -13 },
  { 414, 8, 13, 11, 1, -13 },
  { 427, 9, 13, 11, 1, -13 },
  { 442, 7, 13, 8, 1, -13 },
  { 454, 9, 16, 11, 1, -13 },
  { 472, 7, 13, 9, 1, -13 },
  { 484, 6, 13, 8, 1, -13 },
  { 494, 7, 13, 7, 0, -13 },
  { 506, 8, 13, 10, 1, -13 },
  { 519, 8, 13, 8, 0, -13 },
  { 532, 13, 13, 13, 0, -13 },
  { 554, 7, 13, 8, 0, -13 },
  { 566, 7, 13, 7, 0, -13 },
  { 578, 6, 13, 7, 1, -13 },
  { 588, 4, 16, 6, 1, -13 },
  { 596, 6, 13, 6, 0, -13 },
  { 606, 3, 16, 6, 1, -13 },
  { 612, 8, 7, 8, 0, -13 },
  { 619, 8, 1, 7, 0, 1 },
  { 620, 3, 3, 5, 1, -14 },
  { 622, 6, 10, 8, 1, -10 },
  { 630, 7, 14, 9, 1, -14 },
  { 643, 5, 10, 7, 1, -10 },
  { 650, 7, 14, 9, 1, -14 },
  { 663, 6, 10, 8, 1, -10 },
  { 671, 5, 14, 5, 0, -14 },
  { 680, 6, 14, 9, 1, -10 },
  { 691, 6, 14, 9, 1, -14 },
  { 702, 2, 13, 4, 1, -13 },
  { 706, 3, 17, 4, 0, -13 },
  { 713, 6, 14, 7, 1, -14 },
  { 724, 1, 14, 4, 1, -14 },
  { 726, 11, 10, 13, 1, -10 },
  { 740, 6, 10, 9, 1, -10 },
  { 748, 7, 10, 9, 1, -10 },
  { 757, 7, 14, 9, 1, -10 },
  { 770, 6, 14, 9, 1, -10 },
  { 781, 4, 10, 6, 1, -10 },
  { 786, 5, 10, 7, 1, -10 },
  { 793, 4, 12, 5, 0, -12 },
  { 799, 6, 10, 9, 1, -10 },
  { 807, 7, 10, 7, 0, -10 },
  { 816, 11, 10, 11, 0, -10 },
  { 830, 7, 10, 7, 0, -10 },
  { 839, 7, 14, 7, 0, -10 },
  { 852, 5, 10, 6, 1, -10 },
  { 859, 5, 16, 6, 1, -13 },
  { 869, 1, 18, 8, 3, -14 },
  { 872, 5, 16, 6, 1, -13 },
  { 882, 7, 2, 8, 1, -7 },
};

const GFXfont NotoSans_Condensed_Light18pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light18pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light18pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _NOTOSANS_CONDENSED_LIGHT18PT7B_H_
