#ifndef _NOTOSANS_CONDENSED_LIGHT70PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light70pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC7,
  0x1C, 0x71, 0xC7, 0x1C, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7B, 0xFF,
  0xFF, 0xFD, 0xE3, 0x00, 0xF8, 0x1F, 0x78, 0x1F, 0x78, 0x1F, 0x78, 0x1F,
  0x78, 0x1F, 0x78, 0x0E, 0x78, 0x0E, 0x78, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x70, 0x0E, 0x70, 0x0E, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x78,
  0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xE0,
  0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0x80, 0x1C, 0x00, 0x01,
  0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x38, 0x03, 0x80, 0x00, 0x1C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x3C, 0x01,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80, 0x38,
  0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0xF0, 0x07,
  0x00, 0x00, 0x70, 0x03, 0x80, 0x00, 0x38, 0x03, 0xC0, 0x00, 0x1C, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0x9C, 0x3F,
  0x0F, 0x87, 0x01, 0x87, 0xC1, 0xC0, 0x01, 0xE0, 0x70, 0x00, 0x70, 0x1C,
  0x00, 0x3C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00, 0xF0,
  0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03, 0xC0, 0x70, 0x00,
  0x78, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x03, 0xE1, 0xC0, 0x00, 0xFC, 0x70,
  0x00, 0x1F, 0xDC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xDF, 0xC0,
  0x00, 0x71, 0xF8, 0x00, 0x1C, 0x1F, 0x00, 0x07, 0x03, 0xE0, 0x01, 0xC0,
  0x78, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xF0, 0x01,
  0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x00, 0xE0,
  0x01, 0xC0, 0x78, 0x00, 0x70, 0x1E, 0x00, 0x1C, 0x0F, 0x38, 0x07, 0x07,
  0xCF, 0xC1, 0xC7, 0xE3, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x03, 0xFF,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0x80, 0x03,
  0xFE, 0x00, 0x03, 0xC0, 0x03, 0xC7, 0x80, 0x01, 0xC0, 0x03, 0xC1, 0xE0,
  0x00, 0xE0, 0x01, 0xC0, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x1E, 0x00, 0x78, 0x00, 0x70, 0x07, 0x00, 0x38, 0x00, 0x38,
  0x03, 0x80, 0x1C, 0x00, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x07, 0x80, 0x3C, 0x07, 0x00,
  0x03, 0xC0, 0x1E, 0x03, 0x80, 0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x00, 0xF0,
  0x07, 0x81, 0xC0, 0x00, 0x78, 0x03, 0xC1, 0xE0, 0x00, 0x3C, 0x01, 0xE0,
  0xE0, 0x00, 0x1E, 0x00, 0xF0, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x78, 0x1E,
  0x03, 0x80, 0x38, 0x38, 0x3F, 0xC1, 0xC0, 0x1C, 0x3C, 0x3F, 0xF0, 0xE0,
  0x0E, 0x1C, 0x3C, 0x7C, 0x70, 0x0F, 0x0E, 0x1C, 0x1E, 0x3C, 0x07, 0x0F,
  0x1E, 0x07, 0x8E, 0x03, 0x87, 0x0E, 0x01, 0xC7, 0x83, 0xC7, 0x87, 0x00,
  0xE1, 0xE7, 0xC3, 0x87, 0x80, 0x70, 0x7F, 0xC1, 0xC3, 0x80, 0x3C, 0x1F,
  0xC1, 0xE1, 0xC0, 0x0E, 0x03, 0x80, 0xE0, 0xE0, 0x07, 0x00, 0x00, 0xF0,
  0x70, 0x03, 0x80, 0x00, 0x70, 0x38, 0x01, 0xC0, 0x00, 0x38, 0x1C, 0x00,
  0xE0, 0x00, 0x3C, 0x0E, 0x00, 0x70, 0x00, 0x1C, 0x07, 0x00, 0x38, 0x00,
  0x1E, 0x03, 0x80, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x0E, 0x00, 0x07, 0x00,
  0xE0, 0x07, 0x00, 0x07, 0x80, 0x70, 0x03, 0x80, 0x03, 0x80, 0x38, 0x03,
  0xC0, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0xE0, 0x00,
  0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x00, 0x38, 0x3C, 0x00, 0x38, 0x00, 0x1F, 0x3E,
  0x00, 0x3C, 0x00, 0x07, 0xFE, 0x00, 0x1C, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7C, 0x0F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x38, 0x00, 0x07, 0x80, 0x1C, 0x00, 0x03, 0xC0, 0x0E,
  0x00, 0x01, 0xE0, 0x07, 0x00, 0x00, 0xF0, 0x03, 0x80, 0x00, 0x78, 0x03,
  0xC0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00, 0x78,
  0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01,
  0xF0, 0xF8, 0x01, 0xE1, 0xF0, 0x3C, 0x00, 0xF0, 0xF0, 0x0F, 0x00, 0x78,
  0xF0, 0x07, 0xC0, 0x38, 0x78, 0x01, 0xE0, 0x1C, 0x78, 0x00, 0x78, 0x1E,
  0x3C, 0x00, 0x3E, 0x0F, 0x1E, 0x00, 0x0F, 0x87, 0x0F, 0x00, 0x03, 0xC7,
  0x87, 0x80, 0x00, 0xF3, 0xC3, 0xC0, 0x00, 0x7F, 0xC1, 0xE0, 0x00, 0x1F,
  0xE0, 0xF0, 0x00, 0x07, 0xE0, 0x78, 0x00, 0x03, 0xF0, 0x3C, 0x00, 0x01,
  0xF8, 0x1E, 0x00, 0x00, 0xFC, 0x07, 0x80, 0x00, 0xFF, 0x03, 0xE0, 0x00,
  0xF7, 0xC0, 0xF8, 0x01, 0xF9, 0xF0, 0x7E, 0x01, 0xF8, 0x78, 0x1F, 0xFF,
  0xF0, 0x3E, 0x07, 0xFF, 0xF0, 0x0F, 0x80, 0xFF, 0xE0, 0x03, 0xE0, 0x07,
  0x80, 0x00, 0x00, 0xFB, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0xF8,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x20, 0x1C, 0x03,
  0x78, 0x38, 0x3F, 0xFE, 0x33, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0xF3, 0x80, 0x01,
  0xC7, 0x80, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0xF0,
  0x0F, 0x03, 0xC0, 0x1E, 0x01, 0x80, 0x10, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x1F, 0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78,
  0x70, 0x70, 0xF0, 0xE0, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xC0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x78,
  0x00, 0x78, 0x1E, 0x00, 0x1E, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0,
  0xF0, 0x00, 0x3C, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x39, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x1E,
  0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x83, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x1E, 0x00, 0x7C, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7F,
  0xC3, 0xF7, 0x8F, 0x8F, 0x3E, 0x1E, 0xF8, 0x3F, 0xE0, 0x79, 0x80, 0xF2,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x07,
  0xF0, 0x1F, 0x83, 0xC0, 0x03, 0xE0, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x0F, 0xE0, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0x80, 0x00,
  0xF8, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF3, 0x00, 0x01, 0xF9, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0xF0,
  0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0F, 0x3C, 0x00,
  0x00, 0x38, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x1C, 0x03,
  0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0x70, 0x03, 0xC0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0xC0, 0x0E, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x3C, 0x01, 0xC0, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0, 0x38, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x7F, 0xF0, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xF0, 0x20, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC8,
  0x00, 0x07, 0xC6, 0x00, 0x07, 0xC3, 0xC0, 0x0F, 0xC1, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F,
  0x80, 0x40, 0x3F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x03, 0xF8, 0x07, 0x87, 0xFF, 0x03, 0xCF, 0xFF, 0xE1, 0xCF, 0xE7,
  0xF8, 0xE7, 0x00, 0x7C, 0x77, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0x9F, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x9E, 0x00, 0x03,
  0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x7C, 0x00,
  0xF0, 0x1F, 0x01, 0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x0F, 0x80, 0x7E, 0x07, 0xC0, 0x07, 0x83, 0xE0, 0x01, 0xF0, 0xF0,
  0x00, 0x3C, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x1C, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xC1, 0xE0,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0x80, 0xFC, 0x07, 0xC0,
  0x1F, 0x83, 0xE0, 0x01, 0xE0, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x9E,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x9F, 0x00, 0x03, 0xE3, 0xE0, 0x01, 0xF0, 0x7E, 0x01, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xDE,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3D, 0xE0, 0x00,
  0x1E, 0xF0, 0x00, 0x1F, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xCF, 0x80,
  0x0E, 0xE3, 0xE0, 0x0E, 0xF1, 0xFC, 0x3F, 0x78, 0x7F, 0xFF, 0x3C, 0x1F,
  0xFE, 0x1E, 0x03, 0xFC, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xC0, 0x40, 0x1F, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0x80, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x27, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x0C, 0x3E, 0x3E,
  0x3F, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x78, 0x78, 0x78, 0x70, 0xF0, 0xF0, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x01,
  0xFF, 0xE0, 0x7F, 0xFF, 0x8F, 0xFF, 0xFC, 0x78, 0x07, 0xE6, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xC0, 0x00, 0x18, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x00,
  0xF0, 0x00, 0x00, 0x01, 0xE0, 0x38, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00,
  0x00, 0x00, 0x0F, 0x07, 0x00, 0x00, 0x00, 0x01, 0xC3, 0xC0, 0x01, 0xFF,
  0x00, 0x70, 0xE0, 0x01, 0xFF, 0xE0, 0x1E, 0x78, 0x00, 0xFF, 0xF8, 0x03,
  0x9E, 0x00, 0x78, 0x0E, 0x00, 0xE7, 0x00, 0x3C, 0x03, 0x80, 0x39, 0xC0,
  0x1E, 0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xFC, 0x03, 0xC0,
  0x0E, 0x00, 0xFF, 0x00, 0xF0, 0x03, 0x80, 0x3F, 0x80, 0x38, 0x00, 0xE0,
  0x07, 0xE0, 0x0E, 0x00, 0x38, 0x01, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0x7E,
  0x01, 0xE0, 0x07, 0x80, 0x1F, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0xE0, 0x1E,
  0x00, 0x78, 0x03, 0xF8, 0x07, 0x80, 0x1E, 0x00, 0xFE, 0x01, 0xE0, 0x07,
  0x80, 0x3F, 0x80, 0x78, 0x01, 0xE0, 0x0E, 0xE0, 0x1E, 0x00, 0x78, 0x03,
  0xB8, 0x07, 0x80, 0x1E, 0x00, 0xEE, 0x00, 0xE0, 0x0F, 0x80, 0x7B, 0x80,
  0x38, 0x03, 0x60, 0x1C, 0xE0, 0x0F, 0x00, 0xD8, 0x07, 0x3C, 0x03, 0xC0,
  0x77, 0x03, 0xCF, 0x00, 0x78, 0x39, 0xE1, 0xE1, 0xC0, 0x0F, 0xFC, 0x3F,
  0xF0, 0x70, 0x01, 0xFF, 0x0F, 0xF8, 0x1E, 0x00, 0x3F, 0x00, 0xFC, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x10, 0x00, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0x3B,
  0x80, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x0E,
  0x38, 0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x00,
  0xF0, 0x78, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x38, 0x0F, 0x00, 0x00,
  0x3C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x07, 0x80, 0x3C, 0x00, 0x03, 0xC0, 0x1E, 0x00,
  0x01, 0xC0, 0x07, 0x80, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0xF0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xC0, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x78, 0x00,
  0x03, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00, 0x78, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0xF8, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x83, 0xC0, 0x3F, 0xF0, 0xF0, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xBC, 0x00, 0x01,
  0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0xBC,
  0x00, 0x03, 0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x3E,
  0x3C, 0x00, 0x3F, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x0F, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x7C, 0xF0,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x8F, 0x00, 0x7F,
  0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFC, 0x01, 0xF0, 0x3F, 0x00, 0x02, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x10, 0x1F, 0xE0, 0x0E, 0x00,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0x80, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0x00, 0x0F, 0xE0, 0x78, 0x00, 0x1F, 0x83, 0xC0,
  0x00, 0x7E, 0x1E, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x07, 0xC7, 0x80, 0x00,
  0x1F, 0x3C, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0x7C, 0xF0, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x3E, 0x3C, 0x00, 0x03,
  0xE1, 0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xF0, 0x78, 0x00, 0x7F, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBC,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0x70, 0x0F, 0x80, 0x00, 0x08, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7B,
  0xE0, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0F,
  0x3E, 0x00, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x01,
  0xE1, 0xF0, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x00, 0x78, 0x3F, 0x00, 0x00,
  0x3C, 0x0F, 0xE0, 0x00, 0x1E, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x1F, 0xFE, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03,
  0xE8, 0x1F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFF, 0x07, 0xE0, 0x00, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x8F,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x07, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3E, 0x03, 0xC0, 0x0F, 0x80, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x1F, 0x00, 0x3C, 0x03, 0xC0,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x00, 0x78, 0x7C, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x3C, 0xF8, 0x00, 0x07, 0xBF, 0x80, 0x00, 0xF7, 0xF8, 0x00, 0x1F, 0xEF,
  0x00, 0x03, 0xF9, 0xF0, 0x00, 0x7E, 0x1E, 0x00, 0x0F, 0x83, 0xE0, 0x01,
  0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xF0, 0x0F,
  0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07,
  0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7C, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0xEE, 0x00, 0x00, 0x00, 0x7F, 0xEF, 0x00, 0x00, 0x00, 0xFF, 0xEF, 0x00,
  0x00, 0x00, 0xFF, 0xE7, 0x00, 0x00, 0x00, 0xEF, 0xE7, 0x80, 0x00, 0x01,
  0xEF, 0xE7, 0x80, 0x00, 0x01, 0xEF, 0xF7, 0x80, 0x00, 0x01, 0xCF, 0xF3,
  0xC0, 0x00, 0x03, 0xCF, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0xF3, 0xC0, 0x00,
  0x03, 0x8F, 0xF1, 0xE0, 0x00, 0x07, 0x8F, 0xF1, 0xE0, 0x00, 0x07, 0x8F,
  0xF1, 0xE0, 0x00, 0x07, 0x0F, 0xF0, 0xF0, 0x00, 0x0F, 0x0F, 0xF0, 0xF0,
  0x00, 0x0F, 0x0F, 0xF0, 0xF0, 0x00, 0x0E, 0x0F, 0xF0, 0x70, 0x00, 0x1E,
  0x0F, 0xF0, 0x78, 0x00, 0x1E, 0x0F, 0xF0, 0x78, 0x00, 0x1C, 0x0F, 0xF0,
  0x38, 0x00, 0x3C, 0x0F, 0xF0, 0x3C, 0x00, 0x3C, 0x0F, 0xF0, 0x3C, 0x00,
  0x38, 0x0F, 0xF0, 0x1C, 0x00, 0x78, 0x0F, 0xF0, 0x1E, 0x00, 0x78, 0x0F,
  0xF0, 0x1E, 0x00, 0x70, 0x0F, 0xF0, 0x0E, 0x00, 0xF0, 0x0F, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0x00, 0xE0, 0x0F, 0xF0, 0x07, 0x01, 0xE0,
  0x0F, 0xF0, 0x07, 0x81, 0xE0, 0x0F, 0xF0, 0x07, 0x81, 0xC0, 0x0F, 0xF0,
  0x03, 0x81, 0xC0, 0x0F, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0xF0, 0x03, 0xC3,
  0x80, 0x0F, 0xF0, 0x01, 0xC3, 0x80, 0x0F, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0xF0, 0x01, 0xE7, 0x00, 0x0F, 0xF0, 0x00, 0xE7, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0xF0, 0x00, 0x03, 0xFB,
  0xC0, 0x00, 0x0F, 0xE7, 0x80, 0x00, 0x3F, 0x9E, 0x00, 0x00, 0xFE, 0x3C,
  0x00, 0x03, 0xF8, 0xF0, 0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x3F, 0x87, 0x80,
  0x00, 0xFE, 0x0F, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x0F, 0xF0, 0x78, 0x00,
  0x3F, 0xC1, 0xE0, 0x00, 0xFF, 0x03, 0xC0, 0x03, 0xFC, 0x0F, 0x00, 0x0F,
  0xF0, 0x1E, 0x00, 0x3F, 0xC0, 0x78, 0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFC,
  0x03, 0xC0, 0x0F, 0xF0, 0x07, 0x80, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0x00,
  0x3C, 0x03, 0xFC, 0x00, 0xF0, 0x0F, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x07,
  0x80, 0xFF, 0x00, 0x0F, 0x03, 0xFC, 0x00, 0x3C, 0x0F, 0xF0, 0x00, 0x78,
  0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0x00, 0x03, 0xC3, 0xFC, 0x00, 0x0F, 0x0F,
  0xF0, 0x00, 0x1E, 0x3F, 0xC0, 0x00, 0x78, 0xFF, 0x00, 0x00, 0xF3, 0xFC,
  0x00, 0x03, 0xCF, 0xF0, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0x1E, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF8,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x83,
  0xE0, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F,
  0x1E, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F,
  0x80, 0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xF0, 0x01,
  0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x7C, 0xF0, 0x00,
  0xF8, 0xF0, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xF8, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xE0,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x9E,
  0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x07, 0xBE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x01, 0xE7, 0xC0, 0x00,
  0x00, 0x78, 0xF0, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x07, 0xC1, 0xE0, 0x00, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x0F,
  0x80, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F, 0x00, 0x1F,
  0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x00, 0xF0, 0xF0,
  0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07,
  0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C,
  0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x7C, 0x3C, 0x00,
  0x1F, 0x07, 0x80, 0x07, 0xC0, 0xF0, 0x03, 0xF0, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0x00, 0xF0, 0x01, 0xE0, 0x1E,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E,
  0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC0, 0xF0,
  0x00, 0x7C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x78, 0x00, 0x0F,
  0x0F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0x3C, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7C, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFC, 0x03,
  0xF0, 0xF8, 0x00, 0x30, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF3, 0x00, 0x01, 0xF1,
  0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x7B,
  0xC0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x80,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0xFE, 0x01,
  0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00,
  0x1E, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00,
  0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x07, 0x00, 0x01,
  0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07,
  0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xE0, 0x0F, 0x00, 0x00, 0xF0, 0x0F,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70, 0x1E,
  0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1C,
  0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x3C,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x1E, 0x78,
  0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x0E, 0x70, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x87, 0x80,
  0x00, 0xF7, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x3C, 0x1E,
  0x00, 0x03, 0x9E, 0x00, 0x07, 0x81, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xF0,
  0x3C, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC7, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x70, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x01, 0xE0, 0x03, 0xC3, 0xC0, 0x03, 0xC0, 0x3C, 0x00, 0x78, 0x38,
  0x00, 0xF0, 0x07, 0x80, 0x0E, 0x07, 0x00, 0x1E, 0x00, 0xF0, 0x01, 0xC0,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x38, 0x03, 0xC0, 0x07, 0x80,
  0x38, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x01, 0xC0, 0x78, 0x00,
  0x3C, 0x07, 0x00, 0x38, 0x0F, 0x00, 0x07, 0x80, 0xE0, 0x07, 0x81, 0xE0,
  0x00, 0x78, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x0F, 0x07, 0x80, 0x0E, 0x07,
  0x00, 0x01, 0xE0, 0xF0, 0x01, 0xC1, 0xE0, 0x00, 0x3C, 0x1C, 0x00, 0x3C,
  0x3C, 0x00, 0x03, 0x87, 0x80, 0x07, 0x87, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x0E, 0x3C, 0x00, 0x01, 0xE3, 0x80,
  0x01, 0xC7, 0x80, 0x00, 0x3C, 0x70, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0x9E,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x73, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xDE, 0x00, 0x00,
  0x1D, 0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x78, 0x3E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x1F, 0x00, 0xF0, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0,
  0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x0F, 0x0F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x1E, 0x01, 0xE0, 0x01, 0xE0,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x7C, 0x00, 0x3C, 0x03, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0x81,
  0xE0, 0x00, 0x3E, 0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0xFB, 0xC0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x80, 0x78, 0x00, 0x3C, 0x03, 0xC0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x07, 0x80, 0x01, 0xE0, 0x3C, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F,
  0x0F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1E, 0xE0, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x78,
  0xF0, 0x00, 0x07, 0x83, 0x80, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0xC0, 0x70,
  0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0,
  0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x01,
  0xE0, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0xFF, 0x00, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xF0, 0xFC, 0x1C,
  0x00, 0xF8, 0x20, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFC, 0x07, 0x1F, 0x00, 0x1C, 0xF8, 0x00,
  0x77, 0xC0, 0x01, 0xDE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0xFD, 0xE0, 0x07, 0x77, 0xC0, 0x39,
  0xCF, 0xFF, 0xE7, 0x1F, 0xFF, 0x1C, 0x3F, 0xF0, 0x70, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x7E, 0x00, 0xF0, 0xFF, 0xE0, 0x3C, 0x7F, 0xFE, 0x0F, 0x3F,
  0xFF, 0xC3, 0xDE, 0x01, 0xF8, 0xF7, 0x00, 0x3E, 0x3F, 0x80, 0x07, 0xCF,
  0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8,
  0x00, 0x07, 0xBF, 0x00, 0x03, 0xCF, 0xC0, 0x00, 0xF3, 0xF8, 0x00, 0x78,
  0xF7, 0x00, 0x3E, 0x3D, 0xE0, 0x1F, 0x0E, 0x3F, 0xFF, 0x83, 0x87, 0xFF,
  0xC0, 0xE0, 0x7F, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0xFF, 0x7E, 0x07, 0xC0, 0x10, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x01, 0x81, 0xFF, 0xFE, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x01, 0xFC, 0x0F,
  0x01, 0xFF, 0xC3, 0xC0, 0xFF, 0xF8, 0xF0, 0x7F, 0xFF, 0x3C, 0x3E, 0x01,
  0xEF, 0x1F, 0x00, 0x1F, 0xC7, 0x80, 0x03, 0x73, 0xE0, 0x00, 0xFC, 0xF0,
  0x00, 0x1F, 0x3C, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x3C, 0x00, 0x07, 0xCF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0xFC, 0x78, 0x00, 0x37, 0x1F, 0x00, 0x19, 0xC3,
  0xF0, 0x1E, 0x70, 0x7F, 0xFF, 0x1C, 0x0F, 0xFF, 0x87, 0x01, 0xFF, 0xC1,
  0xC0, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0xFE, 0x7F, 0x00, 0xF8, 0x07, 0xC0, 0x78, 0x01, 0xE0, 0x78,
  0x00, 0x78, 0x38, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x07, 0x9E,
  0x00, 0x01, 0xCF, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x01, 0x81, 0xF0, 0x03, 0xC0, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0,
  0x07, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x04, 0x00, 0x0F, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x1E, 0x04, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0xFF,
  0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x70, 0x3F, 0xFE,
  0x1C, 0x1F, 0xFF, 0xC7, 0x0F, 0x80, 0x39, 0xC7, 0xC0, 0x07, 0x71, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xCF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x37, 0x1E,
  0x00, 0x1F, 0xC7, 0xC0, 0x0E, 0xF0, 0xFC, 0x07, 0xBC, 0x1F, 0xFF, 0xCF,
  0x03, 0xFF, 0xE3, 0xC0, 0x7F, 0xE0, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x08, 0x00, 0x07, 0xC3, 0xC0, 0x07,
  0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0,
  0x1F, 0x80, 0xF0, 0xFF, 0xE0, 0xF1, 0xFF, 0xF8, 0xF3, 0xFF, 0xF8, 0xF7,
  0x80, 0x7C, 0xF7, 0x00, 0x3C, 0xFE, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xFC,
  0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF7, 0xFF, 0xFF, 0xB8, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7,
  0xBC, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x81, 0xF0, 0x3C, 0xFF, 0x9F, 0xE3, 0xF8, 0x7C, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x7D,
  0xE0, 0x01, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x0F, 0x00, 0x3C, 0x1E,
  0x00, 0x78, 0x3C, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xE0,
  0x3C, 0x03, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x1E,
  0x00, 0x3C, 0x78, 0x00, 0x78, 0xF8, 0x00, 0xF3, 0xF0, 0x01, 0xEF, 0xF0,
  0x03, 0xDD, 0xE0, 0x07, 0xF1, 0xE0, 0x0F, 0xC3, 0xC0, 0x1F, 0x83, 0xC0,
  0x3E, 0x07, 0x80, 0x78, 0x07, 0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF9, 0xE0, 0x00, 0xF3, 0xC0,
  0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0xE1, 0xFF, 0xE0,
  0x7F, 0xFC, 0xE3, 0xF7, 0xF0, 0xFD, 0xFC, 0xE7, 0x00, 0xF9, 0xC0, 0x3E,
  0xFE, 0x00, 0x7B, 0x80, 0x1E, 0xFC, 0x00, 0x7B, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x1F, 0x80,
  0xE0, 0xFF, 0xE0, 0xE1, 0xFF, 0xF8, 0xE3, 0xF3, 0xFC, 0xE7, 0x80, 0x7C,
  0xE7, 0x00, 0x3E, 0xFE, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFD, 0xFE, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07,
  0x80, 0x03, 0xC1, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x87, 0x80, 0x00,
  0x71, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7B, 0x80, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x3F, 0x01,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x38, 0x1F, 0xF8, 0x0E, 0x1F, 0xFF,
  0x83, 0x8F, 0xEF, 0xF0, 0xE3, 0x80, 0x7E, 0x3D, 0xC0, 0x07, 0x8F, 0xE0,
  0x01, 0xF3, 0xF0, 0x00, 0x3C, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00,
  0x07, 0xBE, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0xF3, 0xF0, 0x00, 0x3C, 0xFE,
  0x00, 0x1E, 0x3D, 0xC0, 0x0F, 0x8F, 0x38, 0x07, 0xC3, 0xCF, 0xFF, 0xE0,
  0xF1, 0xFF, 0xF0, 0x3C, 0x1F, 0xF8, 0x0F, 0x01, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xF0, 0x70, 0x3F, 0xFE, 0x1C,
  0x1F, 0xFF, 0xC7, 0x0F, 0x80, 0x79, 0xC7, 0xC0, 0x07, 0x71, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF7, 0x80,
  0x00, 0x7D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0x78, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x37, 0x1E, 0x00,
  0x1F, 0xC7, 0xC0, 0x0E, 0xF0, 0xFC, 0x07, 0xBC, 0x1F, 0xFF, 0xCF, 0x03,
  0xFF, 0xE3, 0xC0, 0x7F, 0xE0, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x3F, 0xE0, 0xFF, 0xE1, 0xFF, 0xE3, 0xFF, 0xE3, 0xC0, 0xF7,
  0x00, 0xF6, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xFC, 0x1F, 0xFF,
  0xF3, 0xFC, 0x7E, 0x7C, 0x00, 0xE7, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x1E, 0xF0, 0x07, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x83, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x03,
  0xFF, 0x01, 0xFF, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xDE, 0x00, 0x0F, 0xBC, 0x00,
  0x37, 0x7C, 0x00, 0xEE, 0x7C, 0x07, 0x9C, 0xFF, 0xFE, 0x38, 0xFF, 0xF8,
  0x70, 0x7F, 0xE0, 0xE0, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x07, 0x8F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x1E,
  0x07, 0x80, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x0F, 0x00,
  0x3C, 0x03, 0xC0, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x80, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x38, 0x07, 0x00, 0x0F, 0x03, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x87,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x0E, 0x1C, 0x00, 0x03,
  0xCF, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0x38, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xCE,
  0x00, 0x07, 0xE0, 0x01, 0xE7, 0x80, 0x07, 0xF0, 0x00, 0xF3, 0xC0, 0x03,
  0xB8, 0x00, 0x79, 0xE0, 0x01, 0xDC, 0x00, 0x38, 0x70, 0x00, 0xEF, 0x00,
  0x1C, 0x3C, 0x00, 0xF7, 0x80, 0x1E, 0x1E, 0x00, 0x79, 0xC0, 0x0F, 0x0F,
  0x00, 0x38, 0xE0, 0x07, 0x83, 0x80, 0x1C, 0x70, 0x03, 0x81, 0xE0, 0x1E,
  0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x0E, 0x01, 0xE0, 0x78, 0x07, 0x07, 0x00,
  0xF0, 0x3C, 0x03, 0x83, 0x80, 0x70, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x03, 0xC0, 0xE0, 0x38, 0x1E, 0x01, 0xE0, 0x70,
  0x1C, 0x0E, 0x00, 0x70, 0x78, 0x0F, 0x07, 0x00, 0x3C, 0x3C, 0x07, 0x87,
  0x80, 0x1E, 0x1C, 0x01, 0xC3, 0xC0, 0x0F, 0x0E, 0x00, 0xE1, 0xC0, 0x03,
  0x8F, 0x00, 0x78, 0xE0, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x00, 0xF3, 0x80,
  0x0E, 0x78, 0x00, 0x79, 0xC0, 0x07, 0x3C, 0x00, 0x1C, 0xE0, 0x03, 0x9C,
  0x00, 0x0E, 0xF0, 0x01, 0xEE, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x9E, 0x00, 0x07,
  0x8F, 0x00, 0x07, 0x83, 0xC0, 0x03, 0xC1, 0xF0, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0xBC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE1, 0xE0,
  0x01, 0xE0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x07,
  0x80, 0x78, 0x03, 0xC0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xDC, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xE7, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x0E, 0x07, 0x80, 0x0F,
  0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x01, 0xC0, 0x3C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x03, 0xC0, 0x78, 0x01, 0xE0,
  0x3C, 0x00, 0x70, 0x1E, 0x00, 0x3C, 0x0E, 0x00, 0x1E, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0x83, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00,
  0x38, 0xF0, 0x00, 0x1C, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xBC, 0x00,
  0x01, 0xDC, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x01, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8,
  0x00, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x2F, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xF8, 0x1F,
  0xF3, 0xFC, 0x00, 0xFF, 0xFD, 0x00, 0x07, 0xFF, 0x20, 0x00, 0x3F, 0x80,
};

const GFXglyph NotoSans_Condensed_Light70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 51, 16, 5, -50 },
  { 40, 16, 18, 24, 4, -50 },
  { 76, 33, 50, 35, 1, -50 },
  { 283, 26, 57, 32, 3, -53 },
  { 469, 41, 52, 47, 3, -51 },
  { 736, 33, 52, 36, 3, -51 },
  { 951, 5, 18, 13, 4, -50 },
  { 963, 14, 61, 19, 3, -50 },
  { 1070, 14, 61, 19, 2, -50 },
  { 1177, 23, 23, 30, 3, -53 },
  { 1244, 27, 33, 32, 3, -41 },
  { 1356, 8, 17, 15, 3, -8 },
  { 1373, 16, 4, 20, 2, -21 },
  { 1381, 5, 7, 15, 5, -6 },
  { 1386, 22, 50, 24, 1, -50 },
  { 1524, 26, 52, 32, 3, -51 },
  { 1693, 15, 50, 32, 5, -50 },
  { 1787, 25, 51, 32, 3, -51 },
  { 1947, 25, 52, 32, 3, -51 },
  { 2110, 30, 50, 32, 1, -50 },
  { 2298, 25, 51, 32, 4, -50 },
  { 2458, 25, 52, 32, 4, -51 },
  { 2621, 26, 50, 32, 3, -50 },
  { 2784, 26, 52, 32, 3, -51 },
  { 2953, 25, 52, 32, 3, -51 },
  { 3116, 5, 39, 15, 5, -38 },
  { 3141, 8, 47, 15, 3, -38 },
  { 3188, 27, 30, 32, 3, -40 },
  { 3290, 27, 18, 32, 3, -34 },
  { 3351, 27, 30, 32, 3, -40 },
  { 3453, 20, 52, 23, 1, -51 },
  { 3583, 42, 56, 49, 4, -50 },
  { 3877, 33, 50, 33, 0, -50 },
  { 4084, 26, 50, 35, 6, -50 },
  { 4247, 28, 52, 34, 4, -51 },
  { 4429, 29, 50, 39, 6, -50 },
  { 4611, 21, 50, 31, 6, -50 },
  { 4743, 21, 50, 29, 6, -50 },
  { 4875, 33, 52, 41, 4, -51 },
  { 5090, 28, 50, 40, 6, -50 },
  { 5265, 13, 50, 19, 3, -50 },
  { 5347, 14, 63, 15, -4, -50 },
  { 5458, 27, 50, 33, 6, -50 },
  { 5627, 21, 50, 28, 6, -50 },
  { 5759, 40, 50, 52, 6, -50 },
  { 6009, 30, 50, 42, 6, -50 },
  { 6197, 34, 52, 42, 4, -51 },
  { 6418, 24, 50, 33, 6, -50 },
  { 6568, 34, 63, 42, 4, -51 },
  { 6836, 27, 50, 34, 6, -50 },
  { 7005, 25, 52, 31, 3, -51 },
  { 7168, 27, 50, 29, 1, -50 },
  { 7337, 30, 51, 40, 5, -50 },
  { 7529, 32, 50, 32, 0, -50 },
  { 7729, 51, 50, 52, 1, -50 },
  { 8048, 29, 50, 29, 0, -50 },
  { 8230, 29, 50, 29, 0, -50 },
  { 8412, 25, 50, 29, 2, -50 },
  { 8569, 14, 61, 22, 6, -50 },
  { 8676, 22, 50, 24, 1, -50 },
  { 8814, 14, 61, 22, 2, -50 },
  { 8921, 29, 27, 32, 2, -50 },
  { 9019, 29, 3, 29, 0, 6 },
  { 9030, 12, 12, 18, 3, -54 },
  { 9048, 22, 39, 30, 3, -38 },
  { 9156, 26, 54, 34, 5, -53 },
  { 9332, 22, 39, 26, 3, -38 },
  { 9440, 26, 54, 34, 3, -53 },
  { 9616, 25, 39, 31, 3, -38 },
  { 9738, 19, 54, 18, 1, -54 },
  { 9867, 26, 55, 34, 3, -38 },
  { 10046, 24, 53, 34, 5, -53 },
  { 10205, 5, 51, 14, 5, -51 },
  { 10237, 11, 68, 14, -1, -51 },
  { 10331, 23, 53, 28, 5, -53 },
  { 10484, 4, 53, 14, 5, -53 },
  { 10511, 40, 38, 50, 5, -38 },
  { 10701, 24, 38, 34, 5, -38 },
  { 10815, 27, 39, 33, 3, -38 },
  { 10947, 26, 55, 34, 5, -38 },
  { 11126, 26, 55, 34, 3, -38 },
  { 11305, 16, 38, 22, 5, -38 },
  { 11381, 20, 39, 26, 3, -38 },
  { 11479, 16, 47, 19, 1, -46 },
  { 11573, 23, 38, 34, 5, -37 },
  { 11683, 26, 37, 26, 0, -37 },
  { 11804, 41, 37, 43, 1, -37 },
  { 11994, 25, 37, 27, 1, -37 },
  { 12110, 25, 54, 27, 1, -37 },
  { 12279, 19, 37, 23, 2, -37 },
  { 12367, 19, 61, 25, 3, -50 },
  { 12512, 3, 70, 31, 14, -53 },
  { 12539, 19, 61, 25, 3, -50 },
  { 12684, 27, 7, 32, 3, -28 },
};

const GFXfont NotoSans_Condensed_Light70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light70pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_CONDENSED_LIGHT70PT7B_H_
