#ifndef _NOTOSANS_CONDENSED_LIGHT22PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT22PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light22pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF3, 0xCE, 0x52, 0x94, 0xA4, 0x08, 0x81, 0x10, 0x22, 0x04,
  0x40, 0x90, 0xFF, 0xC4, 0x40, 0x88, 0x11, 0x02, 0x23, 0xFF, 0x09, 0x02,
  0x20, 0x44, 0x08, 0x81, 0x10, 0x10, 0x10, 0x7E, 0xD1, 0x90, 0x90, 0x90,
  0x50, 0x30, 0x1C, 0x12, 0x11, 0x11, 0x11, 0x92, 0xFC, 0x10, 0x10, 0x70,
  0x42, 0x42, 0x22, 0x21, 0x11, 0x08, 0x90, 0x44, 0x82, 0x25, 0x91, 0x5A,
  0x5A, 0x8B, 0xA4, 0x41, 0x22, 0x09, 0x10, 0x88, 0x84, 0x44, 0x42, 0x42,
  0x0E, 0x38, 0x09, 0x04, 0x61, 0x08, 0x46, 0x09, 0x02, 0x80, 0x40, 0x78,
  0x13, 0x38, 0x4A, 0x0A, 0x83, 0xA0, 0x4C, 0x29, 0xF3, 0xF5, 0x50, 0x13,
  0x26, 0x44, 0xC8, 0x88, 0x88, 0x8C, 0x44, 0x62, 0x30, 0x84, 0x42, 0x22,
  0x31, 0x11, 0x11, 0x13, 0x22, 0x64, 0xC0, 0x10, 0x20, 0x47, 0xF1, 0x05,
  0x19, 0x22, 0x08, 0x08, 0x08, 0x08, 0x08, 0xFF, 0x08, 0x08, 0x08, 0x08,
  0x5E, 0x80, 0xFF, 0xC0, 0x70, 0x02, 0x04, 0x18, 0x20, 0x41, 0x02, 0x04,
  0x10, 0x20, 0xC1, 0x02, 0x0C, 0x10, 0x60, 0x3C, 0x66, 0x42, 0x43, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3, 0x42, 0x66, 0x3C, 0x13,
  0x59, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x3C, 0xC6, 0x02, 0x02, 0x03,
  0x02, 0x02, 0x06, 0x04, 0x0C, 0x18, 0x10, 0x20, 0x40, 0xC0, 0xFF, 0x3C,
  0xC6, 0x02, 0x03, 0x03, 0x02, 0x06, 0x38, 0x0C, 0x02, 0x03, 0x01, 0x01,
  0x03, 0x82, 0xFC, 0x03, 0x00, 0xC0, 0x50, 0x14, 0x09, 0x02, 0x41, 0x10,
  0xC4, 0x21, 0x18, 0x44, 0x13, 0xFF, 0x01, 0x00, 0x40, 0x10, 0x04, 0x7E,
  0x40, 0x40, 0x40, 0x40, 0x40, 0x50, 0xFE, 0x02, 0x01, 0x01, 0x01, 0x01,
  0x03, 0x86, 0xFC, 0x1E, 0x30, 0x60, 0x40, 0x40, 0xC0, 0x9C, 0xA6, 0xC3,
  0xC1, 0x81, 0x81, 0xC1, 0x41, 0x62, 0x3C, 0xFF, 0x01, 0x03, 0x02, 0x02,
  0x06, 0x04, 0x04, 0x08, 0x08, 0x08, 0x10, 0x10, 0x30, 0x20, 0x20, 0x3C,
  0x62, 0xC3, 0xC1, 0xC3, 0x42, 0x66, 0x18, 0x3C, 0x42, 0x81, 0x81, 0x81,
  0x81, 0x42, 0x7E, 0x3C, 0x66, 0xC2, 0x83, 0x81, 0x81, 0x81, 0xC3, 0x45,
  0x39, 0x01, 0x02, 0x02, 0x06, 0x04, 0x78, 0x70, 0x00, 0x07, 0x50, 0x00,
  0x05, 0xE8, 0x01, 0x03, 0x0C, 0x30, 0xC0, 0xC0, 0x30, 0x0C, 0x07, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x03,
  0x0C, 0x38, 0xE0, 0x80, 0x79, 0x88, 0x18, 0x10, 0x60, 0x81, 0x04, 0x10,
  0x20, 0x81, 0x00, 0x00, 0x0C, 0x18, 0x07, 0x80, 0xC3, 0x0C, 0x0C, 0x40,
  0x24, 0x00, 0xA3, 0xE7, 0x32, 0x31, 0x11, 0x88, 0x8C, 0x44, 0x62, 0x23,
  0x11, 0x1C, 0xD5, 0x21, 0x11, 0x00, 0x04, 0x00, 0x30, 0x40, 0x7C, 0x00,
  0x0C, 0x03, 0x00, 0xE0, 0x28, 0x12, 0x04, 0x81, 0x30, 0xC4, 0x21, 0x0F,
  0xE3, 0xF9, 0x82, 0x40, 0x90, 0x3C, 0x06, 0x01, 0xF8, 0x86, 0x83, 0x81,
  0x81, 0x83, 0x82, 0xFC, 0x86, 0x83, 0x81, 0x81, 0x81, 0x83, 0x82, 0xFC,
  0x0F, 0x1C, 0x48, 0x08, 0x04, 0x06, 0x03, 0x01, 0x00, 0x80, 0x60, 0x30,
  0x08, 0x04, 0x03, 0x00, 0xC2, 0x3F, 0xF8, 0x47, 0x20, 0xD0, 0x28, 0x1C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x14, 0x1A, 0x19, 0xF8,
  0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x7E, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x7F, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFD, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x0F, 0x83, 0x08, 0x80, 0x30, 0x04, 0x01, 0x80,
  0x30, 0x04, 0x00, 0x83, 0xF8, 0x0F, 0x01, 0xA0, 0x34, 0x06, 0xC0, 0xCC,
  0x18, 0xFE, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xFF, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF6, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x6F, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x3E, 0x81, 0x82, 0x86, 0x8C, 0x88, 0x90, 0xB0, 0xB0, 0xD0, 0x98,
  0x88, 0x8C, 0x84, 0x82, 0x82, 0x81, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0xC0,
  0x7A, 0x05, 0xD0, 0x2E, 0xC1, 0x72, 0x13, 0x90, 0x9C, 0xC4, 0xE2, 0x67,
  0x12, 0x38, 0xD1, 0xC3, 0x8E, 0x18, 0x70, 0xC3, 0x80, 0xE0, 0x70, 0x34,
  0x1A, 0x0C, 0x86, 0x43, 0x11, 0x88, 0xC2, 0x61, 0x30, 0x58, 0x2C, 0x0E,
  0x07, 0x01, 0x0F, 0x06, 0x31, 0x83, 0x20, 0x24, 0x07, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0xA0, 0x34, 0x04, 0xC0, 0x8C, 0x20, 0xF8,
  0xF9, 0x1A, 0x0C, 0x18, 0x30, 0x60, 0xC3, 0xFD, 0xE2, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x0F, 0x06, 0x31, 0x83, 0x20, 0x24, 0x07, 0x80, 0x70, 0x0C,
  0x01, 0x80, 0x38, 0x07, 0x00, 0xA0, 0x34, 0x04, 0xC0, 0x8C, 0x20, 0xF8,
  0x03, 0x00, 0x20, 0x02, 0x00, 0x60, 0xF8, 0x8E, 0x82, 0x82, 0x83, 0x82,
  0x82, 0x86, 0xFC, 0x88, 0x88, 0x84, 0x84, 0x82, 0x82, 0x81, 0x3F, 0x62,
  0xC0, 0x80, 0x80, 0xC0, 0x60, 0x30, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x03,
  0x86, 0xFC, 0xFF, 0x84, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x09,
  0x0C, 0x7C, 0x80, 0x70, 0x34, 0x09, 0x02, 0x40, 0x98, 0x62, 0x10, 0x84,
  0x21, 0x04, 0xC1, 0x20, 0x48, 0x1E, 0x03, 0x00, 0xC0, 0x30, 0xC0, 0x81,
  0xC1, 0x81, 0x41, 0x83, 0x41, 0xC3, 0x41, 0x42, 0x63, 0x42, 0x22, 0x42,
  0x22, 0x46, 0x22, 0x24, 0x32, 0x24, 0x14, 0x24, 0x14, 0x2C, 0x14, 0x38,
  0x14, 0x18, 0x1C, 0x18, 0x08, 0x18, 0x40, 0xA0, 0x88, 0x44, 0x41, 0x20,
  0xB0, 0x70, 0x18, 0x0C, 0x0A, 0x05, 0x86, 0x42, 0x33, 0x09, 0x05, 0x81,
  0x80, 0xE0, 0x90, 0x4C, 0x62, 0x21, 0x10, 0xD0, 0x28, 0x1C, 0x04, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0xFE, 0x04, 0x18, 0x20, 0x41, 0x02,
  0x08, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0x7F, 0xF8, 0x88, 0x88, 0x88,
  0x88, 0x88, 0x88, 0x88, 0x88, 0xFF, 0xC0, 0x81, 0x01, 0x02, 0x04, 0x04,
  0x08, 0x18, 0x10, 0x20, 0x20, 0x40, 0x80, 0x81, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0xFF, 0x08, 0x0C, 0x07, 0x04, 0x82, 0x62,
  0x11, 0x0D, 0x02, 0x81, 0x80, 0xFF, 0x80, 0xC4, 0x21, 0x3C, 0x8C, 0x08,
  0x10, 0x23, 0xD8, 0xC1, 0x83, 0x0E, 0x1B, 0xD0, 0x80, 0x80, 0x80, 0x80,
  0x80, 0xBC, 0xC6, 0x82, 0x83, 0x83, 0x81, 0x81, 0x83, 0x83, 0x82, 0xC6,
  0xBC, 0x1E, 0xC5, 0x06, 0x08, 0x10, 0x20, 0x40, 0xC0, 0x81, 0x81, 0xF0,
  0x01, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x67, 0x43, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0xC1, 0x43, 0x3D, 0x3C, 0x66, 0x42, 0xC3, 0x81, 0xFF, 0x80,
  0x80, 0xC0, 0x40, 0x61, 0x3E, 0x1C, 0xC2, 0x08, 0x23, 0xE2, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x3D, 0x63, 0x43, 0xC1, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC3, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x82, 0x7E, 0x81,
  0x02, 0x04, 0x08, 0x17, 0xB1, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x82, 0xD0, 0x55, 0x55, 0x55, 0x64, 0x02, 0x49, 0x24, 0x92, 0x49,
  0x24, 0xBC, 0x81, 0x02, 0x04, 0x08, 0x10, 0xA3, 0x44, 0x91, 0x43, 0x86,
  0x89, 0x11, 0x22, 0x42, 0x86, 0xFF, 0xFF, 0x80, 0xB8, 0xEC, 0x53, 0x86,
  0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0x86,
  0x18, 0x61, 0xBD, 0x8E, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x10, 0x3C, 0x62, 0x43, 0xC1, 0x81, 0x81, 0x81, 0x81, 0xC1, 0x41, 0x42,
  0x3E, 0xBC, 0xC6, 0x82, 0x83, 0x83, 0x81, 0x81, 0x83, 0x83, 0x82, 0xC6,
  0xBC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x3D, 0x67, 0x43, 0xC1, 0x81, 0x81,
  0x81, 0x81, 0x81, 0xC3, 0x43, 0x3D, 0x01, 0x01, 0x01, 0x01, 0x01, 0xBF,
  0x31, 0x08, 0x42, 0x10, 0x84, 0x21, 0x00, 0x7F, 0x18, 0x20, 0xC1, 0x81,
  0x83, 0x04, 0x18, 0x7E, 0x21, 0x3E, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x1C, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0E, 0x1B, 0xD0,
  0x81, 0xC1, 0x43, 0x42, 0x42, 0x26, 0x24, 0x24, 0x34, 0x18, 0x18, 0x18,
  0xC2, 0x0A, 0x18, 0x50, 0xC2, 0x8A, 0x24, 0x51, 0x32, 0x48, 0x92, 0x45,
  0x16, 0x28, 0xA1, 0xC3, 0x06, 0x18, 0x20, 0xC0, 0x41, 0x62, 0x22, 0x34,
  0x14, 0x18, 0x18, 0x14, 0x34, 0x22, 0x42, 0xC1, 0xC1, 0x41, 0x43, 0x42,
  0x62, 0x22, 0x24, 0x34, 0x14, 0x1C, 0x18, 0x08, 0x18, 0x10, 0x10, 0x30,
  0xE0, 0xFC, 0x30, 0x86, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x3F, 0x0C, 0x63,
  0x08, 0x20, 0x82, 0x08, 0x23, 0x06, 0x08, 0x20, 0x82, 0x08, 0x20, 0xC1,
  0xC1, 0xFF, 0xFF, 0xFC, 0xC1, 0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x71,
  0x84, 0x30, 0xC3, 0x0C, 0x30, 0x8E, 0x20, 0x71, 0x9F,
};

const GFXglyph NotoSans_Condensed_Light22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 16, 5, 2, -16 },
  { 3, 5, 6, 8, 1, -16 },
  { 7, 11, 16, 11, 0, -16 },
  { 29, 8, 18, 10, 1, -17 },
  { 47, 13, 16, 15, 1, -16 },
  { 73, 10, 16, 11, 1, -16 },
  { 93, 2, 6, 4, 1, -16 },
  { 95, 4, 19, 6, 1, -16 },
  { 105, 4, 19, 6, 1, -16 },
  { 115, 7, 8, 9, 1, -17 },
  { 122, 8, 10, 10, 1, -13 },
  { 132, 2, 5, 5, 1, -2 },
  { 134, 5, 2, 6, 1, -7 },
  { 136, 2, 2, 5, 1, -2 },
  { 137, 7, 16, 8, 0, -16 },
  { 151, 8, 16, 10, 1, -16 },
  { 167, 4, 16, 10, 2, -16 },
  { 175, 8, 16, 10, 1, -16 },
  { 191, 8, 16, 10, 1, -16 },
  { 207, 10, 16, 10, 0, -16 },
  { 227, 8, 16, 10, 1, -16 },
  { 243, 8, 16, 10, 1, -16 },
  { 259, 8, 16, 10, 1, -16 },
  { 275, 8, 16, 10, 1, -16 },
  { 291, 8, 16, 10, 1, -16 },
  { 307, 2, 12, 5, 1, -12 },
  { 310, 2, 15, 5, 1, -12 },
  { 314, 8, 10, 10, 1, -13 },
  { 324, 8, 6, 10, 1, -11 },
  { 330, 8, 10, 10, 1, -13 },
  { 340, 7, 16, 7, 0, -16 },
  { 354, 13, 18, 16, 1, -16 },
  { 384, 10, 16, 10, 0, -16 },
  { 404, 8, 16, 11, 2, -16 },
  { 420, 9, 16, 11, 1, -16 },
  { 438, 9, 16, 12, 2, -16 },
  { 456, 7, 16, 10, 2, -16 },
  { 470, 7, 16, 9, 2, -16 },
  { 484, 11, 16, 13, 1, -16 },
  { 506, 9, 16, 13, 2, -16 },
  { 524, 4, 16, 6, 1, -16 },
  { 532, 4, 20, 5, -1, -16 },
  { 542, 8, 16, 10, 2, -16 },
  { 558, 6, 16, 9, 2, -16 },
  { 570, 13, 16, 16, 2, -16 },
  { 596, 9, 16, 13, 2, -16 },
  { 614, 11, 16, 13, 1, -16 },
  { 636, 7, 16, 10, 2, -16 },
  { 650, 11, 20, 13, 1, -16 },
  { 678, 8, 16, 11, 2, -16 },
  { 694, 8, 16, 10, 1, -16 },
  { 710, 9, 16, 9, 0, -16 },
  { 728, 9, 16, 13, 2, -16 },
  { 746, 10, 16, 10, 0, -16 },
  { 766, 16, 16, 16, 0, -16 },
  { 798, 9, 16, 9, 0, -16 },
  { 816, 9, 16, 9, 0, -16 },
  { 834, 7, 16, 9, 1, -16 },
  { 848, 4, 20, 7, 2, -16 },
  { 858, 7, 16, 8, 0, -16 },
  { 872, 4, 20, 7, 1, -16 },
  { 882, 9, 9, 10, 1, -16 },
  { 893, 9, 1, 9, 0, 2 },
  { 895, 4, 4, 6, 1, -17 },
  { 897, 7, 12, 10, 1, -12 },
  { 908, 8, 17, 11, 2, -17 },
  { 925, 7, 12, 8, 1, -12 },
  { 936, 8, 17, 11, 1, -17 },
  { 953, 8, 12, 10, 1, -12 },
  { 965, 6, 17, 6, 0, -17 },
  { 978, 8, 17, 11, 1, -12 },
  { 995, 7, 17, 11, 2, -17 },
  { 1010, 2, 16, 5, 1, -16 },
  { 1014, 3, 21, 5, 0, -16 },
  { 1022, 7, 17, 9, 2, -17 },
  { 1037, 1, 17, 4, 2, -17 },
  { 1040, 12, 12, 16, 2, -12 },
  { 1058, 7, 12, 11, 2, -12 },
  { 1069, 8, 12, 10, 1, -12 },
  { 1081, 8, 17, 11, 2, -12 },
  { 1098, 8, 17, 11, 1, -12 },
  { 1115, 5, 12, 7, 2, -12 },
  { 1123, 6, 12, 8, 1, -12 },
  { 1132, 5, 14, 6, 0, -14 },
  { 1141, 7, 12, 11, 2, -12 },
  { 1152, 8, 12, 8, 0, -12 },
  { 1164, 13, 12, 13, 0, -12 },
  { 1184, 8, 12, 9, 0, -12 },
  { 1196, 8, 17, 8, 0, -12 },
  { 1213, 6, 12, 7, 1, -12 },
  { 1222, 6, 20, 8, 1, -16 },
  { 1237, 1, 22, 10, 4, -17 },
  { 1240, 6, 20, 8, 1, -16 },
  { 1255, 8, 2, 10, 1, -9 },
};

const GFXfont NotoSans_Condensed_Light22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light22pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_CONDENSED_LIGHT22PT7B_H_
