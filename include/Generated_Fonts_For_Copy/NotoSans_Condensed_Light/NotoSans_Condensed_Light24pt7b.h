#ifndef _NOTOSANS_CONDENSED_LIGHT24PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT24PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light24pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xAA, 0xAA, 0x83, 0xC0, 0x9C, 0xE7, 0x39, 0xC8, 0x0C, 0x40,
  0x84, 0x08, 0x80, 0x88, 0x08, 0x87, 0xFF, 0x08, 0x81, 0x88, 0x10, 0x81,
  0x18, 0x11, 0x0F, 0xFE, 0x11, 0x01, 0x10, 0x11, 0x02, 0x10, 0x23, 0x00,
  0x08, 0x0C, 0x1F, 0xD9, 0x08, 0x84, 0x42, 0x20, 0x90, 0x38, 0x0E, 0x02,
  0xC1, 0x30, 0x88, 0x44, 0x27, 0x16, 0xFE, 0x04, 0x02, 0x00, 0x78, 0x21,
  0x21, 0x08, 0xC4, 0x21, 0x10, 0x84, 0x82, 0x12, 0x08, 0xD1, 0x23, 0x5E,
  0x4B, 0x45, 0xE9, 0x10, 0x24, 0x41, 0x31, 0x04, 0x44, 0x31, 0x10, 0x84,
  0x42, 0x13, 0x10, 0x38, 0x3E, 0x04, 0x41, 0x88, 0x31, 0x02, 0x20, 0x4C,
  0x0D, 0x00, 0xC0, 0x38, 0x0D, 0x8F, 0x19, 0x41, 0x28, 0x3D, 0x03, 0x30,
  0x62, 0x1A, 0x7E, 0x60, 0xFC, 0x19, 0x88, 0xC4, 0x23, 0x18, 0xC4, 0x21,
  0x0C, 0x61, 0x08, 0x61, 0x08, 0x21, 0x80, 0xC2, 0x18, 0x43, 0x08, 0x42,
  0x10, 0x86, 0x21, 0x08, 0x46, 0x21, 0x18, 0x88, 0x00, 0x18, 0x08, 0x89,
  0xFF, 0x18, 0x34, 0x66, 0x22, 0x08, 0x04, 0x02, 0x01, 0x00, 0x87, 0xFC,
  0x20, 0x10, 0x08, 0x04, 0x02, 0x00, 0x69, 0x2D, 0x00, 0xF8, 0xF0, 0x01,
  0x02, 0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20,
  0x20, 0x60, 0x40, 0xC0, 0x3E, 0x31, 0x90, 0x48, 0x2C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1A, 0x09, 0x04, 0xC6, 0x3E, 0x00,
  0x19, 0xDB, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x7E,
  0x61, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x06, 0x02, 0x02, 0x03, 0x03,
  0x01, 0x01, 0x01, 0x81, 0x80, 0xFF, 0x80, 0x7E, 0x61, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x0C, 0x38, 0x3E, 0x01, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x05,
  0x06, 0xFE, 0x00, 0x01, 0x00, 0x60, 0x0C, 0x02, 0x80, 0xD0, 0x12, 0x06,
  0x40, 0x88, 0x31, 0x04, 0x21, 0x04, 0x20, 0x8F, 0xFE, 0x02, 0x00, 0x40,
  0x08, 0x01, 0x00, 0x7F, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0xFC,
  0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x05, 0x06, 0xFE, 0x00, 0x1F,
  0x18, 0x18, 0x08, 0x04, 0x02, 0x03, 0x31, 0xFE, 0xE1, 0x60, 0xF0, 0x38,
  0x1C, 0x0A, 0x0D, 0x04, 0xC6, 0x3E, 0x00, 0xFF, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x10, 0x08, 0x0C, 0x04, 0x06, 0x03, 0x01, 0x01, 0x80, 0x80, 0x40,
  0x60, 0x20, 0x00, 0x3E, 0x31, 0x90, 0x58, 0x34, 0x1A, 0x08, 0x88, 0x38,
  0x3C, 0x31, 0x90, 0x58, 0x38, 0x0C, 0x07, 0x06, 0xC6, 0x3E, 0x00, 0x3E,
  0x31, 0xB0, 0x58, 0x28, 0x1C, 0x0E, 0x07, 0x83, 0x43, 0xBF, 0xC4, 0x60,
  0x20, 0x10, 0x18, 0x08, 0x0C, 0x7C, 0x00, 0xB0, 0x00, 0x03, 0xC0, 0x4C,
  0x00, 0x00, 0x01, 0xA4, 0xB4, 0x00, 0x80, 0xC1, 0x83, 0x06, 0x06, 0x01,
  0xC0, 0x30, 0x06, 0x00, 0xC0, 0x20, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x04, 0x0C, 0x18, 0x30,
  0x60, 0x20, 0x00, 0xFC, 0x8C, 0x08, 0x10, 0x20, 0x41, 0x86, 0x18, 0x20,
  0x40, 0x81, 0x00, 0x00, 0x18, 0x30, 0x07, 0xE0, 0x30, 0x60, 0xC0, 0x21,
  0x00, 0x64, 0x00, 0x48, 0x78, 0x91, 0x11, 0xE6, 0x21, 0x88, 0x43, 0x10,
  0x86, 0x21, 0x1C, 0x42, 0x2C, 0x4C, 0x48, 0xF7, 0x10, 0x00, 0x30, 0x00,
  0x20, 0x00, 0x30, 0x40, 0x3F, 0x00, 0x06, 0x01, 0xC0, 0x28, 0x05, 0x00,
  0xB0, 0x32, 0x04, 0x40, 0x8C, 0x30, 0x84, 0x10, 0xFE, 0x10, 0x66, 0x04,
  0x80, 0x90, 0x1E, 0x03, 0xC0, 0x20, 0xFE, 0x41, 0xA0, 0x70, 0x38, 0x1C,
  0x0E, 0x05, 0xFC, 0xFE, 0x40, 0xA0, 0x70, 0x18, 0x0C, 0x06, 0x07, 0x06,
  0xFE, 0x00, 0x0F, 0xCC, 0x12, 0x01, 0x80, 0x40, 0x10, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x01, 0x00, 0x40, 0x18, 0x02, 0x00, 0xE1, 0x0F, 0xC0,
  0xFE, 0x20, 0xC8, 0x1A, 0x02, 0x80, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x28, 0x1A, 0x1C, 0xFC, 0x00, 0xFF, 0x02,
  0x04, 0x08, 0x10, 0x20, 0x7F, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0xFE, 0xFF, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFF, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x80, 0x0F, 0xE1, 0x82, 0x30, 0x06, 0x00, 0x40, 0x04,
  0x00, 0xC0, 0x0C, 0x00, 0xC1, 0xFC, 0x03, 0xC0, 0x34, 0x03, 0x40, 0x36,
  0x03, 0x20, 0x31, 0x83, 0x0F, 0xE0, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xC0, 0xF2, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22, 0x22,
  0xF0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x13, 0xE0,
  0x81, 0xC1, 0xA0, 0x90, 0x88, 0xC4, 0x42, 0x41, 0x60, 0xB0, 0x64, 0x23,
  0x10, 0x88, 0x64, 0x12, 0x0D, 0x02, 0x81, 0x80, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0xFE, 0xC0,
  0x0F, 0x00, 0x7A, 0x01, 0x68, 0x07, 0xA0, 0x3E, 0xC0, 0xB9, 0x02, 0xE4,
  0x1B, 0x98, 0x4E, 0x21, 0x38, 0x8C, 0xE3, 0x23, 0x84, 0x8E, 0x16, 0x38,
  0x70, 0xE0, 0xC3, 0x83, 0x0C, 0xC0, 0x70, 0x1E, 0x06, 0x81, 0xB0, 0x64,
  0x19, 0x86, 0x21, 0x8C, 0x61, 0x18, 0x66, 0x09, 0x83, 0x60, 0x58, 0x1E,
  0x03, 0x80, 0xC0, 0x1F, 0x83, 0x0C, 0x60, 0x66, 0x02, 0x40, 0x3C, 0x03,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x14, 0x03, 0x40, 0x36, 0x02,
  0x20, 0x63, 0x0C, 0x1F, 0x80, 0xFC, 0x86, 0x83, 0x81, 0x81, 0x81, 0x81,
  0x83, 0x86, 0xFC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x1F, 0x83,
  0x0C, 0x60, 0x66, 0x02, 0x40, 0x3C, 0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x14, 0x03, 0x40, 0x36, 0x02, 0x20, 0x63, 0x0C, 0x1F, 0x80,
  0x18, 0x00, 0x80, 0x0C, 0x00, 0x60, 0xFC, 0x43, 0xA0, 0x50, 0x28, 0x14,
  0x0A, 0x05, 0x06, 0xFE, 0x7C, 0x23, 0x10, 0x88, 0x64, 0x12, 0x0D, 0x02,
  0x81, 0x80, 0x3F, 0x30, 0xB0, 0x18, 0x0C, 0x06, 0x01, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x05, 0x06, 0xFE, 0x00, 0xFF, 0xC3,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x3C, 0x09, 0x86, 0x3F, 0x00, 0xC0, 0x78, 0x0D, 0x01, 0x20, 0x26,
  0x0C, 0x41, 0x08, 0x21, 0x04, 0x31, 0x82, 0x20, 0x44, 0x0D, 0x81, 0xA0,
  0x14, 0x02, 0x80, 0x70, 0x04, 0x00, 0xC0, 0xC0, 0xD0, 0x30, 0x24, 0x0C,
  0x09, 0x07, 0x02, 0x61, 0x61, 0x88, 0x48, 0x42, 0x12, 0x10, 0x84, 0x84,
  0x33, 0x33, 0x0C, 0x84, 0xC1, 0x21, 0x20, 0x48, 0x48, 0x16, 0x16, 0x07,
  0x07, 0x80, 0xC0, 0xC0, 0x30, 0x30, 0x0C, 0x0C, 0x00, 0x40, 0xD8, 0x22,
  0x18, 0xC4, 0x13, 0x06, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x81, 0xA0, 0x48,
  0x31, 0x08, 0x46, 0x19, 0x02, 0xC0, 0xC0, 0xC0, 0xD0, 0x24, 0x19, 0x84,
  0x21, 0x0C, 0xC1, 0x20, 0x58, 0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x00, 0xFF, 0x03, 0x02, 0x06, 0x04, 0x04, 0x0C,
  0x08, 0x18, 0x10, 0x30, 0x20, 0x60, 0x40, 0xC0, 0x80, 0xFF, 0xFC, 0x21,
  0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x0F, 0x80,
  0xC0, 0x40, 0x60, 0x20, 0x20, 0x10, 0x10, 0x18, 0x08, 0x08, 0x0C, 0x04,
  0x04, 0x06, 0x02, 0x02, 0x01, 0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x3F, 0x80, 0x08, 0x07, 0x01, 0x40, 0xC8,
  0x22, 0x18, 0x44, 0x13, 0x06, 0x80, 0xC0, 0xFF, 0xC0, 0xC6, 0x30, 0x3C,
  0x46, 0x03, 0x03, 0x03, 0x03, 0x3F, 0xC3, 0x83, 0x83, 0x83, 0xC5, 0x79,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0xE2, 0x89, 0x82, 0x81, 0x40, 0xA0,
  0x70, 0x38, 0x1C, 0x0E, 0x05, 0x82, 0xC3, 0x5F, 0x00, 0x1E, 0x65, 0x82,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x81, 0x03, 0x03, 0xE0, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x09, 0xE5, 0x8A, 0x83, 0xC1, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x06, 0x83, 0x62, 0x9F, 0x40, 0x1C, 0x31, 0x10, 0x48, 0x2C, 0x16,
  0x0F, 0xFF, 0x00, 0xC0, 0x60, 0x10, 0x0C, 0x23, 0xF0, 0x1E, 0x60, 0xC1,
  0x02, 0x1F, 0x88, 0x10, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20,
  0x40, 0x3C, 0xB1, 0x50, 0x78, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0xD0, 0x6C, 0x53, 0xC8, 0x04, 0x02, 0x03, 0x01, 0x33, 0x8F, 0x00, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x9C, 0xA6, 0xC3, 0x83, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xE7, 0xFF, 0xC0, 0x11, 0x10, 0x01, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xBE, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x82, 0x84, 0x8C, 0x98, 0x90, 0xB0, 0xF0, 0xD8, 0x88, 0x8C, 0x84,
  0x86, 0x83, 0xFF, 0xFF, 0xC0, 0xBC, 0x73, 0x9A, 0x6C, 0x30, 0xA0, 0xC3,
  0x82, 0x0E, 0x08, 0x38, 0x20, 0xE0, 0x83, 0x82, 0x0E, 0x08, 0x38, 0x20,
  0xE0, 0x83, 0x82, 0x0C, 0x9C, 0xA6, 0xC3, 0x83, 0x81, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x1E, 0x31, 0x90, 0x58, 0x3C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x50, 0x6C, 0x63, 0xE0, 0x9C, 0x51, 0x30, 0x50,
  0x28, 0x14, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xB0, 0x5C, 0x6B, 0xE4, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x00, 0x3C, 0xB1, 0x50, 0x78, 0x3C, 0x0E,
  0x06, 0x03, 0x01, 0xC0, 0xE0, 0xD0, 0x6C, 0x53, 0xC8, 0x04, 0x02, 0x01,
  0x00, 0x80, 0x40, 0x20, 0x9D, 0x71, 0x88, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x00, 0x3D, 0x86, 0x04, 0x0C, 0x0C, 0x0E, 0x06, 0x06, 0x04, 0x0C, 0x3F,
  0xC0, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x07, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83,
  0xC5, 0x79, 0xC1, 0xE0, 0xD0, 0x48, 0x26, 0x31, 0x10, 0x88, 0x4C, 0x36,
  0x0A, 0x05, 0x03, 0x80, 0x80, 0xC1, 0x05, 0x0C, 0x14, 0x28, 0x50, 0xA3,
  0x62, 0x88, 0x9A, 0x22, 0x4C, 0x89, 0x16, 0x34, 0x50, 0xF1, 0x41, 0x87,
  0x06, 0x0C, 0x18, 0x30, 0x41, 0xB0, 0x88, 0xC6, 0x41, 0x60, 0xE0, 0x30,
  0x38, 0x16, 0x19, 0x08, 0xCC, 0x2C, 0x18, 0xC0, 0xA0, 0xD0, 0x4C, 0x26,
  0x31, 0x18, 0x88, 0x64, 0x16, 0x0A, 0x05, 0x01, 0x80, 0x80, 0x40, 0x20,
  0x30, 0x10, 0x58, 0x30, 0x00, 0xFC, 0x10, 0xC2, 0x18, 0x43, 0x08, 0x61,
  0x0C, 0x20, 0xFC, 0x0C, 0x61, 0x0C, 0x30, 0xC3, 0x0C, 0x31, 0x8C, 0x08,
  0x30, 0xC3, 0x0C, 0x30, 0xC1, 0x06, 0x0C, 0xFF, 0xFF, 0xFF, 0xE0, 0x60,
  0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30, 0x38, 0xC1, 0x02, 0x04, 0x08,
  0x10, 0x20, 0xC3, 0x0C, 0x00, 0x70, 0xEE, 0xE1, 0xC0,
};

const GFXglyph NotoSans_Condensed_Light24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 17, 5, 2, -17 },
  { 6, 5, 6, 8, 2, -17 },
  { 10, 12, 17, 12, 0, -17 },
  { 36, 9, 19, 11, 1, -18 },
  { 58, 14, 17, 16, 1, -17 },
  { 88, 11, 17, 12, 1, -17 },
  { 112, 1, 6, 5, 2, -17 },
  { 113, 5, 21, 7, 1, -17 },
  { 127, 5, 21, 7, 1, -17 },
  { 141, 8, 8, 10, 1, -18 },
  { 149, 9, 11, 11, 1, -14 },
  { 162, 3, 6, 5, 1, -3 },
  { 165, 5, 1, 7, 1, -7 },
  { 166, 2, 2, 5, 2, -2 },
  { 167, 8, 17, 8, 0, -17 },
  { 184, 9, 17, 11, 1, -17 },
  { 204, 5, 17, 11, 2, -17 },
  { 215, 9, 17, 11, 1, -17 },
  { 235, 9, 17, 11, 1, -17 },
  { 255, 11, 17, 11, 0, -17 },
  { 279, 9, 17, 11, 1, -17 },
  { 299, 9, 17, 11, 1, -17 },
  { 319, 9, 17, 11, 1, -17 },
  { 339, 9, 17, 11, 1, -17 },
  { 359, 9, 17, 11, 1, -17 },
  { 379, 2, 13, 5, 2, -13 },
  { 383, 3, 16, 5, 1, -13 },
  { 389, 9, 11, 11, 1, -14 },
  { 402, 9, 7, 11, 1, -12 },
  { 410, 9, 11, 11, 1, -14 },
  { 423, 7, 17, 8, 0, -17 },
  { 438, 15, 19, 17, 1, -17 },
  { 474, 11, 17, 11, 0, -17 },
  { 498, 9, 17, 12, 2, -17 },
  { 518, 10, 17, 12, 1, -17 },
  { 540, 10, 17, 13, 2, -17 },
  { 562, 7, 17, 11, 2, -17 },
  { 577, 7, 17, 10, 2, -17 },
  { 592, 12, 17, 14, 1, -17 },
  { 618, 10, 17, 14, 2, -17 },
  { 640, 4, 17, 6, 1, -17 },
  { 649, 4, 21, 5, -1, -17 },
  { 660, 9, 17, 11, 2, -17 },
  { 680, 7, 17, 10, 2, -17 },
  { 695, 14, 17, 18, 2, -17 },
  { 725, 10, 17, 14, 2, -17 },
  { 747, 12, 17, 14, 1, -17 },
  { 773, 8, 17, 11, 2, -17 },
  { 790, 12, 21, 14, 1, -17 },
  { 822, 9, 17, 12, 2, -17 },
  { 842, 9, 17, 11, 1, -17 },
  { 862, 10, 17, 10, 0, -17 },
  { 884, 10, 17, 14, 2, -17 },
  { 906, 11, 17, 11, 0, -17 },
  { 930, 18, 17, 18, 0, -17 },
  { 969, 10, 17, 10, 0, -17 },
  { 991, 10, 17, 10, 0, -17 },
  { 1013, 8, 17, 10, 1, -17 },
  { 1030, 5, 21, 8, 2, -17 },
  { 1044, 8, 17, 8, 0, -17 },
  { 1061, 5, 21, 8, 1, -17 },
  { 1075, 10, 9, 11, 1, -17 },
  { 1087, 10, 1, 10, 0, 2 },
  { 1089, 4, 3, 6, 1, -18 },
  { 1091, 8, 13, 10, 1, -13 },
  { 1104, 9, 18, 12, 2, -18 },
  { 1125, 7, 13, 9, 1, -13 },
  { 1137, 9, 18, 12, 1, -18 },
  { 1158, 9, 13, 11, 1, -13 },
  { 1173, 7, 18, 6, 0, -18 },
  { 1189, 9, 19, 12, 1, -13 },
  { 1211, 8, 18, 12, 2, -18 },
  { 1229, 1, 18, 5, 2, -18 },
  { 1232, 4, 24, 5, -1, -18 },
  { 1244, 8, 18, 10, 2, -18 },
  { 1262, 1, 18, 5, 2, -18 },
  { 1265, 14, 13, 17, 2, -13 },
  { 1288, 8, 13, 12, 2, -13 },
  { 1301, 9, 13, 11, 1, -13 },
  { 1316, 9, 19, 12, 2, -13 },
  { 1338, 9, 19, 12, 1, -13 },
  { 1360, 5, 13, 8, 2, -13 },
  { 1369, 7, 13, 9, 1, -13 },
  { 1381, 6, 16, 6, 0, -16 },
  { 1393, 8, 13, 12, 2, -13 },
  { 1406, 9, 13, 9, 0, -13 },
  { 1421, 14, 13, 15, 0, -13 },
  { 1444, 9, 13, 9, 0, -13 },
  { 1459, 9, 19, 9, 0, -13 },
  { 1481, 6, 13, 8, 1, -13 },
  { 1491, 6, 21, 9, 1, -17 },
  { 1507, 1, 24, 10, 5, -18 },
  { 1510, 7, 21, 9, 1, -17 },
  { 1529, 9, 3, 11, 1, -10 },
};

const GFXfont NotoSans_Condensed_Light24pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light24pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light24pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _NOTOSANS_CONDENSED_LIGHT24PT7B_H_
