#ifndef _NOTOSANS_CONDENSED_LIGHT71PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT71PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 71pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light71pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xEF,
  0xFF, 0xFF, 0xF7, 0x8C, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0,
  0x7F, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x1D,
  0xC0, 0x3B, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38,
  0x00, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0x00, 0x70, 0x07, 0x00, 0x00, 0x38, 0x03, 0x80, 0x00, 0x3C, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x38, 0x00, 0x03, 0x80, 0x3C, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x00, 0xE0,
  0x0E, 0x00, 0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x70, 0x00, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00, 0x01,
  0xE0, 0x0E, 0x00, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x70, 0x03, 0x80, 0x00,
  0x38, 0x03, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x70, 0x00, 0x07, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x1C, 0x00,
  0x01, 0xC0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1C, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x38, 0x00, 0x03, 0x80, 0x1C,
  0x00, 0x01, 0xC0, 0x1E, 0x00, 0x00, 0xE0, 0x0E, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x78, 0x03, 0x80, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x1C, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x07, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x01, 0xE0, 0x0E, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x1F, 0xFD, 0xFF, 0x0F, 0xC7, 0x03, 0xC3, 0xC1, 0xC0, 0x11, 0xE0,
  0x70, 0x00, 0x78, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x01, 0xC0, 0x03,
  0xC0, 0x70, 0x00, 0xF0, 0x1C, 0x00, 0x3C, 0x07, 0x00, 0x0F, 0x01, 0xC0,
  0x03, 0xC0, 0x70, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x07, 0x00, 0x07, 0xC1,
  0xC0, 0x00, 0xF8, 0x70, 0x00, 0x1F, 0x9C, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x73, 0xF8, 0x00, 0x1C, 0x3F, 0x00, 0x07,
  0x07, 0xC0, 0x01, 0xC0, 0x78, 0x00, 0x70, 0x1F, 0x00, 0x1C, 0x03, 0xC0,
  0x07, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x07, 0x00, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0xF0, 0x01, 0xC0, 0x3C, 0x00, 0x70, 0x0F, 0x00, 0x1C,
  0x07, 0xA0, 0x07, 0x03, 0xEE, 0x01, 0xC1, 0xF3, 0xF8, 0x71, 0xF8, 0xFF,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0x80, 0x03, 0xFE, 0x00, 0x01, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x70, 0x00,
  0xF0, 0x78, 0x00, 0x3C, 0x00, 0x38, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x70, 0x01, 0xC0, 0x01, 0xC0, 0x1C, 0x00,
  0x70, 0x00, 0x70, 0x07, 0x00, 0x3C, 0x00, 0x1C, 0x01, 0xE0, 0x0E, 0x00,
  0x0F, 0x00, 0x78, 0x07, 0x80, 0x03, 0xC0, 0x1E, 0x01, 0xC0, 0x00, 0xF0,
  0x07, 0x80, 0x70, 0x00, 0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x0F, 0x00, 0x38,
  0x0E, 0x00, 0x03, 0xC0, 0x0E, 0x07, 0x80, 0x00, 0xF0, 0x03, 0x81, 0xC0,
  0x00, 0x3C, 0x01, 0xE0, 0x70, 0x00, 0x0F, 0x00, 0x78, 0x3C, 0x00, 0x03,
  0xC0, 0x1E, 0x0E, 0x00, 0x00, 0x70, 0x07, 0x87, 0x83, 0xF0, 0x1C, 0x01,
  0xE1, 0xC1, 0xFF, 0x07, 0x00, 0x70, 0x70, 0xFF, 0xE1, 0xC0, 0x1C, 0x3C,
  0x78, 0x78, 0x78, 0x0F, 0x0E, 0x1C, 0x0F, 0x0E, 0x03, 0xC7, 0x8F, 0x01,
  0xC3, 0xC0, 0xE1, 0xC3, 0xC0, 0x78, 0xF0, 0x78, 0x70, 0xE0, 0x0E, 0x1F,
  0xFC, 0x3C, 0x38, 0x03, 0x83, 0xFE, 0x0E, 0x1E, 0x00, 0xE0, 0x7F, 0x07,
  0x87, 0x80, 0x38, 0x00, 0x01, 0xC1, 0xE0, 0x0F, 0x00, 0x00, 0x70, 0x78,
  0x03, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x00, 0x0E, 0x07, 0x00, 0x3C,
  0x00, 0x07, 0x81, 0xC0, 0x0F, 0x00, 0x01, 0xC0, 0x70, 0x03, 0xC0, 0x00,
  0xF0, 0x1C, 0x00, 0xF0, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0x0E, 0x01,
  0xE0, 0x0F, 0x00, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x01, 0xC0, 0x1E, 0x00,
  0xE0, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0x3C, 0x00, 0xE0, 0x0E, 0x00,
  0x0E, 0x00, 0x38, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xC0,
  0x01, 0xC0, 0x70, 0x00, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x00, 0x0F,
  0xBE, 0x00, 0x0E, 0x00, 0x01, 0xFF, 0x00, 0x07, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0x78, 0x07,
  0x80, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x03, 0xC0,
  0x0F, 0x00, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0, 0x03, 0xC0, 0x00, 0x78,
  0x01, 0xC0, 0x00, 0x1C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x00,
  0x3C, 0x7C, 0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF1, 0xE0, 0x00,
  0x21, 0xF0, 0x78, 0x00, 0xE1, 0xF0, 0x3E, 0x00, 0xF0, 0xF0, 0x0F, 0x80,
  0x78, 0xF0, 0x03, 0xC0, 0x3C, 0x78, 0x01, 0xF0, 0x1E, 0x78, 0x00, 0x7C,
  0x0E, 0x3C, 0x00, 0x1E, 0x0F, 0x1E, 0x00, 0x07, 0x87, 0x8F, 0x00, 0x03,
  0xE7, 0x87, 0x80, 0x00, 0xF3, 0xC3, 0xC0, 0x00, 0x3F, 0xE1, 0xE0, 0x00,
  0x1F, 0xE0, 0xF0, 0x00, 0x07, 0xF0, 0x78, 0x00, 0x01, 0xF0, 0x3C, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFE, 0x07, 0x80, 0x00, 0xFF, 0x83, 0xE0,
  0x00, 0xFB, 0xC0, 0xF8, 0x00, 0xF9, 0xF0, 0x7F, 0x01, 0xF8, 0x7C, 0x1F,
  0xFF, 0xF8, 0x1F, 0x07, 0xFF, 0xF0, 0x07, 0x80, 0xFF, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE,
  0xEE, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00,
  0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x40, 0x18, 0x02, 0x70, 0x18, 0x0E, 0xFE, 0x18, 0x7F, 0xFF, 0xDB,
  0xFF, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xE7, 0x00, 0x01, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x07, 0x81, 0xE0, 0x0F, 0x00, 0xF0, 0x1F, 0x00, 0xF8, 0x0E, 0x00,
  0x70, 0x02, 0x00, 0x40, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x1F, 0x1E, 0x1E,
  0x1E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x70, 0xF0, 0xE0,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xEF, 0xFF,
  0xFB, 0xE2, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x80, 0x1F, 0x83, 0xE0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3D, 0xE0,
  0x00, 0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x3D,
  0xE0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80, 0x00,
  0x78, 0xF0, 0x00, 0x1E, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0xF0, 0x78, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x80,
  0xF8, 0x03, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x3C, 0x00,
  0xF8, 0x07, 0xF0, 0x1F, 0xE0, 0x7D, 0xC1, 0xF3, 0x87, 0xC7, 0x1F, 0x0E,
  0x7C, 0x1F, 0xF0, 0x7B, 0xC0, 0xF2, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0x7C, 0x00, 0x7C, 0x0E,
  0x00, 0x0F, 0x82, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x1C, 0x00, 0x0F,
  0x82, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x20, 0x00, 0x07, 0xCC, 0x00,
  0x07, 0xE3, 0xE0, 0x03, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x0F, 0x3C,
  0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1C, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x07, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x38, 0x03, 0xC0, 0x00,
  0xF0, 0x07, 0x80, 0x03, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xC0,
  0x01, 0xE0, 0x07, 0x80, 0x03, 0xC0, 0x0E, 0x00, 0x07, 0x80, 0x3C, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x3C, 0x07, 0x80, 0x00,
  0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x83, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x83, 0x80, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xF0, 0x38, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE4, 0x00, 0x03, 0xE3,
  0x00, 0x03, 0xF1, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0x80, 0xC0, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x80, 0x0F, 0x07, 0xFE,
  0x07, 0x8F, 0xFF, 0x83, 0xCF, 0xFF, 0xE1, 0xEF, 0x81, 0xF8, 0xF7, 0x00,
  0x3E, 0x77, 0x00, 0x0F, 0x3F, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1E, 0xE0, 0x00, 0x0F,
  0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC7, 0x80, 0x01,
  0xE3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0xF8, 0x1F, 0x01,
  0xF8, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xE0,
  0x7F, 0x01, 0xF0, 0x03, 0xF0, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x03, 0xE1,
  0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00,
  0x1E, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x03, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00, 0x7C, 0x0F, 0xC0, 0x07,
  0xE3, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xE0, 0x00, 0x7C,
  0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x7B, 0xE0, 0x00,
  0x0F, 0x3C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x78, 0x78, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0x07, 0xE0, 0x1F, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x83, 0xC0, 0x01, 0xE1, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x0F, 0x1E, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0x07, 0xBC, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0E,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x7D, 0xE0,
  0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xCF, 0x00, 0x07, 0xF3, 0xE0, 0x03, 0xBC,
  0x7C, 0x01, 0xCF, 0x0F, 0xFF, 0xF3, 0xC1, 0xFF, 0xF8, 0xE0, 0x3F, 0xF8,
  0x38, 0x01, 0xF8, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x3F, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7B, 0xEF, 0xFF,
  0xFB, 0xE7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFB, 0xEF, 0xFF,
  0xFB, 0xE2, 0x00, 0x1E, 0x3E, 0x3F, 0x3F, 0x3F, 0x3E, 0x1C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x1E,
  0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x38, 0x78, 0x78, 0x70, 0x70, 0xF0,
  0xE0, 0xE0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xC0, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x01,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFC, 0x1F, 0xC7, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0x00,
  0x78, 0x07, 0x80, 0x00, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x00, 0x00, 0x70,
  0x3C, 0x00, 0x00, 0x00, 0x0E, 0x0F, 0x00, 0x01, 0xE0, 0x01, 0xE1, 0xE0,
  0x01, 0xFF, 0xE0, 0x1C, 0x38, 0x00, 0xFF, 0xFC, 0x03, 0x8F, 0x00, 0x3F,
  0x0F, 0x80, 0x79, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x38, 0x01, 0xE0, 0x1E,
  0x00, 0xE7, 0x00, 0x78, 0x03, 0xC0, 0x1D, 0xE0, 0x0E, 0x00, 0x78, 0x03,
  0xBC, 0x03, 0xC0, 0x0F, 0x00, 0x77, 0x80, 0x78, 0x01, 0xE0, 0x0E, 0xE0,
  0x0E, 0x00, 0x3C, 0x01, 0xFC, 0x01, 0xC0, 0x07, 0x00, 0x3F, 0x80, 0x38,
  0x00, 0xE0, 0x07, 0xF0, 0x0F, 0x00, 0x1C, 0x00, 0xFE, 0x01, 0xE0, 0x03,
  0x80, 0x1F, 0xC0, 0x3C, 0x00, 0x70, 0x03, 0xB8, 0x07, 0x80, 0x0E, 0x00,
  0x77, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0xE0, 0x1E, 0x00, 0x78, 0x01, 0xDC,
  0x03, 0xC0, 0x0F, 0x00, 0x3B, 0x80, 0x38, 0x01, 0xE0, 0x0F, 0x70, 0x07,
  0x00, 0x3C, 0x01, 0xCE, 0x00, 0xF0, 0x0F, 0x80, 0x39, 0xE0, 0x1E, 0x01,
  0xB8, 0x0F, 0x3C, 0x01, 0xE0, 0x77, 0x03, 0xC7, 0x80, 0x3E, 0x1C, 0x70,
  0xF8, 0x70, 0x03, 0xFF, 0x8F, 0xFE, 0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0x81,
  0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFC, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x00,
  0x77, 0x80, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0x0F, 0x38, 0x00, 0x00,
  0x03, 0x8F, 0x00, 0x00, 0x00, 0xE3, 0xC0, 0x00, 0x00, 0x78, 0x70, 0x00,
  0x00, 0x1E, 0x1E, 0x00, 0x00, 0x07, 0x07, 0x80, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x00, 0xF0, 0x38, 0x00, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x0E, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x78,
  0x07, 0x80, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x0F, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x3E, 0x00, 0x01, 0xE0, 0x0F, 0x00, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1E,
  0x00, 0x00, 0x3E, 0x07, 0x80, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x03,
  0xC7, 0x80, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x00, 0x3E, 0x78, 0x00, 0x00,
  0x07, 0xBE, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x00, 0x7C, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F,
  0x00, 0x0F, 0xE1, 0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x3E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0xFC,
  0x3C, 0x00, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0x03, 0xC0, 0x07, 0xF8, 0x78, 0x00, 0x1F, 0x8F, 0x00, 0x00, 0xF9,
  0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3F, 0x3C, 0x00, 0x0F,
  0xC7, 0x80, 0x3F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x40, 0x3F, 0xC0, 0x1E, 0x00, 0xFF, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0xF0, 0x01, 0xFE, 0x03, 0xC0, 0x00, 0xFC, 0x0F, 0x00,
  0x01, 0xF8, 0x3C, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x00,
  0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x0F, 0xBC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1E,
  0xF0, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x03, 0xCF, 0x00,
  0x00, 0x0F, 0x3C, 0x00, 0x00, 0x7C, 0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00,
  0x0F, 0x8F, 0x00, 0x00, 0x7C, 0x3C, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F,
  0x83, 0xC0, 0x00, 0xFC, 0x0F, 0x00, 0x0F, 0xE0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F,
  0xC0, 0x00, 0xF0, 0x1F, 0x80, 0x00, 0x18, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x01, 0xDE, 0x00, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x00, 0x77, 0x80,
  0x00, 0x00, 0x3B, 0xE0, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00, 0x0E, 0x7C,
  0x00, 0x00, 0x07, 0x1E, 0x00, 0x00, 0x03, 0x8F, 0x80, 0x00, 0x01, 0xC3,
  0xC0, 0x00, 0x00, 0xE1, 0xF0, 0x00, 0x00, 0x70, 0x7C, 0x00, 0x00, 0x38,
  0x1F, 0x00, 0x00, 0x1C, 0x07, 0xE0, 0x00, 0x0E, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x78, 0x01, 0xE0, 0x0F, 0x80, 0x7C, 0xFF, 0xF3, 0xFF, 0x8F, 0xFC, 0x1F,
  0xC0, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xC0, 0x00, 0x3E, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x7C, 0x3C, 0x00, 0x0F,
  0x07, 0x80, 0x03, 0xE0, 0xF0, 0x00, 0xF8, 0x1E, 0x00, 0x1E, 0x03, 0xC0,
  0x07, 0x80, 0x78, 0x01, 0xF0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x3C, 0x03, 0xE0, 0x07, 0x80, 0xF8, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x07,
  0xC0, 0x03, 0xC1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xE3, 0xE0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x9F, 0x80, 0x00, 0xF7, 0xF0,
  0x00, 0x1E, 0xFF, 0x00, 0x03, 0xFD, 0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x0F,
  0xC3, 0xE0, 0x01, 0xF0, 0x3C, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0x80, 0x78,
  0x00, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xF0, 0x0F, 0x00, 0x1E, 0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x3C,
  0x07, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x0F, 0x83, 0xC0,
  0x00, 0xF0, 0x78, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E,
  0x3C, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xBC, 0x00, 0x00, 0x01, 0xFF, 0xDE, 0x00, 0x00, 0x00,
  0xEF, 0xF7, 0x00, 0x00, 0x00, 0xF7, 0xFB, 0xC0, 0x00, 0x00, 0x7B, 0xFD,
  0xE0, 0x00, 0x00, 0x39, 0xFE, 0xF0, 0x00, 0x00, 0x3C, 0xFF, 0x3C, 0x00,
  0x00, 0x1E, 0x7F, 0x9E, 0x00, 0x00, 0x0E, 0x3F, 0xCF, 0x00, 0x00, 0x0F,
  0x1F, 0xE3, 0xC0, 0x00, 0x07, 0x8F, 0xF1, 0xE0, 0x00, 0x03, 0x87, 0xF8,
  0xF0, 0x00, 0x03, 0xC3, 0xFC, 0x3C, 0x00, 0x01, 0xE1, 0xFE, 0x1E, 0x00,
  0x00, 0xE0, 0xFF, 0x0F, 0x00, 0x00, 0xF0, 0x7F, 0x83, 0xC0, 0x00, 0x78,
  0x3F, 0xC1, 0xE0, 0x00, 0x38, 0x1F, 0xE0, 0xF0, 0x00, 0x3C, 0x0F, 0xF0,
  0x3C, 0x00, 0x1E, 0x07, 0xF8, 0x1E, 0x00, 0x0E, 0x03, 0xFC, 0x0F, 0x00,
  0x0F, 0x01, 0xFE, 0x03, 0x80, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x03, 0x80,
  0x7F, 0x80, 0xF0, 0x03, 0xC0, 0x3F, 0xC0, 0x38, 0x01, 0xE0, 0x1F, 0xE0,
  0x1E, 0x00, 0xE0, 0x0F, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0x80,
  0x78, 0x03, 0xFC, 0x01, 0xE0, 0x3C, 0x01, 0xFE, 0x00, 0xF0, 0x3C, 0x00,
  0xFF, 0x00, 0x38, 0x1E, 0x00, 0x7F, 0x80, 0x1E, 0x0F, 0x00, 0x3F, 0xC0,
  0x0F, 0x07, 0x00, 0x1F, 0xE0, 0x03, 0x87, 0x80, 0x0F, 0xF0, 0x01, 0xE3,
  0xC0, 0x07, 0xF8, 0x00, 0xF1, 0xC0, 0x03, 0xFC, 0x00, 0x39, 0xE0, 0x01,
  0xFE, 0x00, 0x1E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFB, 0xC0, 0x00, 0x07,
  0xEF, 0x80, 0x00, 0x1F, 0xDE, 0x00, 0x00, 0x7F, 0x7C, 0x00, 0x01, 0xFC,
  0xF0, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0x1F, 0xC7, 0x80, 0x00, 0x7F, 0x1F,
  0x00, 0x01, 0xFC, 0x3C, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x1F, 0xC1, 0xE0,
  0x00, 0x7F, 0x07, 0xC0, 0x01, 0xFC, 0x0F, 0x00, 0x07, 0xF0, 0x3E, 0x00,
  0x1F, 0xC0, 0x78, 0x00, 0x7F, 0x01, 0xF0, 0x01, 0xFC, 0x03, 0xC0, 0x07,
  0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x1E, 0x00, 0x7F, 0x00, 0x7C, 0x01, 0xFC,
  0x00, 0xF0, 0x07, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x07, 0x80, 0x7F, 0x00,
  0x1F, 0x01, 0xFC, 0x00, 0x3C, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0xC0, 0x01,
  0xE0, 0x7F, 0x00, 0x07, 0xC1, 0xFC, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x3E,
  0x1F, 0xC0, 0x00, 0x78, 0x7F, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x03, 0xC7,
  0xF0, 0x00, 0x0F, 0x9F, 0xC0, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0x7D, 0xFC,
  0x00, 0x00, 0xF7, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x01, 0xF8, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1F, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0xF8, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0x01, 0xF3,
  0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xDF, 0x00, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x00,
  0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00, 0x01, 0xE0, 0x7C, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0x00, 0x3F, 0xC7, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0xF9, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1F, 0x78, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0xFB, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x7C,
  0x78, 0x00, 0xFE, 0x3C, 0x03, 0xFE, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x01, 0xF8,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00,
  0x1F, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0xF8, 0x00, 0x00, 0x3E, 0x1E, 0x00,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x00, 0x0F, 0x1E,
  0x00, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xDF, 0x00,
  0x00, 0x00, 0x79, 0xE0, 0x00, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x01, 0xE7,
  0x80, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x00, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x00, 0x3C, 0x3E, 0x00, 0x00, 0x0F, 0x83, 0xC0, 0x00,
  0x01, 0xE0, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x0F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x80, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x0F,
  0x00, 0x3F, 0xC1, 0xE0, 0x00, 0xFC, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x00,
  0xF8, 0xF0, 0x00, 0x1F, 0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78,
  0x00, 0x07, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C,
  0x3C, 0x00, 0x0F, 0x87, 0x80, 0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x1E, 0x03,
  0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x01,
  0xE0, 0x1E, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x0F,
  0x00, 0x1F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3E, 0x07, 0x80, 0x03,
  0xC0, 0xF0, 0x00, 0x7C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF8, 0x78,
  0x00, 0x0F, 0x0F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE1, 0xFE, 0x0F, 0xE1, 0xF8, 0x00, 0x71, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF3, 0x80, 0x01, 0xF9, 0xF8, 0x03, 0xF8, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00,
  0x79, 0xE0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x3E,
  0x3E, 0x00, 0x00, 0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x0F, 0x78, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1F, 0x78, 0x00,
  0x00, 0x1E, 0x7C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00,
  0x00, 0x3C, 0x3C, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00,
  0x00, 0x3C, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x0F, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x00, 0xF0, 0x07, 0x80, 0x00, 0xF0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80,
  0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x03, 0xC0, 0x01, 0xE0,
  0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x01, 0xE0, 0x07, 0x80, 0x00, 0xF0,
  0x07, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x70,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78,
  0x1E, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x00, 0x3C,
  0x3C, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x1E, 0x3C, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1D, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x03,
  0xB8, 0x00, 0x07, 0xC7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0xF0, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0x1E, 0x00, 0x03, 0xDE, 0x00, 0x03, 0xC3, 0xE0,
  0x00, 0x71, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC7, 0x80, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x01, 0xE0, 0x01, 0xC1, 0xC0, 0x03,
  0xE0, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x07, 0x80,
  0x0F, 0x00, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x0F, 0x00, 0x38, 0x0E,
  0x00, 0x3C, 0x01, 0xE0, 0x07, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0x0F, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x01, 0xE0,
  0x3C, 0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x07,
  0x80, 0xF0, 0x07, 0x80, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x70, 0x3E, 0x00,
  0x0F, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0,
  0x00, 0x3C, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x83, 0xC0, 0x07, 0x83,
  0xC0, 0x00, 0x78, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x0F,
  0x1E, 0x00, 0x01, 0xE3, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00,
  0x3C, 0x78, 0x00, 0x03, 0x8E, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x79, 0xC0,
  0x00, 0x73, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x03, 0xB8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x79,
  0xF0, 0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3E, 0x00, 0x03, 0xC0, 0xF0,
  0x00, 0x1E, 0x07, 0x80, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x00, 0xF0, 0x00,
  0xF8, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xC0,
  0x03, 0xC0, 0x1E, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x03,
  0xC0, 0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0x78, 0x00, 0x03, 0xC3, 0xE0, 0x00,
  0x3C, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0,
  0x0F, 0x00, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x07,
  0x80, 0x3C, 0x00, 0x3C, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x00, 0x07, 0x81,
  0xF0, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x78, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x1E, 0x3C, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0xF0, 0xF8,
  0x00, 0x0F, 0x03, 0xC0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0xC0, 0x78, 0x00,
  0x3C, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x03, 0xC0, 0x01,
  0xE0, 0x3C, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x78, 0x0F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x3C, 0x38, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x0F, 0x1E, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x01, 0xEF, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x07, 0x1C, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x03, 0x83, 0x80, 0x00,
  0x3C, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0xE0,
  0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x38, 0x03, 0xC0, 0x01, 0xE0, 0x1E, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x0F, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x07, 0x87, 0x80,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x01, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0xF8, 0x0F, 0xC0, 0x80, 0x07,
  0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0xFE, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0xFF, 0x00, 0xF3, 0xF0, 0x01, 0xE7, 0xC0,
  0x03, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0xFE, 0xF0, 0x01, 0xBD,
  0xF0, 0x0F, 0x39, 0xFF, 0xFC, 0x71, 0xFF, 0xF0, 0xE1, 0xFF, 0x81, 0xC0,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x3F, 0xE0, 0x3C, 0x3F,
  0xFE, 0x0F, 0x1F, 0xFF, 0xC3, 0xCF, 0x03, 0xF8, 0xF7, 0x80, 0x3E, 0x3D,
  0x80, 0x07, 0xCF, 0xE0, 0x00, 0xF3, 0xF0, 0x00, 0x1E, 0xFC, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0xFB,
  0xF0, 0x00, 0x3C, 0xFE, 0x00, 0x1F, 0x3D, 0xC0, 0x0F, 0x8F, 0x3C, 0x07,
  0xE3, 0xCF, 0xFF, 0xF0, 0xE1, 0xFF, 0xF8, 0x38, 0x1F, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFC,
  0x0E, 0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xFE, 0x01, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0xFF, 0x81, 0xE0,
  0x7F, 0xFC, 0x3C, 0x1F, 0xFF, 0xC7, 0x87, 0xF0, 0x3C, 0xF0, 0xF8, 0x03,
  0xDE, 0x3E, 0x00, 0x1B, 0xC7, 0x80, 0x03, 0xF9, 0xF0, 0x00, 0x3F, 0x3C,
  0x00, 0x07, 0xE7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00, 0x00, 0x7B, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D,
  0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00,
  0x0F, 0xCF, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x0D, 0xE3,
  0xE0, 0x03, 0xBC, 0x3F, 0x01, 0xE7, 0x83, 0xFF, 0xF8, 0xF0, 0x3F, 0xFE,
  0x1E, 0x03, 0xFF, 0x83, 0xC0, 0x07, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x03, 0xC0,
  0xF8, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x3C, 0x00, 0x0F,
  0x1E, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0F, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x01, 0x81, 0xF8, 0x03, 0xC0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0xE0, 0x1F, 0xFC, 0x07, 0xFF, 0x80, 0xF8, 0x30, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7F, 0xFF, 0x80, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xC1, 0xE0, 0x7F,
  0xFC, 0x3C, 0x1F, 0xFF, 0xC7, 0x87, 0xF0, 0x3C, 0xF0, 0xF8, 0x01, 0xDE,
  0x3E, 0x00, 0x1B, 0xC7, 0x80, 0x03, 0xF9, 0xE0, 0x00, 0x3F, 0x3C, 0x00,
  0x07, 0xE7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x3E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7B, 0xC0, 0x00, 0x0F, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0,
  0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x0F,
  0xCF, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x7F, 0x1E, 0x00, 0x0D, 0xE3, 0xE0,
  0x03, 0xBC, 0x3F, 0x01, 0xE7, 0x83, 0xFF, 0xF8, 0xF0, 0x3F, 0xFE, 0x1E,
  0x03, 0xFF, 0x83, 0xC0, 0x07, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x84, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0xFC, 0x1F,
  0xE1, 0xFF, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF0, 0x7F, 0xE0, 0xF0, 0xFF, 0xF0, 0xF1, 0xFF, 0xF8, 0xF3, 0xC0,
  0xFC, 0xF7, 0x80, 0x3E, 0xF6, 0x00, 0x1E, 0xFE, 0x00, 0x1E, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x77, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD,
  0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B,
  0xDE, 0xF7, 0xBD, 0xE0, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0x9B, 0xF3, 0xFC,
  0x7F, 0x8F, 0xC0, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0xE7, 0x80, 0x07,
  0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x03, 0xC0,
  0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x78, 0x07, 0x81, 0xE0, 0x0F,
  0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF3,
  0xF0, 0x01, 0xE7, 0xF0, 0x03, 0xDF, 0xE0, 0x07, 0xB9, 0xE0, 0x0F, 0xE3,
  0xC0, 0x1F, 0x83, 0xC0, 0x3E, 0x07, 0x80, 0x7C, 0x07, 0x80, 0xF0, 0x0F,
  0x01, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF1,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDE,
  0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x1F, 0xF0, 0x70,
  0xFF, 0xF0, 0x1F, 0xFE, 0x38, 0xFF, 0xFC, 0x3F, 0xFF, 0x9E, 0x70, 0x3F,
  0x1E, 0x0F, 0xCF, 0x70, 0x0F, 0x9C, 0x01, 0xF7, 0xF0, 0x03, 0xDC, 0x00,
  0x7B, 0xF0, 0x00, 0xFE, 0x00, 0x3D, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xF0, 0x00, 0x1E,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x01,
  0xFE, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0xE0, 0x7F, 0xE0,
  0xE0, 0xFF, 0xF0, 0xE1, 0xFF, 0xF8, 0xF3, 0xC0, 0xFC, 0xF7, 0x00, 0x3E,
  0xF6, 0x00, 0x1E, 0xFC, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF,
  0xF0, 0x03, 0xF0, 0x3F, 0x00, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x07,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x03, 0xC7, 0x80, 0x00,
  0x79, 0xE0, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xDC, 0x00, 0x00, 0x7B, 0xC0, 0x00, 0x0F,
  0x78, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xBC, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x3C, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE0,
  0xF0, 0x00, 0x3C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0xE0, 0x3F, 0xE0, 0x38, 0x3F, 0xFE, 0x0F, 0x1F, 0xFF,
  0xC3, 0xCF, 0x01, 0xF8, 0xF7, 0x80, 0x3E, 0x3D, 0x80, 0x07, 0xCF, 0xE0,
  0x00, 0xF3, 0xF0, 0x00, 0x1E, 0xFC, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00,
  0x07, 0xBF, 0x00, 0x01, 0xEF, 0xC0, 0x00, 0xFB, 0xF8, 0x00, 0x3C, 0xF6,
  0x00, 0x1F, 0x3D, 0xC0, 0x0F, 0x8F, 0x3C, 0x07, 0xE3, 0xC7, 0xFF, 0xF0,
  0xF0, 0xFF, 0xF8, 0x3C, 0x1F, 0xF8, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC1, 0xE0, 0x3F, 0xFC, 0x3C, 0x1F, 0xFF, 0xC7,
  0x87, 0xF0, 0x3C, 0xF0, 0xF8, 0x03, 0xDE, 0x3E, 0x00, 0x3B, 0xC7, 0x80,
  0x03, 0xF9, 0xF0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xE7, 0x80, 0x00, 0x7D,
  0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00,
  0x07, 0xDE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x78,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3E, 0x78, 0x00, 0x0F, 0xCF, 0x00, 0x01, 0xF9, 0xF0,
  0x00, 0x7F, 0x1E, 0x00, 0x0D, 0xE3, 0xE0, 0x03, 0xBC, 0x3F, 0x01, 0xE7,
  0x83, 0xFF, 0xF8, 0xF0, 0x3F, 0xFE, 0x1E, 0x03, 0xFF, 0x83, 0xC0, 0x07,
  0x80, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78, 0xE0, 0x7F, 0xF0, 0x7F,
  0xB8, 0x7F, 0xDE, 0x7E, 0xEF, 0x38, 0x07, 0xB8, 0x03, 0xF8, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x87, 0xFF,
  0xFC, 0x7C, 0x03, 0xC7, 0xC0, 0x02, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x80, 0x00, 0xF6, 0x00, 0x0F, 0x3C, 0x01,
  0xF9, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xBF, 0xFF, 0xDF,
  0xFF, 0xEF, 0xFF, 0xF0, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0xF8,
  0x1F, 0xFC, 0x07, 0xFE, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0x78, 0x00, 0x3F, 0x78, 0x00, 0x7F, 0x7C, 0x00, 0xEF,
  0x3F, 0x03, 0xE7, 0x1F, 0xFF, 0xC7, 0x0F, 0xFF, 0x87, 0x07, 0xFE, 0x07,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x3D, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC1,
  0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0x70, 0x00,
  0xF0, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x03, 0xC7, 0x00, 0x00, 0xF3,
  0xC0, 0x00, 0x1C, 0xF0, 0x00, 0x07, 0x3C, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0x00, 0xEF, 0x00, 0x03, 0xF0, 0x00, 0x79, 0xC0,
  0x00, 0xFC, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0x00, 0x07, 0x9E, 0x00, 0x0F,
  0xC0, 0x01, 0xC7, 0x80, 0x07, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xDE, 0x00,
  0x3C, 0x3C, 0x00, 0x73, 0x80, 0x0F, 0x0F, 0x00, 0x1C, 0xE0, 0x03, 0x83,
  0xC0, 0x0F, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0xCF, 0x00, 0x78, 0x1E, 0x00,
  0xE3, 0xC0, 0x1E, 0x07, 0x80, 0x38, 0x70, 0x07, 0x81, 0xE0, 0x1E, 0x1C,
  0x01, 0xC0, 0x78, 0x07, 0x87, 0x80, 0xF0, 0x0E, 0x01, 0xC1, 0xE0, 0x3C,
  0x03, 0xC0, 0x70, 0x38, 0x0F, 0x00, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0x3C,
  0x0F, 0x03, 0xC1, 0xE0, 0x07, 0x03, 0x80, 0xF0, 0x78, 0x01, 0xE0, 0xE0,
  0x1C, 0x1E, 0x00, 0x78, 0x78, 0x07, 0x07, 0x00, 0x1E, 0x1E, 0x01, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xC0, 0x0E, 0x3C, 0x00,
  0x3C, 0xF0, 0x03, 0x8E, 0x00, 0x0F, 0x3C, 0x00, 0xF3, 0x80, 0x03, 0xCE,
  0x00, 0x3D, 0xE0, 0x00, 0x73, 0x80, 0x0F, 0x78, 0x00, 0x1E, 0xE0, 0x01,
  0xDE, 0x00, 0x07, 0xF8, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x1D, 0xC0,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1E, 0x03, 0xC0, 0x0F, 0x00, 0xF0,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x80, 0x78, 0x00, 0xF0, 0x3C, 0x00,
  0x3C, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C, 0xF0,
  0x00, 0x0F, 0x7C, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xF3, 0xC0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1E,
  0x00, 0x3E, 0x07, 0x80, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x3C,
  0x78, 0x00, 0x07, 0xBE, 0x00, 0x01, 0xF0, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0x1E,
  0x00, 0x03, 0xC3, 0x80, 0x00, 0xF0, 0xF0, 0x00, 0x3C, 0x3C, 0x00, 0x1E,
  0x0F, 0x00, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x70, 0x1E, 0x00,
  0x3C, 0x03, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x07,
  0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0xC0,
  0x03, 0x80, 0xF0, 0x00, 0xF0, 0x38, 0x00, 0x3C, 0x1E, 0x00, 0x07, 0x07,
  0x80, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0x70, 0x00, 0x0E, 0x3C, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0x78, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x03, 0x3F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F,
  0xFF, 0xF7, 0xFF, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x80, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x27, 0xFE, 0x00, 0x05, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xA0, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xC0,
};

const GFXglyph NotoSans_Condensed_Light71pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 6, 52, 16, 5, -51 },
  { 40, 15, 19, 24, 5, -51 },
  { 76, 33, 51, 36, 1, -51 },
  { 287, 26, 58, 33, 3, -54 },
  { 476, 42, 52, 48, 3, -51 },
  { 749, 33, 52, 37, 3, -51 },
  { 964, 4, 19, 13, 5, -51 },
  { 974, 14, 62, 20, 3, -51 },
  { 1083, 14, 62, 20, 2, -51 },
  { 1192, 24, 24, 30, 3, -54 },
  { 1264, 27, 33, 33, 3, -42 },
  { 1376, 8, 17, 15, 3, -8 },
  { 1393, 16, 4, 20, 2, -21 },
  { 1401, 6, 7, 15, 5, -6 },
  { 1407, 23, 51, 25, 1, -51 },
  { 1554, 26, 52, 33, 3, -51 },
  { 1723, 15, 51, 33, 5, -51 },
  { 1819, 26, 51, 33, 3, -51 },
  { 1985, 26, 52, 33, 3, -51 },
  { 2154, 31, 51, 33, 1, -51 },
  { 2352, 25, 52, 33, 4, -51 },
  { 2515, 25, 52, 33, 4, -51 },
  { 2678, 26, 51, 33, 3, -51 },
  { 2844, 27, 52, 33, 3, -51 },
  { 3020, 26, 52, 33, 3, -51 },
  { 3189, 6, 39, 15, 5, -38 },
  { 3219, 8, 47, 15, 3, -38 },
  { 3266, 27, 31, 33, 3, -41 },
  { 3371, 27, 18, 33, 3, -34 },
  { 3432, 27, 31, 33, 3, -41 },
  { 3537, 21, 52, 23, 1, -51 },
  { 3674, 43, 57, 50, 4, -51 },
  { 3981, 34, 51, 34, 0, -51 },
  { 4198, 27, 51, 36, 6, -51 },
  { 4371, 29, 52, 35, 4, -51 },
  { 4560, 30, 51, 40, 6, -51 },
  { 4752, 22, 51, 31, 6, -51 },
  { 4893, 22, 51, 29, 6, -51 },
  { 5034, 33, 52, 42, 4, -51 },
  { 5249, 29, 51, 41, 6, -51 },
  { 5434, 13, 51, 19, 3, -51 },
  { 5517, 14, 64, 16, -4, -51 },
  { 5629, 27, 51, 33, 6, -51 },
  { 5802, 21, 51, 29, 6, -51 },
  { 5936, 41, 51, 53, 6, -51 },
  { 6198, 30, 51, 42, 6, -51 },
  { 6390, 35, 52, 43, 4, -51 },
  { 6618, 25, 51, 33, 6, -51 },
  { 6778, 35, 63, 43, 4, -51 },
  { 7054, 27, 51, 34, 6, -51 },
  { 7227, 25, 52, 32, 3, -51 },
  { 7390, 27, 51, 29, 1, -51 },
  { 7563, 30, 52, 40, 5, -51 },
  { 7758, 32, 51, 32, 0, -51 },
  { 7962, 51, 51, 53, 1, -51 },
  { 8288, 29, 51, 30, 0, -51 },
  { 8473, 29, 51, 29, 0, -51 },
  { 8658, 25, 51, 29, 2, -51 },
  { 8818, 14, 62, 22, 6, -51 },
  { 8927, 23, 51, 25, 1, -51 },
  { 9074, 15, 62, 22, 2, -51 },
  { 9191, 29, 28, 33, 2, -51 },
  { 9293, 30, 3, 29, 0, 6 },
  { 9305, 12, 11, 18, 3, -54 },
  { 9322, 23, 39, 31, 3, -38 },
  { 9435, 26, 55, 35, 5, -54 },
  { 9614, 22, 39, 27, 3, -38 },
  { 9722, 27, 55, 35, 3, -54 },
  { 9908, 25, 39, 32, 3, -38 },
  { 10030, 19, 54, 18, 1, -54 },
  { 10159, 27, 55, 35, 3, -38 },
  { 10345, 24, 54, 34, 5, -54 },
  { 10507, 5, 52, 15, 5, -52 },
  { 10540, 11, 69, 15, -1, -52 },
  { 10635, 23, 54, 28, 5, -54 },
  { 10791, 4, 54, 14, 5, -54 },
  { 10818, 41, 38, 51, 5, -38 },
  { 11013, 24, 38, 34, 5, -38 },
  { 11127, 27, 39, 34, 3, -38 },
  { 11259, 26, 55, 35, 5, -38 },
  { 11438, 27, 55, 35, 3, -38 },
  { 11624, 17, 38, 22, 5, -38 },
  { 11705, 21, 39, 26, 3, -38 },
  { 11808, 17, 48, 19, 1, -47 },
  { 11910, 24, 39, 34, 5, -38 },
  { 12027, 26, 38, 26, 0, -38 },
  { 12151, 42, 38, 43, 1, -38 },
  { 12351, 26, 38, 28, 1, -38 },
  { 12475, 26, 55, 27, 1, -38 },
  { 12654, 20, 38, 24, 2, -38 },
  { 12749, 19, 62, 25, 3, -51 },
  { 12897, 3, 71, 31, 14, -54 },
  { 12924, 19, 62, 25, 3, -51 },
  { 13072, 27, 8, 33, 3, -29 },
};

const GFXfont NotoSans_Condensed_Light71pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light71pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light71pt7bGlyphs,
  0x20, 0x7E, 97
};

#endif // _NOTOSANS_CONDENSED_LIGHT71PT7B_H_
