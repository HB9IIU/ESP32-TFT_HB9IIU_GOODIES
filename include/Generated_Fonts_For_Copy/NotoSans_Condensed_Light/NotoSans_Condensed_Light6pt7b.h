#ifndef _NOTOSANS_CONDENSED_LIGHT6PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0xC0, 0x5F, 0xE0, 0x69, 0xC0, 0xED, 0x37, 0xCB, 0xF0, 0x80,
  0xF8, 0xF8, 0x70, 0x5D, 0x00, 0xC0, 0xC0, 0x80, 0x5A, 0xFF, 0xD5, 0xD7,
  0xD7, 0x5B, 0xA0, 0xF7, 0xFF, 0xD5, 0xFA, 0xF0, 0xF7, 0xA0, 0xB0, 0xEC,
  0xFC, 0xF8, 0xDA, 0xFF, 0xF8, 0x60, 0x5B, 0xD0, 0xFE, 0xF0, 0xF2, 0x70,
  0xF6, 0xF0, 0xFB, 0xFA, 0xF2, 0xB0, 0xBE, 0xD0, 0xF0, 0xF8, 0xBB, 0x50,
  0xAB, 0x9D, 0xFB, 0xBE, 0xD0, 0xF6, 0xF0, 0xF7, 0x40, 0xF6, 0xF2, 0xF7,
  0x50, 0xE7, 0xD5, 0xB6, 0xF0, 0xB7, 0x20, 0xBB, 0x55, 0xD7, 0xD5, 0xDB,
  0xEA, 0xC0, 0xA5, 0xF8, 0x54, 0xE0, 0x80, 0xFC, 0x9A, 0xDE, 0xEC, 0x2E,
  0xDE, 0xEC, 0x6A, 0x80, 0xF6, 0xF0, 0xAF, 0xC0, 0xF0, 0xF8, 0xAF, 0xC0,
  0xF8, 0xFB, 0xB0, 0xFC, 0xF7, 0x80, 0xF7, 0xC0, 0xF7, 0x90, 0xE8, 0xDC,
  0xF0, 0xFC, 0xD8, 0xDD, 0xA0, 0xDC, 0xDA, 0xEC, 0x59, 0x40, 0xFC, 0xD5,
  0x80, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 1, 0, -1 },
  { 1, 1, 4, 1, 0, -4 },
  { 2, 2, 1, 2, 0, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 2, 5, 3, 0, -5 },
  { 7, 4, 4, 4, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 1, 1, 0, -4 },
  { 12, 1, 5, 2, 0, -4 },
  { 13, 1, 5, 2, 0, -4 },
  { 14, 2, 2, 3, 0, -5 },
  { 15, 3, 3, 3, 0, -4 },
  { 17, 1, 2, 1, 0, -1 },
  { 18, 2, 1, 2, 0, -2 },
  { 19, 1, 1, 1, 0, -1 },
  { 20, 2, 4, 2, 0, -4 },
  { 21, 2, 4, 3, 0, -4 },
  { 22, 2, 4, 3, 0, -4 },
  { 23, 2, 4, 3, 0, -4 },
  { 24, 2, 4, 3, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 2, 4, 3, 0, -4 },
  { 28, 2, 4, 3, 0, -4 },
  { 29, 2, 4, 3, 0, -4 },
  { 30, 3, 4, 3, 0, -4 },
  { 32, 2, 4, 3, 0, -4 },
  { 33, 1, 3, 1, 0, -3 },
  { 34, 1, 4, 1, 0, -3 },
  { 35, 3, 2, 3, 0, -3 },
  { 36, 3, 2, 3, 0, -3 },
  { 37, 3, 2, 3, 0, -3 },
  { 38, 2, 4, 2, 0, -4 },
  { 39, 4, 5, 4, 0, -4 },
  { 42, 3, 4, 3, 0, -4 },
  { 44, 3, 4, 3, 0, -4 },
  { 46, 3, 4, 3, 0, -4 },
  { 48, 3, 4, 3, 0, -4 },
  { 50, 2, 4, 3, 0, -4 },
  { 51, 2, 4, 2, 0, -4 },
  { 52, 3, 4, 4, 0, -4 },
  { 54, 3, 4, 3, 0, -4 },
  { 56, 1, 4, 2, 0, -4 },
  { 57, 1, 5, 1, 0, -4 },
  { 58, 3, 4, 3, 0, -4 },
  { 60, 2, 4, 2, 0, -4 },
  { 61, 4, 4, 4, 0, -4 },
  { 63, 3, 4, 4, 0, -4 },
  { 65, 3, 4, 4, 0, -4 },
  { 67, 3, 4, 3, 0, -4 },
  { 69, 3, 5, 4, 0, -4 },
  { 71, 3, 4, 3, 0, -4 },
  { 73, 2, 4, 3, 0, -4 },
  { 74, 2, 4, 2, 0, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 4, 4, 4, 0, -4 },
  { 81, 2, 4, 3, 0, -4 },
  { 82, 2, 4, 2, 0, -4 },
  { 83, 2, 4, 2, 0, -4 },
  { 84, 2, 5, 2, 0, -4 },
  { 86, 2, 4, 2, 0, -4 },
  { 87, 1, 5, 2, 0, -4 },
  { 88, 3, 2, 3, 0, -4 },
  { 89, 3, 1, 2, 0, 0 },
  { 90, 1, 1, 2, 0, -5 },
  { 91, 2, 3, 3, 0, -3 },
  { 92, 3, 5, 3, 0, -5 },
  { 94, 2, 3, 2, 0, -3 },
  { 95, 3, 5, 3, 0, -5 },
  { 97, 2, 3, 3, 0, -3 },
  { 98, 2, 5, 2, 0, -5 },
  { 100, 3, 4, 3, 0, -3 },
  { 102, 2, 5, 3, 0, -5 },
  { 104, 1, 4, 1, 0, -4 },
  { 105, 1, 5, 1, 0, -4 },
  { 106, 2, 5, 2, 0, -5 },
  { 108, 1, 5, 1, 0, -5 },
  { 109, 4, 3, 4, 0, -3 },
  { 111, 2, 3, 3, 0, -3 },
  { 112, 3, 3, 3, 0, -3 },
  { 114, 3, 4, 3, 0, -3 },
  { 116, 3, 4, 3, 0, -3 },
  { 118, 2, 3, 2, 0, -3 },
  { 119, 2, 3, 2, 0, -3 },
  { 120, 1, 4, 2, 0, -4 },
  { 121, 2, 3, 3, 0, -3 },
  { 122, 2, 3, 2, 0, -3 },
  { 123, 4, 3, 4, 0, -3 },
  { 125, 2, 3, 2, 0, -3 },
  { 126, 2, 4, 2, 0, -3 },
  { 127, 2, 3, 2, 0, -3 },
  { 128, 2, 5, 2, 0, -4 },
  { 130, 1, 6, 3, 1, -5 },
  { 131, 2, 5, 2, 0, -4 },
  { 133, 3, 1, 3, 0, -3 },
};

const GFXfont NotoSans_Condensed_Light6pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light6pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light6pt7bGlyphs,
  0x20, 0x7E, 8
};

#endif // _NOTOSANS_CONDENSED_LIGHT6PT7B_H_
