#ifndef _NOTOSANS_CONDENSED_LIGHT54PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light54pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x77, 0x66, 0x66, 0x66,
  0x66, 0x66, 0x66, 0x60, 0x00, 0x00, 0x6F, 0xFF, 0xF0, 0xF0, 0x77, 0x07,
  0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x70, 0x77, 0x07, 0x60, 0x76, 0x07,
  0x60, 0x76, 0x07, 0x60, 0x76, 0x07, 0x00, 0x70, 0x18, 0x00, 0x38, 0x0C,
  0x00, 0x18, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03, 0x80, 0x03, 0x01,
  0x80, 0x03, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0, 0x30, 0x00, 0x60,
  0x18, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x0E, 0x03, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFC, 0x07, 0x01, 0x80, 0x03, 0x80, 0xC0, 0x01, 0x80, 0x60, 0x00,
  0xC0, 0x70, 0x00, 0x60, 0x38, 0x00, 0x30, 0x1C, 0x00, 0x38, 0x0C, 0x00,
  0x1C, 0x06, 0x00, 0x0E, 0x03, 0x00, 0x06, 0x01, 0x80, 0x03, 0x01, 0xC0,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xC0, 0xE0, 0x30, 0x00, 0x70, 0x18,
  0x00, 0x38, 0x0C, 0x00, 0x18, 0x06, 0x00, 0x0C, 0x07, 0x00, 0x06, 0x03,
  0x80, 0x03, 0x01, 0xC0, 0x01, 0x80, 0xC0, 0x01, 0xC0, 0x60, 0x00, 0xE0,
  0x30, 0x00, 0x70, 0x18, 0x00, 0x30, 0x1C, 0x00, 0x00, 0x60, 0x00, 0x06,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE, 0x1F,
  0x67, 0xE3, 0xC6, 0x04, 0x78, 0x60, 0x07, 0x06, 0x00, 0x60, 0x60, 0x0E,
  0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0x60, 0x60, 0x07, 0x06, 0x00,
  0x70, 0x60, 0x03, 0x86, 0x00, 0x3E, 0x60, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x06, 0xF8, 0x00, 0x63, 0xC0, 0x06,
  0x1E, 0x00, 0x60, 0xF0, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00,
  0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x80, 0x60, 0xEE,
  0x06, 0x3C, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x06, 0x00,
  0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x0F, 0x80,
  0x01, 0x80, 0x1F, 0xE0, 0x03, 0x80, 0x3C, 0xE0, 0x03, 0x80, 0x30, 0x70,
  0x07, 0x00, 0x70, 0x30, 0x07, 0x00, 0x70, 0x30, 0x06, 0x00, 0x60, 0x38,
  0x0E, 0x00, 0x60, 0x38, 0x0C, 0x00, 0x60, 0x38, 0x1C, 0x00, 0x60, 0x38,
  0x1C, 0x00, 0xE0, 0x18, 0x18, 0x00, 0xE0, 0x18, 0x38, 0x00, 0xE0, 0x18,
  0x30, 0x00, 0x60, 0x18, 0x70, 0x00, 0x60, 0x38, 0x70, 0x00, 0x60, 0x38,
  0x60, 0xE0, 0x60, 0x38, 0xE3, 0xF8, 0x60, 0x38, 0xC3, 0xFC, 0x70, 0x31,
  0xC7, 0x0C, 0x70, 0x31, 0xCE, 0x0E, 0x38, 0x71, 0x8E, 0x06, 0x3C, 0xE3,
  0x8C, 0x07, 0x1F, 0xC3, 0x0C, 0x07, 0x0F, 0x87, 0x0C, 0x07, 0x00, 0x07,
  0x1C, 0x07, 0x00, 0x06, 0x1C, 0x07, 0x00, 0x0E, 0x1C, 0x07, 0x00, 0x0C,
  0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x1C, 0x1C, 0x07, 0x00, 0x18,
  0x1C, 0x07, 0x00, 0x38, 0x0C, 0x07, 0x00, 0x30, 0x0C, 0x07, 0x00, 0x70,
  0x0C, 0x06, 0x00, 0x70, 0x0E, 0x06, 0x00, 0x60, 0x06, 0x0E, 0x00, 0xE0,
  0x07, 0x1C, 0x00, 0xC0, 0x03, 0xFC, 0x01, 0xC0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x0E,
  0x07, 0x00, 0x07, 0x00, 0xE0, 0x01, 0xC0, 0x38, 0x00, 0x70, 0x0E, 0x00,
  0x1C, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x00, 0xC0, 0x38, 0x00, 0x38, 0x1C,
  0x00, 0x0E, 0x07, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x0F, 0x70, 0x00, 0x07, 0x8E, 0x01, 0xC3, 0xC3, 0xC0,
  0x71, 0xE0, 0x70, 0x1C, 0x70, 0x0E, 0x07, 0x1C, 0x03, 0xC1, 0x8E, 0x00,
  0x78, 0xE3, 0x80, 0x0E, 0x38, 0xE0, 0x01, 0xDC, 0x38, 0x00, 0x7F, 0x0E,
  0x00, 0x0F, 0xC3, 0x80, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x1C, 0x00, 0x3F,
  0x07, 0x80, 0x1F, 0xC0, 0xE0, 0x0F, 0x38, 0x3E, 0x0F, 0x8F, 0x07, 0xFF,
  0xC1, 0xE0, 0x7F, 0xC0, 0x3C, 0x01, 0x00, 0x00, 0xF7, 0x77, 0x77, 0x77,
  0x76, 0x66, 0x66, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0x81, 0xC0,
  0x70, 0x3C, 0x0E, 0x03, 0x81, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0xE0, 0x38, 0x07, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x01, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x38, 0x0E,
  0x07, 0x81, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x38, 0x1C,
  0x07, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x07, 0x0C, 0x1D, 0xFB, 0x3F, 0xFF, 0xFF, 0x80,
  0xFE, 0x00, 0x1F, 0x00, 0x0E, 0xC0, 0x03, 0x38, 0x01, 0xC7, 0x00, 0xE0,
  0xE0, 0x78, 0x38, 0x1C, 0x07, 0x02, 0x01, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0xF3, 0xCE, 0x38, 0xE3, 0x9C, 0x71,
  0xC6, 0x38, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xEF, 0xFF, 0xF0, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x70, 0x07,
  0x1C, 0x00, 0xE3, 0x80, 0x0E, 0x70, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x03,
  0x70, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0x9C, 0x00, 0x73,
  0x80, 0x0E, 0x70, 0x01, 0xC7, 0x00, 0x70, 0xE0, 0x0E, 0x0E, 0x03, 0x81,
  0xF1, 0xF0, 0x1F, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0,
  0x7F, 0x0F, 0x71, 0xE7, 0x3C, 0x77, 0x87, 0xF0, 0x76, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xF8, 0x01, 0xFF, 0xE0, 0x3F,
  0xFF, 0x07, 0x80, 0x78, 0x30, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x01, 0xFF,
  0xE0, 0x7F, 0xFF, 0x8F, 0x80, 0x78, 0x60, 0x03, 0xC4, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xCC,
  0x00, 0x3C, 0xF8, 0x1F, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC, 0x00, 0x08, 0x00,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x03, 0x0E, 0x00, 0x0E,
  0x1C, 0x00, 0x18, 0x38, 0x00, 0x70, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81,
  0xC0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x38, 0x06, 0x00, 0x70, 0x1C, 0x00, 0xE0, 0x30, 0x01, 0xC0,
  0xE0, 0x03, 0x83, 0x80, 0x07, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xFF, 0xFE,
  0x18, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xF8, 0x0F, 0xFF, 0xC1,
  0xF0, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x40, 0x07, 0xCF, 0x03, 0xF1, 0xFF, 0xFC, 0x1F,
  0xFE, 0x00, 0x08, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x07, 0xC0, 0xE3, 0xFE, 0x1C, 0xFF, 0xE3, 0xB8,
  0x1E, 0x7C, 0x01, 0xEF, 0x00, 0x1D, 0xE0, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0xEF, 0x00,
  0x38, 0xE0, 0x07, 0x1E, 0x01, 0xC1, 0xF0, 0xF8, 0x1F, 0xFE, 0x01, 0xFF,
  0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0x8E,
  0x00, 0x1C, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x38, 0x70, 0x01,
  0xC3, 0x80, 0x0E, 0x1E, 0x00, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0xF0, 0x07,
  0x8F, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x79, 0xF0,
  0x07, 0x87, 0xC0, 0x70, 0x0F, 0x07, 0x00, 0x3C, 0x78, 0x00, 0xE3, 0x80,
  0x03, 0x9C, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07, 0x70, 0x00, 0x1F,
  0x80, 0x01, 0xDC, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9E, 0x00,
  0x38, 0x78, 0x03, 0xC1, 0xF0, 0x7C, 0x07, 0xFF, 0xC0, 0x1F, 0xF8, 0x00,
  0x04, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x78,
  0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x70, 0x01, 0xC7, 0x00, 0x0E, 0x70, 0x00,
  0xEF, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0xF7, 0x00, 0x0F, 0x70,
  0x00, 0xF3, 0x80, 0x1F, 0x3C, 0x03, 0x71, 0xF0, 0xF7, 0x0F, 0xFE, 0x70,
  0x7F, 0x87, 0x00, 0x00, 0x60, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x20, 0x7E, 0x03, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x20, 0x00, 0xEF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xF0, 0x38, 0xF3, 0xCF,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x3C, 0xF3, 0x8E, 0x38, 0xE7, 0x1C, 0x71, 0x8E, 0x30,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xC0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x60, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x03, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xE3, 0xFF,
  0xF3, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x06,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xF0, 0x03,
  0xC0, 0x03, 0xC0, 0x00, 0xE0, 0x07, 0x80, 0x00, 0x70, 0x07, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x18, 0x1C, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x00,
  0x0C, 0x38, 0x00, 0x00, 0x0E, 0x38, 0x01, 0xF8, 0x06, 0x70, 0x07, 0xFE,
  0x06, 0x70, 0x0F, 0x1E, 0x07, 0x70, 0x1C, 0x0E, 0x07, 0x60, 0x38, 0x0E,
  0x03, 0xE0, 0x38, 0x0E, 0x03, 0xE0, 0x70, 0x0E, 0x03, 0xE0, 0x70, 0x0E,
  0x03, 0xE0, 0x70, 0x0C, 0x03, 0xE0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C,
  0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x0C, 0x03, 0xC0, 0x60, 0x1C,
  0x03, 0xC0, 0x60, 0x1C, 0x07, 0xE0, 0x70, 0x1C, 0x07, 0xE0, 0x70, 0x1C,
  0x06, 0xE0, 0x70, 0x36, 0x0E, 0xE0, 0x38, 0x36, 0x0E, 0xE0, 0x3E, 0xE7,
  0xBC, 0x60, 0x1F, 0xE3, 0xF8, 0x70, 0x0F, 0x81, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x03, 0xC0, 0x07, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x70, 0x00, 0x01, 0xB8, 0x00,
  0x01, 0xCC, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x73, 0x80, 0x00, 0x71, 0xC0,
  0x00, 0x38, 0x60, 0x00, 0x1C, 0x38, 0x00, 0x0C, 0x1C, 0x00, 0x0E, 0x0E,
  0x00, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x01, 0xC0,
  0x70, 0x00, 0xE0, 0x1C, 0x00, 0x70, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x03, 0x80, 0x07, 0x03, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xE0,
  0xE0, 0x00, 0x70, 0xF0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38, 0x00, 0x0F,
  0x1C, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0E, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xE0, 0x0F, 0x8F, 0x00, 0x1E, 0x78, 0x00, 0x73, 0xC0,
  0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x1D,
  0xE0, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0x9E, 0x00,
  0x3C, 0xF0, 0x03, 0xC7, 0x83, 0xFC, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x0F,
  0x00, 0x7C, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x77, 0x80, 0x07,
  0xBC, 0x00, 0x39, 0xE0, 0x07, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xF0,
  0x06, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x02, 0x03, 0xF0, 0x78, 0x07, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x01, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x07, 0x80, 0xFE, 0x0F, 0x00, 0x3E, 0x1E, 0x00, 0x1E, 0x3C, 0x00, 0x1C,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0x77,
  0x80, 0x00, 0xEF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xEF, 0x00, 0x01, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0x78, 0x00, 0x3C,
  0xF0, 0x00, 0x71, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x3E, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xEF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xFB, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x01, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x77, 0x00, 0x00, 0x1D, 0xC0,
  0x00, 0x07, 0x70, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xF0, 0x00, 0x07, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x70, 0xF0, 0x00,
  0x1C, 0x1F, 0x00, 0x07, 0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x0C, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0xFF, 0xFF,
  0xF7, 0xF8, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x3F, 0xFF, 0xFC, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x3C, 0x0F, 0x3F, 0xE7, 0xF8, 0x7C, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xBC, 0x00, 0x39, 0xE0, 0x03, 0xCF, 0x00, 0x3C, 0x78, 0x01, 0xC3, 0xC0,
  0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x0E, 0x07, 0x80, 0xE0, 0x3C, 0x0F, 0x01,
  0xE0, 0x70, 0x0F, 0x07, 0x00, 0x78, 0x78, 0x03, 0xC3, 0x80, 0x1E, 0x38,
  0x00, 0xF3, 0xC0, 0x07, 0x9C, 0x00, 0x3D, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xCE, 0x00, 0x7E, 0x78, 0x03, 0xE1, 0xC0, 0x1E, 0x0F, 0x00, 0xF0, 0x38,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xE0, 0x78,
  0x03, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x80, 0x0E,
  0x3C, 0x00, 0x79, 0xE0, 0x01, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0xC0,
  0x00, 0xE0, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xEE, 0x00, 0x00,
  0x77, 0xEE, 0x00, 0x00, 0x77, 0xEE, 0x00, 0x00, 0x77, 0xE6, 0x00, 0x00,
  0x67, 0xE7, 0x00, 0x00, 0xE7, 0xE7, 0x00, 0x00, 0xE7, 0xE3, 0x00, 0x00,
  0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE3, 0x80, 0x01, 0xC7, 0xE1, 0x80, 0x01,
  0x87, 0xE1, 0xC0, 0x03, 0x87, 0xE1, 0xC0, 0x03, 0x87, 0xE1, 0xC0, 0x03,
  0x07, 0xE0, 0xE0, 0x07, 0x07, 0xE0, 0xE0, 0x07, 0x07, 0xE0, 0xE0, 0x06,
  0x07, 0xE0, 0x70, 0x0E, 0x07, 0xE0, 0x70, 0x0E, 0x07, 0xE0, 0x70, 0x0C,
  0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0, 0x38, 0x1C, 0x07, 0xE0, 0x38, 0x18,
  0x07, 0xE0, 0x1C, 0x38, 0x07, 0xE0, 0x1C, 0x38, 0x07, 0xE0, 0x1C, 0x30,
  0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70, 0x07, 0xE0, 0x0E, 0x70,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0, 0x07, 0xE0, 0x03, 0xC0,
  0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xEE, 0x00, 0x07, 0xEF, 0x00,
  0x07, 0xE7, 0x00, 0x07, 0xE7, 0x80, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0xC0,
  0x07, 0xE1, 0xC0, 0x07, 0xE1, 0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xF0,
  0x07, 0xE0, 0x70, 0x07, 0xE0, 0x78, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x3C,
  0x07, 0xE0, 0x1C, 0x07, 0xE0, 0x1E, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0F,
  0x07, 0xE0, 0x07, 0x07, 0xE0, 0x07, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x03,
  0xC7, 0xE0, 0x01, 0xC7, 0xE0, 0x01, 0xE7, 0xE0, 0x00, 0xE7, 0xE0, 0x00,
  0xF7, 0xE0, 0x00, 0x77, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0E, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0xFF, 0x80, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x78, 0x1F, 0xCF, 0x00,
  0x7D, 0xE0, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3B, 0xC0, 0x0F, 0x78, 0x07,
  0xCF, 0x0F, 0xF1, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xC0, 0x3E, 0x00,
  0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x1C, 0x0F, 0x00, 0x03, 0xC1, 0xC0, 0x00,
  0x38, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x00, 0x71, 0xC0, 0x00, 0x0F, 0x38,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x39, 0xC0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C,
  0xE0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0xE1, 0xC0, 0x00, 0x3C, 0x3C, 0x00,
  0x07, 0x03, 0x80, 0x01, 0xE0, 0x38, 0x00, 0x78, 0x07, 0xC0, 0x1E, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x2E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xE0, 0x3F, 0x0F, 0x00, 0x7C, 0x78, 0x00, 0xE3, 0xC0, 0x07, 0x9E, 0x00,
  0x1C, 0xF0, 0x00, 0xE7, 0x80, 0x07, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xCF,
  0x00, 0x0E, 0x78, 0x00, 0x73, 0xC0, 0x03, 0x9E, 0x00, 0x3C, 0xF0, 0x01,
  0xC7, 0x80, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x7E, 0x0F, 0xFF, 0xE0, 0x7F,
  0xF8, 0x03, 0xC0, 0xE0, 0x1E, 0x07, 0x00, 0xF0, 0x1C, 0x07, 0x80, 0xE0,
  0x3C, 0x03, 0x81, 0xE0, 0x1C, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x83, 0xC0,
  0x0E, 0x1E, 0x00, 0x70, 0xF0, 0x03, 0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x79,
  0xE0, 0x01, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3B, 0xC0, 0x01, 0xE0, 0x01,
  0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0xE0, 0x0C, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xCC, 0x00, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xF0, 0x3F, 0xFC,
  0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xF0, 0x00, 0x70, 0xE0, 0x01, 0xE1, 0xF0, 0x07, 0x81, 0xF8,
  0x3E, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x08, 0x00, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0x9C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x1C, 0x38,
  0x00, 0x1C, 0x1E, 0x00, 0x0E, 0x07, 0x00, 0x07, 0x03, 0x80, 0x03, 0x81,
  0xC0, 0x03, 0x80, 0x70, 0x01, 0xC0, 0x38, 0x00, 0xE0, 0x1C, 0x00, 0xF0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x1C,
  0x00, 0x78, 0x0E, 0x00, 0x1C, 0x07, 0x00, 0x0E, 0x03, 0x80, 0x07, 0x03,
  0x80, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x38,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0x1C, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0xCE, 0x00, 0x00, 0x77, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xE0, 0x00, 0x77, 0x00, 0x03, 0xC0, 0x00, 0xEF, 0x00, 0x07, 0xC0, 0x01,
  0xCE, 0x00, 0x0F, 0x80, 0x03, 0x9C, 0x00, 0x3F, 0x00, 0x0F, 0x38, 0x00,
  0x76, 0x00, 0x1C, 0x70, 0x00, 0xEC, 0x00, 0x38, 0x70, 0x01, 0x9C, 0x00,
  0x70, 0xE0, 0x07, 0x38, 0x01, 0xE1, 0xC0, 0x0E, 0x70, 0x03, 0x83, 0x80,
  0x1C, 0x60, 0x07, 0x03, 0x80, 0x38, 0xE0, 0x0E, 0x07, 0x00, 0x61, 0xC0,
  0x1C, 0x0E, 0x01, 0xC3, 0x80, 0x70, 0x1C, 0x03, 0x87, 0x00, 0xE0, 0x38,
  0x07, 0x06, 0x01, 0xC0, 0x38, 0x0C, 0x0E, 0x03, 0x80, 0x70, 0x38, 0x1C,
  0x0F, 0x00, 0xE0, 0x70, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x30, 0x38, 0x01,
  0xC1, 0x80, 0x70, 0x70, 0x03, 0x87, 0x00, 0xE0, 0xE0, 0x07, 0x0E, 0x01,
  0xC3, 0x80, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x03, 0x0E, 0x00,
  0x1C, 0x60, 0x07, 0x1C, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x00, 0x73, 0x80,
  0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x19, 0xC0, 0x00, 0xCC, 0x00, 0x33, 0x80,
  0x01, 0xD8, 0x00, 0x77, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x1C, 0xE0, 0x00, 0xF3, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1C, 0x00,
  0x70, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xC0,
  0x0E, 0x07, 0x00, 0x38, 0x38, 0x00, 0xF0, 0xE0, 0x01, 0xC7, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x0E, 0xE0, 0x00, 0x3B, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0xE0, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x1E,
  0x03, 0x80, 0x38, 0x1E, 0x00, 0xE0, 0x70, 0x01, 0xC3, 0xC0, 0x07, 0x0E,
  0x00, 0x0E, 0x78, 0x00, 0x39, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xC0, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0x9C, 0x00, 0x0E, 0x38, 0x00,
  0x70, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x00, 0x38, 0x1C, 0x00, 0xE0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x70, 0x07, 0x03, 0x80, 0x1C,
  0x0E, 0x00, 0x38, 0x70, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x07, 0x38,
  0x00, 0x1C, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x30, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x06, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x1D, 0xC0,
  0x00, 0x31, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0x83, 0x80, 0x07, 0x07, 0x00,
  0x0C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x1C, 0x03,
  0x80, 0x1C, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x30, 0x70, 0x00, 0x70, 0xE0,
  0x00, 0x63, 0x80, 0x00, 0xEF, 0x00, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xF0, 0x3C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0C, 0x03, 0x07,
  0xFC, 0x0F, 0xFF, 0x81, 0xF1, 0xF0, 0x60, 0x1E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x7F, 0xC1, 0xFF, 0xF1, 0xFF, 0x1C, 0xF8, 0x07, 0x78,
  0x01, 0xDC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x80, 0x0F, 0x70, 0x07, 0xDC, 0x03, 0x77, 0x81, 0xDC,
  0xFF, 0xE7, 0x1F, 0xE1, 0xC0, 0x40, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE1, 0xFC, 0x0E, 0x7F, 0xF0, 0xEF, 0x9F, 0x8E, 0xC0, 0x3C, 0xF8,
  0x01, 0xCF, 0x80, 0x1E, 0xF0, 0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00,
  0x1E, 0xF8, 0x01, 0xCE, 0xC0, 0x3C, 0xEE, 0x0F, 0x8C, 0x7F, 0xF0, 0xC3,
  0xFE, 0x00, 0x03, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0x1F, 0xCE, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x07, 0x0F, 0xFF,
  0x07, 0xFE, 0x00, 0x20, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x07, 0xF8,
  0x70, 0xFF, 0xC7, 0x1F, 0x1E, 0x73, 0xC0, 0x77, 0x38, 0x03, 0x77, 0x00,
  0x1F, 0x70, 0x01, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00, 0x1F, 0x78, 0x01,
  0x73, 0x80, 0x37, 0x3E, 0x0E, 0x71, 0xFF, 0xC7, 0x07, 0xF8, 0x70, 0x04,
  0x00, 0x03, 0xF8, 0x03, 0xFF, 0x81, 0xF1, 0xF0, 0xF0, 0x1C, 0x38, 0x03,
  0x9C, 0x00, 0xE7, 0x00, 0x1D, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x21,
  0xF0, 0x38, 0x3F, 0xFE, 0x03, 0xFF, 0x00, 0x08, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0x30, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x03, 0xFF, 0x1F, 0xFE, 0x3F,
  0xFC, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x07, 0xF8, 0x61, 0xFF, 0x8C, 0x7E, 0xF9, 0x9E, 0x03, 0xB3,
  0x80, 0x36, 0xE0, 0x03, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x0F, 0x78,
  0x03, 0x67, 0x80, 0x6C, 0xF8, 0x39, 0x8F, 0xFE, 0x70, 0x7F, 0x8E, 0x01,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x80, 0x07, 0x98, 0x01, 0xE3, 0xFF,
  0xF8, 0x7F, 0xFE, 0x01, 0xFF, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE1, 0xFC, 0x39,
  0xFF, 0xCE, 0xF9, 0xF3, 0xB0, 0x1E, 0xF8, 0x03, 0xBE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xC0, 0xEF, 0xFE, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xE0, 0x07,
  0x03, 0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x0E, 0x7F, 0x3F, 0x1F, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x7F, 0x00, 0x3B, 0x80, 0x39, 0xC0, 0x38, 0xE0, 0x3C, 0x70, 0x1C,
  0x38, 0x1C, 0x1C, 0x1E, 0x0E, 0x0E, 0x07, 0x0E, 0x03, 0x8E, 0x01, 0xC7,
  0x00, 0xE7, 0x80, 0x77, 0xE0, 0x3B, 0x70, 0x1F, 0x3C, 0x0F, 0x8E, 0x07,
  0x87, 0x83, 0x81, 0xC1, 0xC0, 0xF0, 0xE0, 0x38, 0x70, 0x1E, 0x38, 0x07,
  0x1C, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xE0,
  0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xC1, 0xF8, 0x0F, 0xE1, 0x8F, 0xFC,
  0x3F, 0xF3, 0xBC, 0xF8, 0xF3, 0xE7, 0x60, 0x7B, 0x81, 0xEF, 0x80, 0x76,
  0x01, 0xDE, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xE0,
  0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00,
  0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01,
  0xF8, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F,
  0xC0, 0x07, 0x00, 0x1F, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E,
  0x00, 0x38, 0x00, 0xFC, 0x00, 0x70, 0x01, 0xF8, 0x00, 0xE0, 0x03, 0xF0,
  0x01, 0xC0, 0x07, 0xE0, 0x03, 0x80, 0x0F, 0xC0, 0x07, 0x00, 0x1F, 0x80,
  0x0E, 0x00, 0x3F, 0x00, 0x1C, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xE0, 0xC1,
  0xFC, 0x31, 0xFF, 0xCC, 0xF1, 0xFB, 0xB0, 0x1E, 0xF8, 0x03, 0xBC, 0x00,
  0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xE0, 0x1F, 0x1F,
  0x83, 0xC0, 0x38, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0x70, 0x00, 0xEE, 0x00,
  0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x1E, 0x38, 0x01, 0xC3, 0xC0, 0x3C, 0x1E, 0x0F,
  0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x04, 0x00, 0xC1, 0xFC, 0x0C, 0x3F,
  0xF0, 0xE7, 0x9F, 0x8E, 0xC0, 0x3C, 0xF8, 0x01, 0xCF, 0x80, 0x1E, 0xF0,
  0x00, 0xEF, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00,
  0xEF, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x1C, 0xF8, 0x01, 0xCE, 0xC0,
  0x38, 0xEF, 0x0F, 0x8E, 0x7F, 0xF0, 0xE3, 0xFE, 0x0E, 0x07, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0x03, 0xF8, 0x61, 0xFF, 0x8C, 0x7E, 0x79,
  0x9E, 0x03, 0xB3, 0x80, 0x36, 0xE0, 0x03, 0xDC, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7B,
  0x80, 0x0F, 0x78, 0x03, 0x67, 0x80, 0xEC, 0xF8, 0x39, 0x8F, 0xFE, 0x70,
  0x7F, 0x8E, 0x01, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0xC1, 0xFC, 0x3F,
  0xC7, 0xFE, 0xE0, 0xFC, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xFF, 0x3E, 0x3E, 0x78,
  0x02, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x80, 0x0E, 0xF0, 0x3E, 0xFF,
  0xFC, 0x7F, 0xF0, 0x03, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x00, 0xF1, 0x0F, 0xF0, 0x7F, 0x00,
  0x80, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x07, 0xDC, 0x03, 0x77,
  0xC3, 0xDC, 0xFF, 0xE3, 0x1F, 0xF0, 0xC0, 0x60, 0x00, 0xE0, 0x00, 0x77,
  0x00, 0x07, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE3, 0x80, 0x1C,
  0x38, 0x01, 0xC3, 0x80, 0x1C, 0x18, 0x01, 0xC1, 0xC0, 0x38, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0x0E, 0x03, 0x00, 0xE0, 0x70, 0x0E, 0x07, 0x00, 0x60,
  0x70, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00, 0x30, 0xC0, 0x03,
  0x9C, 0x00, 0x39, 0xC0, 0x01, 0x9C, 0x00, 0x1D, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0x80, 0x0F, 0xC0, 0x07, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x3E,
  0x00, 0x77, 0x00, 0x7C, 0x00, 0xCE, 0x00, 0xDC, 0x03, 0x9C, 0x01, 0xB8,
  0x07, 0x38, 0x07, 0x70, 0x0E, 0x30, 0x0E, 0x60, 0x1C, 0x70, 0x18, 0xC0,
  0x70, 0xE0, 0x31, 0xC0, 0xE1, 0xC0, 0xE3, 0x81, 0xC3, 0x81, 0xC3, 0x03,
  0x83, 0x83, 0x06, 0x06, 0x07, 0x06, 0x0E, 0x1C, 0x0E, 0x1C, 0x1C, 0x38,
  0x1C, 0x38, 0x38, 0x70, 0x1C, 0x60, 0x30, 0xC0, 0x38, 0xC0, 0x73, 0x80,
  0x73, 0x80, 0xE7, 0x00, 0xE7, 0x01, 0xCE, 0x00, 0xCE, 0x01, 0x98, 0x01,
  0xD8, 0x03, 0xB0, 0x03, 0xB0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x07,
  0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xEE, 0x00, 0x38, 0xE0, 0x0F, 0x1C, 0x01,
  0xC1, 0xC0, 0x78, 0x38, 0x0E, 0x03, 0x83, 0xC0, 0x70, 0x70, 0x07, 0x1C,
  0x00, 0xE3, 0x80, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x77, 0x00, 0x0E, 0x70,
  0x03, 0x8E, 0x00, 0xF0, 0xE0, 0x1C, 0x1C, 0x07, 0x81, 0xC0, 0xE0, 0x38,
  0x3C, 0x03, 0x87, 0x00, 0x71, 0xC0, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x0E,
  0x70, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00, 0x73, 0x00, 0x0E, 0x38, 0x00,
  0xE3, 0x80, 0x0E, 0x38, 0x00, 0xC1, 0xC0, 0x1C, 0x1C, 0x01, 0xC1, 0xC0,
  0x1C, 0x0C, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x07,
  0x07, 0x00, 0x70, 0x70, 0x07, 0x07, 0x00, 0x30, 0xE0, 0x03, 0x8E, 0x00,
  0x38, 0xE0, 0x01, 0x8C, 0x00, 0x1D, 0xC0, 0x01, 0xDC, 0x00, 0x1D, 0xC0,
  0x00, 0xD8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF0, 0x00, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0,
  0x07, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x70, 0x01, 0xC0, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x02, 0x00, 0xFC, 0x03, 0xF8, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x0F, 0x80, 0x7E,
  0x00, 0xFC, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x7E, 0x01, 0xE0, 0x07, 0x80, 0x0E, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0x40,
  0x00, 0x1F, 0x00, 0x0B, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0x80, 0xFF, 0xF8,
  0x01, 0xFE, 0x40, 0x01, 0xC0,
};

const GFXglyph NotoSans_Condensed_Light54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 4, 39, 12, 4, -39 },
  { 21, 12, 14, 19, 3, -39 },
  { 42, 25, 39, 27, 1, -39 },
  { 164, 20, 44, 25, 2, -41 },
  { 274, 32, 39, 37, 2, -39 },
  { 430, 26, 40, 28, 2, -39 },
  { 560, 4, 14, 10, 3, -39 },
  { 567, 10, 48, 15, 3, -39 },
  { 627, 10, 48, 15, 2, -39 },
  { 687, 18, 18, 23, 2, -41 },
  { 728, 21, 26, 25, 2, -32 },
  { 797, 6, 13, 11, 2, -6 },
  { 807, 12, 3, 15, 2, -16 },
  { 812, 4, 5, 12, 4, -5 },
  { 815, 17, 39, 19, 1, -39 },
  { 898, 19, 39, 25, 3, -39 },
  { 991, 12, 39, 25, 4, -39 },
  { 1050, 20, 39, 25, 2, -39 },
  { 1148, 20, 40, 25, 2, -39 },
  { 1248, 23, 39, 25, 1, -39 },
  { 1361, 19, 40, 25, 3, -39 },
  { 1456, 19, 40, 25, 3, -39 },
  { 1551, 20, 39, 25, 2, -39 },
  { 1649, 21, 40, 25, 2, -39 },
  { 1754, 20, 40, 25, 2, -39 },
  { 1854, 4, 29, 12, 4, -29 },
  { 1869, 6, 36, 12, 2, -29 },
  { 1896, 21, 24, 25, 2, -31 },
  { 1959, 21, 14, 25, 2, -26 },
  { 1996, 21, 24, 25, 2, -31 },
  { 2059, 15, 39, 18, 1, -39 },
  { 2133, 32, 44, 38, 3, -39 },
  { 2309, 25, 39, 25, 0, -39 },
  { 2431, 21, 39, 27, 4, -39 },
  { 2534, 22, 40, 26, 3, -39 },
  { 2644, 23, 39, 30, 4, -39 },
  { 2757, 17, 39, 24, 4, -39 },
  { 2840, 17, 39, 22, 4, -39 },
  { 2923, 26, 40, 32, 3, -39 },
  { 3053, 23, 39, 31, 4, -39 },
  { 3166, 10, 39, 15, 2, -39 },
  { 3215, 11, 49, 12, -3, -39 },
  { 3283, 21, 39, 25, 4, -39 },
  { 3386, 17, 39, 22, 4, -39 },
  { 3469, 32, 39, 40, 4, -39 },
  { 3625, 24, 39, 32, 4, -39 },
  { 3742, 27, 40, 33, 3, -39 },
  { 3877, 19, 39, 25, 4, -39 },
  { 3970, 27, 48, 33, 3, -39 },
  { 4132, 21, 39, 26, 4, -39 },
  { 4235, 20, 40, 24, 2, -39 },
  { 4335, 22, 39, 22, 0, -39 },
  { 4443, 23, 40, 31, 4, -39 },
  { 4558, 25, 39, 25, 0, -39 },
  { 4680, 39, 39, 40, 1, -39 },
  { 4871, 22, 39, 23, 0, -39 },
  { 4979, 22, 39, 22, 0, -39 },
  { 5087, 19, 39, 22, 2, -39 },
  { 5180, 11, 48, 17, 4, -39 },
  { 5246, 17, 39, 19, 1, -39 },
  { 5329, 11, 48, 17, 2, -39 },
  { 5395, 23, 21, 25, 1, -39 },
  { 5456, 23, 2, 22, 0, 5 },
  { 5462, 9, 8, 14, 2, -41 },
  { 5471, 18, 30, 23, 2, -29 },
  { 5539, 20, 42, 26, 4, -41 },
  { 5644, 16, 30, 20, 3, -29 },
  { 5704, 20, 42, 26, 3, -41 },
  { 5809, 18, 30, 24, 3, -29 },
  { 5877, 15, 41, 14, 1, -41 },
  { 5954, 19, 42, 26, 3, -29 },
  { 6054, 18, 41, 26, 4, -41 },
  { 6147, 4, 39, 11, 4, -39 },
  { 6167, 9, 52, 11, -1, -39 },
  { 6226, 17, 41, 22, 4, -41 },
  { 6314, 3, 41, 11, 4, -41 },
  { 6330, 31, 29, 39, 4, -29 },
  { 6443, 18, 29, 26, 4, -29 },
  { 6509, 20, 30, 26, 3, -29 },
  { 6584, 20, 42, 26, 4, -29 },
  { 6689, 19, 42, 26, 3, -29 },
  { 6789, 12, 29, 17, 4, -29 },
  { 6833, 16, 30, 20, 2, -29 },
  { 6893, 12, 37, 14, 1, -36 },
  { 6949, 18, 30, 26, 4, -29 },
  { 7017, 20, 29, 20, 0, -29 },
  { 7090, 31, 29, 33, 1, -29 },
  { 7203, 19, 29, 21, 1, -29 },
  { 7272, 20, 42, 21, 0, -29 },
  { 7377, 15, 29, 18, 2, -29 },
  { 7432, 15, 48, 19, 2, -39 },
  { 7522, 3, 54, 24, 10, -41 },
  { 7543, 15, 48, 19, 2, -39 },
  { 7633, 21, 6, 25, 2, -22 },
};

const GFXfont NotoSans_Condensed_Light54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light54pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_CONDENSED_LIGHT54PT7B_H_
