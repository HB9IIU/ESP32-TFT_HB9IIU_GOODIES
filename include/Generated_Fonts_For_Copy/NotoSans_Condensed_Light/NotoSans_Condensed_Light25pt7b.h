#ifndef _NOTOSANS_CONDENSED_LIGHT25PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT25PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light25pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0xAA, 0x80, 0xF0, 0x9C, 0x63, 0x18, 0xC6, 0x20, 0x08,
  0x81, 0x10, 0x62, 0x08, 0x41, 0x09, 0xFF, 0xFF, 0xF8, 0x88, 0x11, 0x06,
  0x20, 0x84, 0x7F, 0xE2, 0x30, 0x44, 0x08, 0x81, 0x10, 0x62, 0x08, 0x40,
  0x08, 0x04, 0x0F, 0xED, 0x2C, 0x84, 0x42, 0x21, 0x90, 0x68, 0x1C, 0x03,
  0x81, 0x60, 0x88, 0x44, 0x22, 0x11, 0xCB, 0x7F, 0x02, 0x01, 0x00, 0x38,
  0x30, 0x90, 0x43, 0x11, 0x84, 0x22, 0x08, 0x44, 0x10, 0x98, 0x21, 0x20,
  0x42, 0xDC, 0xCD, 0x24, 0x92, 0x88, 0xE9, 0x18, 0x12, 0x10, 0x64, 0x20,
  0x88, 0x41, 0x11, 0x84, 0x22, 0x08, 0x24, 0x30, 0x70, 0x1E, 0x02, 0x20,
  0x23, 0x06, 0x30, 0x23, 0x02, 0x20, 0x36, 0x01, 0xC0, 0x18, 0x02, 0xC0,
  0x44, 0x2C, 0x26, 0xC3, 0x68, 0x1C, 0x80, 0xCC, 0x1C, 0x63, 0x63, 0xE3,
  0xFE, 0x18, 0x8C, 0x46, 0x21, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x08, 0x43,
  0x08, 0x61, 0x0C, 0x82, 0x18, 0x43, 0x08, 0x42, 0x18, 0xC6, 0x31, 0x8C,
  0x42, 0x11, 0x88, 0xC4, 0x60, 0x08, 0x08, 0x08, 0xEF, 0x18, 0x14, 0x26,
  0x62, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02, 0x0F, 0xFC, 0x20, 0x08,
  0x02, 0x00, 0x80, 0x20, 0x6D, 0x2D, 0x00, 0xF8, 0xF0, 0x01, 0x01, 0x02,
  0x02, 0x06, 0x04, 0x04, 0x0C, 0x08, 0x08, 0x18, 0x10, 0x30, 0x20, 0x20,
  0x60, 0x40, 0xC0, 0x1E, 0x19, 0x98, 0x48, 0x34, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0A, 0x05, 0x06, 0xC2, 0x23, 0x0F, 0x00,
  0x09, 0xDB, 0x98, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x40,
  0x3E, 0x71, 0x80, 0x40, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x01,
  0x81, 0x81, 0x80, 0x80, 0x80, 0xC0, 0xC0, 0x7F, 0xC0, 0x3E, 0x61, 0xA0,
  0x60, 0x30, 0x18, 0x0C, 0x04, 0x06, 0x3C, 0x07, 0x00, 0x40, 0x30, 0x08,
  0x04, 0x06, 0x03, 0x83, 0x7F, 0x00, 0x01, 0x80, 0x30, 0x0E, 0x03, 0xC0,
  0x58, 0x1B, 0x02, 0x60, 0xCC, 0x11, 0x84, 0x30, 0x86, 0x20, 0xCC, 0x19,
  0xFF, 0xC0, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x7F, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0xF8, 0x67, 0x00, 0xC0, 0x20, 0x10, 0x08, 0x04, 0x06,
  0x03, 0x83, 0x3F, 0x00, 0x0F, 0x0C, 0x08, 0x0C, 0x04, 0x02, 0x01, 0x01,
  0xBC, 0xF3, 0x60, 0xF0, 0x38, 0x1C, 0x0A, 0x05, 0x02, 0xC3, 0x21, 0x0F,
  0x00, 0xFF, 0x80, 0x40, 0x60, 0x20, 0x10, 0x18, 0x08, 0x04, 0x06, 0x02,
  0x01, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x30, 0x18, 0x00, 0x3E, 0x31,
  0x90, 0x68, 0x1C, 0x0A, 0x0D, 0x84, 0x6C, 0x1C, 0x1B, 0x18, 0xD8, 0x3C,
  0x0C, 0x06, 0x03, 0x81, 0x61, 0x9F, 0x00, 0x3E, 0x31, 0x90, 0x58, 0x3C,
  0x0C, 0x06, 0x03, 0x81, 0xC1, 0xB1, 0x4F, 0xA0, 0x10, 0x18, 0x08, 0x04,
  0x06, 0x06, 0x3E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x6C, 0x00, 0x00, 0x01,
  0xB4, 0xB4, 0x00, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x70, 0x04, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x70, 0x70, 0x70, 0x70, 0x30,
  0x08, 0x00, 0xFC, 0x46, 0x02, 0x03, 0x03, 0x02, 0x02, 0x06, 0x0C, 0x18,
  0x10, 0x10, 0x10, 0x00, 0x00, 0x00, 0x30, 0x30, 0x03, 0xE0, 0x18, 0x60,
  0x60, 0x21, 0x80, 0x22, 0x00, 0x68, 0x3C, 0x50, 0x88, 0xA2, 0x11, 0xC4,
  0x23, 0x98, 0x47, 0x31, 0x8E, 0x63, 0x1C, 0x46, 0x38, 0x8C, 0xD1, 0xEF,
  0x20, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x40, 0x7F, 0x00, 0x06, 0x00,
  0x60, 0x0E, 0x00, 0xB0, 0x09, 0x00, 0x90, 0x19, 0x81, 0x18, 0x10, 0x83,
  0x08, 0x3F, 0xC3, 0xFC, 0x20, 0x46, 0x06, 0x40, 0x64, 0x02, 0xC0, 0x2C,
  0x03, 0xFE, 0x21, 0xC8, 0x1A, 0x02, 0x80, 0xA0, 0x28, 0x1A, 0x0C, 0xFE,
  0x20, 0xC8, 0x1A, 0x02, 0x80, 0xE0, 0x38, 0x0A, 0x06, 0x83, 0x3F, 0x80,
  0x0F, 0xE3, 0x08, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x10, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x41,
  0xF8, 0xFC, 0x11, 0xE2, 0x06, 0x40, 0x68, 0x0D, 0x00, 0xA0, 0x14, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x28, 0x05, 0x01, 0xA0, 0x34, 0x0C, 0x87,
  0x1F, 0xC0, 0xFF, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xFF, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0xFE, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x07, 0xE1, 0xC3, 0x30, 0x02, 0x00, 0x60, 0x04, 0x00, 0x40,
  0x0C, 0x00, 0xC0, 0x0C, 0x1F, 0xC0, 0x14, 0x01, 0x40, 0x16, 0x01, 0x60,
  0x13, 0x01, 0x18, 0x10, 0xFF, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0xFF, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x10, 0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42,
  0x10, 0x84, 0x27, 0xC0, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x1F, 0xC0, 0x80, 0xA0, 0x68, 0x32, 0x08, 0x84, 0x23, 0x09,
  0x82, 0x40, 0xB0, 0x3E, 0x0C, 0xC2, 0x30, 0x86, 0x20, 0x88, 0x32, 0x04,
  0x81, 0xA0, 0x30, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFF, 0xC0, 0x0F, 0x80,
  0x3A, 0x00, 0xE8, 0x07, 0xB0, 0x16, 0x40, 0x59, 0x03, 0x64, 0x09, 0x98,
  0x26, 0x21, 0x98, 0x84, 0x63, 0x11, 0x84, 0xC6, 0x12, 0x18, 0x68, 0x60,
  0xE1, 0x83, 0x06, 0x0C, 0x10, 0xC0, 0x78, 0x0F, 0x81, 0xD0, 0x3B, 0x07,
  0x20, 0xE6, 0x1C, 0x43, 0x8C, 0x70, 0x8E, 0x19, 0xC1, 0x38, 0x37, 0x02,
  0xE0, 0x7C, 0x05, 0x80, 0xF0, 0x0C, 0x0F, 0x80, 0xC6, 0x0C, 0x08, 0xC0,
  0x64, 0x01, 0x20, 0x09, 0x00, 0x58, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06,
  0x80, 0x34, 0x01, 0x20, 0x09, 0x80, 0xC4, 0x04, 0x38, 0xE0, 0x7C, 0x00,
  0xFC, 0x47, 0xA0, 0x50, 0x38, 0x1C, 0x0E, 0x07, 0x02, 0x83, 0x7F, 0x3E,
  0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x00, 0x0F, 0x80, 0xC7,
  0x0C, 0x08, 0xC0, 0x64, 0x01, 0x20, 0x09, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x06, 0x80, 0x34, 0x01, 0x20, 0x09, 0x80, 0xC4, 0x04, 0x38,
  0xE0, 0x7C, 0x00, 0x60, 0x01, 0x80, 0x04, 0x00, 0x30, 0xFC, 0x23, 0xC8,
  0x12, 0x06, 0x81, 0xA0, 0x68, 0x1A, 0x04, 0x83, 0x3F, 0x88, 0xC2, 0x10,
  0x86, 0x20, 0x88, 0x32, 0x04, 0x81, 0xA0, 0x30, 0x3F, 0x38, 0xD0, 0x18,
  0x0C, 0x06, 0x01, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x30, 0x08, 0x04,
  0x06, 0x03, 0x83, 0x7F, 0x00, 0xFF, 0xC3, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x07, 0x03,
  0x61, 0x8F, 0xC0, 0xC0, 0x38, 0x05, 0x01, 0xA0, 0x36, 0x04, 0xC0, 0x88,
  0x31, 0x04, 0x30, 0x82, 0x30, 0x46, 0x08, 0x81, 0x90, 0x16, 0x02, 0x80,
  0x70, 0x0E, 0x00, 0xC0, 0xC0, 0x40, 0x50, 0x30, 0x14, 0x0E, 0x0D, 0x02,
  0x83, 0x60, 0xA0, 0x98, 0x68, 0x22, 0x12, 0x08, 0x84, 0xC6, 0x31, 0x11,
  0x8C, 0x44, 0x41, 0x31, 0x10, 0x48, 0x6C, 0x12, 0x0B, 0x06, 0x82, 0x80,
  0xE0, 0xA0, 0x30, 0x28, 0x0C, 0x0E, 0x03, 0x01, 0x00, 0x40, 0x58, 0x32,
  0x08, 0xC6, 0x11, 0x06, 0xC0, 0xA0, 0x38, 0x0C, 0x03, 0x80, 0xA0, 0x68,
  0x13, 0x0C, 0x42, 0x19, 0x82, 0x40, 0xF0, 0x10, 0xC0, 0x50, 0x34, 0x09,
  0x86, 0x21, 0x0C, 0x41, 0x30, 0x48, 0x1E, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xFF, 0x00, 0x80, 0xC0, 0x40,
  0x60, 0x30, 0x10, 0x18, 0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01,
  0x80, 0x80, 0x7F, 0xC0, 0xFC, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x7C, 0xC0, 0x40, 0x60, 0x20, 0x20, 0x30,
  0x10, 0x10, 0x08, 0x08, 0x0C, 0x04, 0x04, 0x06, 0x02, 0x02, 0x03, 0x01,
  0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6,
  0x31, 0xFC, 0x08, 0x03, 0x01, 0xC0, 0x48, 0x32, 0x08, 0x46, 0x11, 0x02,
  0xC0, 0xA0, 0x10, 0xFF, 0xC0, 0xC6, 0x21, 0x08, 0x7E, 0x03, 0x01, 0x01,
  0x01, 0x0F, 0x71, 0xC1, 0x81, 0x81, 0xC3, 0xC5, 0x7D, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x42, 0xF9, 0x86, 0xC1, 0xC0, 0xE0, 0x30, 0x18, 0x0C,
  0x06, 0x07, 0x83, 0xC1, 0x51, 0xAF, 0x80, 0x04, 0x3F, 0x60, 0x40, 0x40,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x40, 0x61, 0x3F, 0x00, 0x80, 0x40,
  0x20, 0x10, 0x08, 0x44, 0xFA, 0xC3, 0x41, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0x41, 0xB0, 0xCF, 0xA0, 0x08, 0x1F, 0x18, 0x48, 0x3C,
  0x1E, 0x07, 0xFF, 0x80, 0xC0, 0x60, 0x10, 0x08, 0x02, 0x08, 0xF8, 0x1E,
  0x20, 0xC1, 0x83, 0x06, 0x3F, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC0, 0x08, 0x1F, 0x58, 0x68, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x50, 0x28, 0x36, 0x39, 0xF4, 0x02, 0x01, 0x00, 0x80,
  0xD0, 0xCF, 0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0x88, 0xBE, 0xC3, 0xC1,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0xE0, 0x2A,
  0xAA, 0xAA, 0xA0, 0x18, 0x80, 0x00, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0xDC, 0x80, 0x80, 0x80, 0x80, 0x80, 0x81,
  0x82, 0x84, 0x8C, 0x98, 0x90, 0xB0, 0xF8, 0xC8, 0x8C, 0x84, 0x86, 0x82,
  0x83, 0xFF, 0xFF, 0xE0, 0x08, 0x32, 0xFB, 0xEC, 0x28, 0xF0, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x10, 0x08, 0xBE, 0xC3, 0xC1, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x08, 0x0F, 0xC6, 0x19, 0x02,
  0xC0, 0xB0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x24, 0x09, 0x06, 0x61, 0x0F,
  0x80, 0x08, 0x5F, 0x30, 0xD8, 0x38, 0x1C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0xF0, 0x78, 0x2A, 0x35, 0xF2, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x00,
  0x08, 0x1F, 0x58, 0x68, 0x3C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x28, 0x36, 0x39, 0xF4, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0A,
  0xFA, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x00, 0x10, 0xFF,
  0x04, 0x08, 0x18, 0x1C, 0x0E, 0x06, 0x04, 0x08, 0x18, 0x7F, 0x80, 0x20,
  0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x83, 0x07, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83, 0x83, 0xC5, 0x7D,
  0xC0, 0xA0, 0xD0, 0x4C, 0x26, 0x31, 0x18, 0x88, 0x64, 0x16, 0x0A, 0x05,
  0x03, 0x80, 0xC0, 0xC1, 0x86, 0x83, 0x0D, 0x0A, 0x13, 0x14, 0x26, 0x2C,
  0x44, 0x49, 0x89, 0x92, 0x12, 0x24, 0x34, 0x68, 0x28, 0x70, 0x70, 0xC0,
  0xC1, 0x81, 0x83, 0x00, 0x61, 0x90, 0x8C, 0xC2, 0x41, 0xE0, 0x60, 0x30,
  0x38, 0x12, 0x19, 0x08, 0x4C, 0x3C, 0x08, 0xC0, 0xA0, 0xD0, 0x6C, 0x22,
  0x11, 0x18, 0xC8, 0x24, 0x16, 0x0B, 0x07, 0x01, 0x80, 0xC0, 0x40, 0x20,
  0x30, 0x10, 0x18, 0x38, 0x00, 0xFE, 0x08, 0x30, 0x41, 0x82, 0x0C, 0x10,
  0x60, 0x83, 0x04, 0x0F, 0xE0, 0x06, 0x38, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x63, 0x87, 0x03, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xC0, 0xE0, 0x40, 0x81, 0x02, 0x04, 0x08,
  0x10, 0x30, 0x38, 0x71, 0x82, 0x04, 0x08, 0x10, 0x20, 0x40, 0x83, 0x1C,
  0x00, 0x78, 0x63, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 18, 6, 2, -18 },
  { 6, 5, 7, 9, 2, -18 },
  { 11, 11, 18, 13, 1, -18 },
  { 36, 9, 20, 11, 1, -19 },
  { 59, 15, 18, 17, 1, -18 },
  { 93, 12, 18, 13, 1, -18 },
  { 120, 1, 7, 5, 2, -18 },
  { 121, 5, 22, 7, 1, -18 },
  { 135, 5, 22, 7, 1, -18 },
  { 149, 8, 8, 11, 1, -19 },
  { 157, 10, 12, 12, 1, -15 },
  { 172, 3, 6, 5, 1, -3 },
  { 175, 5, 1, 7, 1, -7 },
  { 176, 2, 2, 5, 2, -2 },
  { 177, 8, 18, 9, 0, -18 },
  { 195, 9, 18, 11, 1, -18 },
  { 216, 5, 18, 11, 2, -18 },
  { 228, 9, 18, 11, 1, -18 },
  { 249, 9, 18, 11, 1, -18 },
  { 270, 11, 18, 11, 0, -18 },
  { 295, 9, 18, 11, 1, -18 },
  { 316, 9, 18, 11, 1, -18 },
  { 337, 9, 18, 11, 1, -18 },
  { 358, 9, 18, 11, 1, -18 },
  { 379, 9, 18, 11, 1, -18 },
  { 400, 2, 13, 5, 2, -13 },
  { 404, 3, 16, 5, 1, -13 },
  { 410, 10, 11, 12, 1, -14 },
  { 424, 10, 6, 12, 1, -12 },
  { 432, 10, 11, 12, 1, -14 },
  { 446, 8, 18, 8, 0, -18 },
  { 464, 15, 20, 18, 1, -18 },
  { 502, 12, 18, 12, 0, -18 },
  { 529, 10, 18, 13, 2, -18 },
  { 552, 11, 18, 12, 1, -18 },
  { 577, 11, 18, 14, 2, -18 },
  { 602, 8, 18, 11, 2, -18 },
  { 620, 8, 18, 10, 2, -18 },
  { 638, 12, 18, 15, 1, -18 },
  { 665, 10, 18, 14, 2, -18 },
  { 688, 5, 18, 7, 1, -18 },
  { 700, 4, 23, 5, -1, -18 },
  { 712, 10, 18, 12, 2, -18 },
  { 735, 8, 18, 10, 2, -18 },
  { 753, 14, 18, 19, 2, -18 },
  { 785, 11, 18, 15, 2, -18 },
  { 810, 13, 18, 15, 1, -18 },
  { 840, 9, 18, 12, 2, -18 },
  { 861, 13, 22, 15, 1, -18 },
  { 897, 10, 18, 12, 2, -18 },
  { 920, 9, 18, 11, 1, -18 },
  { 941, 10, 18, 10, 0, -18 },
  { 964, 10, 18, 14, 2, -18 },
  { 987, 11, 18, 11, 0, -18 },
  { 1012, 18, 18, 19, 0, -18 },
  { 1053, 10, 18, 11, 0, -18 },
  { 1076, 10, 18, 10, 0, -18 },
  { 1099, 9, 18, 10, 1, -18 },
  { 1120, 5, 22, 8, 2, -18 },
  { 1134, 8, 18, 9, 0, -18 },
  { 1152, 5, 22, 8, 1, -18 },
  { 1166, 10, 10, 12, 1, -18 },
  { 1179, 10, 1, 10, 0, 2 },
  { 1181, 4, 4, 6, 1, -19 },
  { 1183, 8, 14, 11, 1, -14 },
  { 1197, 9, 19, 12, 2, -19 },
  { 1219, 8, 14, 9, 1, -14 },
  { 1233, 9, 19, 12, 1, -19 },
  { 1255, 9, 14, 11, 1, -14 },
  { 1271, 7, 19, 6, 0, -19 },
  { 1288, 9, 20, 12, 1, -14 },
  { 1311, 8, 19, 12, 2, -19 },
  { 1330, 2, 18, 5, 2, -18 },
  { 1335, 5, 24, 5, -1, -18 },
  { 1350, 8, 19, 10, 2, -19 },
  { 1369, 1, 19, 5, 2, -19 },
  { 1372, 14, 14, 18, 2, -14 },
  { 1397, 8, 14, 12, 2, -14 },
  { 1411, 10, 14, 12, 1, -14 },
  { 1429, 9, 20, 12, 2, -14 },
  { 1452, 9, 20, 12, 1, -14 },
  { 1475, 6, 14, 8, 2, -14 },
  { 1486, 7, 14, 9, 1, -14 },
  { 1499, 6, 16, 7, 0, -16 },
  { 1511, 8, 13, 12, 2, -13 },
  { 1524, 9, 13, 9, 0, -13 },
  { 1539, 15, 13, 15, 0, -13 },
  { 1564, 9, 13, 10, 0, -13 },
  { 1579, 9, 19, 10, 0, -13 },
  { 1601, 7, 13, 8, 1, -13 },
  { 1613, 7, 22, 9, 1, -18 },
  { 1633, 1, 25, 11, 5, -19 },
  { 1637, 7, 22, 9, 1, -18 },
  { 1657, 10, 2, 12, 1, -10 },
};

const GFXfont NotoSans_Condensed_Light25pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light25pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light25pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _NOTOSANS_CONDENSED_LIGHT25PT7B_H_
