#ifndef _NOTOSANS_CONDENSED_LIGHT65PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT65PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 65pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light65pt7bBitmaps[] PROGMEM = {
  0x00, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x80, 0x00,
  0x00, 0x00, 0x77, 0xFF, 0xFF, 0xF9, 0x80, 0xF0, 0x3F, 0xC0, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xDC, 0x07, 0x70, 0x1D, 0xC0,
  0x77, 0x01, 0xDC, 0x07, 0x70, 0x1D, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x00,
  0x1C, 0x01, 0xC0, 0x00, 0x70, 0x06, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x80,
  0x38, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x00, 0x00, 0xE0, 0x1C,
  0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x38, 0x07, 0x00,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x00,
  0x70, 0x0E, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x18,
  0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x38, 0x07, 0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70,
  0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x03,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFE, 0x01,
  0xC0, 0x38, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00, 0xE0,
  0x0E, 0x00, 0x03, 0x80, 0x38, 0x00, 0x0E, 0x00, 0xC0, 0x00, 0x38, 0x07,
  0x00, 0x00, 0xE0, 0x1C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0C, 0x01, 0xC0,
  0x00, 0x70, 0x07, 0x00, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x00, 0x60, 0x00,
  0x1C, 0x03, 0x80, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x1F, 0xB9, 0xFC, 0x3E, 0x38, 0x18, 0x78, 0x38, 0x00, 0x70, 0x38,
  0x00, 0xF0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38,
  0x00, 0xE0, 0x38, 0x00, 0xE0, 0x38, 0x00, 0xF0, 0x38, 0x00, 0xF0, 0x38,
  0x00, 0x78, 0x38, 0x00, 0x7C, 0x38, 0x00, 0x3E, 0x38, 0x00, 0x1F, 0xB8,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x39, 0xF8, 0x00, 0x38, 0xFC, 0x00, 0x38,
  0x3C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x0F, 0x00, 0x38,
  0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38, 0x0F, 0x00, 0x38,
  0x0E, 0x00, 0x38, 0x0E, 0x00, 0x38, 0x1E, 0x80, 0x38, 0x3C, 0xF0, 0x38,
  0xF8, 0xFF, 0xBF, 0xF0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x01, 0xF8,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0x80, 0x0E, 0x0E, 0x00,
  0x0E, 0x00, 0x38, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x07,
  0x01, 0xC0, 0x0F, 0x00, 0x1C, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x03, 0x80, 0x38, 0x07, 0x00, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x03, 0x80, 0xF0, 0x00, 0xE0, 0x0E, 0x03, 0x80, 0x03, 0x80, 0x38, 0x0E,
  0x00, 0x0E, 0x00, 0xE0, 0x70, 0x00, 0x38, 0x03, 0x81, 0xC0, 0x00, 0xE0,
  0x0E, 0x0E, 0x00, 0x03, 0x80, 0x38, 0x38, 0x00, 0x0E, 0x00, 0xE0, 0xE0,
  0x20, 0x38, 0x03, 0x87, 0x07, 0xF0, 0xE0, 0x0E, 0x1C, 0x3F, 0xE1, 0xC0,
  0x78, 0xE1, 0xE3, 0xC7, 0x01, 0xC3, 0x8F, 0x07, 0x1C, 0x07, 0x0E, 0x38,
  0x1E, 0x38, 0x3C, 0x70, 0xE0, 0x38, 0xF0, 0xE1, 0xC7, 0x80, 0xE1, 0xFF,
  0x8E, 0x1C, 0x03, 0x87, 0xFC, 0x38, 0x70, 0x07, 0x07, 0xC1, 0xE1, 0xC0,
  0x1C, 0x00, 0x07, 0x07, 0x00, 0x70, 0x00, 0x1C, 0x1C, 0x01, 0xC0, 0x00,
  0xE0, 0x70, 0x07, 0x00, 0x03, 0x81, 0xC0, 0x1C, 0x00, 0x1E, 0x07, 0x00,
  0x70, 0x00, 0x70, 0x1C, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x07, 0x00, 0x0E,
  0x01, 0xC0, 0x1C, 0x00, 0x38, 0x07, 0x00, 0x70, 0x01, 0xE0, 0x1C, 0x01,
  0xC0, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x1C, 0x01, 0xC0, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x07, 0x80, 0x1E, 0x00, 0x1C, 0x1C,
  0x00, 0x70, 0x00, 0x78, 0xF0, 0x01, 0xC0, 0x00, 0xFF, 0x80, 0x0E, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0x80, 0x3C,
  0x00, 0x1E, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0x00,
  0x07, 0x80, 0x3C, 0x00, 0x0E, 0x00, 0xE0, 0x00, 0x38, 0x03, 0x80, 0x00,
  0xF0, 0x1E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x07, 0x83, 0xC0, 0x00, 0x1E,
  0x1E, 0x00, 0x00, 0x3C, 0xF8, 0x00, 0x00, 0x77, 0xC0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xBC, 0x00, 0x00, 0x7C, 0x78, 0x00, 0x03, 0xE1, 0xE0, 0x07,
  0x8F, 0x03, 0xC0, 0x1C, 0x78, 0x07, 0x80, 0x71, 0xC0, 0x0F, 0x03, 0xCF,
  0x00, 0x3C, 0x0F, 0x3C, 0x00, 0x78, 0x38, 0xE0, 0x00, 0xF0, 0xE3, 0x80,
  0x03, 0xC7, 0x8E, 0x00, 0x07, 0x9C, 0x38, 0x00, 0x0F, 0xF0, 0xE0, 0x00,
  0x1F, 0xC3, 0x80, 0x00, 0x7E, 0x0E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07,
  0xE0, 0xF0, 0x00, 0x1F, 0xC1, 0xE0, 0x00, 0xFF, 0x07, 0xC0, 0x0F, 0x9E,
  0x0F, 0x80, 0x7C, 0x3C, 0x1F, 0xFF, 0xE0, 0xF0, 0x3F, 0xFF, 0x01, 0xE0,
  0x7F, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF7, 0x77,
  0x77, 0x77, 0x77, 0x00, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1C, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x08, 0x07, 0x00, 0xBC, 0x1C, 0x1E, 0xFE, 0x33, 0xFB, 0xFF, 0xFF,
  0xF0, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x3C, 0x0E, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0x78, 0x0C, 0x01, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x1F, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x79, 0xEF, 0xFF, 0xFD, 0xE2, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x07, 0xC3,
  0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x1C, 0x78, 0x00, 0x1C, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x3C, 0x03, 0xF0, 0x1F, 0xC0, 0xFF, 0x07, 0xFC, 0x3E, 0xF1,
  0xF3, 0xCF, 0x0F, 0xF8, 0x3D, 0xC0, 0xF6, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x01, 0xFE,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0x07, 0x80, 0x1F,
  0x06, 0x00, 0x1F, 0x08, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xF8,
  0x3F, 0x8F, 0x80, 0x0F, 0x8C, 0x00, 0x0F, 0x10, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x7C, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xFA, 0x00, 0x03, 0xE7, 0x80, 0x0F, 0x8F, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xF4, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x3B, 0xC0,
  0x00, 0x03, 0xBC, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x07, 0x3C, 0x00, 0x00,
  0xE3, 0xC0, 0x00, 0x1E, 0x3C, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x3C,
  0x00, 0x03, 0x83, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00,
  0xF0, 0x3C, 0x00, 0x0E, 0x03, 0xC0, 0x01, 0xC0, 0x3C, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0x80, 0x3C, 0x00, 0x78, 0x03, 0xC0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x3C, 0x01, 0xE0, 0x03, 0xC0, 0x1C, 0x00,
  0x3C, 0x03, 0xC0, 0x03, 0xC0, 0x38, 0x00, 0x3C, 0x07, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3C, 0x00, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xC3, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xDF, 0xF8, 0x07,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x0F, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF1, 0x00, 0x03, 0xE3, 0x80, 0x1F, 0x87, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x18, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x70, 0x3F, 0x00, 0x70, 0xFF, 0xC0, 0x71, 0xFF, 0xF0,
  0xF3, 0xE3, 0xF8, 0xF7, 0x00, 0x78, 0xFE, 0x00, 0x3C, 0xFC, 0x00, 0x1C,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0E, 0x38, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x07, 0xF7, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x07, 0x80, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0,
  0x1F, 0x81, 0xF8, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E,
  0x70, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1C,
  0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x0F, 0x01, 0xF0,
  0x07, 0xC3, 0xE0, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x0F, 0x83, 0xE0, 0x1F, 0x01, 0xF0,
  0x3E, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3E, 0x70, 0x00, 0x1E,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7C, 0x00, 0x3C,
  0x3E, 0x00, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0,
  0x00, 0x38, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0xFC, 0x3F, 0x01, 0xE0, 0x1F, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x1E, 0x3C,
  0x00, 0x1C, 0x70, 0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xEE, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0xBC, 0x00, 0x3F,
  0x3C, 0x00, 0xEE, 0x7C, 0x03, 0x9C, 0x7F, 0xFF, 0x38, 0x7F, 0xFC, 0x70,
  0x3F, 0xE1, 0xE0, 0x0C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x03, 0xFF, 0xF0,
  0x07, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x79, 0xEF, 0xFF,
  0xFD, 0xE1, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE7, 0xBF, 0xFF, 0xF7, 0x8C,
  0x0E, 0x1F, 0x1F, 0x3F, 0x1F, 0x1E, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x1F, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C,
  0x3C, 0x38, 0x38, 0x78, 0x70, 0x70, 0xF0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x80, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFC, 0x3E, 0x1F, 0xC6, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x03,
  0x80, 0x00, 0x00, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x70, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x0E, 0x00, 0x00, 0x00, 0x38, 0x1E, 0x00, 0x00, 0x00, 0x3C,
  0x1C, 0x00, 0x07, 0x00, 0x1C, 0x1C, 0x00, 0x7F, 0xF0, 0x1C, 0x3C, 0x00,
  0xFF, 0xF0, 0x1E, 0x38, 0x01, 0xE0, 0x70, 0x0E, 0x38, 0x03, 0xC0, 0x70,
  0x0E, 0x78, 0x07, 0x80, 0x70, 0x0E, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x70,
  0x0F, 0x00, 0x70, 0x0E, 0x70, 0x0E, 0x00, 0x70, 0x0F, 0x70, 0x0E, 0x00,
  0xF0, 0x0F, 0x70, 0x1E, 0x00, 0xF0, 0x0F, 0xF0, 0x1C, 0x00, 0xF0, 0x0F,
  0xF0, 0x1C, 0x00, 0xF0, 0x0F, 0xF0, 0x1C, 0x00, 0xF0, 0x0F, 0xF0, 0x1C,
  0x00, 0xE0, 0x0F, 0xF0, 0x1C, 0x00, 0xE0, 0x0E, 0xF0, 0x1C, 0x00, 0xE0,
  0x0E, 0xF0, 0x1C, 0x00, 0xE0, 0x0E, 0xF0, 0x1C, 0x00, 0xE0, 0x0E, 0x70,
  0x1E, 0x01, 0xE0, 0x0E, 0x70, 0x0E, 0x01, 0xF0, 0x1C, 0x70, 0x0E, 0x01,
  0xB0, 0x1C, 0x70, 0x0F, 0x03, 0x30, 0x38, 0x70, 0x07, 0x87, 0x38, 0x78,
  0x78, 0x03, 0xFE, 0x1F, 0xF0, 0x38, 0x01, 0xFC, 0x1F, 0xE0, 0x38, 0x00,
  0x78, 0x03, 0x80, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x18, 0x00,
  0x00, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xEE, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x07, 0xB8, 0x00, 0x00,
  0x0E, 0x78, 0x00, 0x00, 0x1C, 0x70, 0x00, 0x00, 0x78, 0xE0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x03, 0x83, 0x80, 0x00, 0x0F,
  0x07, 0x00, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0x38, 0x0E, 0x00, 0x00, 0xF0,
  0x1C, 0x00, 0x01, 0xE0, 0x3C, 0x00, 0x03, 0x80, 0x78, 0x00, 0x07, 0x00,
  0x70, 0x00, 0x1E, 0x00, 0xE0, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x70, 0x03,
  0xC0, 0x01, 0xE0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x70, 0x07, 0x80, 0x00, 0xF0,
  0x0F, 0x00, 0x01, 0xE0, 0x1C, 0x00, 0x03, 0xC0, 0x78, 0x00, 0x03, 0x80,
  0xF0, 0x00, 0x07, 0x81, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x1E, 0x1E, 0x00, 0x00, 0x3C, 0x38, 0x00, 0x00, 0x78, 0xF0,
  0x00, 0x00, 0x71, 0xE0, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x1E, 0x00, 0x1F, 0x8F, 0x00, 0x03, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xF7,
  0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1C, 0xF0, 0x00, 0x1E,
  0x78, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xE0, 0x07, 0xF0, 0xF0, 0x00,
  0x7C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0x78, 0x00, 0x3F, 0x3C, 0x00, 0x7F, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x3E, 0x03, 0xF0, 0x01, 0x81,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x06, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0x40, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x7E,
  0x0F, 0x00, 0x03, 0xE0, 0xF0, 0x00, 0x1F, 0x0F, 0x00, 0x00, 0xF8, 0xF0,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x01, 0xEF, 0x00, 0x00, 0x1E, 0xF0,
  0x00, 0x01, 0xEF, 0x00, 0x00, 0x3C, 0xF0, 0x00, 0x03, 0xCF, 0x00, 0x00,
  0x3C, 0xF0, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x78, 0xF0, 0x00, 0x0F, 0x0F,
  0x00, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0xC0, 0xF0, 0x0F,
  0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x80, 0x7F, 0xC0, 0xFF, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0x80, 0x00,
  0x20, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x00, 0x38, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x80, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77, 0x80, 0x00,
  0x01, 0xDE, 0x00, 0x00, 0x07, 0x3C, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x71, 0xE0, 0x00, 0x01, 0xC7, 0xC0, 0x00, 0x07, 0x0F, 0x00, 0x00, 0x1C,
  0x3F, 0x00, 0x00, 0x70, 0x7E, 0x00, 0x01, 0xC0, 0xFE, 0x00, 0x1F, 0x01,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x07, 0xFC, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x0F, 0x00, 0xFB, 0x9F, 0x9F, 0xFC, 0xFF, 0xC3, 0xF8, 0x00, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x07, 0x8F, 0x00,
  0x07, 0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0,
  0x03, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x0F, 0x3E, 0x00, 0x07, 0x9F, 0x80, 0x03, 0xDF, 0xC0, 0x01, 0xFE, 0xF0,
  0x00, 0xFE, 0x78, 0x00, 0x7E, 0x1E, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1,
  0xE0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07,
  0x9E, 0x00, 0x01, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFD, 0xC0, 0x00, 0x00, 0xEF, 0xF7, 0x80, 0x00, 0x03, 0xBF,
  0xDE, 0x00, 0x00, 0x1E, 0xFF, 0x38, 0x00, 0x00, 0x73, 0xFC, 0xF0, 0x00,
  0x01, 0xCF, 0xF3, 0xC0, 0x00, 0x0F, 0x3F, 0xC7, 0x00, 0x00, 0x38, 0xFF,
  0x1E, 0x00, 0x00, 0xE3, 0xFC, 0x78, 0x00, 0x07, 0x8F, 0xF0, 0xE0, 0x00,
  0x1C, 0x3F, 0xC3, 0x80, 0x00, 0x70, 0xFF, 0x0F, 0x00, 0x03, 0xC3, 0xFC,
  0x1C, 0x00, 0x0E, 0x0F, 0xF0, 0x70, 0x00, 0x38, 0x3F, 0xC1, 0xE0, 0x01,
  0xE0, 0xFF, 0x03, 0x80, 0x07, 0x03, 0xFC, 0x0E, 0x00, 0x1C, 0x0F, 0xF0,
  0x3C, 0x00, 0xF0, 0x3F, 0xC0, 0x70, 0x03, 0x80, 0xFF, 0x01, 0xC0, 0x0E,
  0x03, 0xFC, 0x07, 0x80, 0x78, 0x0F, 0xF0, 0x0E, 0x01, 0xC0, 0x3F, 0xC0,
  0x38, 0x07, 0x00, 0xFF, 0x00, 0xF0, 0x3C, 0x03, 0xFC, 0x01, 0xC0, 0xE0,
  0x0F, 0xF0, 0x07, 0x03, 0x80, 0x3F, 0xC0, 0x1E, 0x1E, 0x00, 0xFF, 0x00,
  0x38, 0x70, 0x03, 0xFC, 0x00, 0xE1, 0xC0, 0x0F, 0xF0, 0x03, 0xCF, 0x00,
  0x3F, 0xC0, 0x0F, 0x3C, 0x00, 0xFF, 0x00, 0x1C, 0xE0, 0x03, 0xFC, 0x00,
  0x7B, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x00,
  0x78, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x07,
  0xF7, 0x80, 0x00, 0x7F, 0x3C, 0x00, 0x07, 0xF3, 0xC0, 0x00, 0x7F, 0x1E,
  0x00, 0x07, 0xF1, 0xE0, 0x00, 0x7F, 0x0F, 0x00, 0x07, 0xF0, 0xF0, 0x00,
  0x7F, 0x07, 0x80, 0x07, 0xF0, 0x78, 0x00, 0x7F, 0x03, 0xC0, 0x07, 0xF0,
  0x3C, 0x00, 0x7F, 0x01, 0xE0, 0x07, 0xF0, 0x1E, 0x00, 0x7F, 0x00, 0xF0,
  0x07, 0xF0, 0x0F, 0x00, 0x7F, 0x00, 0x78, 0x07, 0xF0, 0x07, 0x80, 0x7F,
  0x00, 0x3C, 0x07, 0xF0, 0x03, 0xC0, 0x7F, 0x00, 0x1E, 0x07, 0xF0, 0x01,
  0xE0, 0x7F, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0xF0, 0x7F, 0x00, 0x07, 0x87,
  0xF0, 0x00, 0x78, 0x7F, 0x00, 0x03, 0xC7, 0xF0, 0x00, 0x3C, 0x7F, 0x00,
  0x01, 0xE7, 0xF0, 0x00, 0x1E, 0x7F, 0x00, 0x00, 0xF7, 0xF0, 0x00, 0x0F,
  0x7F, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x03,
  0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x00,
  0x78, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00,
  0x1E, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00,
  0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00,
  0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x01,
  0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x80,
  0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0x80, 0x1F,
  0x8F, 0x00, 0x0F, 0x9E, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x00,
  0x07, 0xDE, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0x78, 0x07, 0xF0, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00,
  0x00, 0x78, 0x3C, 0x00, 0x00, 0x78, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x70, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0E, 0xE0, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x00, 0x1E, 0xF0, 0x00,
  0x00, 0x1E, 0x70, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x3C, 0x78, 0x00,
  0x00, 0x3C, 0x78, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00, 0x78, 0x3C, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x0F, 0x00,
  0x01, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x1E, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x03,
  0xE3, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x38, 0xF0, 0x00, 0x1E, 0x78, 0x00,
  0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x1E, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x0F, 0x8F, 0x00, 0x07, 0x87,
  0x80, 0x0F, 0x83, 0xC0, 0x3F, 0x81, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x3C, 0x03, 0x80, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x3C, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x01,
  0xC0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x07, 0x80, 0x03, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x00, 0x78, 0xF0,
  0x00, 0x3C, 0x78, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xEF,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0xFF, 0x0F, 0xE3, 0xF0, 0x01, 0x87, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xFA, 0x00, 0x03, 0xE7, 0x80, 0x1F,
  0x8F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00, 0xF4, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0xF3,
  0xE0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0x87, 0xC0, 0x01, 0xE0, 0x7E, 0x00,
  0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x07, 0x9E, 0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x70, 0xE0, 0x00,
  0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x0F, 0x00, 0x00, 0x3C, 0x3C, 0x00, 0x00,
  0xE0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x70,
  0x0E, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x3C, 0x03,
  0xC0, 0x00, 0xE0, 0x07, 0x00, 0x07, 0x80, 0x1E, 0x00, 0x1E, 0x00, 0x78,
  0x00, 0x70, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x70, 0x07, 0x80, 0x01, 0xC0, 0x1E,
  0x00, 0x07, 0x80, 0x78, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x38, 0x0F, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x0F, 0x03, 0x80, 0x00,
  0x1C, 0x1E, 0x00, 0x00, 0x78, 0x78, 0x00, 0x01, 0xE1, 0xC0, 0x00, 0x03,
  0x8F, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xF3,
  0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x73, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xE7, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xF8, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xF8, 0x00,
  0x0E, 0x3C, 0x00, 0x07, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1E, 0xE0, 0x00,
  0x78, 0x78, 0x00, 0x3D, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x73, 0x80, 0x01,
  0xE1, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC7, 0x00, 0x0F,
  0x03, 0x80, 0x07, 0x8E, 0x00, 0x1E, 0x07, 0x80, 0x0E, 0x1C, 0x00, 0x3C,
  0x0F, 0x00, 0x1C, 0x3C, 0x00, 0x70, 0x1E, 0x00, 0x38, 0x78, 0x01, 0xE0,
  0x1C, 0x00, 0xF0, 0x70, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0xE0, 0x07, 0x80,
  0x78, 0x03, 0x81, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x03, 0xC0, 0x1C, 0x00,
  0xE0, 0x0E, 0x03, 0x80, 0x78, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xF0, 0x03,
  0xC0, 0x70, 0x0E, 0x01, 0xE0, 0x07, 0x80, 0xE0, 0x1E, 0x03, 0x80, 0x07,
  0x01, 0xC0, 0x1C, 0x0F, 0x00, 0x0E, 0x07, 0x80, 0x38, 0x1E, 0x00, 0x1E,
  0x0F, 0x00, 0x70, 0x3C, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x00, 0x78,
  0x38, 0x01, 0xE1, 0xE0, 0x00, 0x70, 0x70, 0x01, 0xC3, 0xC0, 0x00, 0xF1,
  0xE0, 0x03, 0x87, 0x80, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x03, 0xC7,
  0x00, 0x0F, 0x1C, 0x00, 0x03, 0x8E, 0x00, 0x0E, 0x78, 0x00, 0x07, 0x3C,
  0x00, 0x1C, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x39, 0xE0, 0x00, 0x1E, 0xE0,
  0x00, 0x73, 0x80, 0x00, 0x3D, 0xC0, 0x00, 0xF7, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x77, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xC3, 0x80, 0x00, 0x78, 0x78, 0x00,
  0x1E, 0x07, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0x78, 0x07,
  0x80, 0x07, 0x00, 0xE0, 0x00, 0xF0, 0x3C, 0x00, 0x0E, 0x07, 0x00, 0x01,
  0xE1, 0xE0, 0x00, 0x1C, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x07, 0x1E, 0x00, 0x01, 0xE1, 0xE0, 0x00, 0x38, 0x3C, 0x00,
  0x0F, 0x03, 0x80, 0x01, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x00, 0x0F, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x1E, 0x00, 0x3C, 0x03,
  0xC0, 0x03, 0xC0, 0xF0, 0x00, 0x78, 0x1E, 0x00, 0x07, 0x03, 0x80, 0x00,
  0xF0, 0xF0, 0x00, 0x1E, 0x1C, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3D, 0xE0,
  0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0E, 0x1C, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x07,
  0x80, 0x03, 0xC0, 0xF0, 0x00, 0x70, 0x0E, 0x00, 0x1E, 0x01, 0xE0, 0x03,
  0xC0, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x07,
  0x00, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x01, 0xC0, 0xF0,
  0x00, 0x3C, 0x1C, 0x00, 0x03, 0x87, 0x80, 0x00, 0x78, 0xF0, 0x00, 0x0F,
  0x1C, 0x00, 0x00, 0xE7, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x0E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x1C, 0xF0, 0x00, 0x07,
  0x0E, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x38, 0x1C, 0x00, 0x07, 0x03, 0xC0,
  0x01, 0xE0, 0x38, 0x00, 0x38, 0x07, 0x80, 0x0F, 0x00, 0x70, 0x01, 0xC0,
  0x0F, 0x00, 0x78, 0x00, 0xE0, 0x0E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xC0,
  0x70, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x83, 0x80, 0x00, 0x78, 0xF0, 0x00,
  0x07, 0x1C, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0xE0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0,
  0x1F, 0x01, 0xE0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x38, 0x03, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0xF0, 0x3C,
  0x07, 0xC1, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0x07, 0xFF, 0xF8,
  0x7F, 0xF3, 0xCF, 0xC0, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0E,
  0xEF, 0x00, 0xE7, 0x7F, 0x1E, 0x39, 0xFF, 0xE1, 0xC3, 0xFE, 0x0E, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x7F, 0x80, 0xE1,
  0xFF, 0xC0, 0xE3, 0xFF, 0xE0, 0xE7, 0x81, 0xF0, 0xEE, 0x00, 0xF8, 0xEC,
  0x00, 0x7C, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0x1C, 0xF0, 0x00, 0x1E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x3C, 0xFC,
  0x00, 0x3C, 0xEE, 0x00, 0x78, 0xE7, 0x00, 0xF0, 0xE7, 0xEF, 0xF0, 0xE3,
  0xFF, 0xE0, 0xE0, 0xFF, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xC0, 0x1F,
  0xFF, 0x07, 0xFF, 0xE0, 0xFC, 0x06, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x02, 0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0,
  0x03, 0xC0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x00, 0xFE, 0x07, 0x03,
  0xFF, 0x87, 0x07, 0xFF, 0xC7, 0x0F, 0x81, 0xE7, 0x1F, 0x00, 0x77, 0x3E,
  0x00, 0x37, 0x3C, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x78,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F, 0x3C,
  0x00, 0x37, 0x1E, 0x00, 0x77, 0x1F, 0x00, 0xE7, 0x0F, 0xFF, 0xE7, 0x07,
  0xFF, 0xC7, 0x03, 0xFF, 0x07, 0x00, 0x38, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7C, 0x0F, 0x81, 0xF0, 0x0F, 0x03, 0xC0,
  0x0F, 0x0F, 0x00, 0x0E, 0x1C, 0x00, 0x1E, 0x78, 0x00, 0x1C, 0xF0, 0x00,
  0x39, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xF7, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x01, 0x07, 0xC0, 0x0E, 0x07, 0xFB, 0xFC, 0x07, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F,
  0xCE, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x3F, 0xF0, 0xFF, 0xFC, 0x3F, 0xFF, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xFF, 0x07,
  0x03, 0xFF, 0x87, 0x07, 0xFF, 0xC7, 0x0F, 0x81, 0xE7, 0x1F, 0x00, 0x77,
  0x3E, 0x00, 0x37, 0x3C, 0x00, 0x1F, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x3C, 0x00, 0x37, 0x1E, 0x00, 0x77, 0x1F, 0x00, 0xE7, 0x0F, 0xFF, 0xCF,
  0x07, 0xFF, 0x8F, 0x03, 0xFF, 0x0F, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x20, 0x00, 0x7C, 0x38, 0x00, 0xF8, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x07, 0xF0, 0x38,
  0x7F, 0xF0, 0xE3, 0xFF, 0xE3, 0x9E, 0x0F, 0xCE, 0xE0, 0x0F, 0x3B, 0x00,
  0x1E, 0xF8, 0x00, 0x7B, 0xE0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x23, 0xFF, 0xFF,
  0xBC, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x39, 0xCE, 0x01, 0x00, 0xF0, 0x7C, 0x1F, 0x07, 0xC0, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x78, 0x1E, 0xFF, 0x3F, 0xCF, 0xE1, 0xC0, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x03, 0xDC, 0x00, 0x3C, 0xE0, 0x01, 0xC7, 0x00, 0x1E, 0x38, 0x01,
  0xE1, 0xC0, 0x1E, 0x0E, 0x00, 0xF0, 0x70, 0x0F, 0x03, 0x80, 0xF0, 0x1C,
  0x07, 0x00, 0xE0, 0x78, 0x07, 0x07, 0x80, 0x38, 0x38, 0x01, 0xC3, 0xC0,
  0x0E, 0x3C, 0x00, 0x73, 0xF0, 0x03, 0x9F, 0x80, 0x1D, 0xDE, 0x00, 0xFC,
  0x70, 0x07, 0xE3, 0xC0, 0x3E, 0x0E, 0x01, 0xE0, 0x78, 0x0E, 0x01, 0xC0,
  0x70, 0x0F, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xE0, 0xE0, 0x07, 0x07, 0x00,
  0x3C, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x8E, 0x00, 0x1E, 0x70, 0x00, 0xF3,
  0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0x1F, 0xFC, 0x0F, 0xFE,
  0x39, 0xFF, 0xF0, 0xFF, 0xF9, 0xCE, 0x07, 0x8F, 0x07, 0xEE, 0xE0, 0x1E,
  0x60, 0x0F, 0x7E, 0x00, 0xF6, 0x00, 0x7B, 0xE0, 0x03, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0x00, 0x0F, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xC0,
  0x03, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0, 0x00,
  0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00, 0x03,
  0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01, 0xC0,
  0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0x00,
  0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0F, 0xC0, 0x00, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0x00, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x1F, 0x80, 0x01,
  0xC0, 0x00, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x00, 0x70, 0x00, 0x3F,
  0x00, 0x03, 0x80, 0x01, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0xE0, 0x7F, 0x83,
  0x87, 0xFF, 0x0E, 0x3F, 0xFE, 0x39, 0xE0, 0x7C, 0xEE, 0x00, 0xF3, 0xB0,
  0x01, 0xEF, 0x80, 0x07, 0xBE, 0x00, 0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x07, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0x78, 0x70, 0x00, 0x3C, 0x78,
  0x00, 0x0E, 0x3C, 0x00, 0x07, 0x9C, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x77, 0x80, 0x00, 0x3B, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1C, 0xE0, 0x00,
  0x0E, 0x70, 0x00, 0x0F, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x03, 0xC7, 0x00,
  0x01, 0xC3, 0xC0, 0x01, 0xE1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0, 0x1F,
  0x01, 0xF0, 0x07, 0xF7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x7F, 0x80, 0xE1, 0xFF, 0xC0, 0xE3, 0xFF, 0xE0,
  0xE7, 0x81, 0xF0, 0xEE, 0x00, 0x78, 0xEC, 0x00, 0x7C, 0xFC, 0x00, 0x3C,
  0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0E,
  0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x1C, 0xF8, 0x00, 0x3C, 0xEC, 0x00, 0x3C, 0xEE, 0x00, 0x78,
  0xE7, 0x00, 0xF0, 0xE7, 0xFF, 0xF0, 0xE3, 0xFF, 0xE0, 0xE0, 0xFF, 0x80,
  0xE0, 0x3C, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x07,
  0x03, 0xFF, 0x87, 0x07, 0xFF, 0xC7, 0x0F, 0x81, 0xE7, 0x1F, 0x00, 0x77,
  0x1E, 0x00, 0x37, 0x3C, 0x00, 0x3F, 0x38, 0x00, 0x1F, 0x78, 0x00, 0x1F,
  0x78, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0F,
  0x70, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0x3C, 0x00, 0x1F,
  0x3C, 0x00, 0x37, 0x1E, 0x00, 0x77, 0x1F, 0x00, 0xE7, 0x0F, 0xFF, 0xC7,
  0x07, 0xFF, 0x8F, 0x03, 0xFF, 0x0F, 0x00, 0x30, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0xE0, 0xFF, 0xC3, 0xFF, 0x8F, 0xF7, 0x3E, 0x2E, 0x70,
  0x1D, 0xC0, 0x3B, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00, 0x03, 0xFF, 0x00,
  0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xE0, 0x1C, 0x3C, 0x00, 0x47, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x80, 0x01, 0xEF, 0x00, 0x7C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x3F, 0xFE,
  0x00, 0x3F, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xEE, 0x07, 0xFC, 0x07, 0xF8,
  0x03, 0x80, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7D, 0xE0, 0x06, 0xEF,
  0x80, 0xF7, 0x3F, 0xFF, 0x38, 0xFF, 0xF1, 0xC3, 0xFF, 0x06, 0x01, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x1C, 0x3C, 0x00,
  0x3C, 0x1C, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x38, 0x1E, 0x00,
  0x78, 0x0E, 0x00, 0x78, 0x0E, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x07, 0x00,
  0xF0, 0x07, 0x00, 0xE0, 0x07, 0x80, 0xE0, 0x07, 0x81, 0xE0, 0x03, 0x81,
  0xE0, 0x03, 0x81, 0xC0, 0x03, 0xC1, 0xC0, 0x03, 0xC3, 0xC0, 0x01, 0xC3,
  0x80, 0x01, 0xC3, 0x80, 0x01, 0xE7, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xE7,
  0x00, 0x00, 0xE7, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x80, 0x03,
  0xFC, 0x00, 0x3F, 0x00, 0x0E, 0x70, 0x00, 0xFC, 0x00, 0x39, 0xC0, 0x03,
  0xF0, 0x01, 0xE7, 0x80, 0x0F, 0xC0, 0x07, 0x9E, 0x00, 0x73, 0x80, 0x1C,
  0x38, 0x01, 0xCE, 0x00, 0x70, 0xE0, 0x07, 0x38, 0x03, 0xC3, 0xC0, 0x1C,
  0xE0, 0x0F, 0x0F, 0x00, 0xF3, 0xC0, 0x38, 0x1C, 0x03, 0x87, 0x00, 0xE0,
  0x70, 0x0E, 0x1C, 0x03, 0x81, 0xE0, 0x38, 0x70, 0x1E, 0x07, 0x81, 0xE1,
  0xE0, 0x78, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x0E, 0x07, 0x00,
  0xF0, 0x70, 0x38, 0x3C, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x0F, 0x0E, 0x01,
  0xC3, 0x80, 0x1C, 0x38, 0x07, 0x0E, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x01,
  0xE7, 0x80, 0x79, 0xE0, 0x07, 0x9C, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x03,
  0x9C, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x3B, 0xC0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC1, 0xE0, 0x07, 0x83,
  0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0xF0, 0x07, 0x81, 0xE0, 0x07,
  0x07, 0x80, 0x0F, 0x0F, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x70, 0x00, 0x1D,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xE0,
  0x00, 0x79, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0x83, 0xC0, 0x0F, 0x03, 0x80,
  0x1C, 0x07, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0F, 0x03, 0xC0, 0x0E, 0x07,
  0x00, 0x1E, 0x1E, 0x00, 0x1C, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x78, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0x80,
  0x00, 0xF7, 0x00, 0x01, 0xCF, 0x00, 0x07, 0x9E, 0x00, 0x0F, 0x1C, 0x00,
  0x1C, 0x3C, 0x00, 0x38, 0x78, 0x00, 0xF0, 0x70, 0x01, 0xE0, 0xE0, 0x03,
  0x81, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0x80, 0x38, 0x07, 0x80, 0x70,
  0x0F, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x1C, 0x07, 0x00, 0x3C, 0x1E, 0x00,
  0x38, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xE0, 0x01, 0xE3, 0xC0, 0x01,
  0xC7, 0x00, 0x03, 0x8E, 0x00, 0x07, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x0E,
  0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x3F, 0xC0, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x4F, 0xFE, 0x00, 0x37, 0xFF, 0xF0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xA0, 0x00, 0x7F, 0x80,
};

const GFXglyph NotoSans_Condensed_Light65pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 5, 47, 15, 5, -46 },
  { 31, 14, 16, 22, 4, -46 },
  { 59, 30, 46, 33, 1, -46 },
  { 232, 24, 53, 30, 3, -49 },
  { 391, 38, 48, 44, 3, -47 },
  { 619, 30, 48, 34, 3, -47 },
  { 799, 4, 16, 12, 4, -46 },
  { 807, 13, 57, 18, 3, -47 },
  { 900, 13, 57, 18, 2, -47 },
  { 993, 22, 21, 28, 3, -49 },
  { 1051, 26, 30, 30, 2, -38 },
  { 1149, 8, 15, 14, 2, -7 },
  { 1164, 15, 3, 19, 2, -19 },
  { 1170, 6, 7, 14, 4, -6 },
  { 1176, 21, 46, 23, 1, -46 },
  { 1297, 24, 48, 30, 3, -47 },
  { 1441, 14, 46, 30, 5, -46 },
  { 1522, 23, 47, 30, 3, -47 },
  { 1658, 23, 48, 30, 3, -47 },
  { 1796, 28, 47, 30, 1, -47 },
  { 1961, 23, 47, 30, 4, -46 },
  { 2097, 24, 48, 30, 3, -47 },
  { 2241, 24, 46, 30, 3, -46 },
  { 2379, 24, 48, 30, 3, -47 },
  { 2523, 23, 48, 30, 3, -47 },
  { 2661, 6, 36, 14, 4, -35 },
  { 2688, 8, 43, 14, 2, -35 },
  { 2731, 26, 29, 30, 2, -38 },
  { 2826, 26, 17, 30, 2, -31 },
  { 2882, 26, 29, 30, 2, -38 },
  { 2977, 19, 48, 21, 1, -47 },
  { 3091, 40, 53, 46, 3, -47 },
  { 3356, 31, 46, 31, 0, -46 },
  { 3535, 25, 46, 33, 5, -46 },
  { 3679, 26, 48, 32, 4, -47 },
  { 3835, 28, 46, 36, 5, -46 },
  { 3996, 20, 46, 29, 5, -46 },
  { 4111, 20, 46, 27, 5, -46 },
  { 4226, 30, 48, 38, 4, -47 },
  { 4406, 27, 46, 37, 5, -46 },
  { 4562, 12, 46, 17, 3, -46 },
  { 4631, 13, 58, 14, -4, -46 },
  { 4726, 25, 46, 30, 5, -46 },
  { 4870, 20, 46, 26, 5, -46 },
  { 4985, 38, 46, 48, 5, -46 },
  { 5204, 28, 46, 39, 5, -46 },
  { 5365, 32, 48, 39, 4, -47 },
  { 5557, 23, 46, 31, 5, -46 },
  { 5690, 32, 58, 39, 4, -47 },
  { 5922, 25, 46, 31, 5, -46 },
  { 6066, 23, 48, 29, 3, -47 },
  { 6204, 25, 46, 27, 1, -46 },
  { 6348, 27, 47, 37, 5, -46 },
  { 6507, 30, 46, 30, 0, -46 },
  { 6680, 47, 46, 49, 1, -46 },
  { 6951, 27, 46, 27, 0, -46 },
  { 7107, 27, 46, 27, 0, -46 },
  { 7263, 23, 46, 27, 2, -46 },
  { 7396, 13, 57, 20, 5, -47 },
  { 7489, 21, 46, 23, 1, -46 },
  { 7610, 13, 57, 20, 2, -47 },
  { 7703, 27, 25, 30, 2, -46 },
  { 7788, 27, 3, 27, 0, 6 },
  { 7799, 11, 11, 16, 3, -50 },
  { 7815, 21, 36, 28, 3, -35 },
  { 7910, 24, 50, 32, 5, -49 },
  { 8060, 20, 36, 24, 3, -35 },
  { 8150, 24, 50, 32, 3, -49 },
  { 8300, 23, 36, 29, 3, -35 },
  { 8404, 18, 50, 17, 1, -50 },
  { 8517, 24, 51, 32, 3, -35 },
  { 8670, 22, 49, 31, 5, -49 },
  { 8805, 5, 48, 13, 4, -48 },
  { 8835, 10, 64, 13, -1, -48 },
  { 8915, 21, 49, 26, 5, -49 },
  { 9044, 3, 49, 13, 5, -49 },
  { 9063, 37, 35, 47, 5, -35 },
  { 9225, 22, 35, 31, 5, -35 },
  { 9322, 25, 36, 31, 3, -35 },
  { 9435, 24, 50, 32, 5, -35 },
  { 9585, 24, 50, 32, 3, -35 },
  { 9735, 15, 35, 21, 5, -35 },
  { 9801, 20, 36, 24, 2, -35 },
  { 9891, 15, 44, 17, 1, -43 },
  { 9974, 21, 36, 31, 5, -35 },
  { 10069, 24, 35, 24, 0, -35 },
  { 10174, 38, 35, 40, 1, -35 },
  { 10341, 23, 35, 25, 1, -35 },
  { 10442, 23, 51, 25, 1, -35 },
  { 10589, 18, 35, 22, 2, -35 },
  { 10668, 17, 56, 23, 3, -46 },
  { 10787, 3, 66, 28, 13, -50 },
  { 10812, 17, 56, 23, 3, -46 },
  { 10931, 26, 6, 30, 2, -26 },
};

const GFXfont NotoSans_Condensed_Light65pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light65pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light65pt7bGlyphs,
  0x20, 0x7E, 89
};

#endif // _NOTOSANS_CONDENSED_LIGHT65PT7B_H_
