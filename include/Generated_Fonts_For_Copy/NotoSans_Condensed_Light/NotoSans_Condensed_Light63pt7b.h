#ifndef _NOTOSANS_CONDENSED_LIGHT63PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light63pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x8E, 0x38, 0xE3, 0x8E, 0x30, 0xC3,
  0x0C, 0x30, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x79, 0xFF, 0xDF, 0x78, 0x40,
  0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xEF, 0x03,
  0xBC, 0x0E, 0xF0, 0x3B, 0xC0, 0xEF, 0x03, 0x98, 0x0E, 0x60, 0x39, 0x80,
  0xE6, 0x03, 0x98, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x06, 0x00, 0xE0, 0x00, 0x70, 0x06, 0x00, 0x03, 0x80, 0x70, 0x00, 0x1C,
  0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x01, 0x80, 0x00, 0xE0, 0x1C, 0x00,
  0x07, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xFF, 0x00, 0x60, 0x0E, 0x00, 0x07, 0x00, 0x60, 0x00, 0x38, 0x07,
  0x00, 0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xC0, 0x18, 0x00, 0x0E,
  0x00, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x30, 0x07, 0x00,
  0x03, 0x80, 0x30, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xE0, 0x1C, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x38, 0x07, 0x00, 0x01, 0xC0, 0x38, 0x00, 0x0C, 0x01,
  0xC0, 0x00, 0xE0, 0x0C, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x38, 0x07, 0x00,
  0x01, 0xC0, 0x38, 0x00, 0x0E, 0x01, 0xC0, 0x00, 0x70, 0x0E, 0x00, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x60, 0x00, 0x00, 0xC0, 0x00, 0x01, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3E,
  0x30, 0x38, 0xF0, 0x60, 0x11, 0xC0, 0xC0, 0x07, 0x81, 0x80, 0x0E, 0x03,
  0x00, 0x1C, 0x06, 0x00, 0x38, 0x0C, 0x00, 0x70, 0x18, 0x00, 0xE0, 0x30,
  0x01, 0xC0, 0x60, 0x03, 0xC0, 0xC0, 0x03, 0x81, 0x80, 0x07, 0x83, 0x00,
  0x07, 0xC6, 0x00, 0x07, 0xEC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xBF, 0x00, 0x03, 0x1F, 0x00,
  0x06, 0x0F, 0x00, 0x0C, 0x0F, 0x00, 0x18, 0x0E, 0x00, 0x30, 0x1E, 0x00,
  0x60, 0x3C, 0x00, 0xC0, 0x38, 0x01, 0x80, 0x70, 0x03, 0x00, 0xE0, 0x06,
  0x03, 0xC0, 0x0C, 0x07, 0x00, 0x18, 0x1E, 0x80, 0x30, 0x3D, 0xC0, 0x61,
  0xF3, 0xF8, 0xDF, 0xC7, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x0C, 0x00, 0x00, 0x18, 0x00, 0x00, 0x30, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xC0, 0x00, 0x01, 0x80, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xC0, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x78, 0xF0, 0x00, 0xE0,
  0x07, 0x83, 0x80, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x70,
  0x03, 0x80, 0x0C, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x07,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x07, 0x80, 0xE0, 0x01, 0xC0, 0x1C, 0x07,
  0x00, 0x0E, 0x00, 0xE0, 0x70, 0x00, 0x70, 0x07, 0x03, 0x80, 0x03, 0x80,
  0x38, 0x38, 0x00, 0x1C, 0x01, 0xC1, 0xC0, 0x00, 0xE0, 0x0E, 0x0E, 0x00,
  0x07, 0x00, 0x70, 0xE0, 0x00, 0x38, 0x07, 0x87, 0x03, 0x81, 0xC0, 0x38,
  0x70, 0x7F, 0x0E, 0x01, 0xC3, 0x87, 0xFC, 0x30, 0x0E, 0x1C, 0x78, 0xF1,
  0xC0, 0x71, 0xC3, 0x83, 0x8E, 0x07, 0x0E, 0x38, 0x1C, 0x38, 0x38, 0xE1,
  0xC0, 0x71, 0xE3, 0x87, 0x0E, 0x03, 0x87, 0xFC, 0x38, 0xE0, 0x1C, 0x1F,
  0xC3, 0x87, 0x00, 0xE0, 0x38, 0x1C, 0x38, 0x03, 0x80, 0x01, 0xC1, 0xC0,
  0x1C, 0x00, 0x0E, 0x0E, 0x00, 0xE0, 0x00, 0x70, 0x70, 0x07, 0x00, 0x07,
  0x03, 0x80, 0x38, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0x03, 0x80, 0xE0, 0x0E,
  0x00, 0x1C, 0x07, 0x00, 0x70, 0x00, 0xE0, 0x38, 0x03, 0x80, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x0E, 0x00,
  0x38, 0x01, 0xC0, 0x70, 0x01, 0xC0, 0x0E, 0x07, 0x00, 0x1C, 0x00, 0x38,
  0x38, 0x00, 0xE0, 0x01, 0xE3, 0xC0, 0x0E, 0x00, 0x07, 0xFC, 0x00, 0x70,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1C, 0x03, 0x80, 0x00, 0xF0, 0x0F, 0x00, 0x03, 0xC0,
  0x1C, 0x00, 0x0E, 0x00, 0x70, 0x00, 0x38, 0x01, 0xC0, 0x00, 0xE0, 0x07,
  0x00, 0x03, 0xC0, 0x1C, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1C, 0x03, 0x80,
  0x00, 0x70, 0x0E, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x03, 0x81, 0xC0, 0x00,
  0x0F, 0x0F, 0x00, 0x00, 0x1C, 0x78, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x3C, 0x38, 0x01, 0xE1, 0xE0, 0xF0,
  0x07, 0x0F, 0x01, 0xE0, 0x1C, 0x3C, 0x03, 0xC0, 0x71, 0xE0, 0x0F, 0x01,
  0xC7, 0x80, 0x1E, 0x0F, 0x1C, 0x00, 0x3C, 0x38, 0x70, 0x00, 0xF0, 0xE3,
  0xC0, 0x01, 0xE7, 0x8F, 0x00, 0x03, 0xDC, 0x3C, 0x00, 0x07, 0xF0, 0x70,
  0x00, 0x1F, 0x81, 0xC0, 0x00, 0x3E, 0x07, 0x00, 0x00, 0xF8, 0x1E, 0x00,
  0x07, 0xE0, 0x78, 0x00, 0x3F, 0xC0, 0xF0, 0x01, 0xE7, 0x83, 0xE0, 0x1F,
  0x0F, 0x07, 0xFF, 0xF8, 0x3C, 0x0F, 0xFF, 0xC0, 0x78, 0x0F, 0xFC, 0x00,
  0xF0, 0x03, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x66,
  0x66, 0x00, 0x70, 0x0E, 0x01, 0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07,
  0x80, 0x38, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00,
  0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70,
  0xF0, 0x07, 0x80, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1C, 0x01, 0xE0, 0x1E,
  0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E,
  0x01, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70,
  0x0F, 0x00, 0xE0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80, 0xF0, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x1C, 0x0E, 0x0E, 0xFC, 0x73, 0xFF, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEE, 0x00,
  0x0E, 0x70, 0x00, 0xF1, 0xC0, 0x07, 0x0F, 0x00, 0x78, 0x3C, 0x07, 0x80,
  0xE0, 0x78, 0x07, 0x80, 0xC0, 0x10, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x8F, 0x1E, 0x3C, 0x70, 0xE3,
  0xC7, 0x0E, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x33,
  0xFF, 0xFF, 0xBC, 0x80, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00,
  0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xF0, 0x1E, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x1C, 0x1E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0x70,
  0x00, 0x71, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x00, 0x01, 0xCE, 0x00,
  0x03, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x0F, 0x00,
  0x1E, 0x1E, 0x00, 0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x3E, 0x07,
  0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x38, 0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7B, 0x87, 0x9C, 0x78,
  0xE7, 0x87, 0xF8, 0x3F, 0x81, 0xD8, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x00, 0x20, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFE, 0x03,
  0xFF, 0xFE, 0x0F, 0xC0, 0x3E, 0x0E, 0x00, 0x1E, 0x08, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x70, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFF,
  0x03, 0xFE, 0xFF, 0x0F, 0x80, 0x1F, 0x1C, 0x00, 0x1E, 0x10, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x79, 0x00, 0x01, 0xE3, 0x80, 0x0F, 0xC7, 0xFD, 0xFF, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0x70, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x39, 0xC0, 0x00,
  0x07, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x0E, 0x1C,
  0x00, 0x01, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x00, 0x1E, 0x0E, 0x00, 0x03,
  0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0xE0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x03, 0xC0, 0x07, 0x00,
  0x70, 0x00, 0xE0, 0x1E, 0x00, 0x1C, 0x03, 0x80, 0x03, 0x80, 0xF0, 0x00,
  0x70, 0x1C, 0x00, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x03, 0x80, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC1, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFE, 0x07, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x80,
  0x01, 0xF1, 0xE0, 0x07, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x03, 0xFF,
  0xE0, 0x00, 0x3A, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x7F, 0xF0, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0xFC, 0x03,
  0x8F, 0xFE, 0x0F, 0x3F, 0xFE, 0x1E, 0xF8, 0x3E, 0x3D, 0xC0, 0x3E, 0x7E,
  0x00, 0x3C, 0xFC, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0x77, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00,
  0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0x8E, 0x00, 0x07, 0x1E, 0x00, 0x1E,
  0x1C, 0x00, 0x38, 0x3C, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x3F, 0x3F, 0x80,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x38, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0xFF, 0x3F, 0x81, 0xE0, 0x0F, 0x07, 0x80, 0x0F,
  0x0E, 0x00, 0x0E, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCF, 0x00, 0x07, 0x9E,
  0x00, 0x0F, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0x3E, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F,
  0x80, 0x01, 0xFF, 0x80, 0x07, 0xCF, 0xC0, 0x1F, 0x07, 0xC0, 0x78, 0x07,
  0xC1, 0xE0, 0x07, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x07, 0xBC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0E, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xFE,
  0x3F, 0x80, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xE0,
  0x3E, 0x07, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x70, 0x00,
  0x79, 0xE0, 0x00, 0x73, 0xC0, 0x00, 0xF7, 0x00, 0x01, 0xEE, 0x00, 0x01,
  0xDC, 0x00, 0x03, 0xB8, 0x00, 0x07, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x1D,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xEE,
  0x00, 0x07, 0xDE, 0x00, 0x1F, 0xBC, 0x00, 0x7F, 0x3C, 0x01, 0xDC, 0x7E,
  0x07, 0xB8, 0x7F, 0xFE, 0x70, 0x3F, 0xF0, 0xE0, 0x1F, 0xC1, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x01, 0xEF, 0xF8, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x73, 0xFF, 0xFF, 0xBC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x3F, 0xFF, 0xFB,
  0xC8, 0x0C, 0x1E, 0x3E, 0x3F, 0x3E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x1E, 0x1E, 0x1E, 0x1E, 0x1C, 0x3C, 0x3C,
  0x38, 0x38, 0x78, 0x70, 0x70, 0x70, 0xE0, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01,
  0xC0, 0x07, 0xFF, 0x07, 0xFF, 0xE3, 0xFF, 0xFC, 0x70, 0x0F, 0x90, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x70, 0x07,
  0x00, 0x00, 0x00, 0xE0, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x00,
  0x07, 0x07, 0x80, 0x00, 0x00, 0x1C, 0x1C, 0x00, 0x0C, 0x00, 0x38, 0xF0,
  0x03, 0xFF, 0x80, 0xE3, 0x80, 0x1F, 0xFE, 0x03, 0x8E, 0x00, 0xF0, 0x38,
  0x07, 0x78, 0x07, 0x80, 0xE0, 0x1D, 0xC0, 0x1C, 0x03, 0x80, 0x77, 0x00,
  0xE0, 0x0E, 0x01, 0xDC, 0x03, 0x80, 0x38, 0x07, 0x70, 0x1E, 0x00, 0xE0,
  0x1D, 0xC0, 0x70, 0x03, 0x80, 0x7E, 0x01, 0xC0, 0x0E, 0x01, 0xF8, 0x07,
  0x00, 0x78, 0x07, 0xE0, 0x1C, 0x01, 0xE0, 0x1F, 0x80, 0x70, 0x07, 0x80,
  0x7E, 0x01, 0xC0, 0x1E, 0x01, 0xF8, 0x07, 0x00, 0x70, 0x07, 0xE0, 0x1C,
  0x01, 0xC0, 0x1F, 0x80, 0x70, 0x07, 0x00, 0x7E, 0x01, 0xC0, 0x1E, 0x03,
  0xBC, 0x07, 0x00, 0xF8, 0x0E, 0x70, 0x1E, 0x03, 0x60, 0x39, 0xC0, 0x38,
  0x1D, 0x81, 0xC7, 0x00, 0xF0, 0xE7, 0x0F, 0x1C, 0x01, 0xFF, 0x9F, 0xF8,
  0x78, 0x03, 0xFC, 0x3F, 0xC0, 0xE0, 0x07, 0xC0, 0x3E, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x03, 0x00, 0x00, 0x3F, 0x80, 0x7C, 0x00, 0x00, 0x3F, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x77, 0x80, 0x00, 0x01,
  0xCE, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00, 0x3C, 0xE0, 0x00, 0x00, 0xE3,
  0xC0, 0x00, 0x03, 0x87, 0x00, 0x00, 0x0E, 0x1C, 0x00, 0x00, 0x78, 0x78,
  0x00, 0x01, 0xC1, 0xE0, 0x00, 0x07, 0x03, 0x80, 0x00, 0x3C, 0x0E, 0x00,
  0x00, 0xF0, 0x3C, 0x00, 0x03, 0x80, 0x70, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0x78, 0x07, 0x80, 0x01, 0xC0, 0x1E, 0x00, 0x07, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0xE0, 0x00, 0xF0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0x80, 0x3C, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0x3C, 0x03, 0x80, 0x00, 0xF0,
  0x0E, 0x00, 0x01, 0xC0, 0x78, 0x00, 0x07, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xE0, 0xF0, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0x0F, 0x0E, 0x00, 0x00, 0x3C, 0x78, 0x00, 0x00, 0x71, 0xE0, 0x00,
  0x01, 0xE7, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x00,
  0x3C, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0xF0, 0x03,
  0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x38, 0xF0, 0x00, 0xF8, 0xF0, 0x03,
  0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xF0, 0x01,
  0xF8, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x7C, 0xF0, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x07,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xF8, 0x03, 0x80, 0xF8, 0x00, 0x20,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x18,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0x1D,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x78,
  0x03, 0xFC, 0x0F, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x07,
  0x87, 0x80, 0x00, 0xF8, 0xF0, 0x00, 0x0F, 0x1E, 0x00, 0x00, 0xF3, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xDE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xEF,
  0x00, 0x00, 0x1D, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x00, 0xF7, 0x80, 0x00,
  0x1E, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x00, 0xF3, 0xC0, 0x00, 0x1E, 0x78,
  0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0x3C, 0x00, 0x0F,
  0x87, 0x80, 0x03, 0xE0, 0xF0, 0x01, 0xF8, 0x1E, 0x00, 0xFE, 0x03, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x01, 0xFC,
  0x00, 0x78, 0x0F, 0xC0, 0x00, 0x60, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF7, 0x00, 0x00, 0x01,
  0xDC, 0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0x1D, 0xE0, 0x00, 0x00, 0x77,
  0x80, 0x00, 0x01, 0xDE, 0x00, 0x00, 0x07, 0x78, 0x00, 0x00, 0x1C, 0xF0,
  0x00, 0x00, 0x73, 0xC0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x07, 0x1E, 0x00,
  0x00, 0x1C, 0x78, 0x00, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xC3, 0xE0, 0x00,
  0x07, 0x07, 0xC0, 0x00, 0x1C, 0x0F, 0x80, 0x00, 0x70, 0x1F, 0x80, 0x07,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xC0, 0xFF, 0xFF, 0xFC, 0xFE, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1F, 0x7F,
  0xF3, 0xFF, 0x1F, 0xF0, 0x08, 0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF0, 0x07, 0x80,
  0xF0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00,
  0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF1, 0xE0, 0x00, 0xF3, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF7, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0xFE, 0xF0, 0x00, 0xFC, 0x78, 0x00, 0xF8, 0x3C, 0x00,
  0xF8, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1C,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF7, 0x00, 0x00, 0x01, 0xFF,
  0xB8, 0x00, 0x00, 0x1D, 0xFD, 0xE0, 0x00, 0x00, 0xEF, 0xF7, 0x00, 0x00,
  0x07, 0x7F, 0xB8, 0x00, 0x00, 0x7B, 0xFD, 0xE0, 0x00, 0x03, 0x9F, 0xE7,
  0x00, 0x00, 0x1C, 0xFF, 0x38, 0x00, 0x01, 0xE7, 0xF9, 0xE0, 0x00, 0x0E,
  0x3F, 0xC7, 0x00, 0x00, 0x71, 0xFE, 0x38, 0x00, 0x07, 0x8F, 0xF1, 0xE0,
  0x00, 0x38, 0x7F, 0x87, 0x00, 0x01, 0xC3, 0xFC, 0x38, 0x00, 0x1E, 0x1F,
  0xE1, 0xE0, 0x00, 0xE0, 0xFF, 0x07, 0x00, 0x07, 0x07, 0xF8, 0x38, 0x00,
  0x78, 0x3F, 0xC1, 0xE0, 0x03, 0x81, 0xFE, 0x07, 0x00, 0x1C, 0x0F, 0xF0,
  0x38, 0x01, 0xE0, 0x7F, 0x81, 0xE0, 0x0E, 0x03, 0xFC, 0x07, 0x00, 0x70,
  0x1F, 0xE0, 0x38, 0x07, 0x80, 0xFF, 0x01, 0xE0, 0x38, 0x07, 0xF8, 0x07,
  0x01, 0xC0, 0x3F, 0xC0, 0x38, 0x1E, 0x01, 0xFE, 0x01, 0xE0, 0xE0, 0x0F,
  0xF0, 0x07, 0x07, 0x00, 0x7F, 0x80, 0x38, 0x78, 0x03, 0xFC, 0x01, 0xE3,
  0x80, 0x1F, 0xE0, 0x0F, 0x1C, 0x00, 0xFF, 0x00, 0x39, 0xE0, 0x07, 0xF8,
  0x01, 0xEE, 0x00, 0x3F, 0xC0, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFB, 0xC0, 0x00,
  0x3F, 0x78, 0x00, 0x07, 0xE7, 0x80, 0x00, 0xFC, 0xF0, 0x00, 0x1F, 0xCF,
  0x00, 0x03, 0xF9, 0xE0, 0x00, 0x7F, 0x1E, 0x00, 0x0F, 0xE3, 0xC0, 0x01,
  0xFC, 0x3C, 0x00, 0x3F, 0x87, 0x80, 0x07, 0xF0, 0x78, 0x00, 0xFE, 0x0F,
  0x00, 0x1F, 0xC0, 0xF0, 0x03, 0xF8, 0x1E, 0x00, 0x7F, 0x01, 0xE0, 0x0F,
  0xE0, 0x3C, 0x01, 0xFC, 0x03, 0xC0, 0x3F, 0x80, 0x78, 0x07, 0xF0, 0x07,
  0x80, 0xFE, 0x00, 0xF0, 0x1F, 0xC0, 0x0F, 0x03, 0xF8, 0x01, 0xE0, 0x7F,
  0x00, 0x1E, 0x0F, 0xE0, 0x03, 0xC1, 0xFC, 0x00, 0x3C, 0x3F, 0x80, 0x07,
  0x87, 0xF0, 0x00, 0x78, 0xFE, 0x00, 0x0F, 0x1F, 0xC0, 0x00, 0xF3, 0xF8,
  0x00, 0x1E, 0x7F, 0x00, 0x01, 0xEF, 0xE0, 0x00, 0x3D, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1E, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0,
  0xF0, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0xCF,
  0x00, 0x00, 0x03, 0x9E, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78,
  0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x3B, 0x80,
  0x00, 0x00, 0x77, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0E, 0xE0, 0x00,
  0x00, 0x1D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x01, 0xEE, 0x00, 0x00, 0x03, 0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00,
  0x0F, 0x78, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x01, 0xE3, 0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F,
  0x07, 0x80, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3C, 0x03, 0xF8, 0xF0,
  0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x0E, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0xFB, 0xC0, 0x07,
  0xCF, 0x00, 0x3E, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF, 0xF8, 0x0F,
  0xFC, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xFC, 0x00,
  0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0x80, 0x00, 0x78, 0x1E,
  0x00, 0x00, 0x78, 0x3C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x00, 0xF1, 0xE0,
  0x00, 0x01, 0xE3, 0x80, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x03, 0x9E, 0x00,
  0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E, 0xE0, 0x00,
  0x00, 0x3D, 0xC0, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x00,
  0x3B, 0x80, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x03,
  0xDE, 0x00, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x0F, 0x78, 0x00, 0x00, 0x1E,
  0x70, 0x00, 0x00, 0x38, 0xF0, 0x00, 0x00, 0xF1, 0xE0, 0x00, 0x01, 0xE3,
  0xC0, 0x00, 0x03, 0xC3, 0xC0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x78, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x0F,
  0xC0, 0x3F, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xF0, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0xE0, 0xF0, 0x01, 0xF0,
  0xF0, 0x00, 0xF8, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x1C,
  0xF0, 0x00, 0x1C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x38, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0xF0,
  0xF0, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00,
  0xF0, 0x1E, 0x00, 0xF0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0xF0,
  0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x3C,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F,
  0x00, 0x3E, 0x00, 0x07, 0xFF, 0x80, 0x7F, 0xFF, 0xC7, 0xFF, 0xFE, 0x3F,
  0x00, 0x78, 0xF0, 0x00, 0x27, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x7A, 0x00, 0x03, 0xCF, 0x00, 0x3F, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x78, 0xF0, 0x00, 0x3C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0x80,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x3C,
  0xF0, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x0F, 0x1C, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x87, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x01, 0xC0, 0xE0, 0x00,
  0x0E, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x38,
  0x07, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0xF0, 0x07,
  0x00, 0x07, 0x00, 0x38, 0x00, 0x78, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x0F, 0x00, 0x0F, 0x00, 0x78,
  0x00, 0x78, 0x03, 0x80, 0x01, 0xC0, 0x3C, 0x00, 0x0E, 0x01, 0xE0, 0x00,
  0x78, 0x0E, 0x00, 0x01, 0xC0, 0x70, 0x00, 0x0E, 0x07, 0x80, 0x00, 0x78,
  0x3C, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x0E, 0x0E, 0x00, 0x00, 0x70, 0xF0,
  0x00, 0x03, 0xC7, 0x80, 0x00, 0x1E, 0x38, 0x00, 0x00, 0x71, 0xC0, 0x00,
  0x03, 0x9E, 0x00, 0x00, 0x1E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03,
  0xB8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xEF, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xBC, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x70, 0x00, 0x0F, 0x80,
  0x00, 0x79, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xC7, 0x80, 0x01, 0xDC, 0x00,
  0x0F, 0x1E, 0x00, 0x07, 0x70, 0x00, 0x3C, 0x38, 0x00, 0x1D, 0xC0, 0x00,
  0xF0, 0xE0, 0x00, 0x77, 0x00, 0x03, 0x83, 0xC0, 0x03, 0xDE, 0x00, 0x0E,
  0x0F, 0x00, 0x0E, 0x38, 0x00, 0x78, 0x3C, 0x00, 0x38, 0xE0, 0x01, 0xE0,
  0x70, 0x00, 0xE3, 0x80, 0x07, 0x01, 0xC0, 0x03, 0x8E, 0x00, 0x1C, 0x07,
  0x80, 0x1E, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x70, 0x70, 0x03, 0xC0, 0x38,
  0x01, 0xC1, 0xC0, 0x0F, 0x00, 0xE0, 0x07, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0xE0, 0x38, 0x07, 0x80, 0x1C, 0x03,
  0x80, 0xE0, 0x1E, 0x00, 0x70, 0x0E, 0x03, 0x80, 0x70, 0x01, 0xE0, 0x78,
  0x0E, 0x01, 0xC0, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x00,
  0x70, 0x3C, 0x00, 0x38, 0x1C, 0x01, 0xC0, 0xE0, 0x00, 0xE0, 0x70, 0x07,
  0x03, 0x80, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0x0F, 0x0E, 0x00, 0x38,
  0x78, 0x00, 0x1C, 0x38, 0x00, 0xE1, 0xE0, 0x00, 0x70, 0xE0, 0x03, 0x87,
  0x00, 0x01, 0xE7, 0x80, 0x0E, 0x3C, 0x00, 0x07, 0x9E, 0x00, 0x1C, 0xF0,
  0x00, 0x1E, 0x70, 0x00, 0x73, 0xC0, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00,
  0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE1, 0xE0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x0F, 0x03, 0xC0, 0x07, 0x80,
  0x70, 0x01, 0xE0, 0x1E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x00, 0xF0, 0x0E,
  0x00, 0x3C, 0x07, 0x80, 0x07, 0x81, 0xC0, 0x01, 0xE0, 0xF0, 0x00, 0x38,
  0x38, 0x00, 0x0F, 0x1E, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x7B, 0xC0, 0x00,
  0x0E, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0xBC, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x38, 0x38, 0x00, 0x1E, 0x0F, 0x00, 0x07, 0x03, 0xC0,
  0x03, 0xC0, 0x70, 0x00, 0xE0, 0x1E, 0x00, 0x78, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x1C, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x01, 0xE0, 0x78,
  0x00, 0x3C, 0x3C, 0x00, 0x0F, 0x0F, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x79,
  0xE0, 0x00, 0x0E, 0xF0, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x03, 0xDC, 0x00,
  0x01, 0xE7, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x1C, 0x38, 0x00, 0x0F, 0x0F,
  0x00, 0x03, 0xC1, 0xC0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1C,
  0x03, 0x80, 0x0F, 0x00, 0xF0, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x80,
  0x78, 0x01, 0xE0, 0x1C, 0x00, 0x38, 0x0F, 0x00, 0x0F, 0x03, 0x80, 0x01,
  0xC0, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1C, 0x00, 0x03, 0x8F, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7F, 0xFF,
  0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00,
  0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x78, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1D, 0xE0, 0x00, 0x0F, 0x38, 0x00, 0x03, 0x8F, 0x00, 0x01, 0xE1, 0xC0,
  0x00, 0x70, 0x78, 0x00, 0x3C, 0x0E, 0x00, 0x0E, 0x03, 0xC0, 0x07, 0x80,
  0x70, 0x01, 0xC0, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x38, 0x00, 0xE0, 0x1E,
  0x00, 0x1C, 0x07, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x38,
  0x78, 0x00, 0x0F, 0x1C, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x7B, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x3E, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x30, 0x01, 0xFF, 0x00,
  0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x1E, 0x03, 0xC0, 0x80, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x1F,
  0xE0, 0x1F, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0x01, 0xC7, 0xC0, 0x0E, 0x78,
  0x00, 0x77, 0x80, 0x03, 0xBC, 0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1E, 0xE0, 0x01, 0xF7, 0x80,
  0x0F, 0xBC, 0x00, 0xDC, 0xF0, 0x0E, 0xE7, 0xE1, 0xE7, 0x1F, 0xFE, 0x38,
  0x7F, 0xE1, 0xC0, 0x30, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x3F, 0xC0,
  0x70, 0xFF, 0xE0, 0xE7, 0xFF, 0xE1, 0xCE, 0x07, 0xE3, 0xB8, 0x03, 0xC7,
  0xE0, 0x03, 0xCF, 0x80, 0x07, 0x9F, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78,
  0x00, 0x0E, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xBC, 0x00, 0x07, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xF0, 0x00, 0x73, 0xE0, 0x01, 0xE7, 0x60, 0x07, 0x8E,
  0xE0, 0x1F, 0x1C, 0xF9, 0xFC, 0x38, 0xFF, 0xF0, 0x60, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x87, 0xE0, 0x61,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x08, 0x7F, 0xBF, 0x07, 0xFF, 0xE0, 0x3F, 0xF8, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x7F, 0x83, 0x81, 0xFF, 0x87,
  0x0F, 0xFF, 0xCE, 0x1F, 0x03, 0x9C, 0x78, 0x03, 0xB9, 0xE0, 0x03, 0xF3,
  0xC0, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x78, 0x00, 0x1E,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xF0, 0x03, 0x71, 0xF0, 0x0E, 0xE1,
  0xFC, 0xF9, 0xC1, 0xFF, 0xE3, 0x81, 0xFF, 0x87, 0x00, 0x30, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0xF8, 0x1E, 0x00,
  0xF0, 0xF0, 0x01, 0xC3, 0xC0, 0x07, 0x8E, 0x00, 0x0E, 0x78, 0x00, 0x39,
  0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x20, 0xF0, 0x03,
  0x83, 0xFC, 0x7E, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x10, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0xF1, 0xFF, 0xF8, 0xFF, 0xFC,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xFE, 0x0E, 0x07, 0xFF, 0x1C,
  0x3F, 0xFF, 0x38, 0xFC, 0x0F, 0x71, 0xE0, 0x0E, 0xE7, 0x80, 0x0F, 0xCF,
  0x00, 0x0F, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0x7B,
  0xC0, 0x01, 0xF3, 0xC0, 0x03, 0xE7, 0xC0, 0x0D, 0xC7, 0xC0, 0x3B, 0x87,
  0xF7, 0xE7, 0x07, 0xFF, 0x8E, 0x07, 0xFC, 0x1C, 0x00, 0xC0, 0x38, 0x00,
  0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xE2, 0x00, 0x0F, 0x87, 0x80, 0x7E, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x00, 0x03, 0x83, 0xFC, 0x1C, 0x3F, 0xF0, 0xE7, 0xFF, 0xC7,
  0x38, 0x1F, 0x3B, 0x80, 0x7D, 0xF8, 0x01, 0xEF, 0x80, 0x07, 0x78, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x77, 0xFF, 0xF7,
  0x90, 0x00, 0x00, 0x00, 0x07, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE,
  0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C,
  0xE7, 0x38, 0x03, 0x81, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x40, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1E,
  0x07, 0x83, 0xCF, 0xF3, 0xF8, 0xFC, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x01, 0xEE, 0x00, 0x1C, 0xE0,
  0x03, 0xCE, 0x00, 0x78, 0xE0, 0x07, 0x0E, 0x00, 0xF0, 0xE0, 0x1E, 0x0E,
  0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x80, 0xE0, 0xF0, 0x0E, 0x0E, 0x00,
  0xE1, 0xE0, 0x0E, 0x3C, 0x00, 0xE3, 0xC0, 0x0E, 0x7E, 0x00, 0xEF, 0xE0,
  0x0E, 0xCF, 0x00, 0xFC, 0xF0, 0x0F, 0x87, 0x80, 0xF0, 0x78, 0x0E, 0x03,
  0xC0, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xE0, 0x1E, 0x0E, 0x00, 0xF0, 0xE0,
  0x0F, 0x0E, 0x00, 0x78, 0xE0, 0x07, 0x8E, 0x00, 0x3C, 0xE0, 0x03, 0xCE,
  0x00, 0x1E, 0xE0, 0x01, 0xEE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0xFE, 0x00, 0xFE, 0x0C, 0x3F, 0xF0, 0x3F, 0xF8, 0xE7, 0xFF,
  0x87, 0xFF, 0xCE, 0xF0, 0x7C, 0xF0, 0x7C, 0xEC, 0x03, 0xCC, 0x01, 0xEF,
  0x80, 0x1F, 0xC0, 0x1E, 0xF8, 0x01, 0xF8, 0x00, 0xEF, 0x00, 0x0F, 0x00,
  0x0F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00,
  0x0F, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0F, 0xC0, 0xFF,
  0x06, 0x0F, 0xFC, 0x39, 0xFF, 0xF9, 0xCE, 0x07, 0xCE, 0xE0, 0x1F, 0x7E,
  0x00, 0x7B, 0xE0, 0x01, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0x81, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x1C, 0x78, 0x00, 0x1E, 0x70, 0x00, 0x1E, 0x70, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x38, 0x00, 0x1C, 0x3C, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1F, 0x00,
  0xF8, 0x0F, 0xE7, 0xF0, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18,
  0x00, 0xC0, 0xFF, 0x01, 0x83, 0xFF, 0x83, 0x8F, 0xFF, 0x87, 0x38, 0x1F,
  0x8E, 0xE0, 0x0F, 0x1D, 0x80, 0x0F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x1E,
  0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00,
  0x1D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0xC0, 0x01, 0xCF, 0x80, 0x07,
  0x9D, 0x80, 0x1E, 0x3B, 0x80, 0x7C, 0x73, 0xF7, 0xF0, 0xE3, 0xFF, 0xC1,
  0xC3, 0xFE, 0x03, 0x80, 0x70, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x0E, 0x07, 0xFF, 0x1C, 0x3F, 0xFF, 0x38, 0x7C, 0x0E, 0x71, 0xE0, 0x0E,
  0xE7, 0x80, 0x0F, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x78, 0x00, 0x1E,
  0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x70, 0x00, 0x1E, 0xE0, 0x00,
  0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x01, 0xF3, 0xC0, 0x07, 0xE7, 0xC0, 0x0D,
  0xC7, 0xC0, 0x73, 0x87, 0xF7, 0xE7, 0x07, 0xFF, 0x8E, 0x07, 0xFC, 0x1C,
  0x00, 0xE0, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0xC0, 0xFF, 0x07, 0xFE, 0x3F,
  0xF9, 0xE3, 0xEE, 0x03, 0xB0, 0x0F, 0xC0, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x03, 0xFE, 0x01, 0xFF, 0xFC,
  0x7F, 0xFF, 0x1F, 0x00, 0xE7, 0x80, 0x04, 0xF0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1D, 0x00, 0x07, 0xB8, 0x01, 0xF7, 0xFB, 0xFC, 0xFF,
  0xFF, 0x07, 0xFF, 0x80, 0x0F, 0x00, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0xFE, 0xFF, 0xFD,
  0xFF, 0xF8, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xFB, 0x83, 0xFF, 0x03, 0xFE,
  0x00, 0xE0, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC0,
  0x01, 0xF7, 0x00, 0x07, 0xDE, 0x00, 0x1F, 0x78, 0x00, 0xDD, 0xF0, 0x07,
  0x73, 0xE0, 0x39, 0xC7, 0xEF, 0xC7, 0x1F, 0xFE, 0x1C, 0x1F, 0xF0, 0x70,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B,
  0xC0, 0x00, 0xE7, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x8E, 0x00, 0x0F, 0x1E,
  0x00, 0x1C, 0x3C, 0x00, 0x78, 0x38, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0xF0,
  0x03, 0x80, 0xE0, 0x0F, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x07, 0x01, 0xE0, 0x0E, 0x03, 0x80, 0x1E, 0x07, 0x00, 0x1C, 0x1E,
  0x00, 0x38, 0x3C, 0x00, 0x70, 0x70, 0x00, 0xF0, 0xE0, 0x00, 0xE3, 0xC0,
  0x01, 0xC7, 0x00, 0x03, 0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x78, 0x00,
  0x0E, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x7F, 0x00, 0x07,
  0xC0, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x1D, 0xE0, 0x01, 0xF0, 0x00, 0xE7,
  0x00, 0x0F, 0x80, 0x07, 0x38, 0x00, 0xEE, 0x00, 0x79, 0xE0, 0x07, 0x70,
  0x03, 0x8F, 0x00, 0x3B, 0x80, 0x1C, 0x38, 0x01, 0xDC, 0x00, 0xE1, 0xC0,
  0x1C, 0xE0, 0x0F, 0x0E, 0x00, 0xE3, 0x80, 0x78, 0x78, 0x07, 0x1C, 0x03,
  0x81, 0xC0, 0x38, 0xE0, 0x1C, 0x0E, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x1C,
  0x1C, 0x0F, 0x03, 0xC0, 0xE0, 0xE0, 0x70, 0x1E, 0x07, 0x07, 0x03, 0x80,
  0x70, 0x78, 0x38, 0x1C, 0x03, 0x83, 0x80, 0xE1, 0xE0, 0x1E, 0x1C, 0x07,
  0x0E, 0x00, 0xF0, 0xE0, 0x38, 0x70, 0x03, 0x8F, 0x01, 0xC3, 0x80, 0x1C,
  0x70, 0x0F, 0x3C, 0x00, 0xE3, 0x80, 0x39, 0xC0, 0x07, 0x9C, 0x01, 0xCE,
  0x00, 0x1D, 0xE0, 0x0E, 0x70, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x07, 0x70,
  0x01, 0xF8, 0x00, 0x3B, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x78, 0xF0, 0x01, 0xE1, 0xE0, 0x03, 0xC1, 0xE0, 0x0F, 0x03, 0xC0, 0x1C,
  0x03, 0xC0, 0x78, 0x07, 0x80, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x00,
  0x0F, 0x1E, 0x00, 0x0E, 0x38, 0x00, 0x1E, 0xF0, 0x00, 0x1D, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xE0, 0x00, 0xF1,
  0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x83, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x07,
  0x80, 0x70, 0x0F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1E,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3B, 0xC0, 0x00, 0x73, 0x80, 0x01, 0xE7, 0x00, 0x03, 0xCF,
  0x00, 0x07, 0x1E, 0x00, 0x1E, 0x1C, 0x00, 0x3C, 0x38, 0x00, 0x70, 0x78,
  0x00, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x01, 0xE0, 0x0E, 0x03, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x0F, 0x01, 0xC0, 0x0E, 0x07,
  0x80, 0x1C, 0x0E, 0x00, 0x3C, 0x1C, 0x00, 0x38, 0x38, 0x00, 0x70, 0xF0,
  0x00, 0xE1, 0xC0, 0x01, 0xE3, 0x80, 0x01, 0xCF, 0x00, 0x03, 0x9C, 0x00,
  0x07, 0x38, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x70, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70,
  0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x1F, 0xC0,
  0x3F, 0xE0, 0x1F, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x0F, 0x80, 0x3F, 0x80, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x03, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x01, 0xF0, 0x03, 0xF8, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x03, 0xC0,
  0x00, 0x03, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x5F, 0xFE, 0x00, 0x7F, 0x9F,
  0xE0, 0xFE, 0x01, 0xFF, 0xF6, 0x00, 0x3F, 0xF2, 0x00, 0x07, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 6, 46, 14, 4, -45 },
  { 36, 14, 16, 22, 4, -45 },
  { 64, 29, 45, 32, 1, -45 },
  { 228, 23, 52, 29, 3, -48 },
  { 378, 37, 47, 43, 3, -46 },
  { 596, 30, 47, 33, 2, -46 },
  { 773, 4, 16, 12, 4, -45 },
  { 781, 12, 55, 17, 3, -45 },
  { 864, 12, 55, 17, 2, -45 },
  { 947, 21, 21, 27, 3, -48 },
  { 1003, 25, 29, 29, 2, -37 },
  { 1094, 7, 15, 13, 2, -7 },
  { 1108, 14, 4, 18, 2, -19 },
  { 1115, 5, 7, 14, 4, -6 },
  { 1120, 20, 45, 22, 1, -45 },
  { 1233, 23, 47, 29, 3, -46 },
  { 1369, 13, 45, 29, 5, -45 },
  { 1443, 23, 46, 29, 3, -46 },
  { 1576, 23, 47, 29, 3, -46 },
  { 1712, 27, 45, 29, 1, -45 },
  { 1864, 23, 46, 29, 3, -45 },
  { 1997, 23, 47, 29, 3, -46 },
  { 2133, 23, 45, 29, 3, -45 },
  { 2263, 23, 47, 29, 3, -46 },
  { 2399, 23, 47, 29, 3, -46 },
  { 2535, 5, 35, 14, 4, -34 },
  { 2557, 8, 42, 14, 2, -34 },
  { 2599, 25, 27, 29, 2, -36 },
  { 2684, 25, 16, 29, 2, -30 },
  { 2734, 25, 27, 29, 2, -36 },
  { 2819, 18, 47, 21, 1, -46 },
  { 2925, 38, 51, 44, 3, -45 },
  { 3168, 30, 45, 30, 0, -45 },
  { 3337, 24, 45, 32, 5, -45 },
  { 3472, 26, 47, 31, 3, -46 },
  { 3625, 27, 45, 35, 5, -45 },
  { 3777, 20, 45, 28, 5, -45 },
  { 3890, 20, 45, 26, 5, -45 },
  { 4003, 30, 47, 37, 3, -46 },
  { 4180, 26, 45, 36, 5, -45 },
  { 4327, 11, 45, 17, 3, -45 },
  { 4389, 13, 57, 14, -4, -45 },
  { 4482, 24, 45, 29, 5, -45 },
  { 4617, 19, 45, 25, 5, -45 },
  { 4724, 37, 45, 47, 5, -45 },
  { 4933, 27, 45, 37, 5, -45 },
  { 5085, 31, 47, 38, 3, -46 },
  { 5268, 22, 45, 30, 5, -45 },
  { 5392, 31, 57, 38, 3, -46 },
  { 5613, 24, 45, 30, 5, -45 },
  { 5748, 22, 47, 28, 3, -46 },
  { 5878, 25, 45, 26, 0, -45 },
  { 6019, 26, 46, 36, 5, -45 },
  { 6169, 29, 45, 29, 0, -45 },
  { 6333, 46, 45, 47, 1, -45 },
  { 6592, 26, 45, 26, 0, -45 },
  { 6739, 26, 45, 26, 0, -45 },
  { 6886, 22, 45, 26, 2, -45 },
  { 7010, 13, 55, 20, 5, -45 },
  { 7100, 20, 45, 22, 1, -45 },
  { 7213, 13, 55, 20, 2, -45 },
  { 7303, 26, 24, 29, 2, -45 },
  { 7381, 26, 2, 26, 0, 6 },
  { 7388, 10, 10, 16, 3, -48 },
  { 7401, 21, 35, 27, 2, -34 },
  { 7493, 23, 49, 31, 5, -48 },
  { 7634, 19, 35, 24, 3, -34 },
  { 7718, 23, 49, 31, 3, -48 },
  { 7859, 22, 35, 28, 3, -34 },
  { 7956, 17, 48, 16, 1, -48 },
  { 8058, 23, 49, 31, 3, -34 },
  { 8199, 21, 48, 30, 5, -48 },
  { 8325, 5, 46, 13, 4, -46 },
  { 8354, 10, 61, 13, -1, -46 },
  { 8431, 20, 48, 25, 5, -48 },
  { 8551, 3, 48, 13, 5, -48 },
  { 8569, 36, 34, 45, 5, -34 },
  { 8722, 21, 34, 30, 5, -34 },
  { 8812, 24, 35, 30, 3, -34 },
  { 8917, 23, 49, 31, 5, -34 },
  { 9058, 23, 49, 31, 3, -34 },
  { 9199, 14, 34, 20, 5, -34 },
  { 9259, 19, 35, 23, 2, -34 },
  { 9343, 15, 42, 17, 1, -41 },
  { 9422, 22, 35, 30, 4, -34 },
  { 9519, 23, 34, 24, 0, -34 },
  { 9617, 37, 34, 39, 1, -34 },
  { 9775, 23, 34, 25, 1, -34 },
  { 9873, 23, 49, 24, 1, -34 },
  { 10014, 17, 34, 21, 2, -34 },
  { 10087, 17, 55, 22, 3, -45 },
  { 10204, 3, 63, 28, 12, -48 },
  { 10228, 17, 55, 22, 3, -45 },
  { 10345, 25, 7, 29, 2, -26 },
};

const GFXfont NotoSans_Condensed_Light63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light63pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_CONDENSED_LIGHT63PT7B_H_
