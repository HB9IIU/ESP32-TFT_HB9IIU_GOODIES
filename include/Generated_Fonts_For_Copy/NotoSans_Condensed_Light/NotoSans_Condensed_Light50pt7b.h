#ifndef _NOTOSANS_CONDENSED_LIGHT50PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light50pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0xEE, 0x66, 0x60, 0x00, 0x04, 0xEF, 0xFE, 0xE0, 0xFC, 0x1F, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3B, 0x07, 0x60, 0xEC, 0x1D, 0x83, 0xB0, 0x76,
  0x0E, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03,
  0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x38, 0x00, 0xE0, 0x70,
  0x01, 0xC0, 0xC0, 0x03, 0x01, 0x80, 0x06, 0x03, 0x03, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0x30, 0x38, 0x00, 0xE0, 0x70, 0x01, 0xC0, 0xC0, 0x03,
  0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30,
  0x38, 0x00, 0x60, 0x70, 0x01, 0xC0, 0xC0, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0x0C, 0x06, 0x00, 0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70,
  0x01, 0xC0, 0xE0, 0x03, 0x81, 0x80, 0x06, 0x03, 0x00, 0x0C, 0x06, 0x00,
  0x18, 0x0C, 0x00, 0x30, 0x18, 0x00, 0x60, 0x70, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x03, 0x00, 0x00, 0x70, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F,
  0x30, 0xE3, 0x86, 0x04, 0x70, 0xC0, 0x1C, 0x18, 0x03, 0x83, 0x00, 0x70,
  0x60, 0x0E, 0x0C, 0x01, 0xC1, 0x80, 0x18, 0x30, 0x03, 0x86, 0x00, 0x38,
  0xC0, 0x07, 0xD8, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xFC, 0x00, 0x33, 0xC0, 0x06, 0x1C, 0x00, 0xC1, 0xC0, 0x18, 0x38, 0x03,
  0x03, 0x00, 0x60, 0x70, 0x0C, 0x0E, 0x01, 0x81, 0x80, 0x30, 0x70, 0x06,
  0x0E, 0xC0, 0xC3, 0x9F, 0x19, 0xE3, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x0C,
  0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x0F,
  0x80, 0x06, 0x00, 0xFF, 0x00, 0x38, 0x03, 0x8C, 0x00, 0xC0, 0x1C, 0x38,
  0x03, 0x00, 0x60, 0x60, 0x1C, 0x01, 0x81, 0xC0, 0x60, 0x06, 0x07, 0x03,
  0x80, 0x38, 0x1C, 0x0C, 0x00, 0xE0, 0x30, 0x30, 0x03, 0x80, 0xC1, 0xC0,
  0x0E, 0x03, 0x06, 0x00, 0x38, 0x0C, 0x38, 0x00, 0xE0, 0x30, 0xC0, 0x03,
  0x80, 0xC3, 0x00, 0x0E, 0x07, 0x1C, 0x3C, 0x18, 0x1C, 0x63, 0xF8, 0x60,
  0x73, 0x9C, 0x71, 0x81, 0x8C, 0x60, 0xC7, 0x0E, 0x31, 0x83, 0x8E, 0x31,
  0xCE, 0x06, 0x1F, 0xC6, 0x30, 0x18, 0x3E, 0x38, 0xC0, 0x60, 0x00, 0xC3,
  0x01, 0x80, 0x03, 0x0C, 0x06, 0x00, 0x1C, 0x30, 0x1C, 0x00, 0x60, 0xC0,
  0x70, 0x03, 0x83, 0x01, 0xC0, 0x0C, 0x0C, 0x06, 0x00, 0x30, 0x30, 0x18,
  0x01, 0xC0, 0xC0, 0x60, 0x06, 0x03, 0x81, 0x80, 0x38, 0x0E, 0x0E, 0x00,
  0xC0, 0x18, 0x38, 0x07, 0x00, 0x71, 0xC0, 0x1C, 0x00, 0xFE, 0x00, 0xE0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0x1C, 0x00, 0x0C,
  0x0E, 0x00, 0x1C, 0x0E, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x1C,
  0x06, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x06, 0x00, 0x1C, 0x0E, 0x00, 0x0C,
  0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x06, 0x38, 0x00, 0x07, 0x78, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1C,
  0x70, 0x00, 0x38, 0x70, 0x1C, 0x70, 0x38, 0x1C, 0x70, 0x1C, 0x1C, 0xE0,
  0x1E, 0x1C, 0xE0, 0x0E, 0x18, 0xE0, 0x07, 0x38, 0xE0, 0x03, 0xB8, 0xE0,
  0x03, 0xF0, 0xE0, 0x01, 0xF0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xF0, 0x70,
  0x03, 0xF0, 0x78, 0x07, 0xB8, 0x3C, 0x1F, 0x1C, 0x1F, 0xFC, 0x1E, 0x0F,
  0xF8, 0x0F, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFB, 0x6D, 0xB6, 0x01, 0xC0,
  0x60, 0x38, 0x1C, 0x06, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x0E, 0x03, 0x80,
  0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xE0, 0x38, 0x07, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x07, 0x00, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x18, 0x06, 0x01, 0x80, 0x60, 0x1C, 0x06, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x38, 0x0E, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x06, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0C, 0x02, 0x06,
  0x0B, 0xE3, 0x3F, 0xFF, 0xFF, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0xD8, 0x00,
  0xEE, 0x00, 0xE3, 0x80, 0x70, 0xC0, 0x70, 0x70, 0x70, 0x1C, 0x08, 0x08,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x38, 0xF3, 0x8E, 0x38,
  0xC7, 0x1C, 0x71, 0x8E, 0x30, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x27,
  0xFF, 0x70, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0C,
  0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x18, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60, 0x00,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3E, 0xF8, 0x0E, 0x03, 0x81,
  0xC0, 0x70, 0x70, 0x07, 0x0E, 0x00, 0xE3, 0x80, 0x0C, 0x70, 0x01, 0xCE,
  0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE6, 0x00, 0x1C, 0xC0, 0x01, 0xB8,
  0x00, 0x37, 0x00, 0x06, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xB8, 0x00, 0x33, 0x00, 0x06, 0x70,
  0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x1C, 0x70,
  0x07, 0x0E, 0x00, 0xE1, 0xE0, 0x18, 0x1C, 0x07, 0x01, 0xE3, 0xC0, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0x00, 0xC0, 0x70, 0x7C, 0x3F, 0x1E, 0xCF, 0x37,
  0x8F, 0x83, 0x40, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x07, 0xF8, 0x0F, 0xFF, 0x07, 0xE3, 0xE1, 0xC0, 0x3C, 0x20, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x30, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xF8,
  0x0F, 0xFF, 0x07, 0xE3, 0xF3, 0xC0, 0x1C, 0x40, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x0F, 0xF8,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0E, 0x80, 0x07,
  0xBC, 0x07, 0xCF, 0xFF, 0xE0, 0xFF, 0xE0, 0x01, 0x00, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x0D, 0xC0, 0x00, 0xEE, 0x00, 0x06, 0x70, 0x00, 0x73, 0x80, 0x03, 0x1C,
  0x00, 0x38, 0xE0, 0x03, 0x87, 0x00, 0x18, 0x38, 0x01, 0xC1, 0xC0, 0x0C,
  0x0E, 0x00, 0xE0, 0x70, 0x06, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0,
  0x38, 0x07, 0x03, 0x80, 0x38, 0x1C, 0x01, 0xC1, 0xC0, 0x0E, 0x0C, 0x00,
  0x70, 0xE0, 0x03, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0x1F,
  0xFF, 0xC7, 0xFF, 0xF1, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x00,
  0x60, 0x00, 0x38, 0x00, 0x0E, 0x1C, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x18,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x60, 0x00, 0x18, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x80, 0x0E, 0x38,
  0x0F, 0x0F, 0xFF, 0x81, 0xFF, 0xC0, 0x02, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0xFF, 0xC0, 0x7C, 0x30, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x18, 0x00, 0x06, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x3F, 0x83, 0x1F, 0xF0, 0xCE, 0x1E, 0x36,
  0x01, 0xCF, 0x00, 0x7B, 0x80, 0x0E, 0xE0, 0x03, 0xB8, 0x00, 0x6E, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0x98, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x1C, 0x38, 0x07, 0x07,
  0x07, 0x81, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x60, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x18, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x03,
  0xF8, 0x01, 0xFF, 0xC0, 0x7C, 0x7C, 0x1E, 0x03, 0xC3, 0x80, 0x38, 0xE0,
  0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0,
  0x07, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0x38, 0x0E, 0x03, 0x83, 0x80, 0x3D,
  0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xF0, 0x07, 0x0F, 0x01, 0xC0,
  0xF0, 0x70, 0x07, 0x1C, 0x00, 0xF3, 0x80, 0x0E, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x73, 0x80, 0x0E, 0x78, 0x03, 0x87, 0x81, 0xF0, 0x7F, 0xFC, 0x03, 0xFE,
  0x00, 0x04, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xF3, 0xE0, 0xF0, 0x3C,
  0x38, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x39, 0x80, 0x06, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x1D, 0x80, 0x07, 0x70, 0x01, 0xDC, 0x00, 0xF3, 0x80, 0x6C, 0xF0, 0x37,
  0x1F, 0xFD, 0xC3, 0xFC, 0x70, 0x08, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x60, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x08, 0x1E, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x06, 0x00, 0x00, 0x7F, 0xFF, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x27, 0xFF, 0x70, 0x38, 0xE7, 0xCE, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x8E, 0x38,
  0xE7, 0x1C, 0x71, 0x86, 0x38, 0xC3, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0x40,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x18, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x01, 0x00, 0x00, 0x00,
  0x1F, 0xC3, 0xFF, 0xCF, 0x8F, 0x90, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0x0E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x03, 0x80, 0x38, 0x00,
  0x07, 0x00, 0xC0, 0x00, 0x0E, 0x07, 0x00, 0x00, 0x18, 0x38, 0x00, 0x00,
  0x70, 0xE0, 0x00, 0x00, 0xC7, 0x00, 0x3E, 0x03, 0x9C, 0x03, 0xFE, 0x06,
  0x60, 0x3C, 0x38, 0x19, 0x80, 0xE0, 0xE0, 0x6E, 0x07, 0x03, 0x81, 0xF8,
  0x18, 0x0E, 0x07, 0xC0, 0xE0, 0x38, 0x1F, 0x03, 0x80, 0xE0, 0x7C, 0x0C,
  0x03, 0x81, 0xF0, 0x30, 0x0E, 0x07, 0xC0, 0xC0, 0x30, 0x1F, 0x03, 0x00,
  0xC0, 0x7C, 0x0C, 0x03, 0x01, 0xF0, 0x30, 0x0C, 0x06, 0xC0, 0xC0, 0x70,
  0x1B, 0x03, 0x81, 0xC0, 0xEC, 0x0E, 0x05, 0x83, 0x38, 0x1C, 0x36, 0x1C,
  0xE0, 0x3F, 0x8F, 0xE1, 0x80, 0x7C, 0x3F, 0x06, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x70, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x6E, 0x00, 0x00, 0x6E, 0x00, 0x00, 0xE6, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0xC7, 0x00, 0x00, 0xC7, 0x00, 0x01, 0xC3, 0x00, 0x01, 0xC3,
  0x80, 0x01, 0x83, 0x80, 0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x03, 0x81,
  0xC0, 0x03, 0x01, 0xC0, 0x07, 0x00, 0xC0, 0x07, 0x00, 0xE0, 0x06, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x1C, 0x00, 0x70, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x00,
  0x38, 0x38, 0x00, 0x18, 0x38, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0x70, 0x00,
  0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00,
  0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x07, 0xCE, 0x00,
  0x39, 0xC0, 0x03, 0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00,
  0x3B, 0x80, 0x07, 0x70, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x07, 0x38, 0x00,
  0xE7, 0x00, 0x78, 0xFF, 0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x70, 0x03,
  0xCE, 0x00, 0x3D, 0xC0, 0x03, 0xB8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x07, 0x9C, 0x0F, 0xE3, 0xFF, 0xF8,
  0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x07, 0xF3, 0xF0, 0xF8,
  0x02, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x06, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x08, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xC0, 0x1F, 0x0E, 0x00,
  0x3C, 0x70, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0x77,
  0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0,
  0x00, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x07, 0x1C, 0x00, 0x78,
  0xE0, 0x0F, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0xF8, 0x0F, 0xE1, 0xF8, 0x3C, 0x00, 0x60, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0D, 0xC0, 0x00,
  0x1B, 0x80, 0x00, 0x33, 0x80, 0x00, 0x67, 0x00, 0x00, 0xC7, 0x00, 0x01,
  0x8F, 0x00, 0x03, 0x0F, 0x00, 0x06, 0x0F, 0xC0, 0x7C, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x00, 0x60, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x70, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x3F, 0xFF, 0xF0, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0xEC, 0xFB, 0xFC, 0xFE, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x3B,
  0x80, 0x0E, 0x70, 0x03, 0xCE, 0x00, 0x71, 0xC0, 0x1C, 0x38, 0x07, 0x87,
  0x00, 0xE0, 0xE0, 0x38, 0x1C, 0x0F, 0x03, 0x81, 0xC0, 0x70, 0x70, 0x0E,
  0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x07, 0x38, 0x00, 0xE7, 0x80, 0x1D,
  0xF0, 0x03, 0xFF, 0x00, 0x7C, 0xE0, 0x0F, 0x0E, 0x01, 0xC1, 0xC0, 0x38,
  0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x1C, 0x07, 0x83, 0x80, 0x70, 0x70,
  0x0F, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x01, 0xC7, 0x00, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0xF0, 0x00, 0x70, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xB0, 0x00, 0x06, 0xFD, 0xC0, 0x00, 0x77, 0xEE, 0x00,
  0x03, 0xBF, 0x30, 0x00, 0x19, 0xF9, 0xC0, 0x00, 0xCF, 0xCE, 0x00, 0x0E,
  0x7E, 0x70, 0x00, 0x63, 0xF1, 0x80, 0x03, 0x1F, 0x8E, 0x00, 0x38, 0xFC,
  0x70, 0x01, 0x87, 0xE1, 0x80, 0x0C, 0x3F, 0x0E, 0x00, 0xE1, 0xF8, 0x70,
  0x07, 0x0F, 0xC1, 0x80, 0x30, 0x7E, 0x0E, 0x03, 0x83, 0xF0, 0x70, 0x1C,
  0x1F, 0x81, 0x80, 0xC0, 0xFC, 0x0E, 0x0E, 0x07, 0xE0, 0x70, 0x70, 0x3F,
  0x01, 0x83, 0x01, 0xF8, 0x0E, 0x38, 0x0F, 0xC0, 0x71, 0xC0, 0x7E, 0x01,
  0x8C, 0x03, 0xF0, 0x0E, 0xE0, 0x1F, 0x80, 0x77, 0x00, 0xFC, 0x01, 0xB0,
  0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xC0, 0x0F,
  0xC0, 0x0E, 0x00, 0x70, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7E, 0xE0, 0x01, 0xFB,
  0x80, 0x07, 0xE7, 0x00, 0x1F, 0x9C, 0x00, 0x7E, 0x38, 0x01, 0xF8, 0xE0,
  0x07, 0xE1, 0xC0, 0x1F, 0x87, 0x00, 0x7E, 0x0E, 0x01, 0xF8, 0x38, 0x07,
  0xE0, 0x70, 0x1F, 0x81, 0xC0, 0x7E, 0x03, 0x81, 0xF8, 0x0E, 0x07, 0xE0,
  0x1C, 0x1F, 0x80, 0x70, 0x7E, 0x00, 0xE1, 0xF8, 0x03, 0x87, 0xE0, 0x07,
  0x1F, 0x80, 0x1C, 0x7E, 0x00, 0x39, 0xF8, 0x00, 0xE7, 0xE0, 0x01, 0xDF,
  0x80, 0x07, 0x7E, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xE7, 0xE0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x81,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0xFF, 0xC0,
  0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x07, 0x38, 0x01, 0xEE,
  0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x01, 0xB8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xB8, 0x00, 0xEE, 0x00, 0x3B, 0x80, 0x0E, 0xE0, 0x07,
  0x38, 0x03, 0xCE, 0x03, 0xE3, 0xFF, 0xF0, 0xFF, 0xF0, 0x38, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x07, 0xE7, 0xF0, 0x0F, 0x00, 0xF0, 0x1E, 0x00, 0x38, 0x3C, 0x00,
  0x3C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00,
  0x0E, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0x38, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x1C, 0x00, 0x38, 0x0E, 0x00, 0x78, 0x0F, 0x81,
  0xF0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x17, 0x80, 0x00, 0x03,
  0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3C, 0xFF, 0x80,
  0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x70, 0x0F, 0x8E, 0x00, 0x71, 0xC0, 0x07,
  0x38, 0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07,
  0x70, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x00, 0x38,
  0xE0, 0x0F, 0x1C, 0x03, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFF, 0x01,
  0xC0, 0xE0, 0x38, 0x0C, 0x07, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x03, 0x83,
  0x80, 0x70, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xC0, 0x0E, 0x38, 0x01, 0xC7,
  0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x00, 0x70,
  0x03, 0xFE, 0x03, 0xFF, 0xF1, 0xF9, 0xF8, 0xF0, 0x06, 0x78, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E,
  0x80, 0x07, 0x3C, 0x07, 0xCF, 0xFF, 0xE1, 0xFF, 0xE0, 0x01, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x6E, 0x00, 0x07, 0x70, 0x00,
  0x39, 0xC0, 0x01, 0xCE, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xF0, 0x3E, 0x03,
  0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x06, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1D, 0x80, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01, 0xCE, 0x00,
  0x03, 0x0E, 0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x38, 0x00, 0x38, 0x30, 0x00,
  0xE0, 0x70, 0x01, 0xC0, 0xE0, 0x03, 0x81, 0xC0, 0x06, 0x01, 0x80, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x0E, 0x03, 0x80,
  0x1C, 0x07, 0x00, 0x38, 0x0E, 0x00, 0x30, 0x38, 0x00, 0x70, 0x70, 0x00,
  0xE0, 0xE0, 0x01, 0xC1, 0x80, 0x01, 0x87, 0x00, 0x03, 0x8E, 0x00, 0x07,
  0x1C, 0x00, 0x0E, 0x30, 0x00, 0x0C, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B,
  0x00, 0x00, 0x36, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3B, 0x80, 0x03, 0x80,
  0x01, 0xDC, 0x00, 0x1C, 0x00, 0x0C, 0xE0, 0x00, 0xF0, 0x00, 0xE7, 0x00,
  0x0F, 0x80, 0x07, 0x1C, 0x00, 0x6C, 0x00, 0x38, 0xE0, 0x03, 0x60, 0x01,
  0xC7, 0x00, 0x1B, 0x80, 0x1C, 0x38, 0x01, 0xDC, 0x00, 0xE0, 0xC0, 0x0E,
  0x60, 0x07, 0x07, 0x00, 0x73, 0x00, 0x38, 0x38, 0x03, 0x1C, 0x03, 0x81,
  0xC0, 0x18, 0xE0, 0x1C, 0x0E, 0x01, 0xC7, 0x00, 0xE0, 0x38, 0x0E, 0x18,
  0x07, 0x01, 0xC0, 0x60, 0xC0, 0x30, 0x0E, 0x03, 0x07, 0x03, 0x80, 0x70,
  0x38, 0x38, 0x1C, 0x01, 0x81, 0xC0, 0xC0, 0xE0, 0x0E, 0x0E, 0x06, 0x07,
  0x00, 0x70, 0x60, 0x38, 0x70, 0x03, 0x83, 0x01, 0xC3, 0x80, 0x0C, 0x38,
  0x0E, 0x1C, 0x00, 0x71, 0xC0, 0x30, 0xE0, 0x03, 0x8C, 0x01, 0x86, 0x00,
  0x1C, 0x60, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x03, 0x38, 0x01,
  0x9C, 0x00, 0x1D, 0xC0, 0x0C, 0xC0, 0x00, 0xEC, 0x00, 0x6E, 0x00, 0x07,
  0x60, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x70, 0x00, 0x71, 0xC0, 0x03, 0x8E, 0x00, 0x38, 0x38,
  0x01, 0xC1, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x00, 0xE0, 0x70,
  0x07, 0x03, 0x80, 0x18, 0x38, 0x00, 0xE1, 0xC0, 0x07, 0x1C, 0x00, 0x1C,
  0xE0, 0x00, 0xEE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0x80, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0xC0, 0x00, 0xEE,
  0x00, 0x07, 0x38, 0x00, 0x71, 0xC0, 0x03, 0x87, 0x00, 0x38, 0x38, 0x01,
  0xC0, 0xC0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x00, 0xE0, 0x70, 0x07,
  0x07, 0x00, 0x1C, 0x38, 0x00, 0xE3, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xC0,
  0x00, 0xF0, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x70, 0x00, 0x77, 0x00, 0x0E,
  0x38, 0x00, 0xE3, 0x80, 0x1C, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x07, 0x00, 0xE0, 0x70, 0x07, 0x07, 0x00, 0x70,
  0xE0, 0x03, 0x8E, 0x00, 0x38, 0xC0, 0x03, 0x9C, 0x00, 0x1D, 0x80, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x7F, 0xFF, 0xDF, 0xFF,
  0xF7, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x38, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF, 0x00, 0x30, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0D, 0xC0, 0x00, 0xE6, 0x00, 0x06,
  0x38, 0x00, 0x70, 0xC0, 0x03, 0x07, 0x00, 0x38, 0x38, 0x01, 0x80, 0xE0,
  0x1C, 0x07, 0x00, 0xC0, 0x1C, 0x0E, 0x00, 0xE0, 0x60, 0x03, 0x87, 0x00,
  0x1C, 0x30, 0x00, 0x73, 0x80, 0x03, 0x98, 0x00, 0x0F, 0xC0, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF0, 0x38, 0x0E, 0x03,
  0x80, 0xC0, 0x70, 0x1C, 0x03, 0x07, 0xF0, 0x1F, 0xFC, 0x3E, 0x3E, 0x10,
  0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x3F, 0x07, 0xFF, 0x1F, 0xF7, 0x3C, 0x07, 0x78,
  0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0x70, 0x1B, 0x78, 0x3B, 0x3F, 0xF3, 0x1F, 0xE3, 0x02,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00,
  0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C,
  0x00, 0x03, 0x0F, 0xE0, 0xC7, 0xFC, 0x33, 0xCF, 0x8D, 0x80, 0xF3, 0x40,
  0x1E, 0xF0, 0x03, 0xB8, 0x00, 0xEE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x0E, 0xF0, 0x03, 0xBC, 0x01, 0xED, 0x80, 0x73, 0x70, 0x78, 0xCF, 0xFE,
  0x31, 0xFE, 0x00, 0x04, 0x00, 0x01, 0xFC, 0x07, 0xFF, 0x0F, 0xCE, 0x1E,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x1F, 0x02, 0x0F, 0xFE, 0x03, 0xFE, 0x00,
  0x60, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x81, 0xF8, 0x70, 0xFF, 0xCE, 0x3E, 0x3D, 0xC7, 0x01,
  0xF9, 0xC0, 0x1F, 0x38, 0x01, 0xEE, 0x00, 0x3D, 0xC0, 0x07, 0xB8, 0x00,
  0x77, 0x00, 0x0E, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x76, 0x00, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x0F, 0x70, 0x01, 0xE7, 0x00, 0x7C, 0xF0, 0x0F,
  0x8F, 0x07, 0x70, 0xFF, 0xC6, 0x0F, 0xF0, 0xC0, 0x30, 0x00, 0x03, 0xF8,
  0x01, 0xFF, 0x00, 0xF1, 0xE0, 0x70, 0x1C, 0x38, 0x03, 0x0E, 0x00, 0xE7,
  0x00, 0x19, 0xC0, 0x06, 0x70, 0x01, 0xD8, 0x00, 0x76, 0x00, 0x1D, 0x80,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0x80, 0x00, 0x60, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x02, 0x1F, 0x03, 0x83, 0xFF, 0xE0, 0x3F, 0xF0, 0x00,
  0x80, 0x03, 0xF8, 0x3F, 0xC3, 0xC2, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x7F, 0xCF, 0xFE, 0x7F, 0xF0,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x03, 0xF0, 0x61, 0xFF, 0x9C, 0x7E, 0x7B, 0x8E, 0x03,
  0xF3, 0x80, 0x3E, 0x70, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x07, 0x70, 0x00,
  0xEC, 0x00, 0x1D, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00, 0xF9, 0xE0, 0x1F,
  0x1E, 0x0E, 0xE1, 0xFF, 0x9C, 0x1F, 0xE3, 0x80, 0x40, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x10, 0x03, 0xC3, 0xF3, 0xF0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00,
  0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x7F, 0x0C, 0x7F, 0xC6, 0x79, 0xF3, 0x60, 0x3D, 0xA0, 0x0E, 0xF0, 0x07,
  0x70, 0x01, 0xB8, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1C, 0x27, 0xFF, 0x60,
  0x00, 0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77, 0x77,
  0x77, 0x77, 0x77, 0x70, 0x02, 0x07, 0x0F, 0x0F, 0x06, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06, 0x06,
  0x0E, 0x0E, 0xBE, 0xFC, 0xF8, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0,
  0x00, 0xC0, 0x00, 0xC0, 0x0E, 0xC0, 0x1C, 0xC0, 0x1C, 0xC0, 0x38, 0xC0,
  0x70, 0xC0, 0x70, 0xC0, 0xE0, 0xC1, 0xC0, 0xC3, 0x80, 0xC3, 0x80, 0xC7,
  0x00, 0xCF, 0x00, 0xCF, 0x00, 0xDB, 0x80, 0xF9, 0x80, 0xF1, 0xC0, 0xE0,
  0xC0, 0xC0, 0xE0, 0xC0, 0x70, 0xC0, 0x70, 0xC0, 0x38, 0xC0, 0x38, 0xC0,
  0x1C, 0xC0, 0x1C, 0xC0, 0x0E, 0xC0, 0x0E, 0xC0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC3, 0xF0, 0x1F, 0x8C, 0xFF,
  0x87, 0xFC, 0xCE, 0x3C, 0xF3, 0xED, 0x81, 0xCC, 0x0F, 0xF0, 0x0F, 0x80,
  0x7F, 0x00, 0xF0, 0x07, 0xE0, 0x07, 0x00, 0x7E, 0x00, 0x70, 0x03, 0xE0,
  0x07, 0x00, 0x3E, 0x00, 0x70, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60,
  0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C,
  0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06,
  0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03,
  0xC0, 0x06, 0x00, 0x3C, 0x00, 0x60, 0x03, 0xC0, 0x06, 0x00, 0x3C, 0x00,
  0x60, 0x03, 0xC0, 0x06, 0x00, 0x30, 0xC3, 0xF8, 0x63, 0xFE, 0x33, 0x8F,
  0x9B, 0x01, 0xED, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x0D, 0xC0, 0x06, 0xE0,
  0x03, 0x70, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x3C, 0x7C, 0x0E,
  0x03, 0xC3, 0x80, 0x38, 0x70, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x07, 0x70,
  0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0xC0,
  0x03, 0xB8, 0x00, 0x77, 0x00, 0x0C, 0x60, 0x03, 0x8E, 0x00, 0x70, 0xE0,
  0x1C, 0x1E, 0x07, 0x01, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x20, 0x00, 0xC3,
  0xF8, 0x31, 0xFF, 0x0C, 0xF1, 0xE3, 0x60, 0x3C, 0xD8, 0x07, 0xBC, 0x00,
  0xEE, 0x00, 0x3B, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xBC, 0x00,
  0xEF, 0x00, 0x7B, 0x60, 0x1C, 0xCC, 0x1E, 0x33, 0xFF, 0x8C, 0x3F, 0x83,
  0x01, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x00, 0x03, 0xF0, 0x61, 0xFF, 0x9C, 0x7C, 0x7B, 0x8E, 0x03,
  0x73, 0x80, 0x3E, 0x70, 0x03, 0xDC, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x00,
  0xEC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xEC, 0x00, 0x1D, 0x80, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x1E, 0xE0, 0x03, 0xCE, 0x00, 0xF9, 0xE0, 0x17,
  0x1E, 0x0E, 0xE1, 0xFF, 0x9C, 0x1F, 0xE3, 0x80, 0x40, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0xC3, 0xF8, 0xFF, 0x3F, 0xEE, 0x0D, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03,
  0x00, 0x00, 0x0F, 0xF0, 0x7F, 0xF9, 0xF0, 0xF3, 0x80, 0x2E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xF0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x30, 0x00, 0x70, 0x00, 0xE0, 0x01, 0x80, 0x07, 0x40, 0x0E, 0xE0,
  0x79, 0xFF, 0xF1, 0xFF, 0x80, 0x10, 0x00, 0x0C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x80, 0x7F, 0x07, 0xE0, 0x30, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00,
  0x76, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x1E, 0xF0, 0x1B, 0x3C, 0x1D, 0x8F,
  0xFC, 0xC3, 0xF8, 0x60, 0x20, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x39, 0xC0,
  0x07, 0x38, 0x00, 0xE7, 0x00, 0x18, 0x60, 0x07, 0x0E, 0x00, 0xE1, 0xC0,
  0x18, 0x38, 0x07, 0x03, 0x00, 0xE0, 0x70, 0x1C, 0x0E, 0x03, 0x00, 0xC0,
  0xE0, 0x1C, 0x1C, 0x03, 0x83, 0x00, 0x70, 0xE0, 0x06, 0x1C, 0x00, 0xE3,
  0x80, 0x1C, 0x60, 0x01, 0x9C, 0x00, 0x33, 0x80, 0x07, 0x60, 0x00, 0xEC,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xC0,
  0x07, 0x00, 0x3F, 0x00, 0x38, 0x01, 0xF8, 0x03, 0xC0, 0x0F, 0xC0, 0x1F,
  0x00, 0x66, 0x00, 0xD8, 0x07, 0x30, 0x06, 0xC0, 0x39, 0xC0, 0x76, 0x01,
  0xCE, 0x03, 0xB8, 0x0C, 0x70, 0x19, 0xC0, 0xE1, 0x80, 0xC6, 0x07, 0x0E,
  0x0E, 0x30, 0x38, 0x70, 0x71, 0xC1, 0x83, 0x83, 0x0E, 0x0C, 0x0C, 0x18,
  0x30, 0xE0, 0x71, 0xC1, 0x87, 0x03, 0x8E, 0x0E, 0x30, 0x1C, 0x60, 0x71,
  0x80, 0x63, 0x01, 0x9C, 0x03, 0x38, 0x0C, 0xE0, 0x1D, 0xC0, 0x67, 0x00,
  0xEE, 0x03, 0xB0, 0x03, 0x60, 0x1D, 0x80, 0x1B, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xE0, 0x07, 0xC0, 0x1E, 0x00, 0x3C, 0x00, 0xF0, 0x00, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x70, 0xE0, 0x1C, 0x38, 0x0E,
  0x07, 0x03, 0x80, 0xC1, 0xC0, 0x38, 0x70, 0x06, 0x38, 0x01, 0xCE, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F,
  0xC0, 0x07, 0x70, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x38, 0x70, 0x1C, 0x1C,
  0x07, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x1C, 0x70, 0x07, 0x1C, 0x00, 0xEE,
  0x00, 0x3C, 0xE0, 0x00, 0xEE, 0x00, 0x19, 0xC0, 0x07, 0x38, 0x00, 0xE3,
  0x00, 0x1C, 0x70, 0x03, 0x0E, 0x00, 0xE0, 0xC0, 0x1C, 0x1C, 0x03, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x60, 0x1C, 0x1C, 0x01,
  0x83, 0x80, 0x38, 0x60, 0x07, 0x1C, 0x00, 0x63, 0x80, 0x0C, 0x70, 0x01,
  0xCC, 0x00, 0x3B, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x0D, 0xF0, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x18, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1C, 0x03, 0xF0, 0x1F,
  0xC0, 0xF0, 0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xE0, 0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0xF8, 0x0F, 0xC0, 0x3C, 0x00, 0x3F, 0x80, 0x3F, 0xFC, 0x07, 0x87,
  0xF7, 0xC0, 0x3F, 0xE8, 0x00, 0xF8,
};

const GFXglyph NotoSans_Condensed_Light50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 4, 36, 11, 4, -36 },
  { 19, 11, 13, 17, 3, -36 },
  { 37, 23, 36, 25, 1, -36 },
  { 141, 19, 41, 23, 2, -38 },
  { 239, 30, 36, 34, 2, -36 },
  { 374, 24, 37, 26, 2, -36 },
  { 485, 3, 13, 9, 3, -36 },
  { 490, 10, 44, 14, 2, -36 },
  { 545, 10, 44, 14, 2, -36 },
  { 600, 17, 17, 21, 2, -38 },
  { 637, 19, 23, 23, 2, -29 },
  { 692, 6, 13, 10, 2, -6 },
  { 702, 11, 3, 14, 2, -15 },
  { 707, 4, 5, 11, 3, -5 },
  { 710, 16, 36, 17, 1, -36 },
  { 782, 19, 36, 23, 2, -36 },
  { 868, 10, 36, 23, 4, -36 },
  { 913, 18, 36, 23, 2, -36 },
  { 994, 18, 37, 23, 2, -36 },
  { 1078, 21, 36, 23, 1, -36 },
  { 1173, 18, 37, 23, 3, -36 },
  { 1257, 18, 37, 23, 3, -36 },
  { 1341, 19, 36, 23, 2, -36 },
  { 1427, 19, 37, 23, 2, -36 },
  { 1515, 18, 37, 23, 2, -36 },
  { 1599, 4, 27, 11, 3, -27 },
  { 1613, 6, 34, 11, 2, -27 },
  { 1639, 19, 22, 23, 2, -29 },
  { 1692, 19, 13, 23, 2, -24 },
  { 1723, 19, 22, 23, 2, -29 },
  { 1776, 14, 36, 17, 1, -36 },
  { 1839, 30, 41, 35, 3, -36 },
  { 1993, 24, 36, 24, 0, -36 },
  { 2101, 19, 36, 25, 4, -36 },
  { 2187, 20, 37, 24, 3, -36 },
  { 2280, 21, 36, 28, 4, -36 },
  { 2375, 15, 36, 22, 4, -36 },
  { 2443, 16, 36, 20, 4, -36 },
  { 2515, 23, 37, 30, 3, -36 },
  { 2622, 21, 36, 29, 4, -36 },
  { 2717, 9, 36, 13, 2, -36 },
  { 2758, 10, 45, 11, -3, -36 },
  { 2815, 19, 36, 23, 4, -36 },
  { 2901, 15, 36, 20, 4, -36 },
  { 2969, 29, 36, 37, 4, -36 },
  { 3100, 22, 36, 30, 4, -36 },
  { 3199, 24, 37, 30, 3, -36 },
  { 3310, 18, 36, 24, 4, -36 },
  { 3391, 24, 45, 30, 3, -36 },
  { 3526, 19, 36, 24, 4, -36 },
  { 3612, 18, 37, 22, 2, -36 },
  { 3696, 20, 36, 21, 0, -36 },
  { 3786, 21, 37, 28, 4, -36 },
  { 3884, 23, 36, 23, 0, -36 },
  { 3988, 37, 36, 37, 0, -36 },
  { 4155, 21, 36, 21, 0, -36 },
  { 4250, 20, 36, 20, 0, -36 },
  { 4340, 18, 36, 21, 1, -36 },
  { 4421, 10, 44, 16, 4, -36 },
  { 4476, 16, 36, 17, 1, -36 },
  { 4548, 10, 44, 16, 2, -36 },
  { 4603, 21, 20, 23, 1, -36 },
  { 4656, 21, 3, 21, 0, 4 },
  { 4664, 9, 8, 13, 2, -38 },
  { 4673, 16, 28, 22, 2, -27 },
  { 4729, 18, 39, 25, 4, -38 },
  { 4817, 16, 28, 19, 2, -27 },
  { 4873, 19, 39, 25, 2, -38 },
  { 4966, 18, 28, 22, 2, -27 },
  { 5029, 13, 38, 13, 1, -38 },
  { 5091, 19, 39, 24, 2, -27 },
  { 5184, 17, 38, 24, 4, -38 },
  { 5265, 4, 37, 10, 3, -37 },
  { 5284, 8, 49, 10, -1, -37 },
  { 5333, 16, 38, 20, 4, -38 },
  { 5409, 2, 38, 10, 4, -38 },
  { 5419, 28, 27, 36, 4, -27 },
  { 5514, 17, 27, 24, 4, -27 },
  { 5572, 19, 28, 24, 2, -27 },
  { 5639, 18, 39, 24, 4, -27 },
  { 5727, 19, 39, 24, 2, -27 },
  { 5820, 11, 27, 16, 4, -27 },
  { 5858, 15, 28, 18, 2, -27 },
  { 5911, 11, 34, 13, 1, -33 },
  { 5958, 17, 28, 24, 3, -27 },
  { 6018, 19, 27, 19, 0, -27 },
  { 6083, 29, 27, 31, 1, -27 },
  { 6181, 18, 27, 20, 1, -27 },
  { 6242, 19, 39, 19, 0, -27 },
  { 6335, 13, 27, 17, 2, -27 },
  { 6379, 14, 44, 18, 2, -36 },
  { 6456, 2, 50, 22, 10, -38 },
  { 6469, 14, 44, 18, 2, -36 },
  { 6546, 19, 5, 23, 2, -20 },
};

const GFXfont NotoSans_Condensed_Light50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light50pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_CONDENSED_LIGHT50PT7B_H_
