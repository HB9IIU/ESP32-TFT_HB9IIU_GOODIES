#ifndef _NOTOSANS_CONDENSED_LIGHT61PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDE, 0xF7, 0xBD, 0xEF, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0xC6, 0x30, 0x00, 0x00,
  0x00, 0x8F, 0xFF, 0xFE, 0xF2, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xF0, 0x1D, 0x80, 0xEC, 0x07, 0x00, 0x18, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00, 0x03, 0x80, 0x70, 0x00, 0x38,
  0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x38, 0x06, 0x00, 0x03, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07,
  0x00, 0xE0, 0x00, 0x70, 0x0C, 0x03, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x00, 0x0E, 0x01, 0xC0, 0x00,
  0xE0, 0x1C, 0x00, 0x0E, 0x01, 0x80, 0x00, 0xE0, 0x18, 0x00, 0x0C, 0x03,
  0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00,
  0x1C, 0x03, 0x80, 0x01, 0xC0, 0x30, 0x00, 0x1C, 0x03, 0x00, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0x03, 0x80, 0x70, 0x00, 0x38, 0x07, 0x00,
  0x03, 0x80, 0x70, 0x00, 0x38, 0x06, 0x00, 0x03, 0x80, 0x60, 0x00, 0x30,
  0x0E, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xE0,
  0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xC0, 0x00, 0x70, 0x0C, 0x00, 0x06,
  0x01, 0xC0, 0x00, 0x60, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x1C, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFF, 0x8F, 0x9C, 0x3C, 0x78, 0x70, 0x11, 0xC1, 0xC0, 0x0F, 0x07, 0x00,
  0x38, 0x1C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x0E, 0x07, 0x00, 0x38,
  0x1C, 0x00, 0xE0, 0x70, 0x03, 0xC1, 0xC0, 0x07, 0x07, 0x00, 0x1E, 0x1C,
  0x00, 0x3E, 0x70, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0x7E, 0x00, 0x1C, 0x7C, 0x00,
  0x70, 0xF8, 0x01, 0xC1, 0xE0, 0x07, 0x03, 0xC0, 0x1C, 0x07, 0x00, 0x70,
  0x1C, 0x01, 0xC0, 0x70, 0x07, 0x01, 0xC0, 0x1C, 0x07, 0x00, 0x70, 0x3C,
  0x01, 0xC0, 0xE0, 0x07, 0x07, 0xB0, 0x1C, 0x3C, 0xFC, 0x73, 0xE3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x70, 0x03, 0xFC, 0x00, 0x0C, 0x00, 0xF3, 0xC0, 0x03,
  0x80, 0x1C, 0x38, 0x00, 0x70, 0x07, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x70,
  0x03, 0x80, 0x38, 0x06, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x1C, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x1C, 0x03, 0x80, 0xE0, 0x03, 0x80, 0x70, 0x1C, 0x00,
  0x70, 0x0E, 0x07, 0x00, 0x0E, 0x01, 0xC0, 0xE0, 0x01, 0xC0, 0x38, 0x1C,
  0x00, 0x38, 0x07, 0x07, 0x00, 0x07, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0x1C,
  0x38, 0x00, 0x1C, 0x03, 0x87, 0x07, 0x83, 0x80, 0x70, 0xE1, 0xFC, 0x70,
  0x0E, 0x38, 0x7F, 0xCE, 0x03, 0x87, 0x1C, 0x3C, 0xE0, 0x71, 0xC3, 0x83,
  0x9C, 0x0E, 0x38, 0xE0, 0x71, 0xC3, 0x87, 0x1C, 0x07, 0x3F, 0xF1, 0xC3,
  0x80, 0xE3, 0xFC, 0x38, 0xE0, 0x1C, 0x3F, 0x0E, 0x1C, 0x03, 0x80, 0x01,
  0xC3, 0x80, 0x70, 0x00, 0x38, 0x70, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0xC0,
  0x01, 0xC1, 0xC0, 0x18, 0x00, 0x70, 0x38, 0x03, 0x00, 0x0E, 0x07, 0x00,
  0x60, 0x01, 0xC0, 0xE0, 0x1C, 0x00, 0x70, 0x1C, 0x03, 0x80, 0x0E, 0x03,
  0x80, 0x70, 0x03, 0x80, 0x30, 0x0E, 0x00, 0x70, 0x07, 0x01, 0xC0, 0x0E,
  0x00, 0xE0, 0x38, 0x03, 0x80, 0x1C, 0x0E, 0x00, 0x70, 0x01, 0xC1, 0xC0,
  0x1C, 0x00, 0x3C, 0x70, 0x03, 0x80, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x07, 0x80, 0x00, 0x70, 0x1E, 0x00, 0x07,
  0x80, 0x70, 0x00, 0x38, 0x03, 0x80, 0x01, 0xC0, 0x1C, 0x00, 0x0E, 0x00,
  0xE0, 0x00, 0x70, 0x07, 0x00, 0x03, 0x80, 0x38, 0x00, 0x1C, 0x01, 0xC0,
  0x00, 0xF0, 0x0E, 0x00, 0x03, 0x80, 0xE0, 0x00, 0x1C, 0x07, 0x00, 0x00,
  0x70, 0x78, 0x00, 0x03, 0xC7, 0x80, 0x00, 0x0E, 0x78, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF3, 0x80, 0x00, 0x1E, 0x1E, 0x00, 0xF0,
  0xE0, 0x78, 0x07, 0x0F, 0x01, 0xE0, 0x38, 0xF0, 0x0F, 0x01, 0xC7, 0x80,
  0x3C, 0x0E, 0x38, 0x00, 0xF0, 0xF1, 0xC0, 0x03, 0x87, 0x1E, 0x00, 0x1E,
  0x78, 0xF0, 0x00, 0x7B, 0xC7, 0x80, 0x01, 0xFC, 0x3C, 0x00, 0x0F, 0xE0,
  0xE0, 0x00, 0x3E, 0x07, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x0F, 0x81, 0xE0,
  0x00, 0xFE, 0x07, 0x80, 0x0F, 0x78, 0x3E, 0x01, 0xF1, 0xE0, 0xFE, 0xFF,
  0x0F, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0xFE, 0x00, 0xF0, 0x07, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xEE, 0xEE, 0x66, 0x00, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0,
  0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x07, 0x00,
  0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x78, 0x07, 0x80, 0x38, 0x03, 0xC0,
  0x3C, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0,
  0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03, 0x80, 0x38,
  0x03, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x38,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0xC0, 0x60, 0x3F, 0x86, 0x1F, 0xFF,
  0x6F, 0xF3, 0xFF, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00,
  0x39, 0xC0, 0x07, 0x1E, 0x00, 0xF0, 0xE0, 0x0E, 0x07, 0x01, 0xE0, 0x78,
  0x3C, 0x03, 0x80, 0x80, 0x30, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x1E, 0x3C, 0x78, 0xF1,
  0xC7, 0x8F, 0x1E, 0x38, 0x71, 0xE3, 0x87, 0x0C, 0x38, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x23, 0xFF, 0xFF, 0xBC, 0x80, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x80,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x7F, 0xF8, 0x03, 0xE0, 0xF0, 0x1E, 0x01, 0xE0, 0x70, 0x03, 0x83, 0xC0,
  0x0F, 0x0E, 0x00, 0x1C, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x00, 0x03,
  0x9C, 0x00, 0x0E, 0x70, 0x00, 0x3B, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0E, 0x70, 0x00,
  0x39, 0xC0, 0x00, 0xE7, 0x80, 0x03, 0x9E, 0x00, 0x1E, 0x38, 0x00, 0x70,
  0xF0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x0F, 0x03, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x20, 0x00, 0x00, 0x38,
  0x07, 0xC0, 0x7E, 0x07, 0xF0, 0x7F, 0x87, 0xBC, 0x79, 0xE7, 0x8F, 0xF8,
  0x7F, 0x83, 0xD8, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xFC,
  0x00, 0x7F, 0xFC, 0x03, 0xFF, 0xF8, 0x3F, 0x01, 0xF0, 0x70, 0x01, 0xE0,
  0x80, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFE, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFF, 0x87, 0xF0, 0x1F, 0x87, 0x80,
  0x0F, 0x04, 0x00, 0x0F, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x40, 0x00, 0x7C, 0xF0, 0x01, 0xF1, 0xFE, 0x1F, 0xC3,
  0xFF, 0xFF, 0x00, 0xFF, 0xF8, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x77, 0x80, 0x00, 0x1D, 0xE0, 0x00,
  0x0E, 0x78, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x71, 0xE0,
  0x00, 0x38, 0x78, 0x00, 0x0E, 0x1E, 0x00, 0x07, 0x07, 0x80, 0x01, 0xC1,
  0xE0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x1E, 0x00, 0x1C, 0x07, 0x80, 0x0E,
  0x01, 0xE0, 0x03, 0x80, 0x78, 0x01, 0xC0, 0x1E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xE0, 0x0E, 0x00, 0x78, 0x07, 0x00, 0x1E, 0x03, 0xC0, 0x07,
  0x80, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x1C, 0x00, 0x1E, 0x0F, 0x00,
  0x07, 0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xC0, 0x0F, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x20, 0x00, 0x78, 0xE0, 0x03,
  0xE3, 0xFD, 0xFF, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xC0, 0x00,
  0x00, 0x1F, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0xFC, 0x04, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC1,
  0xFC, 0x0F, 0x1F, 0xFC, 0x3C, 0xFF, 0xF8, 0xF7, 0x81, 0xF3, 0xB8, 0x03,
  0xCE, 0xC0, 0x07, 0xBE, 0x00, 0x0E, 0xF8, 0x00, 0x3B, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x03,
  0xDE, 0x00, 0x0F, 0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0xC0, 0x07, 0x87,
  0x80, 0x3C, 0x1F, 0x01, 0xF0, 0x3F, 0x1F, 0x80, 0x7F, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00,
  0x07, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x70, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x07, 0x87, 0x80, 0x07, 0x8F, 0x00,
  0x0F, 0x1C, 0x00, 0x0E, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x38, 0xE0, 0x00,
  0x71, 0xC0, 0x00, 0xE3, 0x80, 0x01, 0xC7, 0x80, 0x07, 0x87, 0x00, 0x0E,
  0x0F, 0x00, 0x3C, 0x0F, 0x00, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x0F, 0x00,
  0x0F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xE0, 0x03,
  0xE3, 0xE0, 0x0F, 0x81, 0xF0, 0x3C, 0x01, 0xF0, 0x70, 0x01, 0xE1, 0xE0,
  0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x70, 0x00, 0x0F, 0xE0, 0x00, 0x1D, 0xC0, 0x00, 0x3B, 0x80, 0x00,
  0x77, 0x00, 0x00, 0xEF, 0x00, 0x03, 0xCE, 0x00, 0x07, 0x1E, 0x00, 0x1E,
  0x1E, 0x00, 0x78, 0x1F, 0x87, 0xE0, 0x1F, 0xFF, 0x80, 0x1F, 0xFC, 0x00,
  0x01, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF8, 0x07,
  0xC1, 0xF0, 0x3C, 0x01, 0xE1, 0xE0, 0x03, 0x87, 0x00, 0x0F, 0x1C, 0x00,
  0x1C, 0xF0, 0x00, 0x73, 0x80, 0x01, 0xEE, 0x00, 0x03, 0xB8, 0x00, 0x0E,
  0xE0, 0x00, 0x3B, 0x80, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7D, 0xE0, 0x03, 0xF7, 0x80, 0x0F, 0xCF, 0x00, 0xEF, 0x1F, 0x9F, 0xBC,
  0x3F, 0xFC, 0xE0, 0x7F, 0xC3, 0x80, 0x18, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xE3, 0xF8, 0x03, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x77, 0xFF, 0xFF, 0xB8, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x47, 0xFF, 0xFF, 0x78, 0x1C, 0x7C, 0xF9, 0xF3, 0xE3, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x78, 0xF1, 0xE3, 0xC7, 0x1E, 0x3C, 0x70, 0xE1, 0xC7,
  0x0E, 0x1C, 0x30, 0xE0, 0x00, 0x00, 0x03, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFF, 0x0F,
  0xFF, 0xE1, 0xC0, 0x7C, 0x40, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x00,
  0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x0F, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x70, 0x00, 0x00, 0x0E, 0x03,
  0x80, 0x00, 0x00, 0x38, 0x38, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x01, 0x80,
  0x0E, 0x1C, 0x00, 0x7F, 0xE0, 0x38, 0xE0, 0x0F, 0xFF, 0x01, 0xC7, 0x00,
  0xF8, 0x38, 0x0E, 0x70, 0x07, 0x01, 0xC0, 0x3B, 0x80, 0x70, 0x0E, 0x01,
  0xDC, 0x03, 0x80, 0x70, 0x0E, 0xE0, 0x38, 0x03, 0x80, 0x76, 0x01, 0xC0,
  0x1C, 0x03, 0xF0, 0x0E, 0x00, 0xE0, 0x1F, 0x80, 0xE0, 0x07, 0x00, 0xFC,
  0x07, 0x00, 0x38, 0x07, 0xE0, 0x38, 0x01, 0xC0, 0x3F, 0x01, 0xC0, 0x0E,
  0x01, 0xF8, 0x0E, 0x00, 0xF0, 0x0F, 0xC0, 0x70, 0x07, 0x80, 0x7E, 0x03,
  0x80, 0x38, 0x03, 0xF0, 0x1C, 0x01, 0xC0, 0x3B, 0x80, 0x70, 0x0F, 0x01,
  0xDC, 0x03, 0x80, 0xD8, 0x0E, 0x70, 0x1C, 0x06, 0xC0, 0xE3, 0x80, 0xF0,
  0x77, 0x0F, 0x1C, 0x03, 0xEF, 0x3F, 0xF0, 0xE0, 0x0F, 0xF0, 0xFF, 0x07,
  0x80, 0x3F, 0x03, 0xF0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x30, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77,
  0x00, 0x00, 0x07, 0xB8, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xC7, 0x00,
  0x00, 0x0E, 0x38, 0x00, 0x00, 0xE1, 0xE0, 0x00, 0x07, 0x07, 0x00, 0x00,
  0x38, 0x38, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0x1C, 0x0F, 0x00, 0x00, 0xE0,
  0x38, 0x00, 0x07, 0x01, 0xC0, 0x00, 0x78, 0x0F, 0x00, 0x03, 0x80, 0x78,
  0x00, 0x1C, 0x01, 0xC0, 0x01, 0xE0, 0x0E, 0x00, 0x0F, 0x00, 0x78, 0x00,
  0x70, 0x01, 0xC0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x03,
  0xC0, 0x38, 0x00, 0x1E, 0x01, 0xC0, 0x00, 0x70, 0x1E, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x1E, 0x07, 0x00, 0x00, 0x70, 0x78, 0x00, 0x03, 0x83, 0xC0,
  0x00, 0x1E, 0x1C, 0x00, 0x00, 0xF0, 0xE0, 0x00, 0x03, 0x8F, 0x00, 0x00,
  0x1E, 0x78, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x07, 0xBC, 0x00, 0x00, 0x1D,
  0xE0, 0x00, 0x00, 0xF0, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x87, 0x01, 0xFF, 0x8E, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0x38, 0x00, 0x0F,
  0x70, 0x00, 0x1E, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x3B, 0x80, 0x00, 0x77,
  0x00, 0x00, 0xEE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0x70,
  0x00, 0x1C, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0x80, 0x07, 0xC7, 0x00,
  0x3F, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x70, 0x00,
  0xF8, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x77, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0F, 0x70, 0x00, 0x7C, 0xE0,
  0x03, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x00, 0xE0,
  0x3E, 0x00, 0x10, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x01, 0x00, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0xE0, 0x03, 0xF0,
  0x38, 0x00, 0x3E, 0x0E, 0x00, 0x03, 0xC3, 0x80, 0x00, 0xF8, 0xE0, 0x00,
  0x1E, 0x38, 0x00, 0x03, 0xCE, 0x00, 0x00, 0xF3, 0x80, 0x00, 0x1C, 0xE0,
  0x00, 0x07, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00, 0x3B, 0x80, 0x00, 0x0E,
  0xE0, 0x00, 0x03, 0xB8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0E, 0xE0, 0x00, 0x03, 0xB8, 0x00, 0x01, 0xEE, 0x00, 0x00,
  0x7B, 0x80, 0x00, 0x1E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x03, 0xCE, 0x00,
  0x00, 0xF3, 0x80, 0x00, 0x78, 0xE0, 0x00, 0x1E, 0x38, 0x00, 0x0F, 0x0E,
  0x00, 0x07, 0x83, 0x80, 0x07, 0xE0, 0xE0, 0x0F, 0xE0, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF,
  0xFF, 0xF7, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF,
  0xFE, 0xFF, 0xFF, 0xDC, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE,
  0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0x03, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x03, 0xBC, 0x00,
  0x00, 0x1D, 0xE0, 0x00, 0x00, 0xEF, 0x00, 0x00, 0x07, 0x38, 0x00, 0x00,
  0x39, 0xE0, 0x00, 0x01, 0xCF, 0x00, 0x00, 0x0E, 0x3C, 0x00, 0x00, 0x71,
  0xE0, 0x00, 0x03, 0x87, 0x80, 0x00, 0x1C, 0x1E, 0x00, 0x00, 0xE0, 0xFC,
  0x00, 0x07, 0x03, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0F,
  0x00, 0xF8, 0x1E, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7B, 0x80, 0x00, 0xF7, 0x00, 0x03, 0xCE, 0x00, 0x0F, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x78, 0x70, 0x01, 0xE0, 0xE0, 0x07, 0x81, 0xC0, 0x0F,
  0x03, 0x80, 0x3C, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x07, 0x80,
  0x38, 0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0xF0, 0x01, 0xC3, 0xC0, 0x03,
  0x87, 0x00, 0x07, 0x1E, 0x00, 0x0E, 0x7C, 0x00, 0x1C, 0xFC, 0x00, 0x3B,
  0xBC, 0x00, 0x7E, 0x78, 0x00, 0xFC, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xC0,
  0xF0, 0x07, 0x01, 0xE0, 0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x03,
  0xC0, 0x70, 0x03, 0xC0, 0xE0, 0x07, 0x81, 0xC0, 0x07, 0x83, 0x80, 0x0F,
  0x07, 0x00, 0x0F, 0x0E, 0x00, 0x1E, 0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1C,
  0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x7B, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xF0, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFB, 0x80, 0x00, 0x03,
  0xBF, 0x70, 0x00, 0x00, 0x77, 0xEF, 0x00, 0x00, 0x0E, 0xFC, 0xE0, 0x00,
  0x03, 0x9F, 0x9C, 0x00, 0x00, 0x73, 0xF3, 0xC0, 0x00, 0x0E, 0x7E, 0x38,
  0x00, 0x03, 0x8F, 0xC7, 0x00, 0x00, 0x71, 0xF8, 0xF0, 0x00, 0x0E, 0x3F,
  0x0E, 0x00, 0x03, 0x87, 0xE1, 0xC0, 0x00, 0x70, 0xFC, 0x3C, 0x00, 0x0E,
  0x1F, 0x83, 0x80, 0x03, 0x83, 0xF0, 0x70, 0x00, 0x70, 0x7E, 0x0F, 0x00,
  0x0E, 0x0F, 0xC0, 0xE0, 0x03, 0x81, 0xF8, 0x1C, 0x00, 0x70, 0x3F, 0x03,
  0xC0, 0x0E, 0x07, 0xE0, 0x38, 0x03, 0xC0, 0xFC, 0x07, 0x00, 0x70, 0x1F,
  0x80, 0xE0, 0x0E, 0x03, 0xF0, 0x0E, 0x03, 0xC0, 0x7E, 0x01, 0xC0, 0x70,
  0x0F, 0xC0, 0x38, 0x0E, 0x01, 0xF8, 0x07, 0x83, 0xC0, 0x3F, 0x00, 0x70,
  0x70, 0x07, 0xE0, 0x0E, 0x0E, 0x00, 0xFC, 0x01, 0xE3, 0xC0, 0x1F, 0x80,
  0x1C, 0x70, 0x03, 0xF0, 0x03, 0x8E, 0x00, 0x7E, 0x00, 0x7B, 0xC0, 0x0F,
  0xC0, 0x07, 0x70, 0x01, 0xF8, 0x00, 0xEE, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x03, 0xF0, 0x00, 0x70, 0x00, 0x70, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xBC, 0x00, 0x07, 0xEF, 0x00, 0x01,
  0xF9, 0xE0, 0x00, 0x7E, 0x78, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xE3, 0xC0,
  0x01, 0xF8, 0x78, 0x00, 0x7E, 0x1E, 0x00, 0x1F, 0x83, 0xC0, 0x07, 0xE0,
  0xF0, 0x01, 0xF8, 0x1E, 0x00, 0x7E, 0x07, 0x80, 0x1F, 0x80, 0xF0, 0x07,
  0xE0, 0x3C, 0x01, 0xF8, 0x07, 0x80, 0x7E, 0x01, 0xE0, 0x1F, 0x80, 0x3C,
  0x07, 0xE0, 0x0F, 0x01, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x78, 0x1F, 0x80,
  0x0F, 0x07, 0xE0, 0x03, 0xC1, 0xF8, 0x00, 0x78, 0x7E, 0x00, 0x1E, 0x1F,
  0x80, 0x03, 0xC7, 0xE0, 0x00, 0xF1, 0xF8, 0x00, 0x1E, 0x7E, 0x00, 0x03,
  0x9F, 0x80, 0x00, 0xF7, 0xE0, 0x00, 0x1D, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x3E, 0x00, 0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C,
  0x1C, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x8E,
  0x00, 0x00, 0x1E, 0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xDC, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x80,
  0x00, 0x03, 0xDE, 0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00,
  0x01, 0xE3, 0xC0, 0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00,
  0xF0, 0x38, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x03, 0x40, 0x00, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8E, 0x00, 0x3E, 0x70, 0x00, 0xFB, 0x80,
  0x03, 0xDC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xEE,
  0x00, 0x0F, 0x70, 0x01, 0xF3, 0x80, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x07, 0xFF, 0xC0, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0x3C, 0x1C, 0x00, 0x00,
  0xF0, 0xF0, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x07, 0x8E, 0x00, 0x00, 0x1E,
  0x78, 0x00, 0x00, 0x39, 0xE0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDC,
  0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x77, 0x00, 0x00, 0x01, 0xDC, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0x3D, 0xC0, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x03, 0xDE,
  0x00, 0x00, 0x0E, 0x38, 0x00, 0x00, 0x38, 0xE0, 0x00, 0x01, 0xE3, 0xC0,
  0x00, 0x07, 0x87, 0x00, 0x00, 0x3C, 0x1E, 0x00, 0x00, 0xF0, 0x38, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x3E, 0x01, 0xE0, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0E, 0x00, 0x3E, 0x1C, 0x00, 0x3E, 0x38, 0x00, 0x3C, 0x70, 0x00,
  0x3C, 0xE0, 0x00, 0x79, 0xC0, 0x00, 0x73, 0x80, 0x00, 0xE7, 0x00, 0x01,
  0xCE, 0x00, 0x03, 0x9C, 0x00, 0x07, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C,
  0xE0, 0x00, 0x79, 0xC0, 0x00, 0xF3, 0x80, 0x03, 0xC7, 0x00, 0x07, 0x8E,
  0x00, 0x1E, 0x1C, 0x00, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0xFF,
  0xFC, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x00,
  0xF0, 0x1C, 0x01, 0xE0, 0x38, 0x01, 0xE0, 0x70, 0x03, 0xC0, 0xE0, 0x03,
  0xC1, 0xC0, 0x07, 0x83, 0x80, 0x07, 0x87, 0x00, 0x0F, 0x0E, 0x00, 0x0F,
  0x1C, 0x00, 0x1E, 0x38, 0x00, 0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3D,
  0xC0, 0x00, 0x7B, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x01, 0xFF, 0x80,
  0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x3F, 0x01, 0xE3, 0xE0, 0x01, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xD0, 0x00, 0x3E, 0xE0, 0x03, 0xE7, 0xFF, 0xFE, 0x3F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x00, 0x3C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C, 0x00, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xEF, 0x00, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x78, 0x78, 0x00,
  0x3C, 0x1F, 0x00, 0x7C, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xF8, 0x00, 0x01, 0x80, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1C, 0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x3C, 0x3C, 0x00, 0x03,
  0xC3, 0xC0, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x81, 0xE0, 0x00, 0x78, 0x1E,
  0x00, 0x07, 0x80, 0xE0, 0x00, 0x70, 0x0E, 0x00, 0x07, 0x00, 0xF0, 0x00,
  0xF0, 0x0F, 0x00, 0x0E, 0x00, 0x70, 0x00, 0xE0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x38, 0x01, 0xC0, 0x03, 0x80,
  0x3C, 0x00, 0x3C, 0x03, 0x80, 0x01, 0xC0, 0x38, 0x00, 0x1C, 0x03, 0x80,
  0x01, 0xE0, 0x78, 0x00, 0x1E, 0x07, 0x00, 0x00, 0xE0, 0x70, 0x00, 0x0E,
  0x0F, 0x00, 0x00, 0xF0, 0xF0, 0x00, 0x07, 0x0E, 0x00, 0x00, 0x70, 0xE0,
  0x00, 0x07, 0x1E, 0x00, 0x00, 0x79, 0xC0, 0x00, 0x03, 0x9C, 0x00, 0x00,
  0x39, 0xC0, 0x00, 0x03, 0xBC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00,
  0x0E, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xE7, 0x00, 0x01, 0xF8, 0x00, 0x1E,
  0x70, 0x00, 0x1F, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xB8, 0x00, 0x1C, 0x78,
  0x00, 0x3B, 0x80, 0x01, 0xC3, 0x80, 0x03, 0xB8, 0x00, 0x3C, 0x38, 0x00,
  0x39, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x9C, 0x00, 0x3C, 0x3C, 0x00, 0x71,
  0xC0, 0x03, 0x81, 0xC0, 0x07, 0x1C, 0x00, 0x38, 0x1C, 0x00, 0x71, 0xE0,
  0x07, 0x81, 0xC0, 0x07, 0x0E, 0x00, 0x78, 0x1E, 0x00, 0xF0, 0xE0, 0x07,
  0x01, 0xE0, 0x0E, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x00,
  0xE0, 0x0E, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x70, 0x0E, 0x00, 0xF0,
  0x1C, 0x07, 0x00, 0xE0, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x00, 0x70, 0x1C,
  0x07, 0x81, 0xE0, 0x07, 0x81, 0xC0, 0x38, 0x1E, 0x00, 0x78, 0x3C, 0x03,
  0x81, 0xC0, 0x03, 0x83, 0x80, 0x38, 0x1C, 0x00, 0x38, 0x38, 0x03, 0x83,
  0xC0, 0x03, 0x83, 0x80, 0x1C, 0x3C, 0x00, 0x3C, 0x38, 0x01, 0xC3, 0x80,
  0x03, 0xC7, 0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x01, 0xC7, 0x80, 0x01,
  0xC7, 0x00, 0x0E, 0x78, 0x00, 0x1C, 0x70, 0x00, 0xE7, 0x00, 0x01, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0x0E, 0xE0, 0x00, 0xE7, 0x00, 0x00, 0xEE, 0x00,
  0x0E, 0xF0, 0x00, 0x0E, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0xEE, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x07, 0x9E, 0x00, 0x03, 0x87,
  0x00, 0x03, 0xC3, 0xC0, 0x01, 0xC1, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x3C,
  0x00, 0xF0, 0x1C, 0x00, 0x38, 0x1E, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x0F,
  0x00, 0x03, 0x87, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x73, 0x80, 0x00, 0x3D,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x3D, 0xC0, 0x00, 0x1C, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x0E, 0x1C, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x03, 0x80, 0x07, 0x81, 0xE0, 0x03, 0x80, 0x70,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x07, 0x00, 0xE0, 0x03,
  0xC0, 0xF0, 0x00, 0xE0, 0x78, 0x00, 0x78, 0x78, 0x00, 0x1C, 0x3C, 0x00,
  0x0F, 0x1C, 0x00, 0x07, 0x9E, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0x9C, 0x00, 0x03, 0xCF, 0x00, 0x01, 0xE3,
  0x80, 0x00, 0xE1, 0xE0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x38, 0x00, 0x38,
  0x1E, 0x00, 0x3C, 0x07, 0x00, 0x1C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x00, 0x3C, 0x07, 0x80, 0x0E, 0x03, 0x80, 0x07, 0x83,
  0xC0, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x1C,
  0x70, 0x00, 0x0E, 0x38, 0x00, 0x07, 0xB8, 0x00, 0x01, 0xDC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x70,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x07,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFE, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0C, 0x00,
  0x00, 0x03, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0E, 0xE0, 0x00, 0x07, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00,
  0xE1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x1C, 0x0E, 0x00, 0x07, 0x01, 0xC0,
  0x03, 0x80, 0x70, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0x70, 0x0E, 0x00, 0x1C, 0x03, 0x80, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x3C, 0x38, 0x00, 0x07, 0x0E, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3B,
  0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0xF8, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xE0,
  0x3E, 0x08, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x3F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0x71, 0xF8, 0x07,
  0x3E, 0x00, 0x73, 0x80, 0x07, 0x78, 0x00, 0x77, 0x00, 0x07, 0x70, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x70, 0x00, 0xF7, 0x00,
  0x1F, 0x78, 0x01, 0xF7, 0xC0, 0x37, 0x3E, 0x0E, 0x71, 0xFF, 0xC7, 0x0F,
  0xF8, 0x30, 0x0C, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00,
  0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xE0, 0x00, 0x03, 0x83, 0xF8, 0x0E, 0x3F, 0xF8, 0x39, 0xFF, 0xF0,
  0xEF, 0x03, 0xE3, 0xB0, 0x07, 0x8F, 0x80, 0x0F, 0x3E, 0x00, 0x1C, 0xF0,
  0x00, 0x7B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xB8, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3B, 0xC0, 0x00,
  0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF8, 0x00, 0xF3, 0xF0, 0x03, 0xCE,
  0xE0, 0x1E, 0x33, 0xE3, 0xF0, 0xC7, 0xFF, 0x83, 0x07, 0xFC, 0x00, 0x03,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xF0, 0x7F, 0xFC, 0x3E, 0x03, 0x1F,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x10, 0xFE, 0x7C,
  0x1F, 0xFF, 0x01, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x07, 0xF0, 0x70, 0x7F, 0xF1,
  0xC3, 0xFF, 0xE7, 0x1F, 0x03, 0xDC, 0x78, 0x03, 0x73, 0xC0, 0x07, 0xCE,
  0x00, 0x1F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1D, 0xC0, 0x00, 0xF7, 0x00, 0x03, 0xDE, 0x00, 0x0F, 0x38, 0x00, 0x7C,
  0xF0, 0x03, 0xF1, 0xE0, 0x1D, 0xC7, 0xE1, 0xE3, 0x0F, 0xFF, 0x0C, 0x0F,
  0xF8, 0x30, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xE0, 0x1E, 0x07, 0x81, 0xE0, 0x1E, 0x1E, 0x00, 0x70, 0xE0, 0x01, 0xCF,
  0x00, 0x0E, 0x70, 0x00, 0x7B, 0x80, 0x01, 0xDC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x8F, 0x80, 0x18,
  0x3F, 0x87, 0xC0, 0xFF, 0xFE, 0x01, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0x00,
  0x1C, 0x00, 0x7F, 0xC0, 0xFF, 0xC0, 0x7C, 0x60, 0x78, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x01, 0xFF, 0xF0, 0xFF, 0xF8, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x30, 0xFF, 0xF9, 0xC7,
  0xC0, 0xF7, 0x1E, 0x00, 0xFC, 0xF0, 0x01, 0xF3, 0x80, 0x07, 0xDE, 0x00,
  0x0F, 0x70, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0x70, 0x00, 0x3D,
  0xC0, 0x00, 0xF7, 0x80, 0x03, 0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xDC, 0x78,
  0x07, 0x71, 0xF8, 0x79, 0xC3, 0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x01, 0x80,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01, 0xE4, 0x00,
  0x07, 0x9C, 0x00, 0x7C, 0x7E, 0x0F, 0xE1, 0xFF, 0xFF, 0x01, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x0F, 0xE0, 0xE3, 0xFF, 0x8E, 0x7F, 0xFC, 0xEF, 0x07, 0xCE, 0xC0, 0x1E,
  0xF8, 0x00, 0xEF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0x27, 0xBF,
  0xFF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39,
  0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x00, 0x01, 0x01, 0xE0, 0x78, 0x1F, 0x07, 0x80, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x38, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x07, 0x81, 0xE0, 0x78,
  0x1C, 0x9F, 0x3F, 0x8F, 0xC1, 0xC0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x00, 0xF7, 0x00, 0x3C, 0xE0, 0x07, 0x1C, 0x01,
  0xE3, 0x80, 0x78, 0x70, 0x0E, 0x0E, 0x03, 0x81, 0xC0, 0xF0, 0x38, 0x3C,
  0x07, 0x07, 0x00, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0x8E, 0x00, 0x73, 0xE0,
  0x0E, 0xFC, 0x01, 0xDF, 0xC0, 0x3F, 0x38, 0x07, 0xC7, 0x80, 0xF0, 0x70,
  0x1C, 0x0F, 0x03, 0x80, 0xE0, 0x70, 0x1E, 0x0E, 0x01, 0xC1, 0xC0, 0x3C,
  0x38, 0x03, 0x87, 0x00, 0x78, 0xE0, 0x07, 0x1C, 0x00, 0xF3, 0x80, 0x0E,
  0x70, 0x01, 0xEE, 0x00, 0x1D, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xFC, 0x01, 0xFC, 0x18, 0x7F, 0xC0, 0xFF, 0xC3, 0x1F,
  0xFC, 0x3F, 0xFC, 0x67, 0x07, 0xC7, 0x07, 0xCD, 0xC0, 0x3D, 0xC0, 0x7D,
  0xF0, 0x07, 0xF0, 0x07, 0xBC, 0x00, 0x7C, 0x00, 0x77, 0x80, 0x0F, 0x80,
  0x0E, 0xF0, 0x01, 0xE0, 0x01, 0xDC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07,
  0x80, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xC0,
  0x03, 0xC0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F,
  0xE0, 0x01, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07, 0x80,
  0x07, 0xF0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x03,
  0xC0, 0x03, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0xE0,
  0x01, 0xE0, 0x01, 0xFC, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x07, 0x80, 0x07,
  0xF0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x03, 0xC0,
  0x03, 0xF8, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x00, 0xFE, 0x0C, 0x3F, 0xF8, 0xC7, 0xFF, 0xCC, 0xF0,
  0x3C, 0xCC, 0x01, 0xED, 0x80, 0x0E, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x70, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xF8,
  0x0F, 0x01, 0xE0, 0x0F, 0x07, 0x80, 0x0F, 0x0E, 0x00, 0x0E, 0x3C, 0x00,
  0x1E, 0x70, 0x00, 0x3C, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xB8, 0x00, 0x0E, 0x70,
  0x00, 0x1C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xE1, 0xE0, 0x03, 0xC3, 0xC0,
  0x07, 0x83, 0xC0, 0x1E, 0x03, 0xF1, 0xF8, 0x03, 0xFF, 0xE0, 0x01, 0xFF,
  0x00, 0x00, 0x70, 0x00, 0x00, 0xFE, 0x03, 0x0F, 0xFE, 0x0C, 0x7F, 0xFC,
  0x33, 0xC0, 0xF8, 0xCC, 0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x07, 0x3C,
  0x00, 0x1E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEE, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0E, 0xF0, 0x00,
  0x3B, 0xC0, 0x01, 0xEF, 0x00, 0x07, 0xBE, 0x00, 0x3C, 0xFC, 0x00, 0xF3,
  0xB8, 0x07, 0x8E, 0x7C, 0xFC, 0x38, 0xFF, 0xE0, 0xE1, 0xFF, 0x03, 0x80,
  0xC0, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00,
  0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E,
  0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x30, 0xFF, 0xF9, 0xC7, 0xC0,
  0xF7, 0x1E, 0x00, 0xDC, 0xF0, 0x01, 0xF3, 0x80, 0x07, 0xDE, 0x00, 0x0F,
  0x70, 0x00, 0x3D, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0x70, 0x00, 0x3D, 0xC0,
  0x00, 0xF7, 0x80, 0x07, 0xCE, 0x00, 0x1F, 0x3C, 0x00, 0xDC, 0x78, 0x07,
  0x71, 0xFC, 0xF9, 0xC3, 0xFF, 0xC7, 0x03, 0xFE, 0x1C, 0x01, 0x80, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00,
  0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01,
  0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x70, 0x00, 0x01, 0xC0,
  0x00, 0xFF, 0x0F, 0xEC, 0x7F, 0xB3, 0xE2, 0xCE, 0x03, 0xF0, 0x0F, 0x80,
  0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x03, 0xFE,
  0x03, 0xFF, 0xE1, 0xFF, 0xFC, 0xF8, 0x0E, 0x78, 0x00, 0x9C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x0F, 0x80, 0x03, 0xF8, 0x01, 0xEF, 0xE7, 0xF3, 0xFF, 0xF8, 0x3F, 0xFC,
  0x00, 0x70, 0x00, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F, 0x30, 0x7F, 0xC0,
  0xFF, 0x00, 0xE0, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFB, 0x80, 0x07, 0xDE,
  0x00, 0x3E, 0xF0, 0x03, 0x73, 0xC0, 0x3B, 0x9F, 0x9F, 0x9C, 0x7F, 0xF8,
  0xE1, 0xFF, 0x87, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39,
  0xC0, 0x00, 0xF3, 0xC0, 0x01, 0xC3, 0x80, 0x03, 0x87, 0x00, 0x0F, 0x0F,
  0x00, 0x1E, 0x1E, 0x00, 0x38, 0x1C, 0x00, 0x70, 0x38, 0x01, 0xE0, 0x78,
  0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0xC0,
  0x70, 0x03, 0x80, 0xE0, 0x07, 0x03, 0xC0, 0x0F, 0x07, 0x00, 0x0E, 0x0E,
  0x00, 0x1C, 0x1C, 0x00, 0x38, 0x78, 0x00, 0x78, 0xE0, 0x00, 0x71, 0xC0,
  0x00, 0xE7, 0x80, 0x01, 0xCE, 0x00, 0x01, 0xDC, 0x00, 0x03, 0xB8, 0x00,
  0x07, 0x60, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3C, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x00, 0x0E, 0xF0,
  0x01, 0xF0, 0x00, 0xE7, 0x00, 0x1F, 0x80, 0x1E, 0x70, 0x01, 0xF8, 0x01,
  0xE7, 0x00, 0x1B, 0x80, 0x1C, 0x78, 0x03, 0xB8, 0x01, 0xC3, 0x80, 0x39,
  0xC0, 0x1C, 0x38, 0x03, 0x9C, 0x03, 0xC3, 0x80, 0x39, 0xC0, 0x38, 0x3C,
  0x07, 0x1C, 0x03, 0x83, 0xC0, 0x71, 0xE0, 0x38, 0x1C, 0x07, 0x0E, 0x07,
  0x81, 0xC0, 0x70, 0xE0, 0x70, 0x1E, 0x0E, 0x0E, 0x07, 0x01, 0xE0, 0xE0,
  0xE0, 0x70, 0x0E, 0x0E, 0x07, 0x0F, 0x00, 0xE0, 0xE0, 0x70, 0xE0, 0x0E,
  0x1C, 0x07, 0x0E, 0x00, 0xF1, 0xC0, 0x70, 0xE0, 0x07, 0x1C, 0x03, 0x8E,
  0x00, 0x71, 0xC0, 0x39, 0xC0, 0x07, 0x38, 0x03, 0x9C, 0x00, 0x73, 0x80,
  0x39, 0xC0, 0x03, 0xB8, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x1D, 0xC0, 0x03,
  0xB0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x78, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0xC0, 0x0F, 0x07, 0x00,
  0x38, 0x1E, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xF0, 0x3C, 0x01, 0xC0, 0xE0,
  0x07, 0x87, 0x80, 0x0E, 0x1C, 0x00, 0x3C, 0xF0, 0x00, 0x73, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x73, 0x80, 0x03, 0xCF, 0x00,
  0x0E, 0x1C, 0x00, 0x78, 0x78, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0xC0, 0x78,
  0x07, 0x01, 0xE0, 0x1E, 0x0F, 0x00, 0x38, 0x3C, 0x00, 0xF1, 0xE0, 0x01,
  0xC7, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xEF,
  0x00, 0x03, 0x9C, 0x00, 0x1E, 0x70, 0x00, 0x79, 0xE0, 0x01, 0xC3, 0x80,
  0x07, 0x0E, 0x00, 0x3C, 0x3C, 0x00, 0xE0, 0x70, 0x03, 0x81, 0xC0, 0x1E,
  0x07, 0x00, 0x70, 0x1E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x03,
  0xC0, 0xE0, 0x07, 0x03, 0x80, 0x1C, 0x1E, 0x00, 0x70, 0x70, 0x00, 0xE1,
  0xC0, 0x03, 0x87, 0x00, 0x0E, 0x3C, 0x00, 0x3C, 0xE0, 0x00, 0x73, 0x80,
  0x01, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x78, 0x00, 0x27, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x3F, 0xFF, 0x80, 0x01, 0xC0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F,
  0x00, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0xFE, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0xC0, 0x00, 0x0F, 0x00, 0x01, 0x3F, 0xF0, 0x01,
  0x7F, 0xF8, 0x03, 0xF0, 0x7F, 0x0F, 0xC0, 0x1F, 0xFE, 0x80, 0x07, 0xFC,
  0x80, 0x00, 0x60,
};

const GFXglyph NotoSans_Condensed_Light61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 5, 45, 14, 4, -44 },
  { 30, 13, 16, 21, 4, -44 },
  { 56, 28, 44, 31, 1, -44 },
  { 210, 22, 50, 28, 3, -46 },
  { 348, 35, 45, 41, 3, -44 },
  { 545, 29, 45, 32, 2, -44 },
  { 709, 4, 16, 12, 4, -44 },
  { 717, 12, 54, 17, 3, -44 },
  { 798, 12, 54, 17, 2, -44 },
  { 879, 20, 20, 26, 3, -46 },
  { 929, 24, 29, 28, 2, -36 },
  { 1016, 7, 15, 13, 2, -7 },
  { 1030, 14, 3, 17, 2, -18 },
  { 1036, 5, 7, 13, 4, -6 },
  { 1041, 19, 44, 21, 1, -44 },
  { 1146, 22, 45, 28, 3, -44 },
  { 1270, 13, 44, 28, 5, -44 },
  { 1342, 22, 44, 28, 3, -44 },
  { 1463, 23, 45, 28, 2, -44 },
  { 1593, 26, 44, 28, 1, -44 },
  { 1736, 22, 45, 28, 3, -44 },
  { 1860, 22, 45, 28, 3, -44 },
  { 1984, 22, 44, 28, 3, -44 },
  { 2105, 23, 45, 28, 2, -44 },
  { 2235, 22, 45, 28, 3, -44 },
  { 2359, 5, 33, 13, 4, -33 },
  { 2380, 7, 41, 13, 2, -33 },
  { 2416, 24, 27, 28, 2, -35 },
  { 2497, 24, 15, 28, 2, -29 },
  { 2542, 24, 27, 28, 2, -35 },
  { 2623, 18, 45, 20, 1, -44 },
  { 2725, 37, 49, 43, 3, -44 },
  { 2952, 29, 44, 29, 0, -44 },
  { 3112, 23, 44, 31, 5, -44 },
  { 3239, 25, 45, 30, 3, -44 },
  { 3380, 26, 44, 34, 5, -44 },
  { 3523, 19, 44, 27, 5, -44 },
  { 3628, 19, 44, 25, 5, -44 },
  { 3733, 29, 45, 36, 3, -44 },
  { 3897, 25, 44, 35, 5, -44 },
  { 4035, 12, 44, 16, 2, -44 },
  { 4101, 12, 55, 13, -4, -44 },
  { 4184, 23, 44, 28, 5, -44 },
  { 4311, 18, 44, 25, 5, -44 },
  { 4410, 35, 44, 45, 5, -44 },
  { 4603, 26, 44, 36, 5, -44 },
  { 4746, 30, 45, 37, 3, -44 },
  { 4915, 21, 44, 29, 5, -44 },
  { 5031, 30, 54, 37, 3, -44 },
  { 5234, 23, 44, 29, 5, -44 },
  { 5361, 21, 45, 27, 3, -44 },
  { 5480, 24, 44, 25, 0, -44 },
  { 5612, 25, 45, 35, 5, -44 },
  { 5753, 28, 44, 28, 0, -44 },
  { 5907, 44, 44, 46, 1, -44 },
  { 6149, 25, 44, 26, 0, -44 },
  { 6287, 25, 44, 25, 0, -44 },
  { 6425, 22, 44, 25, 2, -44 },
  { 6546, 12, 54, 19, 5, -44 },
  { 6627, 19, 44, 21, 1, -44 },
  { 6732, 12, 54, 19, 2, -44 },
  { 6813, 26, 24, 28, 1, -44 },
  { 6891, 25, 3, 25, 0, 5 },
  { 6901, 11, 10, 15, 2, -47 },
  { 6915, 20, 34, 26, 2, -33 },
  { 7000, 22, 47, 30, 5, -46 },
  { 7130, 18, 34, 23, 3, -33 },
  { 7207, 22, 47, 30, 3, -46 },
  { 7337, 21, 34, 27, 3, -33 },
  { 7427, 17, 47, 16, 1, -47 },
  { 7527, 22, 48, 30, 3, -33 },
  { 7659, 20, 46, 29, 5, -46 },
  { 7774, 5, 45, 13, 4, -45 },
  { 7803, 10, 60, 13, -1, -45 },
  { 7878, 19, 46, 24, 5, -46 },
  { 7988, 3, 46, 12, 5, -46 },
  { 8006, 35, 33, 44, 5, -33 },
  { 8151, 20, 33, 29, 5, -33 },
  { 8234, 23, 34, 29, 3, -33 },
  { 8332, 22, 47, 30, 5, -33 },
  { 8462, 22, 47, 30, 3, -33 },
  { 8592, 14, 33, 19, 5, -33 },
  { 8650, 18, 34, 22, 2, -33 },
  { 8727, 14, 41, 16, 1, -40 },
  { 8799, 21, 33, 29, 4, -32 },
  { 8886, 23, 32, 23, 0, -32 },
  { 8978, 36, 32, 37, 1, -32 },
  { 9122, 22, 32, 24, 1, -32 },
  { 9210, 22, 47, 23, 1, -32 },
  { 9340, 17, 32, 20, 2, -32 },
  { 9408, 17, 54, 22, 2, -44 },
  { 9523, 3, 61, 27, 12, -46 },
  { 9546, 16, 54, 22, 3, -44 },
  { 9654, 24, 7, 28, 2, -25 },
};

const GFXfont NotoSans_Condensed_Light61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light61pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_CONDENSED_LIGHT61PT7B_H_
