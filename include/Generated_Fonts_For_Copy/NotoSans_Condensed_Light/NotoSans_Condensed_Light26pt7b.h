#ifndef _NOTOSANS_CONDENSED_LIGHT26PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x8C, 0x63, 0x18, 0xC6, 0x20, 0x08,
  0x40, 0x8C, 0x08, 0x81, 0x88, 0x18, 0x81, 0x08, 0xFF, 0xF1, 0x08, 0x11,
  0x81, 0x10, 0x11, 0x03, 0x10, 0xFF, 0xE2, 0x10, 0x21, 0x02, 0x30, 0x22,
  0x02, 0x20, 0x62, 0x00, 0x08, 0x02, 0x01, 0xF1, 0xE6, 0xC8, 0x32, 0x08,
  0x83, 0x20, 0x48, 0x1E, 0x01, 0xC0, 0x3C, 0x09, 0x82, 0x30, 0x8C, 0x23,
  0x08, 0xB2, 0xE7, 0xE0, 0x20, 0x08, 0x02, 0x00, 0x30, 0x10, 0xD0, 0x61,
  0x10, 0x86, 0x21, 0x08, 0x46, 0x10, 0x88, 0x21, 0x30, 0x42, 0x40, 0xC4,
  0xBC, 0x8B, 0x45, 0xA4, 0x89, 0x9B, 0x10, 0x26, 0x20, 0x4C, 0x41, 0x18,
  0x82, 0x31, 0x0C, 0x22, 0x10, 0x4C, 0x60, 0x70, 0x0C, 0x03, 0x60, 0x23,
  0x02, 0x10, 0x21, 0x02, 0x30, 0x33, 0x01, 0x60, 0x1C, 0x03, 0x80, 0x64,
  0x34, 0x62, 0xC3, 0x2C, 0x16, 0x81, 0xEC, 0x0C, 0xC0, 0xC6, 0x32, 0x3E,
  0x30, 0xFE, 0x08, 0xC4, 0x42, 0x31, 0x08, 0xC6, 0x31, 0x8C, 0x63, 0x08,
  0x42, 0x18, 0x43, 0x08, 0x60, 0x82, 0x18, 0x43, 0x08, 0x43, 0x18, 0xC6,
  0x11, 0x8C, 0x63, 0x10, 0x8C, 0x46, 0x23, 0x00, 0x08, 0x04, 0x02, 0x19,
  0x37, 0xF0, 0xE0, 0x50, 0x44, 0x63, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x3F, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x6D, 0x2D,
  0x00, 0xFF, 0xF0, 0xF0, 0x01, 0x80, 0x80, 0x40, 0x60, 0x20, 0x30, 0x10,
  0x08, 0x0C, 0x04, 0x02, 0x03, 0x01, 0x00, 0x80, 0xC0, 0x40, 0x60, 0x20,
  0x30, 0x00, 0x1E, 0x0F, 0xC6, 0x19, 0x86, 0x40, 0x90, 0x2C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x24, 0x09, 0x02, 0x61, 0x8C,
  0xC1, 0xE0, 0x08, 0xCE, 0xDC, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21,
  0x08, 0x42, 0x1C, 0x3D, 0xC4, 0x18, 0x06, 0x00, 0x80, 0x20, 0x18, 0x06,
  0x01, 0x00, 0xC0, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x00, 0xC0, 0x60, 0x30,
  0x0F, 0xFC, 0x1E, 0x1D, 0xC8, 0x18, 0x02, 0x00, 0x80, 0x20, 0x18, 0x04,
  0x06, 0x0F, 0x00, 0x30, 0x06, 0x00, 0x80, 0x30, 0x0C, 0x02, 0x01, 0xA0,
  0xCF, 0xE0, 0x00, 0x80, 0x18, 0x03, 0x80, 0x28, 0x06, 0x80, 0x48, 0x0C,
  0x80, 0x88, 0x18, 0x81, 0x08, 0x20, 0x86, 0x08, 0x40, 0x8F, 0xFF, 0xFF,
  0xF0, 0x08, 0x00, 0x80, 0x08, 0x00, 0x80, 0x7F, 0x9F, 0xE6, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x7F, 0x10, 0xE0, 0x18, 0x02, 0x00, 0xC0,
  0x30, 0x0C, 0x02, 0x01, 0xB0, 0xC7, 0xE0, 0x07, 0x87, 0x63, 0x00, 0x80,
  0x60, 0x10, 0x04, 0x01, 0x10, 0xDF, 0x38, 0x6C, 0x0B, 0x03, 0xC0, 0xF0,
  0x34, 0x0D, 0x03, 0x60, 0x8C, 0x61, 0xF0, 0xFF, 0xFF, 0xF0, 0x08, 0x02,
  0x01, 0x80, 0x40, 0x10, 0x0C, 0x02, 0x01, 0x80, 0x60, 0x10, 0x0C, 0x03,
  0x00, 0x80, 0x60, 0x10, 0x04, 0x03, 0x00, 0x1E, 0x0F, 0xC6, 0x19, 0x02,
  0x40, 0x90, 0x26, 0x18, 0x84, 0x1E, 0x07, 0x83, 0x31, 0x86, 0xC0, 0xB0,
  0x3C, 0x0F, 0x03, 0xC0, 0x98, 0x63, 0xF0, 0x1C, 0x0F, 0xC6, 0x13, 0x06,
  0xC0, 0xB0, 0x2C, 0x0B, 0x03, 0xC0, 0xD0, 0x77, 0x38, 0xF2, 0x00, 0x80,
  0x20, 0x18, 0x04, 0x03, 0x01, 0x87, 0xC0, 0xF8, 0x00, 0x00, 0xF0, 0x6D,
  0x00, 0x00, 0x00, 0x36, 0x96, 0x80, 0x00, 0x40, 0x70, 0x70, 0x70, 0x70,
  0x30, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x18, 0x18, 0x1C, 0x1C, 0x0C, 0x00, 0x3C, 0xFE, 0x03, 0x03, 0x01,
  0x03, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x10, 0x10, 0x00, 0x00, 0x00,
  0x30, 0x30, 0x01, 0xC0, 0x07, 0x70, 0x18, 0x0C, 0x10, 0x04, 0x20, 0x02,
  0x60, 0x02, 0x43, 0xE3, 0x46, 0x21, 0x44, 0x21, 0xC4, 0x21, 0xC4, 0x21,
  0xC4, 0x21, 0xC4, 0x21, 0xC4, 0x63, 0x46, 0x52, 0x43, 0x9C, 0x40, 0x00,
  0x20, 0x00, 0x30, 0x00, 0x18, 0x10, 0x0F, 0xF0, 0x06, 0x00, 0x60, 0x07,
  0x00, 0xD0, 0x09, 0x00, 0x90, 0x09, 0x81, 0x88, 0x10, 0x81, 0x0C, 0x30,
  0xC3, 0xFC, 0x3F, 0xC2, 0x06, 0x60, 0x66, 0x02, 0x40, 0x3C, 0x03, 0xC0,
  0x10, 0xFC, 0x3F, 0xCC, 0x1B, 0x02, 0xC0, 0xF0, 0x3C, 0x0B, 0x06, 0xC3,
  0x3F, 0x8C, 0x1B, 0x03, 0xC0, 0xF0, 0x1C, 0x0F, 0x03, 0xC0, 0xB0, 0xEF,
  0xE0, 0x07, 0xC3, 0xFC, 0xE0, 0x18, 0x06, 0x00, 0xC0, 0x10, 0x02, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x20, 0x04, 0x00, 0x80, 0x18, 0x01, 0x00, 0x30,
  0x03, 0x04, 0x3F, 0x80, 0xF8, 0x1F, 0xE3, 0x06, 0x60, 0x6C, 0x05, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x16, 0x06, 0xC1, 0x98, 0xE3, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x03, 0xE0, 0x7F,
  0xC6, 0x04, 0x60, 0x06, 0x00, 0x30, 0x01, 0x00, 0x08, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x3E, 0x80, 0x34, 0x01, 0xA0, 0x0D, 0x80, 0x64, 0x03, 0x30,
  0x18, 0xE0, 0xC3, 0xFC, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0x80, 0xFB, 0x88, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x2F,
  0x98, 0xC0, 0xF0, 0x6C, 0x13, 0x0C, 0xC6, 0x31, 0x0C, 0xC3, 0x60, 0xD0,
  0x3E, 0x0E, 0x83, 0x30, 0xC6, 0x31, 0x8C, 0x33, 0x04, 0xC1, 0xB0, 0x2C,
  0x0C, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xC0, 0x07, 0xC0, 0x0E,
  0x80, 0x3D, 0x00, 0x5F, 0x00, 0xBA, 0x03, 0x74, 0x04, 0xEC, 0x09, 0xD8,
  0x33, 0x90, 0x47, 0x30, 0x8E, 0x63, 0x1C, 0x44, 0x38, 0xC8, 0x71, 0xB0,
  0xE1, 0x41, 0xC2, 0x83, 0x87, 0x07, 0x04, 0x08, 0xC0, 0x38, 0x07, 0x80,
  0xD0, 0x1F, 0x03, 0xA0, 0x76, 0x0E, 0x41, 0xCC, 0x38, 0x87, 0x18, 0xE1,
  0x1C, 0x33, 0x82, 0x70, 0x6E, 0x05, 0xC0, 0xF8, 0x0F, 0x01, 0x80, 0x07,
  0x80, 0xFF, 0x0C, 0x08, 0x40, 0x66, 0x01, 0x20, 0x0D, 0x00, 0x68, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x02, 0x80, 0x14, 0x01, 0xA0, 0x0D, 0x80, 0x6C,
  0x02, 0x30, 0x30, 0xC3, 0x03, 0xF0, 0xF0, 0x7F, 0xB0, 0xD8, 0x3C, 0x0E,
  0x07, 0x03, 0x83, 0xC1, 0xE1, 0xBF, 0x98, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x00, 0x07, 0x80, 0xFF, 0x0C, 0x08, 0x40, 0x66, 0x01,
  0x20, 0x0D, 0x00, 0x68, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x02, 0x80, 0x14,
  0x01, 0xA0, 0x0D, 0x80, 0x6C, 0x02, 0x30, 0x30, 0xC3, 0x03, 0xF0, 0x01,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0xF0, 0x3F, 0xCC, 0x1B, 0x06, 0xC0,
  0xB0, 0x2C, 0x0B, 0x06, 0xC1, 0xB1, 0xCF, 0xC3, 0x10, 0xC6, 0x30, 0x8C,
  0x33, 0x04, 0xC1, 0xB0, 0x2C, 0x0C, 0x1F, 0x1F, 0xD8, 0x18, 0x0C, 0x06,
  0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x08, 0x04, 0x02, 0x01,
  0x01, 0xE1, 0xBF, 0x80, 0xFF, 0xFF, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00,
  0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10,
  0x04, 0x01, 0x00, 0x40, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0,
  0x1E, 0x03, 0x40, 0x4C, 0x38, 0xFC, 0x00, 0xC0, 0x3C, 0x03, 0x40, 0x24,
  0x02, 0x60, 0x66, 0x04, 0x20, 0x42, 0x0C, 0x30, 0xC3, 0x08, 0x10, 0x81,
  0x18, 0x19, 0x80, 0x90, 0x09, 0x00, 0xF0, 0x0E, 0x00, 0x60, 0x06, 0x00,
  0xC0, 0x40, 0x28, 0x0C, 0x0D, 0x01, 0x81, 0xA0, 0x70, 0x36, 0x0A, 0x04,
  0xC1, 0x60, 0x88, 0x2C, 0x31, 0x0C, 0x86, 0x31, 0x90, 0x86, 0x22, 0x10,
  0x44, 0x66, 0x09, 0x84, 0xC1, 0x30, 0x90, 0x34, 0x12, 0x06, 0x83, 0x40,
  0x50, 0x78, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x30, 0x18, 0x00, 0x40, 0x6C,
  0x08, 0x83, 0x18, 0x41, 0x18, 0x22, 0x06, 0xC0, 0x50, 0x0E, 0x00, 0xC0,
  0x38, 0x05, 0x01, 0xB0, 0x22, 0x0C, 0x61, 0x04, 0x60, 0xC8, 0x0B, 0x01,
  0x80, 0xC0, 0x78, 0x09, 0x03, 0x30, 0x42, 0x18, 0x63, 0x0C, 0x40, 0x98,
  0x1A, 0x01, 0x40, 0x38, 0x06, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x04,
  0x00, 0x80, 0x10, 0x00, 0xFF, 0xFF, 0xC0, 0x40, 0x60, 0x30, 0x30, 0x18,
  0x08, 0x0C, 0x04, 0x06, 0x02, 0x03, 0x01, 0x01, 0x80, 0x80, 0xC0, 0x60,
  0x3F, 0xE0, 0xFF, 0xE1, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10,
  0x84, 0x21, 0x08, 0x43, 0xE0, 0xC0, 0x20, 0x18, 0x04, 0x02, 0x01, 0x80,
  0x40, 0x20, 0x18, 0x04, 0x03, 0x00, 0x80, 0x40, 0x30, 0x08, 0x04, 0x03,
  0x00, 0x80, 0x60, 0xFF, 0xC2, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x21, 0x08, 0x42, 0x10, 0x87, 0xE0, 0x04, 0x03, 0x00, 0xE0, 0x48, 0x13,
  0x08, 0x42, 0x19, 0x02, 0x40, 0xF0, 0x10, 0xFF, 0xE0, 0xC6, 0x21, 0x3E,
  0x63, 0x01, 0x01, 0x01, 0x01, 0x1F, 0x61, 0xC1, 0xC1, 0x81, 0xC3, 0xC3,
  0x7D, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x09, 0xE2, 0x8C, 0xC1,
  0xB0, 0x2C, 0x0A, 0x02, 0x80, 0xA0, 0x38, 0x0A, 0x02, 0xC0, 0xB0, 0x6A,
  0x32, 0x78, 0x1F, 0x31, 0x60, 0x40, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0x40, 0x60, 0x31, 0x1F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x31,
  0xEC, 0xCF, 0x60, 0xD0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x40, 0xD0, 0x36, 0x14, 0xF9, 0x1E, 0x19, 0x98, 0x68, 0x1C, 0x0E, 0x07,
  0xFF, 0x80, 0xC0, 0x60, 0x10, 0x0C, 0x03, 0x08, 0xFC, 0x0E, 0x34, 0xC1,
  0x83, 0x06, 0x3F, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC1, 0x80, 0x1E, 0x4C, 0xD6, 0x0D, 0x03, 0xC0, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF0, 0x34, 0x0D, 0x03, 0x61, 0xCF, 0xB0, 0x0C, 0x03, 0x00,
  0xC0, 0x24, 0x19, 0xFC, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x79,
  0x46, 0xC1, 0x60, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x30, 0xF0, 0x2A, 0xAA, 0xAA, 0xA8, 0x10, 0xC0, 0x00, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x46, 0xF0,
  0x80, 0x80, 0x80, 0x80, 0x80, 0x80, 0x83, 0x86, 0x84, 0x8C, 0x98, 0x90,
  0xB8, 0xF8, 0xCC, 0x8C, 0x86, 0x86, 0x83, 0x81, 0xFF, 0xFF, 0xF0, 0x9E,
  0x79, 0x45, 0x9B, 0x0E, 0x1E, 0x08, 0x38, 0x10, 0x70, 0x20, 0xE0, 0x41,
  0xC0, 0x83, 0x81, 0x07, 0x02, 0x0E, 0x04, 0x1C, 0x08, 0x38, 0x10, 0x70,
  0x20, 0xC0, 0x9E, 0x51, 0xB0, 0x58, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0C, 0x1F, 0x0C, 0x66, 0x09, 0x03, 0xC0,
  0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x34, 0x0D, 0x82, 0x21, 0x87, 0xC0,
  0x9E, 0x28, 0xCC, 0x1B, 0x02, 0xC0, 0xA0, 0x28, 0x0A, 0x03, 0x80, 0xA0,
  0x2C, 0x0B, 0x06, 0xA3, 0x27, 0x88, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x1E, 0x4C, 0xD6, 0x1D, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x34, 0x0D, 0x83, 0x61, 0xCF, 0xB0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x9E, 0xDC, 0x30, 0xC2, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x00, 0x3E, 0x62, 0xC0, 0x80, 0xC0, 0x60, 0x38, 0x1C, 0x06, 0x02, 0x03,
  0x03, 0x86, 0xFC, 0x20, 0x82, 0x3F, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0x82, 0x0C, 0x1C, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x78, 0x7C, 0x7B, 0xEC, 0xC0, 0xF0, 0x24, 0x19,
  0x06, 0x61, 0x08, 0x42, 0x30, 0xCC, 0x32, 0x04, 0x81, 0x60, 0x70, 0x0C,
  0x03, 0x00, 0xC1, 0x83, 0x41, 0x82, 0x41, 0x82, 0x43, 0xC6, 0x62, 0x46,
  0x22, 0x44, 0x22, 0x44, 0x26, 0x64, 0x36, 0x6C, 0x34, 0x28, 0x14, 0x28,
  0x14, 0x28, 0x1C, 0x38, 0x18, 0x10, 0x40, 0xD8, 0x62, 0x10, 0xCC, 0x12,
  0x03, 0x80, 0xC0, 0x30, 0x1E, 0x04, 0x83, 0x30, 0x84, 0x61, 0xB0, 0x30,
  0xC0, 0xD0, 0x24, 0x09, 0x86, 0x21, 0x88, 0x43, 0x10, 0xCC, 0x12, 0x04,
  0x81, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x20, 0x08, 0x06, 0x01, 0x03,
  0xC0, 0xFE, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x20, 0xC1, 0x02, 0x0C,
  0x1F, 0xC0, 0x02, 0x1C, 0x60, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0xC7,
  0x06, 0x06, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xC0, 0x81, 0xE0, 0xC0, 0x81, 0x02, 0x04, 0x08, 0x10, 0x30,
  0x60, 0x30, 0xC3, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x06, 0x38, 0x00,
  0x20, 0x3F, 0x18, 0x78,
};

const GFXglyph NotoSans_Condensed_Light26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 2, 19, 6, 2, -19 },
  { 6, 5, 7, 9, 2, -19 },
  { 11, 12, 19, 13, 1, -19 },
  { 40, 10, 22, 12, 1, -20 },
  { 68, 15, 19, 18, 1, -19 },
  { 104, 12, 19, 13, 1, -19 },
  { 133, 1, 7, 5, 2, -19 },
  { 134, 5, 23, 7, 1, -19 },
  { 149, 5, 23, 7, 1, -19 },
  { 164, 9, 9, 11, 1, -20 },
  { 175, 10, 12, 12, 1, -15 },
  { 190, 3, 6, 5, 1, -3 },
  { 193, 6, 2, 7, 1, -8 },
  { 195, 2, 2, 6, 2, -2 },
  { 196, 9, 19, 9, 0, -19 },
  { 218, 10, 19, 12, 1, -19 },
  { 242, 5, 19, 12, 2, -19 },
  { 254, 10, 19, 12, 1, -19 },
  { 278, 10, 19, 12, 1, -19 },
  { 302, 12, 19, 12, 0, -19 },
  { 331, 10, 19, 12, 1, -19 },
  { 355, 10, 19, 12, 1, -19 },
  { 379, 10, 19, 12, 1, -19 },
  { 403, 10, 19, 12, 1, -19 },
  { 427, 10, 19, 12, 1, -19 },
  { 451, 2, 14, 6, 2, -14 },
  { 455, 3, 17, 6, 1, -14 },
  { 462, 10, 11, 12, 1, -15 },
  { 476, 10, 7, 12, 1, -13 },
  { 485, 10, 11, 12, 1, -15 },
  { 499, 8, 19, 9, 0, -19 },
  { 518, 16, 21, 18, 1, -19 },
  { 560, 12, 19, 12, 0, -19 },
  { 589, 10, 19, 13, 2, -19 },
  { 613, 11, 19, 13, 1, -19 },
  { 640, 11, 19, 15, 2, -19 },
  { 667, 8, 19, 11, 2, -19 },
  { 686, 8, 19, 11, 2, -19 },
  { 705, 13, 19, 15, 1, -19 },
  { 736, 11, 19, 15, 2, -19 },
  { 763, 5, 19, 7, 1, -19 },
  { 775, 6, 24, 6, -2, -19 },
  { 793, 10, 19, 12, 2, -19 },
  { 817, 8, 19, 11, 2, -19 },
  { 836, 15, 19, 19, 2, -19 },
  { 872, 11, 19, 15, 2, -19 },
  { 899, 13, 19, 16, 1, -19 },
  { 930, 9, 19, 12, 2, -19 },
  { 952, 13, 23, 16, 1, -19 },
  { 990, 10, 19, 13, 2, -19 },
  { 1014, 9, 19, 12, 1, -19 },
  { 1036, 10, 19, 11, 0, -19 },
  { 1060, 11, 19, 15, 2, -19 },
  { 1087, 12, 19, 12, 0, -19 },
  { 1116, 19, 19, 19, 0, -19 },
  { 1162, 11, 19, 11, 0, -19 },
  { 1189, 11, 19, 11, 0, -19 },
  { 1216, 9, 19, 11, 1, -19 },
  { 1238, 5, 23, 8, 2, -19 },
  { 1253, 9, 19, 9, 0, -19 },
  { 1275, 5, 23, 8, 1, -19 },
  { 1290, 10, 10, 12, 1, -19 },
  { 1303, 11, 1, 11, 0, 2 },
  { 1305, 4, 4, 7, 1, -20 },
  { 1307, 8, 14, 11, 1, -14 },
  { 1321, 10, 20, 13, 2, -20 },
  { 1346, 8, 14, 10, 1, -14 },
  { 1360, 10, 20, 13, 1, -20 },
  { 1385, 9, 14, 12, 1, -14 },
  { 1401, 7, 20, 7, 0, -20 },
  { 1419, 10, 20, 13, 1, -14 },
  { 1444, 9, 20, 13, 2, -20 },
  { 1467, 2, 19, 5, 2, -19 },
  { 1472, 5, 25, 5, -1, -19 },
  { 1488, 8, 20, 10, 2, -20 },
  { 1508, 1, 20, 5, 2, -20 },
  { 1511, 15, 14, 19, 2, -14 },
  { 1538, 9, 14, 13, 2, -14 },
  { 1554, 10, 14, 12, 1, -14 },
  { 1572, 10, 20, 13, 2, -14 },
  { 1597, 10, 20, 13, 1, -14 },
  { 1622, 6, 14, 8, 2, -14 },
  { 1633, 8, 14, 10, 1, -14 },
  { 1647, 6, 17, 7, 0, -17 },
  { 1660, 9, 14, 13, 2, -14 },
  { 1676, 10, 14, 10, 0, -14 },
  { 1694, 16, 14, 16, 0, -14 },
  { 1722, 10, 14, 10, 0, -14 },
  { 1740, 10, 20, 10, 0, -14 },
  { 1765, 7, 14, 9, 1, -14 },
  { 1778, 7, 23, 9, 1, -19 },
  { 1799, 1, 26, 11, 5, -20 },
  { 1803, 7, 23, 9, 1, -19 },
  { 1824, 10, 3, 12, 1, -11 },
};

const GFXfont NotoSans_Condensed_Light26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light26pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_CONDENSED_LIGHT26PT7B_H_
