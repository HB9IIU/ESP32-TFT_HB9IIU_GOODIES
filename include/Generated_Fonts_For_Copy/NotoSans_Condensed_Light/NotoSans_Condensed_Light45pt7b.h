#ifndef _NOTOSANS_CONDENSED_LIGHT45PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT45PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light45pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66,
  0x66, 0x00, 0x00, 0x6F, 0xFF, 0xE1, 0xF8, 0x7E, 0x1F, 0x86, 0xC1, 0xB0,
  0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x18, 0x01, 0xC1, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC0, 0xC0, 0x06,
  0x06, 0x00, 0x70, 0x60, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE,
  0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x1C, 0x18, 0x00, 0xC0,
  0xC0, 0x06, 0x06, 0x00, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C, 0x0F,
  0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x30, 0x30, 0x01, 0x81, 0x80, 0x0C, 0x0C,
  0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x18, 0x18, 0x00, 0xC1, 0xC0, 0x0C,
  0x0C, 0x00, 0x60, 0x60, 0x03, 0x03, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00,
  0x60, 0x00, 0xFF, 0x01, 0xFF, 0xE1, 0xEC, 0x71, 0xC6, 0x09, 0xC3, 0x00,
  0xE1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x30, 0x0E, 0x18, 0x03, 0x0C,
  0x01, 0xC6, 0x00, 0x7B, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x37, 0x80, 0x19, 0xE0, 0x0C, 0x38, 0x06, 0x0C, 0x03, 0x06, 0x01, 0x83,
  0x80, 0xC1, 0x80, 0x60, 0xC0, 0x30, 0x60, 0x18, 0x77, 0x0C, 0xF3, 0xFF,
  0xF0, 0xFF, 0xE0, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00,
  0x18, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0x0E, 0x03, 0x38, 0x03, 0x01,
  0x87, 0x00, 0xC0, 0x60, 0xC0, 0x60, 0x18, 0x30, 0x18, 0x0C, 0x0C, 0x0E,
  0x03, 0x03, 0x03, 0x00, 0xC0, 0xE0, 0xC0, 0x30, 0x38, 0x60, 0x0C, 0x0E,
  0x18, 0x03, 0x03, 0x8C, 0x00, 0xC0, 0xE3, 0x00, 0x30, 0x30, 0xC3, 0x0C,
  0x0C, 0x63, 0xF1, 0x83, 0x19, 0xCE, 0x60, 0xCC, 0x61, 0x98, 0x63, 0x38,
  0x33, 0xB9, 0xCC, 0x0C, 0xFC, 0x63, 0x03, 0x04, 0x18, 0xC0, 0xC0, 0x0C,
  0x30, 0x30, 0x03, 0x0C, 0x0C, 0x01, 0xC3, 0x03, 0x00, 0x60, 0xC0, 0xC0,
  0x18, 0x30, 0x30, 0x0C, 0x0C, 0x0C, 0x03, 0x03, 0x03, 0x01, 0xC0, 0xC0,
  0xC0, 0x60, 0x18, 0x70, 0x18, 0x06, 0x18, 0x0C, 0x00, 0xFE, 0x03, 0x00,
  0x3F, 0x00, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00, 0x38, 0x70,
  0x01, 0x81, 0x80, 0x1C, 0x0E, 0x00, 0xE0, 0x70, 0x07, 0x03, 0x80, 0x18,
  0x1C, 0x00, 0xC0, 0xC0, 0x06, 0x06, 0x00, 0x38, 0x70, 0x00, 0xC7, 0x00,
  0x07, 0x70, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xEE,
  0x00, 0x0E, 0x38, 0x1C, 0xE1, 0xC0, 0xE6, 0x07, 0x07, 0x70, 0x1C, 0x33,
  0x80, 0x61, 0x98, 0x03, 0x9C, 0xC0, 0x0E, 0xC6, 0x00, 0x3E, 0x30, 0x01,
  0xE1, 0xC0, 0x07, 0x0E, 0x00, 0x7C, 0x38, 0x07, 0x61, 0xE0, 0xF3, 0x87,
  0xFF, 0x0E, 0x1F, 0xE0, 0x38, 0xFF, 0xFF, 0xB6, 0xDB, 0x00, 0x03, 0x83,
  0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x06,
  0x03, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x30, 0x18, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x01, 0xC0, 0x60, 0x38, 0x0E, 0xC0, 0x60, 0x70, 0x30, 0x38, 0x18,
  0x1C, 0x0C, 0x0E, 0x0E, 0x06, 0x06, 0x07, 0x07, 0x07, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x07, 0x06, 0x06, 0x0E,
  0x0E, 0x0C, 0x1C, 0x18, 0x38, 0x30, 0x70, 0x60, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x0C, 0x08, 0x10, 0x3E, 0x23, 0xFF, 0xFF, 0x87, 0xF0,
  0x03, 0x80, 0x0D, 0x80, 0x3B, 0x80, 0xE3, 0x81, 0x83, 0x07, 0x07, 0x04,
  0x04, 0x00, 0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18,
  0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xE0, 0x30, 0x00, 0x18, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x00,
  0x01, 0x80, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00, 0x39,
  0xCC, 0xE7, 0x39, 0x8C, 0xE6, 0x30, 0xFF, 0xFF, 0xF0, 0xEF, 0xFE, 0x00,
  0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00,
  0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0x01, 0xC0, 0x03, 0xF8, 0x03,
  0xFE, 0x03, 0x83, 0x83, 0x80, 0xC1, 0x80, 0x71, 0xC0, 0x18, 0xE0, 0x0E,
  0x60, 0x07, 0x30, 0x03, 0xB8, 0x00, 0xDC, 0x00, 0x6E, 0x00, 0x37, 0x00,
  0x1B, 0x80, 0x0D, 0xC0, 0x06, 0xE0, 0x03, 0xF0, 0x01, 0xB8, 0x00, 0xDC,
  0x00, 0x6E, 0x00, 0x37, 0x00, 0x1B, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x07,
  0x30, 0x03, 0x9C, 0x01, 0x8E, 0x00, 0xC3, 0x00, 0xE1, 0xC0, 0x60, 0x70,
  0x70, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x01, 0xC0, 0xF0, 0x7C, 0x3B, 0x1D,
  0xDE, 0x7F, 0x1D, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x03, 0x00,
  0x1F, 0xF0, 0x7F, 0xF8, 0xF0, 0x1C, 0x40, 0x0E, 0x00, 0x0E, 0x00, 0x06,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x06, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x00, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x1F, 0xF0, 0x7F, 0xF8, 0xF0, 0x1C,
  0x40, 0x0E, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x0F, 0xE0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x80, 0x0E, 0xC0, 0x3C, 0xFF, 0xF8, 0x7F, 0xF0, 0x00, 0x0E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0xDC,
  0x00, 0x3B, 0x80, 0x06, 0x70, 0x01, 0xCE, 0x00, 0x31, 0xC0, 0x0E, 0x38,
  0x01, 0x87, 0x00, 0x70, 0xE0, 0x0C, 0x1C, 0x03, 0x03, 0x80, 0x60, 0x70,
  0x18, 0x0E, 0x07, 0x01, 0xC0, 0xC0, 0x38, 0x38, 0x07, 0x06, 0x00, 0xE1,
  0xC0, 0x1C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x3F, 0xFE, 0x3F, 0xFE, 0x30, 0x00, 0x30, 0x00, 0x30, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x70, 0x00,
  0x60, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x7F, 0xFC, 0x20, 0x1E, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03, 0x00, 0x03,
  0x00, 0x03, 0x00, 0x03, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x80, 0x1E,
  0xE0, 0x3C, 0xFF, 0xF8, 0x7F, 0xE0, 0x00, 0x30, 0x00, 0xFF, 0x01, 0xFF,
  0x81, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x06, 0x00, 0x03, 0x0F, 0x83,
  0x9F, 0xF1, 0xDC, 0x7C, 0xF8, 0x0E, 0x78, 0x03, 0xBC, 0x01, 0xDC, 0x00,
  0x6E, 0x00, 0x37, 0x00, 0x1F, 0x80, 0x0E, 0xC0, 0x07, 0x60, 0x03, 0xB0,
  0x01, 0x9C, 0x00, 0xCE, 0x00, 0xE3, 0x00, 0x71, 0xC0, 0x70, 0x70, 0x78,
  0x1F, 0xF8, 0x07, 0xF8, 0x00, 0x40, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x03, 0x00, 0x03, 0x80, 0x01,
  0x80, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x18, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x06, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x00, 0x80, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x01, 0xC7,
  0x00, 0x63, 0x80, 0x39, 0x80, 0x1C, 0xC0, 0x0E, 0x60, 0x07, 0x30, 0x03,
  0x9C, 0x01, 0xC6, 0x01, 0xC3, 0x80, 0xE0, 0xE1, 0xE0, 0x3D, 0xE0, 0x0F,
  0xC0, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0x0F, 0x07, 0x03, 0xC7, 0x00, 0x63,
  0x00, 0x3B, 0x80, 0x0D, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x6E, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x38, 0x7F, 0xF8, 0x0F,
  0xF8, 0x00, 0x01, 0x80, 0x0F, 0xF0, 0x1F, 0xF8, 0x38, 0x1C, 0x70, 0x0C,
  0x60, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0x60, 0x07, 0x70, 0x0F,
  0x70, 0x1B, 0x3C, 0x7B, 0x1F, 0xF3, 0x07, 0xC3, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x06, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xF0, 0x3F, 0xE0, 0x3F, 0xC0, 0xEF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFE, 0x73, 0xDE, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x73, 0x99, 0xCE, 0x63,
  0x39, 0x8C, 0x60, 0x00, 0x00, 0x80, 0x01, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0,
  0x80, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x30, 0x00, 0x10, 0x00, 0x00, 0x04, 0x03, 0xFE, 0x3F, 0xF9,
  0x81, 0xE0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x38,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xC0, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x06, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x38, 0x1C, 0x00,
  0x01, 0x81, 0x80, 0x00, 0x0C, 0x38, 0x00, 0x00, 0xC3, 0x00, 0xFE, 0x0E,
  0x30, 0x3F, 0xE0, 0x66, 0x03, 0x06, 0x06, 0x60, 0x60, 0x60, 0x66, 0x06,
  0x06, 0x06, 0x60, 0xE0, 0x60, 0x6E, 0x0C, 0x06, 0x07, 0xE0, 0xC0, 0x60,
  0x7E, 0x0C, 0x06, 0x06, 0xE0, 0xC0, 0x60, 0x6E, 0x0C, 0x06, 0x06, 0xE0,
  0xC0, 0x60, 0x6E, 0x0C, 0x0E, 0x06, 0x60, 0xC0, 0xE0, 0xE6, 0x0E, 0x0A,
  0x0C, 0x60, 0x71, 0xB1, 0xC6, 0x03, 0xF1, 0xF8, 0x70, 0x1E, 0x0F, 0x03,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0x00, 0x08, 0x00, 0x3C, 0x07, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xB0, 0x00, 0x0D, 0x80, 0x00, 0x6E, 0x00, 0x07,
  0x30, 0x00, 0x31, 0x80, 0x01, 0x8E, 0x00, 0x1C, 0x70, 0x00, 0xE1, 0x80,
  0x06, 0x0C, 0x00, 0x30, 0x70, 0x03, 0x81, 0x80, 0x18, 0x0C, 0x00, 0xC0,
  0x70, 0x0E, 0x03, 0x80, 0x70, 0x0C, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81,
  0xFF, 0xFC, 0x0E, 0x00, 0x60, 0x60, 0x03, 0x87, 0x00, 0x1C, 0x38, 0x00,
  0xE1, 0x80, 0x03, 0x0C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x03, 0x30,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x7F, 0xFE, 0x30,
  0x0F, 0x98, 0x01, 0xCC, 0x00, 0x76, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x0E,
  0xC0, 0x07, 0x60, 0x03, 0xB0, 0x01, 0xD8, 0x00, 0xCC, 0x00, 0xE6, 0x00,
  0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xC0, 0x3C, 0x60, 0x07, 0x30, 0x01, 0xD8,
  0x00, 0x6C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xD8, 0x00, 0xEC, 0x00, 0xE6, 0x01, 0xF3, 0xFF,
  0xE1, 0xFF, 0xC0, 0x00, 0x08, 0x00, 0x1F, 0xF8, 0x0F, 0xFF, 0x83, 0xC0,
  0x20, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00,
  0x18, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x30, 0x00, 0x06, 0x00, 0x00, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x10, 0x1F, 0xFE, 0x00, 0xFF, 0x80, 0xFF, 0xE0,
  0x1F, 0xFF, 0x03, 0x01, 0xF0, 0x60, 0x07, 0x0C, 0x00, 0x71, 0x80, 0x07,
  0x30, 0x00, 0xE6, 0x00, 0x0E, 0xC0, 0x01, 0xD8, 0x00, 0x3B, 0x00, 0x03,
  0x60, 0x00, 0x6C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x6C, 0x00, 0x0D,
  0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x0E, 0xC0, 0x01, 0x98, 0x00, 0x73,
  0x00, 0x1C, 0x60, 0x07, 0x8C, 0x01, 0xE1, 0x80, 0xF8, 0x3F, 0xFE, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0F, 0xFF, 0xBF, 0xFE, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x3F, 0xFE, 0xFF, 0xFB, 0xFF, 0xEC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x81, 0xE0, 0x0E, 0x0F, 0x00, 0x08, 0x78, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x38, 0x00, 0x00, 0xC0, 0x00, 0x07, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x60, 0x00, 0x01, 0x80, 0x00, 0x06, 0x00, 0x00, 0x38,
  0x00, 0x00, 0xE0, 0x00, 0x03, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xD8, 0x00,
  0x07, 0x60, 0x00, 0x1D, 0x80, 0x00, 0x77, 0x00, 0x01, 0xDC, 0x00, 0x07,
  0x70, 0x00, 0x1C, 0xE0, 0x00, 0x73, 0x80, 0x01, 0xC7, 0x00, 0x07, 0x1E,
  0x00, 0x1C, 0x3C, 0x00, 0x70, 0x7C, 0x03, 0xC0, 0xFF, 0xFF, 0x00, 0xFF,
  0xF0, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x70, 0x3C, 0x3B, 0xFD, 0xF8, 0xC0, 0x07, 0xE0, 0x03, 0x30, 0x03,
  0x98, 0x03, 0x8C, 0x01, 0x86, 0x01, 0xC3, 0x01, 0xC1, 0x81, 0xC0, 0xC0,
  0xE0, 0x60, 0xE0, 0x30, 0xE0, 0x18, 0x70, 0x0C, 0x70, 0x06, 0x70, 0x03,
  0x38, 0x01, 0xBE, 0x00, 0xFB, 0x00, 0x79, 0xC0, 0x38, 0x70, 0x18, 0x38,
  0x0C, 0x0E, 0x06, 0x07, 0x03, 0x01, 0xC1, 0x80, 0xE0, 0xC0, 0x38, 0x60,
  0x0C, 0x30, 0x07, 0x18, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x3B, 0x00, 0x1D,
  0x80, 0x07, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF6, 0x00,
  0x03, 0x7D, 0xC0, 0x00, 0xDF, 0x70, 0x00, 0x77, 0xCC, 0x00, 0x19, 0xF3,
  0x80, 0x06, 0x7C, 0xE0, 0x03, 0x9F, 0x18, 0x00, 0xE7, 0xC6, 0x00, 0x31,
  0xF1, 0xC0, 0x0C, 0x7C, 0x30, 0x07, 0x1F, 0x0C, 0x01, 0x87, 0xC3, 0x80,
  0x61, 0xF0, 0x60, 0x38, 0x7C, 0x18, 0x0C, 0x1F, 0x07, 0x03, 0x07, 0xC0,
  0xC1, 0xC1, 0xF0, 0x30, 0x60, 0x7C, 0x0E, 0x18, 0x1F, 0x01, 0x8E, 0x07,
  0xC0, 0x63, 0x01, 0xF0, 0x1C, 0xC0, 0x7C, 0x03, 0x70, 0x1F, 0x00, 0xD8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x01, 0xC0, 0x1F, 0x00,
  0x70, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0x07, 0xB0, 0x00, 0xF7, 0x00, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x78,
  0xC0, 0x0F, 0x1C, 0x01, 0xE1, 0xC0, 0x3C, 0x38, 0x07, 0x83, 0x80, 0xF0,
  0x70, 0x1E, 0x07, 0x03, 0xC0, 0xE0, 0x78, 0x0E, 0x0F, 0x01, 0xC1, 0xE0,
  0x1C, 0x3C, 0x03, 0x87, 0x80, 0x38, 0xF0, 0x07, 0x1E, 0x00, 0x73, 0xC0,
  0x0E, 0x78, 0x00, 0xEF, 0x00, 0x1D, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0x00, 0x18, 0x00, 0x03, 0xFE, 0x00,
  0x1F, 0xFF, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x0E,
  0x00, 0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x18, 0xE0, 0x00, 0x39, 0xC0,
  0x00, 0x73, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3B, 0x00, 0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x9C, 0x00, 0x07,
  0x38, 0x00, 0x0E, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xE0, 0x00, 0xE1,
  0xC0, 0x01, 0xC1, 0xC0, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0xFF, 0xC1, 0xFF, 0xE3, 0x01, 0xE6, 0x00,
  0xEC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0x60, 0x1E, 0xC1,
  0xF9, 0xFF, 0xE3, 0xFE, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0x00, 0x10, 0x00, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0x78, 0x0F, 0x01, 0xE0, 0x0F, 0x03, 0x80, 0x0E, 0x0E, 0x00,
  0x0E, 0x1C, 0x00, 0x1C, 0x30, 0x00, 0x1C, 0xE0, 0x00, 0x39, 0xC0, 0x00,
  0x73, 0x00, 0x00, 0x66, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x98, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3B,
  0x00, 0x00, 0x76, 0x00, 0x00, 0xCC, 0x00, 0x01, 0x9C, 0x00, 0x07, 0x38,
  0x00, 0x0E, 0x70, 0x00, 0x1C, 0x60, 0x00, 0x30, 0xE0, 0x00, 0xE1, 0xC0,
  0x01, 0xC1, 0xC0, 0x07, 0x01, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x70, 0xFF, 0xC0, 0x7F, 0xF8, 0x30, 0x3F, 0x18, 0x03, 0x8C,
  0x00, 0xE6, 0x00, 0x73, 0x00, 0x19, 0x80, 0x0C, 0xC0, 0x06, 0x60, 0x03,
  0x30, 0x01, 0x98, 0x00, 0xCC, 0x00, 0xE6, 0x00, 0x63, 0x00, 0x71, 0x80,
  0xF0, 0xFF, 0xF0, 0x7F, 0xE0, 0x30, 0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x06,
  0x03, 0x83, 0x01, 0xC1, 0x80, 0x70, 0xC0, 0x38, 0x60, 0x0E, 0x30, 0x07,
  0x18, 0x01, 0xCC, 0x00, 0xE6, 0x00, 0x3B, 0x00, 0x1D, 0x80, 0x07, 0x00,
  0xE0, 0x0F, 0xFE, 0x1F, 0xFF, 0x3C, 0x06, 0x70, 0x00, 0x70, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x0E, 0xE0,
  0x3C, 0xFF, 0xF8, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00,
  0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00,
  0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30,
  0x00, 0x0C, 0x00, 0x03, 0x00, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0x60, 0x00, 0xEC, 0x00, 0x1D, 0xC0, 0x03, 0xB8, 0x00, 0xE3,
  0x80, 0x1C, 0x3C, 0x0F, 0x03, 0xFF, 0xC0, 0x3F, 0xE0, 0xE0, 0x00, 0x3F,
  0x00, 0x03, 0x98, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x06, 0x18, 0x00,
  0x70, 0xC0, 0x03, 0x87, 0x00, 0x18, 0x38, 0x00, 0xC0, 0xC0, 0x0E, 0x06,
  0x00, 0x70, 0x38, 0x03, 0x01, 0xC0, 0x18, 0x06, 0x01, 0xC0, 0x38, 0x0E,
  0x01, 0xC0, 0x60, 0x06, 0x07, 0x00, 0x30, 0x38, 0x01, 0xC1, 0x80, 0x0E,
  0x0C, 0x00, 0x30, 0xE0, 0x01, 0x87, 0x00, 0x0E, 0x30, 0x00, 0x71, 0x80,
  0x01, 0x9C, 0x00, 0x0C, 0xC0, 0x00, 0x76, 0x00, 0x01, 0xB0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x0E, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xB0, 0x00, 0xE0, 0x01, 0xDC, 0x00, 0x78, 0x00, 0xEE, 0x00, 0x3C,
  0x00, 0x67, 0x00, 0x1E, 0x00, 0x31, 0x80, 0x1B, 0x00, 0x38, 0xE0, 0x0D,
  0x80, 0x1C, 0x70, 0x06, 0xE0, 0x0E, 0x38, 0x03, 0x30, 0x06, 0x0C, 0x03,
  0x98, 0x07, 0x06, 0x01, 0x8C, 0x03, 0x83, 0x80, 0xC7, 0x01, 0xC1, 0xC0,
  0x61, 0x80, 0xC0, 0x60, 0x70, 0xC0, 0x60, 0x30, 0x38, 0x60, 0x70, 0x1C,
  0x18, 0x38, 0x38, 0x0E, 0x0C, 0x1C, 0x18, 0x07, 0x06, 0x06, 0x0C, 0x01,
  0x87, 0x03, 0x0E, 0x00, 0xC3, 0x01, 0x87, 0x00, 0x71, 0x80, 0xE3, 0x80,
  0x38, 0xC0, 0x31, 0x80, 0x0C, 0xE0, 0x19, 0xC0, 0x06, 0x70, 0x0C, 0xE0,
  0x03, 0x30, 0x06, 0x70, 0x01, 0xD8, 0x03, 0xB0, 0x00, 0xEC, 0x00, 0xD8,
  0x00, 0x3E, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x07, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x70, 0x01, 0xC7,
  0x00, 0x38, 0xE0, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x30, 0x18, 0x0E, 0x03,
  0x81, 0x80, 0x30, 0x70, 0x07, 0x0C, 0x00, 0x63, 0x80, 0x0E, 0x60, 0x00,
  0xDC, 0x00, 0x1B, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x06, 0xE0, 0x01, 0xDC, 0x00, 0x31, 0x80, 0x0E,
  0x38, 0x01, 0x83, 0x00, 0x70, 0x70, 0x0C, 0x06, 0x03, 0x80, 0xE0, 0x60,
  0x0C, 0x1C, 0x01, 0xC3, 0x80, 0x38, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x00,
  0x07, 0xE0, 0x01, 0xD8, 0x00, 0x77, 0x00, 0x19, 0xC0, 0x0E, 0x30, 0x03,
  0x8E, 0x00, 0xC1, 0x80, 0x70, 0x70, 0x18, 0x1C, 0x0E, 0x03, 0x03, 0x00,
  0xE0, 0xC0, 0x18, 0x70, 0x07, 0x18, 0x01, 0xCE, 0x00, 0x33, 0x00, 0x0E,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0x00, 0x00, 0xC0,
  0x00, 0x30, 0x00, 0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00,
  0x0C, 0x00, 0x03, 0x00, 0x00, 0xC0, 0x00, 0x30, 0x00, 0x0C, 0x00, 0x03,
  0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00,
  0x0C, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00,
  0x70, 0x00, 0xE0, 0x00, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0x80, 0x03,
  0x80, 0x03, 0x00, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x70, 0x00, 0x70, 0x00, 0x60,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF,
  0xFE, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00,
  0x18, 0x00, 0x70, 0x00, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x60,
  0x01, 0xC0, 0x03, 0x00, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x1F, 0xFF, 0xFE, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0xC0,
  0x00, 0xD8, 0x00, 0x3B, 0x80, 0x06, 0x30, 0x01, 0xC7, 0x00, 0x30, 0x60,
  0x0E, 0x0E, 0x01, 0x80, 0xC0, 0x70, 0x1C, 0x0C, 0x01, 0x83, 0x80, 0x38,
  0x60, 0x03, 0x1C, 0x00, 0x73, 0x00, 0x06, 0xE0, 0x00, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xE0, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x1F, 0xF0,
  0xFF, 0xE3, 0x03, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x3F, 0xC7, 0xFF, 0x3C, 0x0D, 0xC0, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0xE0, 0x3D, 0xC1,
  0xB7, 0xFE, 0xCF, 0xE3, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0xFE, 0x1D, 0xFF, 0x8E, 0xC1, 0xE7, 0xC0, 0x73, 0xC0, 0x1D,
  0xE0, 0x06, 0xE0, 0x03, 0x70, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x6F, 0x00, 0x77, 0x80, 0x3B, 0xE0, 0x39, 0xD8, 0x3C,
  0xCF, 0xFC, 0x63, 0xFC, 0x00, 0x07, 0xFC, 0x3F, 0xE1, 0xE0, 0x8E, 0x00,
  0x30, 0x01, 0xC0, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x11, 0xFF, 0xC1, 0xFE, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC1, 0xF8, 0xE3, 0xFF,
  0x73, 0xC1, 0xF9, 0xC0, 0x7D, 0xC0, 0x1E, 0xE0, 0x0F, 0x60, 0x03, 0xB0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xEC, 0x00, 0x77, 0x00,
  0x7B, 0x80, 0x3C, 0xE0, 0x3E, 0x78, 0x33, 0x1F, 0xF9, 0x87, 0xF0, 0xC0,
  0x07, 0xF0, 0x1F, 0xF8, 0x1C, 0x1C, 0x38, 0x0C, 0x70, 0x0E, 0x70, 0x06,
  0x60, 0x06, 0x60, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x06, 0x0F, 0xFE, 0x07, 0xFC,
  0x03, 0xF8, 0x3F, 0xC1, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01,
  0x80, 0x0C, 0x00, 0x60, 0x0F, 0xF9, 0xFF, 0xC0, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00,
  0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00, 0x07, 0xF1, 0x8F, 0xFC,
  0xCF, 0x07, 0xE7, 0x01, 0xF7, 0x00, 0x7B, 0x80, 0x1D, 0x80, 0x0E, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0xDC, 0x01,
  0xEE, 0x00, 0xF3, 0x80, 0xF9, 0xE0, 0xDC, 0x7F, 0xEE, 0x1F, 0xC7, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38,
  0x00, 0x1C, 0x80, 0x1C, 0x7E, 0x7C, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x8F, 0xE7, 0x7F, 0xEE, 0xC1, 0xDF,
  0x01, 0xFC, 0x03, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0C, 0x7F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x06, 0x1C, 0x38, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0D, 0x7B, 0xE7, 0x80, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x77, 0x00, 0xCE, 0x03, 0x9C, 0x0E, 0x38, 0x38, 0x70,
  0x60, 0xE1, 0xC1, 0xC7, 0x03, 0x8C, 0x07, 0x38, 0x0E, 0xF0, 0x1D, 0xF0,
  0x3E, 0xE0, 0x78, 0xE0, 0xE1, 0xC1, 0xC1, 0xC3, 0x83, 0x87, 0x03, 0x8E,
  0x07, 0x1C, 0x07, 0x38, 0x0E, 0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x1C, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xC7, 0xF0, 0x7E, 0x33, 0xFE, 0x3F, 0xED, 0x83, 0x98, 0x3B, 0xE0, 0x7C,
  0x07, 0xF0, 0x0E, 0x01, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x0F, 0x80,
  0x38, 0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0, 0x0F,
  0x80, 0x38, 0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00, 0xE0,
  0x0F, 0x80, 0x38, 0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E, 0x00,
  0xE0, 0x0F, 0x80, 0x38, 0x03, 0xE0, 0x0E, 0x00, 0xF8, 0x03, 0x80, 0x3E,
  0x00, 0xE0, 0x0F, 0x80, 0x38, 0x03, 0xC3, 0xF9, 0x9F, 0xFB, 0x30, 0x76,
  0xC0, 0x7F, 0x00, 0xFE, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0x07, 0xF8, 0x0F, 0xFE, 0x07, 0x07, 0x87, 0x00, 0xC7,
  0x00, 0x73, 0x80, 0x19, 0x80, 0x0E, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x07, 0x60, 0x03, 0xB0, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE3, 0x80, 0x60,
  0xE0, 0x70, 0x7F, 0xF0, 0x0F, 0xF0, 0xC3, 0xF8, 0x63, 0xFE, 0x33, 0x07,
  0x9F, 0x01, 0xCF, 0x00, 0x77, 0x80, 0x1B, 0x80, 0x0D, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xBC, 0x01, 0xDE, 0x00,
  0xEF, 0x80, 0xE7, 0x60, 0xF3, 0xBF, 0xF1, 0xC7, 0xF0, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x00, 0x07, 0xF1, 0x8F,
  0xFC, 0xCF, 0x07, 0xE7, 0x01, 0xF7, 0x00, 0x7B, 0x80, 0x3D, 0x80, 0x0F,
  0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xB0, 0x01, 0xDC,
  0x01, 0xEE, 0x00, 0xF3, 0x80, 0xF9, 0xE0, 0xDC, 0x7F, 0xEE, 0x1F, 0xC7,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0xC3, 0xF8, 0xFB, 0x30, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x1F, 0xF1, 0xFF,
  0xDC, 0x05, 0xC0, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x03,
  0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0x60, 0x3B, 0xFF, 0x8F, 0xF8,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x07, 0xFF, 0xFF, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1F,
  0xC3, 0xF0, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x77, 0x01, 0xEF, 0x06, 0xCF, 0xF9, 0x8F, 0xE3, 0xE0,
  0x03, 0xB0, 0x01, 0x98, 0x01, 0xCE, 0x00, 0xE7, 0x00, 0x61, 0x80, 0x30,
  0xC0, 0x38, 0x70, 0x1C, 0x18, 0x0C, 0x0C, 0x0E, 0x07, 0x07, 0x03, 0x83,
  0x00, 0xC1, 0x80, 0x61, 0xC0, 0x38, 0xC0, 0x0C, 0x60, 0x06, 0x30, 0x03,
  0x38, 0x01, 0xD8, 0x00, 0x6C, 0x00, 0x36, 0x00, 0x1E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0xE0, 0x0E, 0x00, 0xEC, 0x01, 0xE0, 0x1D, 0xC0, 0x3C, 0x03,
  0x38, 0x07, 0x80, 0x63, 0x01, 0xF0, 0x0C, 0x60, 0x37, 0x03, 0x8C, 0x06,
  0x60, 0x71, 0xC0, 0xCC, 0x0C, 0x38, 0x39, 0x81, 0x83, 0x06, 0x30, 0x70,
  0x60, 0xC3, 0x0E, 0x0E, 0x18, 0x61, 0x81, 0xC7, 0x0C, 0x30, 0x18, 0xC1,
  0x86, 0x03, 0x18, 0x39, 0xC0, 0x73, 0x03, 0x30, 0x0E, 0xE0, 0x66, 0x00,
  0xD8, 0x0C, 0xC0, 0x1B, 0x01, 0xF8, 0x03, 0x60, 0x1E, 0x00, 0x7C, 0x03,
  0xC0, 0x07, 0x80, 0x78, 0x00, 0xE0, 0x0F, 0x00, 0x1C, 0x00, 0xE0, 0xE0,
  0x07, 0x70, 0x0E, 0x70, 0x0C, 0x38, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x0C,
  0x30, 0x0E, 0x70, 0x06, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x03,
  0xC0, 0x07, 0xC0, 0x06, 0xE0, 0x0E, 0x60, 0x0C, 0x70, 0x1C, 0x30, 0x18,
  0x38, 0x38, 0x18, 0x30, 0x1C, 0x70, 0x0E, 0x60, 0x0E, 0xE0, 0x07, 0xE0,
  0x03, 0xB0, 0x01, 0xDC, 0x00, 0xCE, 0x00, 0xE3, 0x00, 0x71, 0xC0, 0x30,
  0xE0, 0x18, 0x30, 0x1C, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x07, 0x01, 0x83,
  0x80, 0xE1, 0x80, 0x70, 0xC0, 0x18, 0xE0, 0x0C, 0x60, 0x07, 0x30, 0x01,
  0xB8, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x01, 0xC0, 0x00, 0xC0, 0x00, 0x60, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x18, 0x00, 0x1C, 0x00, 0x0C, 0x00, 0x9E, 0x00, 0x7E, 0x00, 0x3C,
  0x00, 0x00, 0x7F, 0xFB, 0xFF, 0xC0, 0x0C, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00,
  0x30, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x3F, 0x07, 0x80, 0x70, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0xF8, 0x0E, 0x00, 0xF8,
  0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x70, 0x03,
  0x80, 0x3F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x0F, 0xC0, 0x1C, 0x00, 0xE0, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xF0, 0x07, 0x01, 0xF0,
  0x38, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x1C, 0x0F,
  0xC0, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0xE0, 0xF0, 0x7F, 0xF0, 0x0F, 0xE0,
};

const GFXglyph NotoSans_Condensed_Light45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 4, 32, 10, 3, -32 },
  { 17, 10, 11, 15, 3, -32 },
  { 31, 21, 32, 23, 1, -32 },
  { 115, 17, 37, 21, 2, -34 },
  { 194, 26, 33, 30, 2, -33 },
  { 302, 21, 33, 23, 2, -33 },
  { 389, 3, 11, 9, 3, -32 },
  { 394, 9, 39, 12, 2, -32 },
  { 438, 8, 39, 12, 2, -32 },
  { 477, 15, 15, 19, 2, -34 },
  { 506, 17, 21, 21, 2, -26 },
  { 551, 5, 11, 9, 2, -5 },
  { 558, 10, 2, 13, 1, -13 },
  { 561, 4, 4, 10, 3, -4 },
  { 563, 14, 32, 16, 1, -32 },
  { 619, 17, 33, 21, 2, -33 },
  { 690, 10, 32, 21, 3, -32 },
  { 730, 16, 33, 21, 2, -33 },
  { 796, 16, 33, 21, 2, -33 },
  { 862, 19, 32, 21, 1, -32 },
  { 938, 16, 32, 21, 2, -32 },
  { 1002, 17, 34, 21, 2, -33 },
  { 1075, 17, 32, 21, 2, -32 },
  { 1143, 17, 33, 21, 2, -33 },
  { 1214, 16, 33, 21, 2, -33 },
  { 1280, 4, 24, 10, 3, -24 },
  { 1292, 5, 30, 10, 2, -24 },
  { 1311, 17, 20, 21, 2, -26 },
  { 1354, 17, 12, 21, 2, -22 },
  { 1380, 17, 20, 21, 2, -26 },
  { 1423, 13, 33, 15, 1, -33 },
  { 1477, 28, 36, 32, 2, -32 },
  { 1603, 21, 32, 21, 0, -32 },
  { 1687, 17, 32, 23, 4, -32 },
  { 1755, 19, 33, 22, 2, -33 },
  { 1834, 19, 32, 25, 4, -32 },
  { 1910, 14, 32, 20, 4, -32 },
  { 1966, 14, 32, 18, 4, -32 },
  { 2022, 22, 33, 27, 2, -33 },
  { 2113, 18, 32, 26, 4, -32 },
  { 2185, 8, 32, 12, 2, -32 },
  { 2217, 9, 40, 10, -3, -32 },
  { 2262, 17, 32, 21, 4, -32 },
  { 2330, 13, 32, 18, 4, -32 },
  { 2382, 26, 32, 33, 4, -32 },
  { 2486, 19, 32, 27, 4, -32 },
  { 2562, 23, 33, 27, 2, -33 },
  { 2657, 15, 32, 21, 4, -32 },
  { 2717, 23, 41, 27, 2, -33 },
  { 2835, 17, 32, 22, 4, -32 },
  { 2903, 16, 33, 20, 2, -33 },
  { 2969, 18, 32, 18, 0, -32 },
  { 3041, 19, 32, 26, 3, -32 },
  { 3117, 21, 32, 21, 0, -32 },
  { 3201, 33, 32, 34, 0, -32 },
  { 3333, 19, 32, 19, 0, -32 },
  { 3409, 18, 32, 18, 0, -32 },
  { 3481, 16, 32, 19, 1, -32 },
  { 3545, 9, 39, 14, 4, -32 },
  { 3589, 14, 32, 16, 1, -32 },
  { 3645, 9, 39, 14, 1, -32 },
  { 3689, 19, 17, 21, 1, -32 },
  { 3730, 19, 2, 19, 0, 4 },
  { 3735, 8, 7, 11, 2, -34 },
  { 3742, 14, 24, 20, 2, -24 },
  { 3784, 17, 34, 22, 3, -34 },
  { 3857, 14, 24, 17, 2, -24 },
  { 3899, 17, 34, 22, 2, -34 },
  { 3972, 16, 24, 20, 2, -24 },
  { 4020, 13, 34, 11, 0, -34 },
  { 4076, 17, 35, 22, 2, -24 },
  { 4151, 15, 34, 22, 3, -34 },
  { 4215, 3, 33, 9, 3, -33 },
  { 4228, 7, 44, 9, -1, -33 },
  { 4267, 15, 34, 18, 3, -34 },
  { 4331, 3, 34, 9, 3, -34 },
  { 4344, 26, 24, 32, 3, -24 },
  { 4422, 15, 24, 22, 3, -24 },
  { 4467, 17, 24, 21, 2, -24 },
  { 4518, 17, 35, 22, 3, -24 },
  { 4593, 17, 35, 22, 2, -24 },
  { 4668, 11, 24, 14, 3, -24 },
  { 4701, 13, 24, 17, 2, -24 },
  { 4740, 10, 30, 12, 1, -30 },
  { 4778, 15, 24, 22, 3, -24 },
  { 4823, 17, 24, 17, 0, -24 },
  { 4874, 27, 24, 28, 0, -24 },
  { 4955, 16, 24, 18, 1, -24 },
  { 5003, 17, 35, 17, 0, -24 },
  { 5078, 13, 24, 15, 1, -24 },
  { 5117, 12, 39, 16, 2, -32 },
  { 5176, 2, 45, 20, 9, -34 },
  { 5188, 12, 39, 16, 2, -32 },
  { 5247, 17, 4, 21, 2, -18 },
};

const GFXfont NotoSans_Condensed_Light45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light45pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_CONDENSED_LIGHT45PT7B_H_
