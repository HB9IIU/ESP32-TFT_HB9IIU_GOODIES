#ifndef _NOTOSANS_CONDENSED_LIGHT40PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light40pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF2, 0x49, 0x24, 0x80, 0x0B, 0xFE,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x01,
  0x02, 0x00, 0xC0, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x06, 0x00, 0xC1,
  0x80, 0x30, 0x60, 0x08, 0x10, 0x06, 0x04, 0x1F, 0xFF, 0xF7, 0xFF, 0xFC,
  0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00, 0x40, 0x80, 0x30, 0x20, 0x0C,
  0x18, 0x03, 0x06, 0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0x0C, 0x18, 0x02, 0x06,
  0x00, 0x81, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x0C, 0x01, 0x83, 0x00,
  0x60, 0xC0, 0x10, 0x30, 0x00, 0x03, 0x00, 0x0C, 0x00, 0x78, 0x07, 0xFF,
  0x7B, 0x79, 0x8C, 0x2C, 0x30, 0x30, 0xC0, 0xC3, 0x03, 0x0C, 0x0C, 0x30,
  0x30, 0xC0, 0x63, 0x01, 0xEC, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x0D,
  0xE0, 0x31, 0x80, 0xC3, 0x03, 0x0C, 0x0C, 0x30, 0x30, 0xC0, 0xC3, 0x03,
  0x0E, 0x0C, 0x6F, 0x3F, 0xBF, 0xF8, 0x07, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x1C, 0x00, 0xC0, 0x7E, 0x01, 0x81, 0x8C, 0x06, 0x02, 0x0C, 0x0C,
  0x0C, 0x18, 0x18, 0x18, 0x30, 0x60, 0x30, 0x60, 0xC0, 0x60, 0xC3, 0x00,
  0xC1, 0x86, 0x01, 0x83, 0x0C, 0x03, 0x06, 0x30, 0x06, 0x0C, 0x61, 0x0C,
  0x19, 0x8F, 0x98, 0x33, 0x33, 0x90, 0x66, 0x63, 0x31, 0x99, 0x83, 0x3E,
  0x33, 0x06, 0x38, 0xC6, 0x0C, 0x01, 0x8C, 0x18, 0x03, 0x18, 0x30, 0x0C,
  0x30, 0x60, 0x18, 0x60, 0xC0, 0x60, 0xC1, 0x80, 0xC1, 0x83, 0x01, 0x83,
  0x06, 0x06, 0x06, 0x0C, 0x0C, 0x06, 0x30, 0x30, 0x0E, 0xE0, 0x60, 0x0F,
  0x80, 0x07, 0x80, 0x07, 0xF8, 0x01, 0x86, 0x00, 0xC1, 0xC0, 0x30, 0x30,
  0x0C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x70, 0x06, 0x18, 0x01,
  0x8E, 0x00, 0x37, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x01, 0xF0, 0x00, 0xEE,
  0x00, 0x71, 0x81, 0x98, 0x30, 0x6C, 0x0E, 0x1B, 0x01, 0xC6, 0xC0, 0x33,
  0x30, 0x0E, 0xCC, 0x01, 0xF3, 0x00, 0x38, 0xC0, 0x0E, 0x38, 0x07, 0xC7,
  0x03, 0xB9, 0xFF, 0xC6, 0x1F, 0xC1, 0xC0, 0xFF, 0xFF, 0xFC, 0x03, 0x06,
  0x0C, 0x1C, 0x18, 0x38, 0x30, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60,
  0x60, 0x70, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x07, 0xE0, 0x60, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x07, 0x07, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06,
  0x0E, 0x0C, 0x0C, 0x1C, 0x18, 0x30, 0x30, 0xE0, 0x07, 0x00, 0x30, 0x00,
  0x80, 0x04, 0x0E, 0x23, 0xFF, 0xFC, 0x7F, 0x00, 0xE0, 0x0D, 0x80, 0xC6,
  0x0E, 0x30, 0xE0, 0xC1, 0x04, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x77, 0x66, 0x6E, 0xCC, 0xC0, 0xFF,
  0xFF, 0xC0, 0x5F, 0xF0, 0x00, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01, 0x80, 0x30, 0x03, 0x00,
  0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x30, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x00,
  0x07, 0xC0, 0x7F, 0x83, 0x87, 0x0C, 0x0E, 0x70, 0x19, 0x80, 0x66, 0x01,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x36, 0x00, 0xD8, 0x06, 0x70, 0x18, 0xC0, 0xE3, 0x83, 0x07,
  0xFC, 0x0F, 0xC0, 0x01, 0x83, 0xC3, 0xE3, 0xF3, 0xBB, 0x9F, 0x8E, 0x87,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x0F, 0x81, 0xFF, 0x8F, 0x07, 0x10, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xC0, 0x06,
  0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x1F, 0x81, 0xFF, 0x8F, 0x07, 0x30, 0x0E, 0x00, 0x18,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0xE0, 0x7F, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x60, 0x01,
  0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00,
  0x68, 0x03, 0xBF, 0xFC, 0x7F, 0xC0, 0x00, 0x18, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0D, 0x80, 0x06, 0xC0, 0x06, 0x60, 0x03, 0x30, 0x03,
  0x18, 0x01, 0x8C, 0x01, 0x86, 0x00, 0xC3, 0x00, 0xC1, 0x80, 0xE0, 0xC0,
  0x60, 0x60, 0x60, 0x30, 0x30, 0x18, 0x30, 0x0C, 0x18, 0x06, 0x18, 0x03,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x60, 0x00, 0x30, 0x00, 0x18, 0x00,
  0x0C, 0x00, 0x06, 0x00, 0x03, 0x00, 0x01, 0x80, 0x3F, 0xF9, 0xFF, 0xE6,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01,
  0x80, 0x06, 0x00, 0x18, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00,
  0xC0, 0x03, 0x00, 0x1C, 0x00, 0xE8, 0x07, 0x3F, 0xF8, 0x7F, 0xC0, 0x01,
  0xF8, 0x0F, 0xF0, 0x38, 0x20, 0xE0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC0, 0x03, 0x80, 0x06, 0x1E, 0x0C, 0xFF, 0x1B,
  0x8F, 0x34, 0x06, 0x70, 0x0E, 0xE0, 0x0D, 0xC0, 0x1B, 0x00, 0x36, 0x00,
  0x7C, 0x00, 0xFC, 0x01, 0xD8, 0x03, 0x30, 0x06, 0x60, 0x0C, 0x60, 0x38,
  0xE0, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0,
  0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x00, 0xC0,
  0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80,
  0x06, 0x00, 0x38, 0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80,
  0x0E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x07, 0xC0, 0x3F,
  0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x01, 0xDC, 0x01, 0xB8, 0x03, 0x70, 0x06,
  0x60, 0x1C, 0xC0, 0x31, 0xC0, 0xE1, 0xC3, 0x81, 0xEE, 0x00, 0xF8, 0x03,
  0xF0, 0x0E, 0x70, 0x38, 0x70, 0xE0, 0x33, 0x80, 0x76, 0x00, 0x6C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0D, 0xC0, 0x39, 0xC0, 0xE1,
  0xFF, 0x81, 0xFE, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0x87, 0x1C, 0x0C, 0x60,
  0x1B, 0x00, 0x6C, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x76, 0x01, 0xDC, 0x1B, 0x3F, 0xEC, 0x7E, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x01, 0xC0, 0x0E, 0x1F, 0xF0, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0B, 0xFE, 0x39, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xCE, 0x63, 0x19, 0xCC, 0x66, 0x00, 0x00, 0x01, 0x00, 0x07,
  0x00, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x00,
  0xC0, 0x00, 0x80, 0x00, 0x3F, 0x1F, 0xF3, 0x07, 0x00, 0x70, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x06, 0x01,
  0xC0, 0x70, 0x0C, 0x01, 0x80, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x00, 0x70, 0x0E, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00,
  0xFF, 0xC0, 0x03, 0xC0, 0xE0, 0x07, 0x00, 0x30, 0x0C, 0x00, 0x18, 0x1C,
  0x00, 0x0C, 0x18, 0x00, 0x0C, 0x30, 0x00, 0x06, 0x30, 0x0E, 0x06, 0x60,
  0x3F, 0x83, 0x60, 0x61, 0x83, 0x60, 0xC1, 0x83, 0xC1, 0xC1, 0x83, 0xC1,
  0x81, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x81, 0x83, 0xC1,
  0x81, 0x83, 0xC1, 0x81, 0x83, 0xC1, 0x83, 0x83, 0xC1, 0x83, 0x82, 0xC1,
  0x82, 0x86, 0x40, 0xCE, 0xCE, 0x60, 0xFC, 0xFC, 0x60, 0x10, 0x10, 0x60,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x38, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0E,
  0x00, 0x40, 0x07, 0x81, 0xC0, 0x01, 0xFF, 0x80, 0x00, 0x18, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0xD8, 0x00, 0x1B, 0x00, 0x03,
  0x60, 0x00, 0xEC, 0x00, 0x18, 0xC0, 0x03, 0x18, 0x00, 0x63, 0x00, 0x18,
  0x70, 0x03, 0x06, 0x00, 0x60, 0xC0, 0x1C, 0x18, 0x03, 0x01, 0x80, 0x60,
  0x30, 0x0C, 0x06, 0x03, 0xFF, 0xE0, 0x7F, 0xFC, 0x0C, 0x01, 0x83, 0x80,
  0x30, 0x60, 0x07, 0x0C, 0x00, 0x61, 0x80, 0x0C, 0x70, 0x01, 0xCC, 0x00,
  0x19, 0x80, 0x03, 0x70, 0x00, 0x6C, 0x00, 0x0E, 0xFE, 0x00, 0xFF, 0xF0,
  0xE1, 0xF8, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0C, 0xE0, 0x1C, 0xE0, 0x38, 0xFF, 0xE0,
  0xFF, 0xF0, 0xE0, 0x3C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x06,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0xE0, 0x06, 0xE0, 0x0E, 0xE0, 0x0C,
  0xE0, 0x3C, 0xFF, 0xF8, 0xFF, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x0F, 0x03,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x30, 0x00, 0x70, 0x00, 0x60, 0x00,
  0x60, 0x00, 0x60, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x01,
  0x07, 0xFF, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x38, 0x7E, 0x1C, 0x03,
  0x8E, 0x00, 0xE7, 0x00, 0x33, 0x80, 0x1D, 0xC0, 0x06, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1B, 0x80, 0x1D, 0xC0, 0x0C, 0xE0, 0x0E, 0x70, 0x0E, 0x38,
  0x1E, 0x1F, 0xFE, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x7F, 0xFB, 0xFF, 0xDC, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xDF, 0xFE, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF8, 0x1E,
  0x07, 0x87, 0x00, 0x21, 0xC0, 0x00, 0x70, 0x00, 0x0C, 0x00, 0x03, 0x80,
  0x00, 0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00,
  0x01, 0xC0, 0x00, 0x38, 0x07, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x06, 0xE0, 0x00, 0xDC, 0x00,
  0x19, 0x80, 0x03, 0x38, 0x00, 0x63, 0x80, 0x0C, 0x3C, 0x01, 0x83, 0xFF,
  0xF0, 0x1F, 0xFC, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x38, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC7, 0xEF, 0xE0, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x06, 0x06, 0x0E, 0xFC, 0xF8, 0xE0, 0x06, 0xE0, 0x0E, 0xE0,
  0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0x60, 0xE0, 0xC0, 0xE1,
  0xC0, 0xE1, 0x80, 0xE3, 0x00, 0xE7, 0x00, 0xEE, 0x00, 0xEE, 0x00, 0xFF,
  0x00, 0xFB, 0x00, 0xF3, 0x80, 0xE1, 0x80, 0xE1, 0xC0, 0xE0, 0xC0, 0xE0,
  0xE0, 0xE0, 0x70, 0xE0, 0x30, 0xE0, 0x38, 0xE0, 0x18, 0xE0, 0x1C, 0xE0,
  0x0C, 0xE0, 0x0E, 0xE0, 0x07, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF,
  0xF0, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0xFD, 0x80, 0x01, 0xFB, 0x00, 0x07, 0xF7, 0x00, 0x0D, 0xE6, 0x00, 0x1B,
  0xCC, 0x00, 0x77, 0x9C, 0x00, 0xCF, 0x18, 0x01, 0x9E, 0x30, 0x07, 0x3C,
  0x60, 0x0C, 0x78, 0x60, 0x18, 0xF0, 0xC0, 0x71, 0xE1, 0x80, 0xC3, 0xC1,
  0x81, 0x87, 0x83, 0x03, 0x0F, 0x06, 0x0C, 0x1E, 0x06, 0x18, 0x3C, 0x0C,
  0x30, 0x78, 0x18, 0xC0, 0xF0, 0x19, 0x81, 0xE0, 0x33, 0x03, 0xC0, 0x6C,
  0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x1E, 0x01, 0xC0, 0x3C, 0x01, 0x80,
  0x60, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3D, 0x80, 0x1E,
  0xC0, 0x0F, 0x30, 0x07, 0x98, 0x03, 0xC6, 0x01, 0xE3, 0x00, 0xF0, 0xC0,
  0x78, 0x60, 0x3C, 0x18, 0x1E, 0x0C, 0x0F, 0x03, 0x07, 0x81, 0xC3, 0xC0,
  0x61, 0xE0, 0x38, 0xF0, 0x0C, 0x78, 0x07, 0x3C, 0x01, 0x9E, 0x00, 0xEF,
  0x00, 0x37, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x18, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0x0F, 0x01, 0xC0,
  0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00, 0xE6, 0x00, 0x06, 0x60,
  0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x66, 0x00, 0x06, 0x70, 0x00,
  0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x18, 0x1E, 0x07, 0x80, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x03, 0xFF, 0x8E, 0x3F, 0x38, 0x0E, 0xE0,
  0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x6E, 0x07, 0xBF, 0xFC, 0xFF, 0xC3, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0x0F, 0x01, 0xC0, 0x38, 0x38, 0x01, 0xC3, 0x00, 0x0C, 0x70, 0x00,
  0xE6, 0x00, 0x06, 0x60, 0x00, 0x66, 0x00, 0x06, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x76, 0x00, 0x07, 0x60, 0x00, 0x66,
  0x00, 0x06, 0x70, 0x00, 0xE3, 0x00, 0x0C, 0x38, 0x01, 0xC1, 0xC0, 0x18,
  0x1E, 0x07, 0x80, 0xFF, 0xF0, 0x03, 0xFC, 0x00, 0x01, 0xC0, 0x00, 0x0C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0xFC, 0x00, 0xFF, 0xE0, 0xE7, 0xF0, 0xE0, 0x38, 0xE0, 0x1C, 0xE0,
  0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0, 0x0C, 0xE0,
  0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE1, 0xF0, 0xFF, 0xC0, 0xFF, 0x80, 0xE1,
  0xC0, 0xE0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0xE0, 0x70, 0xE0, 0x30, 0xE0,
  0x38, 0xE0, 0x18, 0xE0, 0x1C, 0xE0, 0x0C, 0xE0, 0x0E, 0xE0, 0x07, 0x07,
  0xE0, 0x7F, 0xF3, 0xC3, 0x9C, 0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE8, 0x07, 0xBF, 0xFC,
  0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x06, 0x60, 0x03, 0x38, 0x03, 0x8E, 0x03, 0x83, 0xFF, 0x80,
  0xFF, 0x80, 0xC0, 0x00, 0xF8, 0x00, 0x36, 0x00, 0x1D, 0x80, 0x06, 0x60,
  0x01, 0x9C, 0x00, 0x63, 0x00, 0x38, 0xC0, 0x0C, 0x30, 0x03, 0x0E, 0x01,
  0xC1, 0x80, 0x70, 0x60, 0x18, 0x1C, 0x06, 0x03, 0x03, 0x80, 0xC0, 0xC0,
  0x30, 0x30, 0x0E, 0x0C, 0x01, 0x87, 0x00, 0x61, 0x80, 0x18, 0x60, 0x03,
  0x18, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xE0, 0x00, 0xE0, 0x03, 0x00, 0x1D,
  0x80, 0x0C, 0x00, 0x66, 0x00, 0x70, 0x01, 0x98, 0x01, 0xE0, 0x06, 0x70,
  0x07, 0x80, 0x38, 0xC0, 0x1E, 0x00, 0xC3, 0x00, 0xD8, 0x03, 0x0C, 0x03,
  0x30, 0x0C, 0x38, 0x0C, 0xC0, 0x70, 0xE0, 0x33, 0x01, 0x81, 0x80, 0xCC,
  0x06, 0x06, 0x06, 0x30, 0x18, 0x18, 0x18, 0x60, 0xE0, 0x70, 0x61, 0x83,
  0x80, 0xC1, 0x86, 0x0C, 0x03, 0x0E, 0x18, 0x30, 0x0C, 0x30, 0x30, 0xC0,
  0x38, 0xC0, 0xC7, 0x00, 0x63, 0x03, 0x18, 0x01, 0x8C, 0x0C, 0x60, 0x06,
  0x60, 0x39, 0x80, 0x19, 0x80, 0x6E, 0x00, 0x76, 0x01, 0xB0, 0x00, 0xD8,
  0x06, 0xC0, 0x03, 0x60, 0x1B, 0x00, 0x0F, 0x00, 0x2C, 0x00, 0x3C, 0x00,
  0xF0, 0x00, 0x70, 0x03, 0x80, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x18,
  0x03, 0x8C, 0x01, 0x87, 0x01, 0xC1, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x60,
  0x1C, 0x30, 0x06, 0x38, 0x03, 0x18, 0x00, 0xDC, 0x00, 0x6C, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x01,
  0x8C, 0x00, 0xC6, 0x00, 0xE3, 0x80, 0x60, 0xC0, 0x70, 0x70, 0x30, 0x18,
  0x38, 0x0E, 0x18, 0x03, 0x1C, 0x01, 0x8C, 0x00, 0xEE, 0x00, 0x38, 0xC0,
  0x03, 0xE0, 0x03, 0x60, 0x06, 0x70, 0x06, 0x30, 0x0E, 0x30, 0x0C, 0x38,
  0x0C, 0x18, 0x18, 0x1C, 0x18, 0x0C, 0x38, 0x0C, 0x30, 0x0E, 0x30, 0x06,
  0x60, 0x06, 0x60, 0x03, 0x60, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x7F, 0xFD, 0xFF,
  0xF0, 0x00, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x30, 0x00,
  0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03,
  0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x06, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x18, 0x01, 0x80, 0x1C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0xFF, 0xFF, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0xFF, 0xFF, 0x00, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x6C, 0x00, 0x36, 0x00, 0x33, 0x80, 0x18, 0xC0, 0x18, 0x70, 0x0C,
  0x18, 0x0C, 0x0E, 0x06, 0x03, 0x06, 0x01, 0xC3, 0x00, 0x63, 0x00, 0x31,
  0x80, 0x0D, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0xC3, 0x87, 0x0C, 0x18, 0x30,
  0x40, 0x07, 0x01, 0xFF, 0x1E, 0x38, 0x80, 0xE0, 0x03, 0x00, 0x18, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x03, 0xC3, 0xFE, 0x7C, 0x77, 0x03, 0xF0, 0x1F,
  0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F, 0xC1, 0xB7, 0xB9, 0x9F,
  0x8C, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x30, 0x00, 0x60, 0x00, 0xC1, 0x81, 0x9F, 0xC3, 0x71, 0xE6, 0x81, 0xCE,
  0x01, 0xDC, 0x01, 0xB8, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xE0, 0x0D,
  0xC0, 0x3B, 0xC0, 0x66, 0x81, 0xCD, 0xFF, 0x19, 0xFC, 0x00, 0x01, 0xC0,
  0xFF, 0x1E, 0x33, 0x80, 0x70, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1F, 0xF0, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x07, 0x8E,
  0x3F, 0xDC, 0xF1, 0xD9, 0x81, 0xB7, 0x01, 0xEC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x59, 0x81, 0xB3,
  0xFE, 0x61, 0xF8, 0xC0, 0x03, 0x00, 0x7F, 0x83, 0xC7, 0x0C, 0x0E, 0x60,
  0x19, 0x80, 0x6E, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00, 0x60, 0x01, 0x80, 0x07,
  0x00, 0x0E, 0x02, 0x1F, 0xF8, 0x3F, 0xC0, 0x01, 0x80, 0x7F, 0x0F, 0x20,
  0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0xFF, 0x8F,
  0xF8, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x00, 0x07, 0x80, 0x3F, 0xCC, 0xF1, 0xD9,
  0x80, 0xB7, 0x01, 0xEC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x59, 0x81, 0xF3, 0xFE, 0xE1, 0xF9, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30, 0x00, 0xE4, 0x03,
  0x8F, 0x1F, 0x1F, 0xF8, 0x07, 0xC0, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC3, 0x86, 0x7F, 0x37, 0x3D,
  0xE0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0xDF, 0x00, 0x00, 0xDB, 0x6D,
  0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x0C, 0x1C, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x6B, 0xDF, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x03, 0xB0, 0x19, 0x81,
  0x8C, 0x1C, 0x60, 0xC3, 0x0C, 0x18, 0xC0, 0xCE, 0x06, 0x70, 0x37, 0x81,
  0xEE, 0x0F, 0x30, 0x71, 0xC3, 0x06, 0x18, 0x38, 0xC0, 0xC6, 0x07, 0x30,
  0x19, 0x80, 0xEC, 0x03, 0x60, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0x80, 0xE1, 0x9F, 0xC7, 0xF3, 0x63, 0x9C, 0xF7, 0x83,
  0xA0, 0x6E, 0x03, 0x80, 0xFC, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xE0, 0x1C, 0x03,
  0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0x80, 0x78, 0x07, 0x00, 0xC0, 0x03, 0x86, 0x7F, 0x37, 0x1D, 0xE0,
  0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0x03, 0x80, 0x3F, 0xE0, 0xF1, 0xE1,
  0x80, 0xC6, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x07,
  0x60, 0x0C, 0xC0, 0x19, 0xC0, 0x71, 0xC1, 0xC1, 0xFF, 0x01, 0xFC, 0x00,
  0x03, 0x81, 0x9F, 0xE3, 0x71, 0xE6, 0x80, 0xCE, 0x01, 0xDC, 0x01, 0xB8,
  0x03, 0x60, 0x06, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x06, 0xE0, 0x0D, 0xC0, 0x3B, 0xC0, 0x66,
  0xC1, 0xCD, 0xFF, 0x18, 0xFC, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80,
  0x03, 0x00, 0x06, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x30, 0x00, 0x00, 0x07,
  0x00, 0x3F, 0xCC, 0xF1, 0xD9, 0x81, 0xB7, 0x01, 0xEC, 0x01, 0xF8, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0E, 0xC0, 0x1D, 0xC0, 0x59, 0x81,
  0xF3, 0xFE, 0xE3, 0xF9, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0xE7,
  0xF7, 0xFB, 0x0F, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x06,
  0x07, 0xFD, 0xC3, 0xF0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xC0, 0x7F, 0xFD, 0xFF, 0x00, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x07,
  0xFF, 0xFE, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x1F, 0x8F, 0xC0,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x3F, 0x01, 0xD8, 0x1E, 0xFF, 0xB3, 0xF9, 0x80, 0xE0,
  0x0E, 0xC0, 0x19, 0x80, 0x33, 0x00, 0xE7, 0x01, 0x86, 0x03, 0x0C, 0x06,
  0x1C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0xE3, 0x00, 0xC6, 0x01,
  0x8C, 0x03, 0x38, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0xE0, 0x1C, 0x03, 0x60, 0x1C, 0x07, 0x60, 0x3C, 0x06,
  0x70, 0x34, 0x06, 0x30, 0x36, 0x06, 0x30, 0x36, 0x06, 0x30, 0x66, 0x0C,
  0x30, 0x66, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0x63, 0x0C, 0x18, 0xC3, 0x1C,
  0x18, 0xC3, 0x18, 0x1C, 0xC1, 0x98, 0x0C, 0xC1, 0x98, 0x0C, 0xC1, 0x98,
  0x0D, 0x81, 0xB0, 0x0D, 0x80, 0xB0, 0x07, 0x80, 0xF0, 0x07, 0x80, 0xF0,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0xE0, 0x1D, 0x80, 0xE3, 0x03, 0x0C,
  0x1C, 0x18, 0x60, 0x63, 0x80, 0xCC, 0x03, 0x70, 0x07, 0x80, 0x1C, 0x00,
  0x70, 0x01, 0xE0, 0x0F, 0x80, 0x33, 0x01, 0x8C, 0x06, 0x18, 0x30, 0x70,
  0xC0, 0xC6, 0x03, 0xB8, 0x06, 0xC0, 0x1C, 0xE0, 0x06, 0xC0, 0x1D, 0x80,
  0x31, 0x80, 0x63, 0x01, 0xC6, 0x03, 0x0E, 0x06, 0x0C, 0x0C, 0x18, 0x30,
  0x30, 0x60, 0x30, 0xC0, 0x63, 0x80, 0xC6, 0x01, 0xCC, 0x01, 0x98, 0x03,
  0x60, 0x06, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x18, 0x00, 0x70,
  0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x0C, 0x00, 0x18, 0x00, 0x70, 0x09,
  0xC0, 0x1F, 0x00, 0x18, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x7F, 0xFF, 0xFE, 0x00,
  0x40, 0xF0, 0x78, 0x38, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x38, 0x3C, 0x0F, 0x00, 0x60,
  0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0E, 0x01, 0xF0, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x7C, 0x0F, 0x83, 0x80, 0xE0, 0x18, 0x03,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x1C, 0x1F, 0x03, 0xC0, 0x00, 0x3F, 0x01, 0x7F, 0xC3, 0xC1, 0xFF,
  0x80, 0x3C,
};

const GFXglyph NotoSans_Condensed_Light40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 29, 9, 3, -29 },
  { 12, 8, 11, 14, 3, -29 },
  { 23, 18, 29, 20, 1, -29 },
  { 89, 14, 32, 18, 2, -30 },
  { 145, 23, 29, 27, 2, -29 },
  { 229, 18, 29, 21, 2, -29 },
  { 295, 2, 11, 8, 3, -29 },
  { 298, 8, 35, 11, 2, -29 },
  { 333, 8, 35, 11, 1, -29 },
  { 368, 13, 13, 17, 2, -30 },
  { 390, 16, 18, 18, 1, -23 },
  { 426, 4, 9, 8, 2, -4 },
  { 431, 9, 2, 11, 1, -12 },
  { 434, 3, 4, 9, 3, -4 },
  { 436, 12, 29, 14, 1, -29 },
  { 480, 14, 29, 18, 2, -29 },
  { 531, 9, 29, 18, 3, -29 },
  { 564, 14, 29, 18, 2, -29 },
  { 615, 14, 29, 18, 2, -29 },
  { 666, 17, 29, 18, 1, -29 },
  { 728, 14, 29, 18, 2, -29 },
  { 779, 15, 29, 18, 2, -29 },
  { 834, 14, 29, 18, 2, -29 },
  { 885, 15, 29, 18, 2, -29 },
  { 940, 14, 29, 18, 2, -29 },
  { 991, 3, 21, 9, 3, -21 },
  { 999, 5, 26, 9, 1, -21 },
  { 1016, 16, 18, 18, 1, -23 },
  { 1052, 16, 10, 18, 1, -19 },
  { 1072, 16, 18, 18, 1, -23 },
  { 1108, 11, 29, 13, 1, -29 },
  { 1148, 24, 33, 28, 2, -29 },
  { 1247, 19, 29, 19, 0, -29 },
  { 1316, 16, 29, 20, 3, -29 },
  { 1374, 16, 29, 20, 2, -29 },
  { 1432, 17, 29, 22, 3, -29 },
  { 1494, 13, 29, 18, 3, -29 },
  { 1542, 13, 29, 16, 3, -29 },
  { 1590, 19, 29, 24, 2, -29 },
  { 1659, 17, 29, 23, 3, -29 },
  { 1721, 7, 29, 11, 2, -29 },
  { 1747, 8, 36, 9, -2, -29 },
  { 1783, 16, 29, 19, 3, -29 },
  { 1841, 12, 29, 16, 3, -29 },
  { 1885, 23, 29, 30, 3, -29 },
  { 1969, 17, 29, 24, 3, -29 },
  { 2031, 20, 29, 24, 2, -29 },
  { 2104, 14, 29, 19, 3, -29 },
  { 2155, 20, 36, 24, 2, -29 },
  { 2245, 16, 29, 19, 3, -29 },
  { 2303, 14, 29, 18, 2, -29 },
  { 2354, 16, 29, 16, 0, -29 },
  { 2412, 17, 29, 23, 3, -29 },
  { 2474, 18, 29, 18, 0, -29 },
  { 2540, 30, 29, 30, 0, -29 },
  { 2649, 17, 29, 17, 0, -29 },
  { 2711, 16, 29, 16, 0, -29 },
  { 2769, 14, 29, 16, 1, -29 },
  { 2820, 8, 35, 13, 3, -29 },
  { 2855, 12, 29, 14, 1, -29 },
  { 2899, 8, 35, 13, 1, -29 },
  { 2934, 17, 16, 19, 1, -29 },
  { 2968, 17, 1, 17, 0, 4 },
  { 2971, 6, 7, 10, 2, -31 },
  { 2977, 13, 22, 17, 2, -22 },
  { 3013, 15, 30, 20, 3, -30 },
  { 3070, 12, 22, 15, 2, -22 },
  { 3103, 15, 30, 20, 2, -30 },
  { 3160, 14, 22, 18, 2, -22 },
  { 3199, 12, 31, 10, 0, -31 },
  { 3246, 15, 32, 20, 2, -22 },
  { 3306, 13, 30, 19, 3, -30 },
  { 3355, 3, 29, 8, 3, -29 },
  { 3366, 7, 39, 8, -1, -29 },
  { 3401, 13, 30, 16, 3, -30 },
  { 3450, 2, 30, 8, 3, -30 },
  { 3458, 23, 22, 29, 3, -22 },
  { 3522, 13, 22, 19, 3, -22 },
  { 3558, 15, 22, 19, 2, -22 },
  { 3600, 15, 31, 20, 3, -22 },
  { 3659, 15, 31, 20, 2, -22 },
  { 3718, 9, 22, 13, 3, -22 },
  { 3743, 11, 22, 15, 2, -22 },
  { 3774, 9, 26, 11, 1, -26 },
  { 3804, 13, 21, 19, 3, -21 },
  { 3839, 15, 21, 15, 0, -21 },
  { 3879, 24, 21, 24, 0, -21 },
  { 3942, 14, 21, 16, 1, -21 },
  { 3979, 15, 31, 15, 0, -21 },
  { 4038, 11, 21, 13, 1, -21 },
  { 4067, 10, 35, 14, 2, -29 },
  { 4111, 2, 40, 17, 8, -30 },
  { 4121, 11, 35, 14, 2, -29 },
  { 4170, 16, 4, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Light40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light40pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_CONDENSED_LIGHT40PT7B_H_
