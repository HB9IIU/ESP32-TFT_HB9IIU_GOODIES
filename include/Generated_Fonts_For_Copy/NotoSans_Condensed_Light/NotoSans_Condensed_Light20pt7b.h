#ifndef _NOTOSANS_CONDENSED_LIGHT20PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light20pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x55, 0x50, 0x70, 0xDC, 0xE7, 0x29, 0x00, 0x09, 0x04, 0x41,
  0x10, 0x44, 0x7F, 0xC4, 0x81, 0x20, 0x48, 0x12, 0x3F, 0xE2, 0x20, 0x88,
  0x24, 0x09, 0x00, 0x10, 0x79, 0x4C, 0x89, 0x12, 0x14, 0x18, 0x1C, 0x24,
  0x48, 0x91, 0x3F, 0x84, 0x08, 0x70, 0x89, 0x10, 0x89, 0x08, 0x90, 0x8A,
  0x08, 0xAC, 0x95, 0x25, 0x52, 0x25, 0x10, 0x91, 0x09, 0x11, 0x11, 0x11,
  0x23, 0x0E, 0x78, 0x22, 0x11, 0x08, 0x86, 0x81, 0xC0, 0xC0, 0xB1, 0x89,
  0xC2, 0xA1, 0xD0, 0x4C, 0x73, 0xC4, 0xEA, 0x80, 0x32, 0x44, 0xC8, 0x88,
  0x88, 0x88, 0xC4, 0x42, 0x30, 0x84, 0x42, 0x22, 0x23, 0x33, 0x22, 0x22,
  0x44, 0x80, 0x10, 0x23, 0x79, 0x82, 0x89, 0x80, 0x10, 0x20, 0x40, 0x8F,
  0xE2, 0x04, 0x08, 0x10, 0x20, 0x7A, 0x80, 0xF0, 0x70, 0x06, 0x08, 0x10,
  0x40, 0x81, 0x04, 0x08, 0x20, 0x40, 0x82, 0x04, 0x18, 0x00, 0x7C, 0x8B,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0A, 0x14, 0x47, 0x00, 0x35,
  0x91, 0x11, 0x11, 0x11, 0x11, 0x11, 0xFD, 0x08, 0x08, 0x10, 0x60, 0x81,
  0x04, 0x18, 0x20, 0x82, 0x0C, 0x1F, 0xC0, 0xFD, 0x0C, 0x08, 0x10, 0x61,
  0x8C, 0x06, 0x02, 0x04, 0x08, 0x18, 0x5F, 0x80, 0x06, 0x03, 0x02, 0x81,
  0x41, 0x20, 0x90, 0x88, 0x44, 0x42, 0x61, 0x3F, 0xE0, 0x40, 0x20, 0x10,
  0x7C, 0x81, 0x02, 0x08, 0x17, 0x13, 0x01, 0x02, 0x04, 0x08, 0x18, 0x5F,
  0x00, 0x3E, 0xC1, 0x02, 0x08, 0x17, 0xB1, 0xE1, 0x83, 0x06, 0x0E, 0x14,
  0x67, 0x80, 0xFE, 0x04, 0x18, 0x20, 0x41, 0x02, 0x04, 0x10, 0x20, 0x41,
  0x02, 0x0C, 0x00, 0x7D, 0x86, 0x0C, 0x14, 0x6D, 0x86, 0x36, 0xC3, 0x06,
  0x0C, 0x1C, 0x2F, 0x80, 0x7D, 0x8A, 0x0C, 0x18, 0x30, 0x61, 0xA7, 0x32,
  0x04, 0x18, 0x20, 0xCF, 0x00, 0x70, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xA0,
  0x02, 0x0C, 0x31, 0x8C, 0x18, 0x0C, 0x06, 0x02, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x06, 0x18, 0x60, 0x80, 0xF8,
  0x10, 0x41, 0x04, 0x21, 0x84, 0x20, 0x80, 0x00, 0x20, 0x80, 0x1F, 0x83,
  0x04, 0x60, 0x24, 0x01, 0x4F, 0x98, 0x91, 0x91, 0x19, 0x11, 0x91, 0x19,
  0x11, 0x89, 0xA8, 0x6E, 0x40, 0x06, 0x00, 0x30, 0x80, 0xF0, 0x0C, 0x06,
  0x05, 0x02, 0x81, 0x21, 0x90, 0x88, 0x46, 0x3F, 0x20, 0x90, 0x48, 0x1C,
  0x0C, 0x04, 0xFD, 0x0E, 0x0C, 0x18, 0x30, 0xBE, 0x43, 0x83, 0x06, 0x0C,
  0x18, 0x7F, 0x00, 0x3F, 0x20, 0x40, 0x40, 0xC0, 0x80, 0x80, 0x80, 0x80,
  0xC0, 0x40, 0x40, 0x20, 0x1F, 0xFC, 0x86, 0x82, 0x83, 0x81, 0x81, 0x81,
  0x81, 0x81, 0x81, 0x83, 0x82, 0x84, 0xF8, 0xFE, 0x08, 0x20, 0x82, 0x0F,
  0xE0, 0x82, 0x08, 0x20, 0x83, 0xF0, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x3F,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x1F, 0x88, 0x04, 0x01, 0x00, 0xC0, 0x20,
  0x08, 0x02, 0x0F, 0x80, 0xF0, 0x34, 0x0D, 0x03, 0x20, 0xC7, 0xE0, 0x81,
  0x81, 0x81, 0x81, 0x81, 0x81, 0xFF, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81,
  0x81, 0xF4, 0x44, 0x44, 0x44, 0x44, 0x44, 0x4F, 0x11, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x11, 0x11, 0xAC, 0x87, 0x0A, 0x24, 0xC9, 0x14, 0x38, 0x78,
  0x91, 0x12, 0x24, 0x28, 0x70, 0x40, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x83, 0xF0, 0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x5A, 0x0B,
  0x41, 0x68, 0x4C, 0x89, 0x91, 0x32, 0x46, 0x28, 0xC5, 0x18, 0xC3, 0x08,
  0x40, 0x81, 0xC1, 0xC1, 0xA1, 0xA1, 0x91, 0x91, 0x89, 0x89, 0x85, 0x85,
  0x83, 0x83, 0x81, 0x3F, 0x18, 0x64, 0x0B, 0x03, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x14, 0x09, 0x02, 0x21, 0x87, 0x80, 0xF9, 0x0A, 0x1C,
  0x38, 0x70, 0xA1, 0x7C, 0x81, 0x02, 0x04, 0x08, 0x10, 0x00, 0x3F, 0x18,
  0x64, 0x0B, 0x03, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x14, 0x09,
  0x02, 0x21, 0x87, 0x80, 0x20, 0x0C, 0x01, 0x80, 0xF9, 0x0A, 0x1C, 0x38,
  0x70, 0xA3, 0x78, 0x99, 0x12, 0x34, 0x28, 0x70, 0x40, 0x7F, 0x82, 0x04,
  0x08, 0x08, 0x0C, 0x06, 0x06, 0x04, 0x08, 0x18, 0x5F, 0x00, 0xFF, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x81, 0x83,
  0xC2, 0x7C, 0x80, 0xE0, 0x50, 0x48, 0x24, 0x11, 0x18, 0x88, 0x44, 0x32,
  0x0A, 0x05, 0x02, 0x80, 0xC0, 0x40, 0xC1, 0x06, 0x82, 0x09, 0x0A, 0x12,
  0x14, 0x24, 0x28, 0x44, 0x51, 0x09, 0x12, 0x12, 0x24, 0x24, 0x48, 0x68,
  0xB0, 0x51, 0x40, 0xC1, 0x81, 0x83, 0x03, 0x06, 0x00, 0x41, 0x62, 0x22,
  0x24, 0x14, 0x18, 0x08, 0x18, 0x14, 0x24, 0x22, 0x42, 0x43, 0xC1, 0x81,
  0x42, 0x42, 0x22, 0x24, 0x24, 0x18, 0x18, 0x08, 0x08, 0x08, 0x08, 0x08,
  0x08, 0xFE, 0x08, 0x30, 0x40, 0x82, 0x04, 0x10, 0x20, 0x81, 0x06, 0x08,
  0x1F, 0xC0, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0,
  0x81, 0x01, 0x02, 0x06, 0x04, 0x08, 0x08, 0x10, 0x20, 0x20, 0x40, 0xC0,
  0xF1, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0x11, 0xF0, 0x08, 0x0A, 0x05,
  0x04, 0x42, 0x23, 0x0B, 0x06, 0xFF, 0xC8, 0x80, 0x39, 0x10, 0x41, 0x05,
  0xFC, 0x61, 0x86, 0x37, 0x40, 0xC0, 0xC0, 0xC0, 0xC0, 0xDC, 0xE6, 0xC2,
  0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC3, 0xA2, 0xBC, 0x3D, 0x94, 0x20, 0x82,
  0x08, 0x20, 0xC1, 0x03, 0xC0, 0x02, 0x04, 0x08, 0x13, 0xA8, 0xF0, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x28, 0xDE, 0x80, 0x38, 0x8B, 0x0C, 0x18, 0x3F,
  0xE0, 0x40, 0xC0, 0x84, 0xF8, 0x3C, 0x82, 0x08, 0xF8, 0x82, 0x08, 0x20,
  0x82, 0x08, 0x20, 0x82, 0x00, 0x3A, 0x8F, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x8D, 0xE8, 0x10, 0x20, 0x61, 0x3C, 0xC1, 0x83, 0x06, 0x0D, 0xDC,
  0xF0, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0x80, 0x70, 0x55, 0x55,
  0x54, 0x2C, 0x06, 0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x78, 0xB2, 0x68, 0xD1, 0xE3, 0x66, 0x4C, 0xD8, 0xB1, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x98, 0xEA, 0x53, 0xC2, 0x1C, 0x21, 0xC2, 0x1C, 0x21,
  0xC2, 0x1C, 0x21, 0xC2, 0x1C, 0x21, 0xC2, 0x10, 0x9D, 0x4F, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xC3, 0x87, 0x08, 0x38, 0x44, 0xC2, 0x82, 0x82, 0x83,
  0x82, 0x82, 0x82, 0x46, 0x3C, 0x9C, 0xA6, 0xC2, 0xC1, 0xC1, 0xC1, 0xC1,
  0xC1, 0xC2, 0xE2, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3A, 0x8F, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x82, 0x8D, 0xE8, 0x10, 0x20, 0x40, 0x81, 0x9D,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x30, 0x7F, 0x28, 0x20, 0xC0, 0xC1, 0x83,
  0x06, 0x2F, 0x80, 0x21, 0x3E, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0x80,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x8D, 0xE8, 0x83, 0x85,
  0x0A, 0x24, 0x44, 0x89, 0x14, 0x28, 0x30, 0x40, 0x82, 0x1C, 0x61, 0x46,
  0x34, 0x52, 0x45, 0x26, 0x92, 0x29, 0x22, 0x94, 0x28, 0xC3, 0x0C, 0x10,
  0xC0, 0x42, 0x84, 0x91, 0x21, 0x83, 0x06, 0x16, 0x24, 0x87, 0x08, 0x83,
  0x42, 0x42, 0x42, 0x44, 0x24, 0x24, 0x28, 0x18, 0x18, 0x18, 0x10, 0x10,
  0x10, 0x20, 0xC0, 0xF8, 0x44, 0x22, 0x11, 0x88, 0xC4, 0x3E, 0x19, 0x08,
  0x42, 0x10, 0x8C, 0xC1, 0x08, 0x42, 0x10, 0x84, 0x18, 0xFF, 0xFF, 0xF0,
  0xC1, 0x08, 0x42, 0x10, 0x86, 0x09, 0x88, 0x42, 0x10, 0x84, 0xC0, 0xF1,
  0x8E,
};

const GFXglyph NotoSans_Condensed_Light20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 2, 14, 4, 1, -14 },
  { 5, 5, 5, 7, 1, -14 },
  { 9, 10, 14, 10, 0, -14 },
  { 27, 7, 16, 9, 1, -15 },
  { 41, 12, 14, 14, 1, -14 },
  { 62, 9, 14, 10, 1, -14 },
  { 78, 2, 5, 4, 1, -14 },
  { 80, 4, 17, 6, 1, -14 },
  { 89, 4, 17, 6, 1, -14 },
  { 98, 7, 6, 8, 1, -15 },
  { 104, 7, 10, 9, 1, -12 },
  { 113, 2, 5, 4, 1, -2 },
  { 115, 4, 1, 6, 1, -6 },
  { 116, 2, 2, 4, 1, -2 },
  { 117, 7, 14, 7, 0, -14 },
  { 130, 7, 14, 9, 1, -14 },
  { 143, 4, 14, 9, 2, -14 },
  { 150, 7, 14, 9, 1, -14 },
  { 163, 7, 14, 9, 1, -14 },
  { 176, 9, 14, 9, 0, -14 },
  { 192, 7, 14, 9, 1, -14 },
  { 205, 7, 14, 9, 1, -14 },
  { 218, 7, 14, 9, 1, -14 },
  { 231, 7, 14, 9, 1, -14 },
  { 244, 7, 14, 9, 1, -14 },
  { 257, 2, 11, 4, 1, -11 },
  { 260, 2, 14, 4, 1, -11 },
  { 264, 7, 9, 9, 1, -12 },
  { 272, 7, 6, 9, 1, -10 },
  { 278, 8, 9, 9, 1, -12 },
  { 287, 6, 14, 7, 0, -14 },
  { 298, 12, 16, 14, 1, -14 },
  { 322, 9, 14, 9, 0, -14 },
  { 338, 7, 14, 10, 2, -14 },
  { 351, 8, 14, 10, 1, -14 },
  { 365, 8, 14, 11, 2, -14 },
  { 379, 6, 14, 9, 2, -14 },
  { 390, 6, 14, 8, 2, -14 },
  { 401, 10, 14, 12, 1, -14 },
  { 419, 8, 14, 11, 2, -14 },
  { 433, 4, 14, 5, 1, -14 },
  { 440, 4, 18, 4, -1, -14 },
  { 449, 7, 14, 9, 2, -14 },
  { 462, 6, 14, 8, 2, -14 },
  { 473, 11, 14, 15, 2, -14 },
  { 493, 8, 14, 12, 2, -14 },
  { 507, 10, 14, 12, 1, -14 },
  { 525, 7, 14, 9, 2, -14 },
  { 538, 10, 17, 12, 1, -14 },
  { 560, 7, 14, 10, 2, -14 },
  { 573, 7, 14, 9, 1, -14 },
  { 586, 8, 14, 8, 0, -14 },
  { 600, 8, 14, 11, 2, -14 },
  { 614, 9, 14, 9, 0, -14 },
  { 630, 15, 14, 15, 0, -14 },
  { 657, 8, 14, 8, 0, -14 },
  { 671, 8, 14, 8, 0, -14 },
  { 685, 7, 14, 8, 1, -14 },
  { 698, 4, 17, 6, 2, -14 },
  { 707, 7, 14, 7, 0, -14 },
  { 720, 4, 17, 6, 1, -14 },
  { 729, 9, 7, 9, 0, -14 },
  { 737, 8, 1, 8, 0, 2 },
  { 738, 3, 3, 5, 1, -15 },
  { 740, 6, 11, 9, 1, -11 },
  { 749, 8, 15, 10, 1, -15 },
  { 764, 6, 11, 7, 1, -11 },
  { 773, 7, 15, 10, 1, -15 },
  { 787, 7, 11, 9, 1, -11 },
  { 797, 6, 15, 5, 0, -15 },
  { 809, 7, 16, 10, 1, -11 },
  { 823, 7, 15, 10, 1, -15 },
  { 837, 2, 15, 4, 1, -15 },
  { 841, 3, 20, 4, 0, -15 },
  { 849, 7, 15, 8, 1, -15 },
  { 863, 2, 15, 4, 1, -15 },
  { 867, 12, 11, 14, 1, -11 },
  { 884, 7, 11, 10, 1, -11 },
  { 894, 8, 11, 9, 1, -11 },
  { 905, 8, 16, 10, 1, -11 },
  { 921, 7, 16, 10, 1, -11 },
  { 935, 5, 11, 6, 1, -11 },
  { 942, 6, 11, 7, 1, -11 },
  { 951, 5, 13, 5, 0, -13 },
  { 960, 7, 11, 10, 1, -11 },
  { 970, 7, 11, 7, 0, -11 },
  { 980, 12, 11, 12, 0, -11 },
  { 997, 7, 11, 8, 0, -11 },
  { 1007, 8, 16, 8, 0, -11 },
  { 1023, 5, 11, 7, 1, -11 },
  { 1030, 5, 17, 7, 1, -14 },
  { 1041, 1, 20, 9, 4, -15 },
  { 1044, 5, 17, 7, 1, -14 },
  { 1055, 8, 2, 9, 1, -8 },
};

const GFXfont NotoSans_Condensed_Light20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light20pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_CONDENSED_LIGHT20PT7B_H_
