#ifndef _NOTOSANS_CONDENSED_LIGHT57PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light57pt7bBitmaps[] PROGMEM = {
  0x00, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73,
  0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x38, 0x00, 0x00, 0x00, 0x07,
  0x7F, 0xFF, 0xF1, 0x00, 0xE0, 0xFE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x06, 0xE0, 0x60, 0x00, 0x30, 0x0C, 0x00, 0x0C, 0x03, 0x00, 0x03, 0x00,
  0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07,
  0x01, 0xC0, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x18, 0x06, 0x00,
  0x0E, 0x03, 0x80, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x00, 0xC0, 0x30, 0x00, 0x70,
  0x1C, 0x00, 0x1C, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00,
  0x60, 0x18, 0x00, 0x18, 0x06, 0x00, 0x06, 0x01, 0x80, 0x03, 0x80, 0xE0,
  0x00, 0xE0, 0x38, 0x0F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0x03, 0x00,
  0xE0, 0x00, 0xC0, 0x30, 0x00, 0x30, 0x0C, 0x00, 0x1C, 0x03, 0x00, 0x07,
  0x01, 0xC0, 0x01, 0xC0, 0x70, 0x00, 0x70, 0x1C, 0x00, 0x18, 0x07, 0x00,
  0x06, 0x01, 0x80, 0x01, 0x80, 0x60, 0x00, 0x60, 0x18, 0x00, 0x38, 0x0E,
  0x00, 0x0E, 0x03, 0x80, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60,
  0x00, 0x06, 0x00, 0x07, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0x6F, 0xE7, 0x86,
  0x0C, 0x70, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xC0,
  0x60, 0x0C, 0x06, 0x00, 0xE0, 0x60, 0x0E, 0x06, 0x00, 0xE0, 0x60, 0x0F,
  0x06, 0x00, 0x78, 0x60, 0x03, 0xE6, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x06, 0x7C, 0x00, 0x61,
  0xE0, 0x06, 0x0F, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06,
  0x07, 0x00, 0x60, 0x70, 0x06, 0x07, 0x00, 0x60, 0x70, 0x06, 0x0F, 0x80,
  0x61, 0xEF, 0x06, 0x3C, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0x0F, 0xF8, 0x00,
  0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00, 0x00, 0x60, 0x00, 0x06, 0x00,
  0x1F, 0x80, 0x01, 0xC0, 0x1F, 0xE0, 0x00, 0xC0, 0x0E, 0x38, 0x00, 0xE0,
  0x0E, 0x0E, 0x00, 0x70, 0x06, 0x07, 0x00, 0x70, 0x07, 0x01, 0x80, 0x38,
  0x03, 0x80, 0xC0, 0x18, 0x01, 0xC0, 0x70, 0x1C, 0x00, 0xC0, 0x38, 0x0E,
  0x00, 0x60, 0x1C, 0x0E, 0x00, 0x30, 0x0E, 0x07, 0x00, 0x18, 0x07, 0x03,
  0x00, 0x0C, 0x03, 0x83, 0x80, 0x06, 0x01, 0xC1, 0xC0, 0x03, 0x00, 0xE1,
  0xC0, 0x01, 0x80, 0x70, 0xE0, 0x00, 0xC0, 0x38, 0x60, 0xF8, 0x70, 0x1C,
  0x71, 0xFE, 0x38, 0x0C, 0x38, 0xE7, 0x9C, 0x06, 0x38, 0xE1, 0xC6, 0x07,
  0x1C, 0x60, 0x73, 0x83, 0x0C, 0x70, 0x38, 0xE7, 0x8E, 0x38, 0x0C, 0x7F,
  0x87, 0x1C, 0x07, 0x1F, 0x87, 0x0C, 0x03, 0x80, 0x03, 0x86, 0x01, 0xC0,
  0x01, 0x83, 0x00, 0xE0, 0x01, 0xC1, 0x80, 0x70, 0x00, 0xC0, 0xC0, 0x38,
  0x00, 0xE0, 0x60, 0x1C, 0x00, 0x70, 0x30, 0x0E, 0x00, 0x30, 0x18, 0x07,
  0x00, 0x38, 0x0C, 0x03, 0x80, 0x18, 0x07, 0x01, 0xC0, 0x1C, 0x03, 0x80,
  0xC0, 0x0E, 0x01, 0xC0, 0x60, 0x0E, 0x00, 0x60, 0x70, 0x07, 0x00, 0x38,
  0x38, 0x03, 0x00, 0x1E, 0x38, 0x03, 0x80, 0x07, 0xF8, 0x01, 0xC0, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x10, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0x81, 0xC0, 0x00, 0xE0, 0x38, 0x00, 0x1C,
  0x03, 0x80, 0x03, 0x80, 0x70, 0x00, 0x70, 0x0E, 0x00, 0x0E, 0x01, 0xC0,
  0x01, 0xC0, 0x38, 0x00, 0x38, 0x07, 0x00, 0x07, 0x01, 0xC0, 0x00, 0xE0,
  0x38, 0x00, 0x0E, 0x07, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x1C, 0x78, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0x70, 0x00, 0x07, 0x8F, 0x00, 0x71,
  0xE0, 0xF0, 0x1E, 0x38, 0x0E, 0x03, 0x8F, 0x01, 0xE0, 0x71, 0xC0, 0x1E,
  0x0E, 0x38, 0x01, 0xC1, 0xCF, 0x00, 0x1C, 0x71, 0xC0, 0x03, 0xCE, 0x38,
  0x00, 0x3B, 0xC7, 0x00, 0x03, 0xF0, 0xE0, 0x00, 0x7E, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0xF0, 0x38, 0x00, 0x3F, 0x07, 0x80, 0x0F, 0xF0, 0x78,
  0x07, 0xCF, 0x07, 0xC3, 0xF0, 0xE0, 0x7F, 0xF8, 0x1E, 0x07, 0xFE, 0x01,
  0xE0, 0x08, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0,
  0x38, 0x0E, 0x01, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x1C, 0x03, 0x80,
  0xE0, 0x1C, 0x07, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0,
  0x0E, 0x01, 0xE0, 0x1C, 0x01, 0xC0, 0x3C, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x01, 0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0xE0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x00,
  0xE0, 0x3C, 0x07, 0x00, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0E, 0x01,
  0xC0, 0x70, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x00, 0x00,
  0x60, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x38, 0x30, 0x77, 0xE6, 0x7E, 0xFF,
  0xFF, 0xE1, 0xFF, 0x80, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x73, 0x80, 0x0E,
  0x70, 0x03, 0x87, 0x00, 0xE0, 0x70, 0x3C, 0x0F, 0x03, 0x00, 0xC0, 0x20,
  0x10, 0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00,
  0x00, 0x30, 0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30,
  0x00, 0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00,
  0x00, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x30, 0x00, 0x00,
  0xC0, 0x00, 0x1E, 0x38, 0x71, 0xE3, 0xC7, 0x0E, 0x1C, 0x70, 0xE1, 0xC3,
  0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF7, 0xBF, 0xEF, 0x10, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x01,
  0xC0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x1C, 0x00, 0x07, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x07, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0xC3, 0x80, 0x1C, 0x38,
  0x01, 0xE7, 0x80, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x77, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x38, 0x01, 0xE3,
  0x80, 0x1C, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x0F, 0x9F, 0x80, 0x7F, 0xF0,
  0x03, 0xFC, 0x00, 0x06, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3F, 0x07,
  0xF0, 0xF7, 0x1E, 0x77, 0xC7, 0xF8, 0x76, 0x07, 0x20, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0xFC, 0x00, 0xFF, 0xF8,
  0x0F, 0xFF, 0xE0, 0xF8, 0x07, 0x83, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80,
  0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF1, 0xF0, 0x07, 0xC7, 0x00, 0x1E, 0x20, 0x00, 0x78, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x78, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80,
  0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03,
  0xC0, 0x00, 0x1C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x70, 0x01, 0xF3, 0xF0,
  0x3F, 0x1F, 0xFF, 0xF0, 0x3F, 0xFE, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x06, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x18, 0xE0, 0x00, 0x38, 0xE0, 0x00, 0x70, 0xE0, 0x00, 0x70,
  0xE0, 0x00, 0xE0, 0xE0, 0x00, 0xE0, 0xE0, 0x01, 0xC0, 0xE0, 0x01, 0xC0,
  0xE0, 0x03, 0x80, 0xE0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x1C, 0x00, 0xE0, 0x38, 0x00,
  0xE0, 0x38, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0x70, 0x00, 0xE0, 0xE0, 0x00,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0xE0, 0x3F, 0xFF, 0xC3, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x71, 0xF0, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x07, 0x80, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x80, 0x03, 0xCC, 0x00, 0x78,
  0xFC, 0x3F, 0x8F, 0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x7F,
  0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x1C, 0x00, 0x00, 0xE1, 0xFE, 0x07, 0x1F, 0xFC, 0x39, 0xFF, 0xF1,
  0xDC, 0x07, 0x8F, 0xC0, 0x1E, 0x7C, 0x00, 0x73, 0xC0, 0x03, 0xDE, 0x00,
  0x0E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEE, 0x00, 0x0E, 0x70, 0x00,
  0x73, 0x80, 0x03, 0x9E, 0x00, 0x3C, 0x70, 0x01, 0xC3, 0xC0, 0x1E, 0x0F,
  0x01, 0xE0, 0x3C, 0x1F, 0x00, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x01, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x70,
  0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x78, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0x80, 0x78,
  0x3C, 0x00, 0xF0, 0xE0, 0x01, 0xC3, 0x80, 0x07, 0x1E, 0x00, 0x1E, 0x78,
  0x00, 0x39, 0xE0, 0x00, 0xE7, 0x80, 0x03, 0x8E, 0x00, 0x1E, 0x38, 0x00,
  0x70, 0xF0, 0x03, 0xC1, 0xC0, 0x0E, 0x03, 0x80, 0x78, 0x0F, 0x83, 0xC0,
  0x1F, 0x3E, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x1F,
  0x3E, 0x00, 0xF0, 0x7C, 0x07, 0x80, 0x78, 0x3C, 0x00, 0xF0, 0xE0, 0x01,
  0xC7, 0x80, 0x07, 0x9C, 0x00, 0x0E, 0x70, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1D, 0xC0, 0x00, 0xF7, 0x00,
  0x03, 0x9E, 0x00, 0x1E, 0x38, 0x00, 0x70, 0xF0, 0x03, 0xC1, 0xF8, 0x7E,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3C, 0x07, 0x83, 0xC0, 0x1E, 0x1C, 0x00,
  0x71, 0xE0, 0x03, 0x8E, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0xEE, 0x00, 0x07, 0x70, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xF0,
  0x01, 0xF3, 0x80, 0x0F, 0x9E, 0x00, 0xDC, 0x7C, 0x1E, 0xE1, 0xFF, 0xE7,
  0x07, 0xFC, 0x38, 0x03, 0x81, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0xC1, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x1C, 0x00, 0x00,
  0x27, 0xBD, 0xFF, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3D, 0xEF, 0xFB, 0xC0, 0x18, 0x78, 0xF9, 0xF3,
  0xC3, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x70, 0xE3, 0xC7, 0x8E, 0x1C,
  0x38, 0xE1, 0xC3, 0x86, 0x1C, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x70,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1C, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x38, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x1F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFC, 0x60, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07,
  0x00, 0x02, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x03, 0xE0, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x01, 0xC0, 0x3C, 0x00, 0x00,
  0x38, 0x0E, 0x00, 0x00, 0x07, 0x07, 0x00, 0x00, 0x01, 0xC1, 0xC0, 0x00,
  0x00, 0x38, 0xE0, 0x00, 0x00, 0x0E, 0x38, 0x01, 0xFF, 0x03, 0x8C, 0x01,
  0xFF, 0xC0, 0x77, 0x00, 0xF0, 0x70, 0x1D, 0xC0, 0x78, 0x1C, 0x07, 0x70,
  0x1C, 0x07, 0x01, 0xD8, 0x0E, 0x01, 0xC0, 0x7E, 0x03, 0x80, 0x70, 0x0F,
  0x80, 0xE0, 0x1C, 0x03, 0xE0, 0x30, 0x07, 0x00, 0xF8, 0x1C, 0x01, 0xC0,
  0x3E, 0x07, 0x00, 0x70, 0x0F, 0x81, 0xC0, 0x1C, 0x03, 0xE0, 0x70, 0x07,
  0x01, 0xF8, 0x1C, 0x01, 0xC0, 0x7E, 0x07, 0x00, 0x70, 0x1F, 0x81, 0xC0,
  0x3C, 0x07, 0xE0, 0x38, 0x0F, 0x01, 0xB8, 0x0E, 0x03, 0xC0, 0xEE, 0x03,
  0x81, 0xB0, 0x39, 0x80, 0x70, 0xEE, 0x1C, 0x70, 0x1F, 0xF1, 0xFE, 0x1C,
  0x03, 0xF8, 0x3F, 0x07, 0x00, 0x38, 0x03, 0x00, 0xE0, 0x00, 0x00, 0x00,
  0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x18, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xB8, 0x00,
  0x00, 0x77, 0x00, 0x00, 0x0E, 0xE0, 0x00, 0x01, 0x9C, 0x00, 0x00, 0x71,
  0xC0, 0x00, 0x0E, 0x38, 0x00, 0x01, 0xC7, 0x00, 0x00, 0x70, 0xF0, 0x00,
  0x0E, 0x0E, 0x00, 0x01, 0xC1, 0xC0, 0x00, 0x38, 0x38, 0x00, 0x0E, 0x03,
  0x80, 0x01, 0xC0, 0x70, 0x00, 0x38, 0x0E, 0x00, 0x0F, 0x01, 0xE0, 0x01,
  0xC0, 0x1C, 0x00, 0x38, 0x03, 0x80, 0x07, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF8, 0x07, 0x00, 0x07, 0x00, 0xE0, 0x00, 0xE0, 0x3C, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xC0, 0xE0, 0x00, 0x38, 0x3C, 0x00, 0x07, 0x07, 0x00,
  0x00, 0xF0, 0xE0, 0x00, 0x0E, 0x1C, 0x00, 0x01, 0xC7, 0x80, 0x00, 0x3C,
  0xE0, 0x00, 0x03, 0x9C, 0x00, 0x00, 0x77, 0x80, 0x00, 0x0E, 0xE0, 0x00,
  0x01, 0xE0, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xC0, 0x1F,
  0x8E, 0x00, 0x1E, 0x70, 0x00, 0x7B, 0x80, 0x03, 0xDC, 0x00, 0x0E, 0xE0,
  0x00, 0x77, 0x00, 0x03, 0xB8, 0x00, 0x1D, 0xC0, 0x00, 0xEE, 0x00, 0x07,
  0x70, 0x00, 0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x01, 0xE7, 0x00,
  0x3E, 0x3F, 0xFF, 0xE1, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x70, 0x03, 0xE3,
  0x80, 0x07, 0x9C, 0x00, 0x1E, 0xE0, 0x00, 0x77, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01,
  0xEE, 0x00, 0x1F, 0x70, 0x01, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x1F,
  0x00, 0x70, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xC0, 0xFF, 0x1F, 0x80, 0x7F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x0E, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0xE0, 0x1F, 0xC0, 0xE0, 0x03, 0xE0, 0xE0, 0x00, 0xF0, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0x78, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x1C, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E,
  0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x0E, 0xE0, 0x00, 0x1E, 0xE0, 0x00, 0x1C,
  0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x3C, 0xE0, 0x00, 0x78, 0xE0, 0x00, 0x78,
  0xE0, 0x00, 0xF0, 0xE0, 0x03, 0xE0, 0xE0, 0x0F, 0xC0, 0xFF, 0xFF, 0x80,
  0xFF, 0xFE, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x3F, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xF7, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFD, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x81, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x04, 0x1F, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1D, 0xC0, 0x00, 0x03, 0xB8, 0x00, 0x00,
  0x77, 0x00, 0x00, 0x0E, 0xF0, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x39, 0xC0,
  0x00, 0x07, 0x3C, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1C, 0x78, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x70, 0x78, 0x00, 0x0E, 0x07, 0xC0, 0x01, 0xC0, 0x7F,
  0x0F, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x38, 0x00,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0E, 0xFF, 0xFF,
  0xFC, 0xFE, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xC7, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xC0, 0x70,
  0x1E, 0xFF, 0x9F, 0xF3, 0xF8, 0x00, 0xE0, 0x00, 0x7B, 0x80, 0x01, 0xCE,
  0x00, 0x0F, 0x38, 0x00, 0x78, 0xE0, 0x01, 0xC3, 0x80, 0x0F, 0x0E, 0x00,
  0x78, 0x38, 0x03, 0xC0, 0xE0, 0x0E, 0x03, 0x80, 0x78, 0x0E, 0x03, 0xC0,
  0x38, 0x0E, 0x00, 0xE0, 0x78, 0x03, 0x83, 0xC0, 0x0E, 0x0E, 0x00, 0x38,
  0x78, 0x00, 0xE3, 0xC0, 0x03, 0x8E, 0x00, 0x0E, 0x78, 0x00, 0x3B, 0xF0,
  0x00, 0xEF, 0xC0, 0x03, 0xF7, 0x80, 0x0F, 0x8E, 0x00, 0x3C, 0x3C, 0x00,
  0xE0, 0x70, 0x03, 0x81, 0xE0, 0x0E, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1E, 0x03, 0x80, 0x38, 0x0E, 0x00, 0xF0, 0x38, 0x01, 0xC0, 0xE0, 0x07,
  0x83, 0x80, 0x0E, 0x0E, 0x00, 0x3C, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xE3,
  0x80, 0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x01, 0xDF, 0xF0, 0x00, 0x00, 0xEF, 0xDC, 0x00, 0x00, 0x67,
  0xEE, 0x00, 0x00, 0x77, 0xF7, 0x00, 0x00, 0x3B, 0xF9, 0xC0, 0x00, 0x1D,
  0xFC, 0xE0, 0x00, 0x1C, 0xFE, 0x70, 0x00, 0x0E, 0x7F, 0x1C, 0x00, 0x07,
  0x3F, 0x8E, 0x00, 0x07, 0x1F, 0xC7, 0x00, 0x03, 0x8F, 0xE1, 0xC0, 0x01,
  0xC7, 0xF0, 0xE0, 0x01, 0xC3, 0xF8, 0x70, 0x00, 0xE1, 0xFC, 0x1C, 0x00,
  0x70, 0xFE, 0x0E, 0x00, 0x70, 0x7F, 0x07, 0x00, 0x38, 0x3F, 0x83, 0xC0,
  0x1C, 0x1F, 0xC0, 0xE0, 0x1C, 0x0F, 0xE0, 0x70, 0x0E, 0x07, 0xF0, 0x3C,
  0x07, 0x03, 0xF8, 0x0E, 0x07, 0x01, 0xFC, 0x07, 0x03, 0x80, 0xFE, 0x03,
  0xC1, 0xC0, 0x7F, 0x00, 0xE1, 0xC0, 0x3F, 0x80, 0x70, 0xE0, 0x1F, 0xC0,
  0x38, 0x70, 0x0F, 0xE0, 0x0E, 0x70, 0x07, 0xF0, 0x07, 0x38, 0x03, 0xF8,
  0x03, 0x9C, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0x00, 0x1F, 0xC0, 0x07, 0x80, 0x0F,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xEE, 0x00, 0x07, 0xEF, 0x00, 0x07, 0xE7, 0x00, 0x07, 0xE7,
  0x80, 0x07, 0xE3, 0x80, 0x07, 0xE3, 0xC0, 0x07, 0xE1, 0xC0, 0x07, 0xE1,
  0xE0, 0x07, 0xE0, 0xE0, 0x07, 0xE0, 0xF0, 0x07, 0xE0, 0x70, 0x07, 0xE0,
  0x78, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x3C, 0x07, 0xE0, 0x1C, 0x07, 0xE0,
  0x1E, 0x07, 0xE0, 0x0E, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x07, 0x07, 0xE0,
  0x07, 0x87, 0xE0, 0x03, 0x87, 0xE0, 0x03, 0xC7, 0xE0, 0x01, 0xC7, 0xE0,
  0x01, 0xE7, 0xE0, 0x00, 0xE7, 0xE0, 0x00, 0xF7, 0xE0, 0x00, 0x77, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00,
  0x0F, 0x01, 0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C,
  0x38, 0x00, 0x01, 0xC3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x00,
  0x00, 0x0E, 0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00,
  0x00, 0xE7, 0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E,
  0x38, 0x00, 0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xE0,
  0x00, 0x78, 0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x20, 0x00, 0xFF,
  0xC0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0E, 0x03, 0xF8, 0xE0, 0x07, 0xCE,
  0x00, 0x3C, 0xE0, 0x01, 0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x0E,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0xEE, 0x00, 0x1E, 0xE0, 0x01, 0xCE, 0x00,
  0x3C, 0xE0, 0x0F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E,
  0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00,
  0x0E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFF,
  0x80, 0x03, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x78, 0x1E, 0x00, 0x03, 0x83, 0xC0, 0x00, 0x3C, 0x38, 0x00,
  0x01, 0xC3, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0E,
  0x70, 0x00, 0x00, 0xE7, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0x70, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x0F, 0x70, 0x00, 0x00, 0xE7,
  0x00, 0x00, 0x0E, 0x78, 0x00, 0x00, 0xE3, 0x80, 0x00, 0x1E, 0x38, 0x00,
  0x01, 0xC3, 0xC0, 0x00, 0x3C, 0x1C, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0x78,
  0x0F, 0x00, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xEE, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x07, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF0, 0x38, 0x0F, 0xE0, 0xE0, 0x07, 0xC3, 0x80, 0x0F, 0x0E, 0x00, 0x1E,
  0x38, 0x00, 0x38, 0xE0, 0x00, 0xE3, 0x80, 0x03, 0xCE, 0x00, 0x0F, 0x38,
  0x00, 0x3C, 0xE0, 0x00, 0xF3, 0x80, 0x03, 0xCE, 0x00, 0x0E, 0x38, 0x00,
  0x38, 0xE0, 0x01, 0xE3, 0x80, 0x07, 0x0E, 0x00, 0x3C, 0x38, 0x01, 0xE0,
  0xE0, 0x7F, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x38, 0x1E, 0x00, 0xE0,
  0x38, 0x03, 0x80, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80, 0xE0, 0x0E,
  0x03, 0x80, 0x3C, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xE0, 0x03, 0x83,
  0x80, 0x0F, 0x0E, 0x00, 0x1C, 0x38, 0x00, 0x78, 0xE0, 0x00, 0xE3, 0x80,
  0x03, 0xCE, 0x00, 0x07, 0x38, 0x00, 0x1E, 0xE0, 0x00, 0x3C, 0x03, 0xFF,
  0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE3, 0xE0, 0x0E, 0x78, 0x00, 0x07, 0x00,
  0x00, 0xF0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xCC, 0x00, 0x7C, 0xFE, 0x7F, 0x8F,
  0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00,
  0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0,
  0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x38, 0x00, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0x70, 0x00, 0x07, 0x70, 0x00, 0x0F, 0x70, 0x00, 0x0E, 0x78,
  0x00, 0x0E, 0x38, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x0F,
  0xC3, 0xF8, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x18, 0x00, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xF7, 0x00, 0x00, 0x39, 0xC0, 0x00, 0x0E,
  0x70, 0x00, 0x03, 0x9E, 0x00, 0x01, 0xE3, 0x80, 0x00, 0x70, 0xE0, 0x00,
  0x1C, 0x3C, 0x00, 0x07, 0x07, 0x00, 0x03, 0xC1, 0xC0, 0x00, 0xE0, 0x70,
  0x00, 0x38, 0x1E, 0x00, 0x1E, 0x03, 0x80, 0x07, 0x00, 0xE0, 0x01, 0xC0,
  0x38, 0x00, 0x70, 0x0F, 0x00, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x70, 0x00, 0xE0, 0x1C, 0x00, 0x38,
  0x07, 0x00, 0x0F, 0x03, 0xC0, 0x01, 0xC0, 0xE0, 0x00, 0x70, 0x38, 0x00,
  0x1C, 0x0E, 0x00, 0x07, 0x87, 0x80, 0x00, 0xE1, 0xC0, 0x00, 0x38, 0x70,
  0x00, 0x0E, 0x1C, 0x00, 0x01, 0xCE, 0x00, 0x00, 0x73, 0x80, 0x00, 0x1C,
  0xE0, 0x00, 0x07, 0x38, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xE7, 0x00, 0x03,
  0xE0, 0x00, 0x73, 0x80, 0x01, 0xF0, 0x00, 0x39, 0xC0, 0x01, 0xF8, 0x00,
  0x3C, 0xE0, 0x00, 0xEC, 0x00, 0x1C, 0x78, 0x00, 0x77, 0x00, 0x0E, 0x1C,
  0x00, 0x3B, 0x80, 0x07, 0x0E, 0x00, 0x39, 0xC0, 0x07, 0x87, 0x00, 0x1C,
  0xE0, 0x03, 0xC3, 0xC0, 0x0E, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x1C, 0x00,
  0xE0, 0x70, 0x03, 0x0E, 0x00, 0x70, 0x38, 0x03, 0x87, 0x00, 0x78, 0x1C,
  0x01, 0xC1, 0x80, 0x38, 0x0F, 0x00, 0xE0, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x70, 0x0E, 0x01, 0xC0, 0x70, 0x38, 0x0F, 0x00, 0xE0, 0x38, 0x1C, 0x07,
  0x00, 0x78, 0x1C, 0x07, 0x03, 0x80, 0x1C, 0x0E, 0x03, 0x81, 0xC0, 0x0E,
  0x0E, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x00, 0xE0, 0xF0, 0x03, 0xC3, 0x80,
  0x30, 0x70, 0x00, 0xE1, 0xC0, 0x1C, 0x38, 0x00, 0x70, 0xE0, 0x0E, 0x1C,
  0x00, 0x38, 0xE0, 0x07, 0x1E, 0x00, 0x1C, 0x70, 0x03, 0x8E, 0x00, 0x0F,
  0x38, 0x00, 0xE7, 0x00, 0x03, 0x9C, 0x00, 0x73, 0x80, 0x01, 0xCC, 0x00,
  0x39, 0xC0, 0x00, 0xEE, 0x00, 0x1D, 0xC0, 0x00, 0x77, 0x00, 0x06, 0xE0,
  0x00, 0x1F, 0x80, 0x03, 0x70, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x0E, 0x38,
  0x00, 0x1E, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x1E, 0x00, 0x38, 0x0E,
  0x00, 0x78, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x80, 0xE0, 0x03,
  0x80, 0xE0, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0xC0, 0x00,
  0xE3, 0x80, 0x00, 0xE7, 0x80, 0x00, 0xF7, 0x00, 0x00, 0x77, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x77, 0x00, 0x00, 0xE7, 0x00, 0x00,
  0xE7, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC3, 0xC0, 0x03, 0xC1, 0xC0, 0x03,
  0x81, 0xC0, 0x07, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0x70, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0x38, 0x3C, 0x00, 0x3C, 0x38,
  0x00, 0x1C, 0x38, 0x00, 0x1C, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xC0, 0x00, 0x73, 0xC0, 0x00, 0xE3, 0x80,
  0x03, 0xC7, 0x00, 0x07, 0x0F, 0x00, 0x1E, 0x0E, 0x00, 0x38, 0x1E, 0x00,
  0x70, 0x1C, 0x01, 0xE0, 0x38, 0x03, 0x80, 0x78, 0x07, 0x00, 0x70, 0x1C,
  0x00, 0xF0, 0x38, 0x00, 0xE0, 0xF0, 0x01, 0xC1, 0xC0, 0x01, 0xC3, 0x80,
  0x03, 0x8E, 0x00, 0x07, 0x9C, 0x00, 0x07, 0x78, 0x00, 0x0E, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07,
  0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70,
  0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0xF0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00,
  0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFF, 0xFF, 0xFF,
  0xFC, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00,
  0x78, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x18, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x76, 0x00, 0x00, 0x77,
  0x00, 0x00, 0xE3, 0x00, 0x00, 0xE3, 0x80, 0x01, 0xC3, 0x80, 0x01, 0xC1,
  0xC0, 0x03, 0x81, 0xC0, 0x03, 0x80, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x0E, 0x00, 0x70, 0x0E, 0x00, 0x38, 0x1C, 0x00, 0x38, 0x1C, 0x00,
  0x1C, 0x38, 0x00, 0x1C, 0x38, 0x00, 0x0E, 0x70, 0x00, 0x0E, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x01, 0xF8,
  0x01, 0xFF, 0xE0, 0x7F, 0xFE, 0x0E, 0x03, 0xC1, 0x00, 0x3C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0x7F, 0xFF,
  0x1F, 0x00, 0xE7, 0x80, 0x1D, 0xE0, 0x03, 0xB8, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7D,
  0xC0, 0x0F, 0xBC, 0x03, 0x73, 0xC1, 0xCE, 0x7F, 0xF1, 0xC3, 0xFC, 0x38,
  0x18, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00,
  0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x07, 0xC0,
  0x70, 0xFF, 0x83, 0x9F, 0xFE, 0x1C, 0xE0, 0x78, 0xEC, 0x01, 0xE7, 0x40,
  0x07, 0x3E, 0x00, 0x3D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x78, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xEF, 0x00, 0x07, 0x7C, 0x00, 0x7B, 0xB0, 0x03, 0x9D, 0xC0, 0x3C, 0xE7,
  0x87, 0xC7, 0x1F, 0xFC, 0x38, 0x7F, 0xC0, 0x00, 0x30, 0x00, 0x00, 0xFE,
  0x01, 0xFF, 0xC3, 0xFF, 0xE3, 0xE0, 0x21, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x11, 0xF8, 0x78,
  0x7F, 0xFC, 0x0F, 0xFC, 0x00, 0x40, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00,
  0x00, 0x70, 0x1F, 0x03, 0x83, 0xFE, 0x1C, 0x3F, 0xFC, 0xE3, 0xE0, 0xF7,
  0x3C, 0x01, 0xB9, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xE0, 0x00, 0xF7, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x0F, 0xBC, 0x00, 0x7C, 0xE0, 0x06,
  0xE7, 0x80, 0x77, 0x1F, 0x0F, 0x38, 0x7F, 0xF1, 0xC1, 0xFF, 0x0E, 0x00,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xE0, 0x78,
  0x3C, 0x03, 0xC3, 0x80, 0x1C, 0x78, 0x01, 0xE7, 0x00, 0x0E, 0x70, 0x00,
  0xEE, 0x00, 0x0E, 0xE0, 0x00, 0x6E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x06,
  0x0F, 0x83, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0x80, 0x01, 0x00, 0x00, 0x30,
  0x03, 0xFC, 0x0F, 0xF8, 0x3E, 0x10, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x3F, 0xFE, 0x7F, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xF1, 0xC3, 0xFF, 0xCE, 0x3E, 0x0F, 0x73, 0xC0, 0x1B, 0x9C, 0x00,
  0x7D, 0xE0, 0x03, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xEE, 0x00, 0x0F,
  0x70, 0x00, 0xFB, 0xC0, 0x07, 0xCE, 0x00, 0x6E, 0x78, 0x07, 0x71, 0xF0,
  0xF3, 0x87, 0xFF, 0x1C, 0x1F, 0xF0, 0xE0, 0x08, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00,
  0x38, 0x00, 0x03, 0xC0, 0x00, 0x1C, 0x60, 0x01, 0xE3, 0xC0, 0x7E, 0x1F,
  0xFF, 0xE0, 0x7F, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x07, 0xC1, 0xC3, 0xFE, 0x39, 0xFF, 0xE7, 0x38, 0x3E, 0xEC, 0x01,
  0xDF, 0x00, 0x3F, 0xE0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0x80, 0x6F, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0xEE, 0xEE, 0xEE,
  0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE, 0xEE,
  0x03, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE8, 0xF7,
  0xF3, 0xF0, 0xE0, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00,
  0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00,
  0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x05, 0xC0, 0x07,
  0x38, 0x01, 0xE7, 0x00, 0x78, 0xE0, 0x0E, 0x1C, 0x03, 0x83, 0x80, 0xF0,
  0x70, 0x1C, 0x0E, 0x07, 0x01, 0xC1, 0xE0, 0x38, 0x38, 0x07, 0x0E, 0x00,
  0xE3, 0x80, 0x1C, 0xF8, 0x03, 0x9F, 0x00, 0x77, 0xF0, 0x0F, 0xCE, 0x01,
  0xF1, 0xE0, 0x3C, 0x1C, 0x07, 0x83, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x83,
  0x80, 0x70, 0x70, 0x0F, 0x0E, 0x00, 0xE1, 0xC0, 0x1E, 0x38, 0x01, 0xC7,
  0x00, 0x3C, 0xE0, 0x03, 0x9C, 0x00, 0x7B, 0x80, 0x07, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0xF8, 0x01, 0xF0, 0x71, 0xFF, 0x03, 0xFE, 0x39,
  0xFF, 0xC3, 0xFF, 0x9D, 0xC1, 0xF3, 0x83, 0xEE, 0xC0, 0x3B, 0x80, 0xF7,
  0xC0, 0x1D, 0x80, 0x3B, 0xE0, 0x07, 0x80, 0x1F, 0xE0, 0x03, 0xC0, 0x07,
  0xF0, 0x01, 0xE0, 0x03, 0xF8, 0x00, 0xE0, 0x01, 0xFC, 0x00, 0x70, 0x00,
  0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00,
  0x1F, 0x80, 0x07, 0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0,
  0x03, 0xF0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38,
  0x00, 0x7E, 0x00, 0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07,
  0x00, 0x0F, 0xC0, 0x03, 0x80, 0x07, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x00,
  0xE0, 0x01, 0xF8, 0x00, 0x70, 0x00, 0xFC, 0x00, 0x38, 0x00, 0x7E, 0x00,
  0x1C, 0x00, 0x3F, 0x00, 0x0E, 0x00, 0x1F, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x7C, 0x1C, 0x3F, 0xE3, 0x9F, 0xFE, 0x73, 0x83, 0xEE, 0xC0, 0x1D, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x38, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x07, 0x83,
  0xC0, 0x1E, 0x1C, 0x00, 0x71, 0xE0, 0x03, 0xCE, 0x00, 0x0E, 0x70, 0x00,
  0x77, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xEE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0xC0, 0x07, 0x8E, 0x00, 0x38,
  0x38, 0x03, 0xC1, 0xF8, 0x7C, 0x07, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x04,
  0x00, 0x00, 0x7C, 0x07, 0x0F, 0xF8, 0x38, 0xFF, 0xE1, 0xCE, 0x07, 0x8E,
  0xC0, 0x1E, 0x76, 0x00, 0x7B, 0xE0, 0x03, 0xDE, 0x00, 0x0E, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0E, 0xF8, 0x00, 0x77, 0xC0, 0x07, 0xBB, 0x00, 0x39,
  0xDC, 0x03, 0xCE, 0x78, 0x7C, 0x71, 0xFF, 0xC3, 0x87, 0xFC, 0x1C, 0x03,
  0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E,
  0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00,
  0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0xF1, 0xC3, 0xFF, 0xCE, 0x3E, 0x0E, 0x73, 0xC0, 0x1B, 0x9C, 0x00,
  0xFD, 0xE0, 0x03, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7F, 0x80, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0x70, 0x00, 0xFB, 0xC0, 0x07, 0xCE, 0x00, 0x6E, 0x78, 0x07, 0x71, 0xF0,
  0xF3, 0x87, 0xFF, 0x1C, 0x1F, 0xF0, 0xE0, 0x08, 0x07, 0x00, 0x00, 0x38,
  0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0xFF, 0x0F, 0xF8, 0xFF, 0xCF, 0x1E,
  0xE0, 0x76, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xFF,
  0x8F, 0xFF, 0xE7, 0x80, 0xE7, 0x80, 0x13, 0x80, 0x03, 0x80, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xD8, 0x01, 0xEF, 0x83, 0xE7, 0xFF, 0xE0,
  0xFF, 0xE0, 0x02, 0x00, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x06, 0x00, 0x70, 0x03, 0x80, 0xFF, 0xFF, 0xFF, 0xC7, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x03,
  0x80, 0x1E, 0x10, 0x7F, 0x81, 0xFC, 0x01, 0x80, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03, 0xEE, 0x00, 0x7D, 0xE0, 0x1B,
  0x9F, 0x0F, 0x31, 0xFF, 0xC6, 0x1F, 0xE0, 0xC0, 0x20, 0x00, 0xF0, 0x00,
  0x3B, 0x80, 0x03, 0xDC, 0x00, 0x1C, 0xE0, 0x00, 0xE3, 0x80, 0x0F, 0x1C,
  0x00, 0x70, 0xE0, 0x03, 0x87, 0x80, 0x1C, 0x1C, 0x01, 0xE0, 0xE0, 0x0E,
  0x07, 0x00, 0x70, 0x1C, 0x03, 0x80, 0xE0, 0x38, 0x07, 0x01, 0xC0, 0x38,
  0x0E, 0x00, 0xE0, 0xF0, 0x07, 0x07, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0,
  0x07, 0x1C, 0x00, 0x38, 0xE0, 0x01, 0xC7, 0x00, 0x07, 0x38, 0x00, 0x3B,
  0x80, 0x01, 0xDC, 0x00, 0x06, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x38, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xF0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0x7C, 0x00, 0xE7, 0x00, 0x36,
  0x00, 0x73, 0x80, 0x3B, 0x80, 0x39, 0xC0, 0x1D, 0xC0, 0x1C, 0xF0, 0x0E,
  0xE0, 0x1C, 0x38, 0x07, 0x30, 0x0E, 0x1C, 0x07, 0x1C, 0x07, 0x0E, 0x03,
  0x8E, 0x03, 0x87, 0x81, 0xC7, 0x03, 0x81, 0xC0, 0xE1, 0x81, 0xC0, 0xE0,
  0xE0, 0xE0, 0xE0, 0x70, 0x70, 0x70, 0x70, 0x38, 0x38, 0x38, 0x38, 0x0E,
  0x1C, 0x1C, 0x38, 0x07, 0x1C, 0x07, 0x1C, 0x03, 0x8E, 0x03, 0x8E, 0x01,
  0xC7, 0x01, 0xC7, 0x00, 0x73, 0x80, 0xE7, 0x00, 0x39, 0x80, 0x33, 0x80,
  0x1D, 0xC0, 0x1D, 0xC0, 0x0E, 0xE0, 0x0E, 0xE0, 0x03, 0x70, 0x07, 0x60,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0xF0, 0x00, 0xF7,
  0x80, 0x0E, 0x38, 0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x07, 0x00, 0x70, 0x70, 0x07, 0x0E, 0x00, 0x39, 0xE0, 0x03, 0x9C,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x03, 0x9C, 0x00, 0x39, 0xE0, 0x07,
  0x0E, 0x00, 0x70, 0x70, 0x0E, 0x07, 0x01, 0xE0, 0x38, 0x1C, 0x03, 0x83,
  0xC0, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x0E, 0x70, 0x00, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0x38, 0x01, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC3, 0xC0,
  0x3C, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1C, 0x03, 0x80, 0xE0, 0x70, 0x0E,
  0x07, 0x00, 0xE0, 0x70, 0x07, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x0E, 0x00,
  0x70, 0xE0, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x19, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x8F, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x07, 0x00,
  0x07, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0xF0, 0x01, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80,
  0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xF0,
  0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0x80,
  0x07, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x05, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC1, 0xF8, 0x1F, 0xFF, 0x80, 0x1F, 0xFA, 0x00, 0x0F,
  0x80,
};

const GFXglyph NotoSans_Condensed_Light57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 5, 42, 13, 4, -41 },
  { 28, 12, 15, 20, 4, -41 },
  { 51, 26, 41, 29, 1, -41 },
  { 185, 20, 46, 26, 3, -43 },
  { 300, 33, 42, 39, 3, -41 },
  { 474, 27, 42, 29, 2, -41 },
  { 616, 3, 15, 11, 4, -41 },
  { 622, 11, 50, 16, 3, -41 },
  { 691, 11, 50, 16, 2, -41 },
  { 760, 19, 19, 24, 3, -43 },
  { 806, 22, 26, 26, 2, -33 },
  { 878, 7, 13, 12, 2, -6 },
  { 890, 12, 3, 16, 2, -17 },
  { 895, 5, 6, 12, 4, -5 },
  { 899, 18, 41, 20, 1, -41 },
  { 992, 20, 42, 26, 3, -41 },
  { 1097, 12, 41, 26, 4, -41 },
  { 1159, 21, 41, 26, 2, -41 },
  { 1267, 21, 42, 26, 2, -41 },
  { 1378, 24, 41, 26, 1, -41 },
  { 1501, 20, 42, 26, 3, -41 },
  { 1606, 21, 42, 26, 3, -41 },
  { 1717, 21, 41, 26, 2, -41 },
  { 1825, 22, 42, 26, 2, -41 },
  { 1941, 21, 42, 26, 2, -41 },
  { 2052, 5, 31, 12, 4, -31 },
  { 2072, 7, 38, 12, 2, -31 },
  { 2106, 22, 25, 26, 2, -33 },
  { 2175, 22, 14, 26, 2, -27 },
  { 2214, 22, 25, 26, 2, -33 },
  { 2283, 16, 42, 19, 1, -41 },
  { 2367, 34, 46, 40, 3, -41 },
  { 2563, 27, 41, 27, 0, -41 },
  { 2702, 21, 41, 29, 5, -41 },
  { 2810, 23, 42, 28, 3, -41 },
  { 2931, 24, 41, 32, 5, -41 },
  { 3054, 17, 41, 25, 5, -41 },
  { 3142, 17, 41, 23, 5, -41 },
  { 3230, 27, 42, 34, 3, -41 },
  { 3372, 23, 41, 33, 5, -41 },
  { 3490, 11, 41, 15, 2, -41 },
  { 3547, 11, 51, 12, -3, -41 },
  { 3618, 22, 41, 27, 5, -41 },
  { 3731, 17, 41, 23, 5, -41 },
  { 3819, 33, 41, 42, 5, -41 },
  { 3989, 24, 41, 34, 5, -41 },
  { 4112, 28, 42, 34, 3, -41 },
  { 4259, 20, 41, 27, 5, -41 },
  { 4362, 28, 51, 34, 3, -41 },
  { 4541, 22, 41, 28, 5, -41 },
  { 4654, 20, 42, 25, 3, -41 },
  { 4759, 23, 41, 23, 0, -41 },
  { 4877, 24, 42, 32, 4, -41 },
  { 5003, 26, 41, 26, 0, -41 },
  { 5137, 41, 41, 43, 1, -41 },
  { 5348, 24, 41, 24, 0, -41 },
  { 5471, 23, 41, 23, 0, -41 },
  { 5589, 20, 41, 23, 2, -41 },
  { 5692, 11, 50, 18, 5, -41 },
  { 5761, 18, 41, 20, 1, -41 },
  { 5854, 11, 50, 18, 2, -41 },
  { 5923, 24, 22, 26, 1, -41 },
  { 5989, 24, 3, 24, 0, 5 },
  { 5998, 10, 9, 14, 2, -44 },
  { 6010, 19, 32, 25, 2, -31 },
  { 6086, 21, 44, 28, 4, -43 },
  { 6202, 17, 32, 21, 3, -31 },
  { 6270, 21, 44, 28, 3, -43 },
  { 6386, 20, 32, 25, 3, -31 },
  { 6466, 15, 44, 15, 1, -44 },
  { 6549, 21, 45, 28, 3, -31 },
  { 6668, 19, 43, 27, 4, -43 },
  { 6771, 4, 42, 12, 4, -42 },
  { 6792, 9, 56, 12, -1, -42 },
  { 6855, 19, 43, 23, 4, -43 },
  { 6958, 3, 43, 12, 4, -43 },
  { 6975, 33, 31, 41, 4, -31 },
  { 7103, 19, 31, 27, 4, -31 },
  { 7177, 21, 32, 27, 3, -31 },
  { 7261, 21, 44, 28, 4, -31 },
  { 7377, 21, 44, 28, 3, -31 },
  { 7493, 13, 31, 18, 4, -31 },
  { 7544, 17, 32, 21, 2, -31 },
  { 7612, 13, 39, 15, 1, -38 },
  { 7676, 19, 31, 27, 4, -30 },
  { 7750, 21, 30, 21, 0, -30 },
  { 7829, 33, 30, 35, 1, -30 },
  { 7953, 20, 30, 22, 1, -30 },
  { 8028, 20, 44, 22, 1, -30 },
  { 8138, 16, 30, 19, 2, -30 },
  { 8198, 16, 50, 20, 2, -41 },
  { 8298, 3, 57, 25, 11, -43 },
  { 8320, 16, 50, 20, 2, -41 },
  { 8420, 22, 6, 26, 2, -23 },
};

const GFXfont NotoSans_Condensed_Light57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light57pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_CONDENSED_LIGHT57PT7B_H_
