#ifndef _NOTOSANS_CONDENSED_LIGHT32PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT32PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light32pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDA, 0x49, 0x24, 0x92, 0x40, 0x07, 0xF8, 0xC7, 0x8F,
  0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0x06, 0x10, 0x10, 0x40, 0x43, 0x01, 0x0C,
  0x0C, 0x30, 0x30, 0x80, 0xC2, 0x1F, 0xFF, 0x08, 0x20, 0x21, 0x80, 0x86,
  0x06, 0x18, 0x18, 0x40, 0x61, 0x0F, 0xFF, 0xFF, 0xFF, 0x10, 0xC0, 0x43,
  0x01, 0x0C, 0x0C, 0x20, 0x30, 0x80, 0xC2, 0x02, 0x08, 0x00, 0x02, 0x00,
  0x20, 0x1F, 0xC3, 0xBE, 0x62, 0x24, 0x20, 0xC2, 0x0C, 0x20, 0x42, 0x06,
  0x20, 0x32, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x02, 0x60, 0x23, 0x02, 0x30,
  0x21, 0x02, 0x30, 0x23, 0x82, 0x6F, 0xFC, 0x3F, 0x00, 0x20, 0x02, 0x00,
  0x20, 0x3C, 0x02, 0x0C, 0xC0, 0xC1, 0x88, 0x10, 0x21, 0x86, 0x04, 0x30,
  0x81, 0x86, 0x30, 0x30, 0xC6, 0x06, 0x18, 0x80, 0x43, 0x30, 0x08, 0x64,
  0x71, 0x0D, 0x9B, 0x31, 0x36, 0x32, 0x64, 0xC6, 0x79, 0x90, 0xC0, 0x22,
  0x08, 0x0C, 0x41, 0x01, 0x88, 0x20, 0x21, 0x04, 0x0C, 0x20, 0x81, 0x06,
  0x30, 0x60, 0xC6, 0x0C, 0x09, 0x83, 0x01, 0xE0, 0x0F, 0x00, 0x33, 0x00,
  0xC3, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x18, 0x0C, 0x30, 0x08, 0x60, 0x19,
  0x80, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x03, 0x30, 0x6C, 0x30, 0x98, 0x63,
  0x60, 0x66, 0xC0, 0x6D, 0x80, 0xF3, 0x00, 0xE2, 0x01, 0xC6, 0x06, 0xCF,
  0x39, 0x87, 0xE1, 0x80, 0xFF, 0xFF, 0x06, 0x18, 0x60, 0xC3, 0x06, 0x08,
  0x30, 0x60, 0xC1, 0x83, 0x04, 0x18, 0x30, 0x20, 0x40, 0xC1, 0x83, 0x06,
  0x04, 0x0C, 0x18, 0x18, 0x30, 0x30, 0x30, 0xC1, 0x82, 0x0C, 0x10, 0x61,
  0x82, 0x0C, 0x30, 0xC3, 0x0C, 0x10, 0x43, 0x0C, 0x30, 0xC3, 0x0C, 0x61,
  0x86, 0x30, 0xC6, 0x30, 0x06, 0x00, 0xC0, 0x10, 0x22, 0x3F, 0xFE, 0x0C,
  0x03, 0x80, 0xC8, 0x11, 0x86, 0x18, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x1F, 0xFF, 0x02, 0x00, 0x10, 0x00, 0x80,
  0x04, 0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0x33, 0x66, 0x66, 0x4C, 0xFF,
  0xFC, 0xDF, 0x80, 0x00, 0xC0, 0x20, 0x18, 0x04, 0x03, 0x00, 0xC0, 0x20,
  0x18, 0x06, 0x01, 0x00, 0xC0, 0x30, 0x18, 0x06, 0x01, 0x00, 0xC0, 0x30,
  0x08, 0x06, 0x01, 0x80, 0x40, 0x30, 0x0C, 0x00, 0x0F, 0x81, 0xDC, 0x30,
  0x63, 0x06, 0x60, 0x26, 0x03, 0x60, 0x36, 0x03, 0x40, 0x34, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x34, 0x03, 0x40, 0x34, 0x03, 0x60, 0x36, 0x03, 0x60,
  0x22, 0x06, 0x30, 0x61, 0xDC, 0x0F, 0x80, 0x06, 0x1C, 0x79, 0xBE, 0x68,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x80, 0x1F, 0x87, 0xBC, 0x40, 0xE0, 0x06, 0x00, 0x60,
  0x02, 0x00, 0x20, 0x06, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x01, 0x80,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x03, 0x00, 0x60, 0x0F,
  0xFF, 0xFF, 0xF0, 0x1F, 0x87, 0xBC, 0xC0, 0x60, 0x06, 0x00, 0x20, 0x03,
  0x00, 0x20, 0x06, 0x00, 0x60, 0x0C, 0x1F, 0x81, 0xF8, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x80, 0x6E, 0x1C,
  0x7F, 0x80, 0x00, 0xC0, 0x06, 0x00, 0x50, 0x06, 0x80, 0x34, 0x03, 0x20,
  0x19, 0x01, 0x88, 0x08, 0x40, 0xC2, 0x04, 0x10, 0x60, 0x82, 0x04, 0x30,
  0x23, 0x01, 0x18, 0x08, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x7F, 0xCF, 0xF9, 0x00, 0x20, 0x04, 0x01, 0x80,
  0x30, 0x06, 0x00, 0xC0, 0x1F, 0xC3, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x68, 0x0D, 0xC7, 0x3F, 0xC0,
  0x0F, 0xC3, 0xD8, 0xC0, 0x30, 0x06, 0x00, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1B, 0xF2, 0xEF, 0x50, 0x6C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xA0, 0x36, 0x0C, 0x63, 0x87, 0xE0, 0xFF, 0xFF, 0xFF, 0x00,
  0x30, 0x02, 0x00, 0x60, 0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x08, 0x01,
  0x80, 0x18, 0x03, 0x00, 0x30, 0x03, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0C,
  0x00, 0xC0, 0x08, 0x01, 0x80, 0x18, 0x00, 0x1F, 0x83, 0xDE, 0x70, 0x66,
  0x03, 0x60, 0x36, 0x03, 0x60, 0x36, 0x06, 0x30, 0x61, 0x9C, 0x0F, 0x00,
  0xF8, 0x19, 0xC3, 0x06, 0x60, 0x34, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x36,
  0x03, 0x60, 0x73, 0x8E, 0x1F, 0xC0, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0x40, 0x2C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x34, 0x03, 0x60, 0x36, 0x07,
  0x30, 0xB1, 0xFB, 0x00, 0x30, 0x03, 0x00, 0x20, 0x06, 0x00, 0x60, 0x0C,
  0x01, 0xC4, 0x38, 0x7E, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x37, 0xE0,
  0x77, 0x70, 0x00, 0x00, 0x00, 0x00, 0x03, 0x36, 0x66, 0x64, 0xC0, 0x00,
  0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0x80, 0x04, 0xFF, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x00, 0x40, 0x00, 0x7E, 0x77,
  0x80, 0xC0, 0x30, 0x18, 0x0C, 0x06, 0x02, 0x03, 0x03, 0x01, 0x81, 0x81,
  0x80, 0x80, 0xC0, 0x60, 0x30, 0x00, 0x00, 0x00, 0x03, 0x01, 0xC0, 0xC0,
  0x01, 0xF8, 0x00, 0xF7, 0xC0, 0x30, 0x0C, 0x0C, 0x00, 0xC3, 0x00, 0x08,
  0xC0, 0x01, 0x98, 0x18, 0x12, 0x0F, 0xC2, 0xC3, 0x08, 0x78, 0x41, 0x0E,
  0x18, 0x21, 0xC3, 0x0C, 0x38, 0x61, 0x87, 0x08, 0x30, 0xE1, 0x86, 0x1C,
  0x30, 0xC3, 0x86, 0x18, 0x58, 0x45, 0x9B, 0x0F, 0x9E, 0x60, 0x00, 0x06,
  0x00, 0x00, 0xC0, 0x00, 0x0C, 0x00, 0x00, 0xC0, 0x20, 0x0F, 0xFC, 0x00,
  0x7E, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0A, 0x00, 0x16, 0x00, 0x6C, 0x00,
  0xD8, 0x01, 0x10, 0x06, 0x30, 0x0C, 0x60, 0x18, 0x40, 0x20, 0xC0, 0xC1,
  0x81, 0x83, 0x03, 0xFE, 0x0F, 0xFE, 0x18, 0x0C, 0x30, 0x18, 0x40, 0x19,
  0x80, 0x33, 0x00, 0x66, 0x00, 0x58, 0x00, 0xF0, 0x01, 0x80, 0xFF, 0x0F,
  0xFC, 0x80, 0xE8, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x06, 0x80, 0x68,
  0x0C, 0xFF, 0x8F, 0xF8, 0x80, 0xE8, 0x06, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x06, 0x80, 0xEF, 0xFC, 0xFF, 0x00, 0x07, 0xF0, 0xFB,
  0xCE, 0x00, 0x60, 0x06, 0x00, 0x30, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06,
  0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x03, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0F, 0x18, 0x1F, 0xC0, 0xFE,
  0x07, 0xFC, 0x20, 0x39, 0x00, 0xC8, 0x03, 0x40, 0x1A, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xA0, 0x0D, 0x00, 0xC8, 0x0E, 0x7F, 0xC3, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40,
  0x3F, 0xFF, 0xF8, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x07, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x1F, 0xFF, 0xFC, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20,
  0x10, 0x08, 0x04, 0x02, 0x00, 0x03, 0xF8, 0x1F, 0x7C, 0x60, 0x11, 0x80,
  0x06, 0x00, 0x0C, 0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03,
  0x00, 0x06, 0x07, 0xFC, 0x0F, 0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x06, 0xC0, 0x0D, 0x80, 0x19, 0x80, 0x33, 0x80, 0x63, 0xE3, 0xC1, 0xFF,
  0x00, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x60, 0xFC, 0xE3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xC0, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x30, 0xFE, 0xF0, 0x80, 0x78, 0x06, 0x80, 0xC8,
  0x18, 0x81, 0x88, 0x30, 0x86, 0x08, 0x60, 0x8C, 0x09, 0x80, 0xB8, 0x0B,
  0xC0, 0xEC, 0x0C, 0x60, 0x86, 0x08, 0x30, 0x83, 0x08, 0x18, 0x81, 0x88,
  0x0C, 0x80, 0x68, 0x06, 0x80, 0x30, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04,
  0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x07, 0xFF, 0xFE, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x1E, 0x80, 0x0F, 0xB0, 0x03, 0xEC, 0x00, 0xB9, 0x00, 0x6E,
  0x60, 0x1B, 0x98, 0x04, 0xE2, 0x03, 0x38, 0xC0, 0xCE, 0x30, 0x23, 0x84,
  0x18, 0xE1, 0x86, 0x38, 0x61, 0x0E, 0x08, 0xC3, 0x83, 0x30, 0xE0, 0xC8,
  0x38, 0x36, 0x0E, 0x07, 0x83, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x0C, 0x0C,
  0xC0, 0x0E, 0x00, 0x78, 0x03, 0x40, 0x1B, 0x00, 0xC8, 0x06, 0x60, 0x31,
  0x01, 0x8C, 0x0C, 0x20, 0x61, 0x83, 0x04, 0x18, 0x30, 0xC0, 0x86, 0x06,
  0x30, 0x11, 0x80, 0xCC, 0x02, 0x60, 0x1B, 0x00, 0x58, 0x03, 0xC0, 0x0E,
  0x00, 0x60, 0x0F, 0xE0, 0x1F, 0xF0, 0x30, 0x18, 0x60, 0x0C, 0x60, 0x0C,
  0x40, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0x40, 0x06, 0x60, 0x0C, 0x60, 0x0C, 0x30, 0x18, 0x1E, 0x70, 0x0F, 0xE0,
  0xFE, 0x1F, 0xF2, 0x07, 0x40, 0x68, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x1A, 0x03, 0x40, 0xCF, 0xF1, 0xF0, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x40, 0x08, 0x01, 0x00, 0x20, 0x00, 0x0F, 0xE0, 0x1F, 0xF0,
  0x30, 0x18, 0x60, 0x0C, 0x60, 0x0C, 0x40, 0x06, 0xC0, 0x06, 0xC0, 0x06,
  0xC0, 0x06, 0xC0, 0x02, 0xC0, 0x02, 0xC0, 0x03, 0xC0, 0x02, 0xC0, 0x02,
  0xC0, 0x06, 0xC0, 0x06, 0xC0, 0x06, 0x40, 0x06, 0x60, 0x0C, 0x60, 0x0C,
  0x30, 0x18, 0x1E, 0x70, 0x0F, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x30,
  0x00, 0x38, 0x00, 0x1C, 0xFE, 0x0F, 0xF8, 0x81, 0xC8, 0x0C, 0x80, 0x68,
  0x06, 0x80, 0x68, 0x06, 0x80, 0x68, 0x0C, 0x80, 0xC8, 0x78, 0xFE, 0x08,
  0x60, 0x83, 0x08, 0x30, 0x81, 0x88, 0x18, 0x80, 0xC8, 0x0C, 0x80, 0x68,
  0x06, 0x80, 0x30, 0x0F, 0xE3, 0xFE, 0x70, 0x06, 0x00, 0x60, 0x04, 0x00,
  0x40, 0x06, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E,
  0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x06, 0x00, 0x6F, 0x1C,
  0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x04, 0x00, 0x20, 0x01, 0x00,
  0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20, 0x01,
  0x00, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04, 0x00, 0x20,
  0x01, 0x00, 0x08, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0D, 0x00, 0x36,
  0x00, 0x98, 0x06, 0x70, 0x38, 0xF1, 0xC0, 0xFE, 0x00, 0xC0, 0x07, 0x80,
  0x19, 0x00, 0x33, 0x00, 0x66, 0x00, 0x8C, 0x03, 0x0C, 0x06, 0x18, 0x0C,
  0x30, 0x30, 0x20, 0x60, 0x60, 0xC0, 0xC1, 0x01, 0x86, 0x01, 0x0C, 0x03,
  0x18, 0x06, 0x20, 0x0C, 0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x34, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xC0, 0x00, 0xC0, 0x18, 0x03, 0x40, 0x18, 0x06, 0x60,
  0x18, 0x06, 0x60, 0x3C, 0x06, 0x60, 0x3C, 0x06, 0x20, 0x3C, 0x04, 0x30,
  0x24, 0x0C, 0x30, 0x64, 0x0C, 0x30, 0x66, 0x0C, 0x30, 0x66, 0x0C, 0x10,
  0x46, 0x18, 0x18, 0xC2, 0x18, 0x18, 0xC3, 0x18, 0x18, 0xC3, 0x18, 0x08,
  0x83, 0x10, 0x0C, 0x81, 0x30, 0x0D, 0x81, 0x30, 0x0D, 0x81, 0xB0, 0x0D,
  0x81, 0xA0, 0x05, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x07,
  0x00, 0xE0, 0x60, 0x1B, 0x01, 0x8C, 0x0C, 0x60, 0x41, 0x86, 0x0C, 0x30,
  0x33, 0x01, 0x98, 0x05, 0x80, 0x3C, 0x00, 0xC0, 0x06, 0x00, 0x78, 0x02,
  0xC0, 0x32, 0x01, 0x98, 0x18, 0xC0, 0xC3, 0x0C, 0x18, 0x60, 0x66, 0x03,
  0x30, 0x0F, 0x00, 0x60, 0xC0, 0x1A, 0x00, 0xD8, 0x0C, 0xC0, 0x63, 0x06,
  0x18, 0x30, 0x41, 0x83, 0x18, 0x18, 0xC0, 0x64, 0x03, 0x60, 0x0B, 0x00,
  0x70, 0x03, 0x80, 0x08, 0x00, 0x40, 0x02, 0x00, 0x10, 0x00, 0x80, 0x04,
  0x00, 0x20, 0x01, 0x00, 0x08, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x60,
  0x0C, 0x03, 0x00, 0x60, 0x18, 0x03, 0x00, 0x40, 0x18, 0x03, 0x00, 0xC0,
  0x18, 0x06, 0x00, 0xC0, 0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0xFF,
  0xFF, 0xF8, 0xFF, 0xF8, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x08, 0x3F, 0x80,
  0x30, 0x0C, 0x01, 0x80, 0x60, 0x08, 0x03, 0x00, 0xC0, 0x10, 0x06, 0x01,
  0x80, 0x20, 0x0C, 0x03, 0x00, 0x60, 0x18, 0x02, 0x00, 0xC0, 0x30, 0x04,
  0x01, 0x80, 0x60, 0x0C, 0xFF, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x04, 0x10,
  0x7F, 0x02, 0x00, 0x38, 0x01, 0x40, 0x1B, 0x00, 0x88, 0x0C, 0x60, 0x41,
  0x06, 0x0C, 0x20, 0x63, 0x01, 0x90, 0x0D, 0x80, 0x3C, 0x01, 0x80, 0xFF,
  0xF8, 0xE0, 0xC3, 0x06, 0x0C, 0x3F, 0x86, 0x38, 0x03, 0x00, 0x20, 0x06,
  0x00, 0xC0, 0x18, 0x7F, 0x3E, 0x6C, 0x0D, 0x01, 0xE0, 0x3C, 0x07, 0x81,
  0xD0, 0x3B, 0x0B, 0x3E, 0x60, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0xF8, 0xD9, 0xCE, 0x06, 0xE0, 0x2E, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0,
  0x2E, 0x06, 0xD9, 0xCC, 0xF8, 0x1F, 0x9C, 0x58, 0x18, 0x0C, 0x06, 0x02,
  0x01, 0x00, 0x80, 0x40, 0x20, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xE1, 0x1F,
  0x80, 0x00, 0x20, 0x04, 0x00, 0x80, 0x10, 0x02, 0x00, 0x40, 0x09, 0xF9,
  0x71, 0xAC, 0x17, 0x01, 0xE0, 0x3C, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x0F, 0x01, 0xE0, 0x3C, 0x06, 0xC1, 0x5C, 0x69, 0xF9, 0x1F, 0x0E,
  0x31, 0x83, 0x60, 0x6C, 0x05, 0x80, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x02,
  0x00, 0x60, 0x0C, 0x01, 0x80, 0x18, 0x01, 0xC6, 0x1F, 0xC0, 0x0F, 0x8E,
  0x06, 0x03, 0x01, 0x80, 0xC0, 0x61, 0xFE, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x3F, 0x2E, 0x35, 0x83, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xE0, 0x3C, 0x07, 0x80, 0xD8, 0x2B, 0x8D, 0x3F,
  0x20, 0x04, 0x00, 0x80, 0x30, 0x06, 0x00, 0xF0, 0x37, 0xFC, 0x1E, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x7C, 0xD8,
  0xDC, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xDC, 0x00, 0x36,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB0, 0x18, 0xC0, 0x00, 0x00, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31,
  0xFB, 0x80, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x06, 0xC1, 0x98, 0x23, 0x0C, 0x63, 0x0C, 0xC1, 0x98, 0x37, 0x07, 0xE0,
  0xE6, 0x18, 0xC3, 0x0C, 0x61, 0x8C, 0x19, 0x81, 0x30, 0x36, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCF, 0x8F, 0x9A, 0x3B, 0x3B, 0x83, 0xC3,
  0x70, 0x70, 0x3C, 0x06, 0x07, 0x80, 0xC0, 0xF0, 0x10, 0x1E, 0x02, 0x03,
  0xC0, 0x40, 0x78, 0x08, 0x0F, 0x01, 0x01, 0xE0, 0x20, 0x3C, 0x04, 0x07,
  0x80, 0x80, 0xF0, 0x10, 0x1E, 0x02, 0x03, 0xC0, 0x40, 0x60, 0xCF, 0x9B,
  0x1B, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0x1F, 0x87,
  0x1C, 0x60, 0xCC, 0x06, 0xC0, 0x6C, 0x02, 0x80, 0x38, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x3C, 0x02, 0xC0, 0x6C, 0x06, 0x60, 0xC7, 0x1C, 0x1F, 0x80,
  0xCF, 0x8D, 0x8C, 0xF0, 0x6E, 0x03, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x3E, 0x02, 0xF0, 0x6D, 0x8C,
  0xCF, 0x8C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x00, 0x1F, 0x93, 0x8D, 0x30, 0x56, 0x03, 0x60, 0x36, 0x03, 0x40,
  0x34, 0x01, 0xC0, 0x14, 0x01, 0x40, 0x36, 0x03, 0x60, 0x36, 0x03, 0x30,
  0x53, 0x8D, 0x1F, 0x90, 0x01, 0x00, 0x10, 0x01, 0x00, 0x10, 0x01, 0x00,
  0x10, 0x01, 0x00, 0x10, 0xCF, 0xD9, 0xF0, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x9C, 0x64,
  0x03, 0x00, 0xC0, 0x10, 0x07, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x18, 0x02,
  0x00, 0xC0, 0x38, 0x1B, 0x8E, 0x7F, 0x00, 0x20, 0x40, 0x83, 0x0F, 0xEC,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x81,
  0x93, 0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xD8, 0x3B, 0x8D,
  0x3E, 0x20, 0xC0, 0x34, 0x02, 0x60, 0x66, 0x06, 0x60, 0x62, 0x0C, 0x30,
  0xC3, 0x0C, 0x10, 0x81, 0x98, 0x19, 0x81, 0x98, 0x09, 0x00, 0xF0, 0x0F,
  0x00, 0x60, 0x06, 0x00, 0xC0, 0x60, 0x68, 0x0C, 0x0D, 0x83, 0x81, 0xB0,
  0x78, 0x26, 0x0B, 0x0C, 0x41, 0x21, 0x8C, 0x64, 0x31, 0x8C, 0xC4, 0x31,
  0x18, 0x82, 0x21, 0x30, 0x6C, 0x26, 0x0D, 0x86, 0xC1, 0xA0, 0xD0, 0x14,
  0x1E, 0x03, 0x81, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x00, 0xC0, 0x6C, 0x19,
  0x82, 0x18, 0xC3, 0x10, 0x36, 0x07, 0x80, 0x70, 0x0C, 0x01, 0xC0, 0x6C,
  0x19, 0x83, 0x18, 0xC3, 0x18, 0x36, 0x06, 0xC0, 0x60, 0xC0, 0x36, 0x03,
  0x60, 0x26, 0x06, 0x20, 0x63, 0x04, 0x30, 0xC1, 0x0C, 0x18, 0xC1, 0x88,
  0x19, 0x80, 0x98, 0x0D, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x40, 0x0C, 0x00, 0xC0, 0x18, 0x0F, 0x80, 0xE0, 0x00, 0xFF,
  0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C, 0x0C, 0x06,
  0x02, 0x03, 0x01, 0x01, 0xFF, 0xFF, 0x80, 0x01, 0x83, 0xC3, 0x01, 0x80,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x03, 0x01, 0x87, 0x83, 0xC0,
  0x30, 0x18, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0x20, 0x10, 0x0C, 0x06,
  0x01, 0xC0, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x7C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC0, 0x3C, 0x0E, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x0C, 0x1E, 0x1C, 0x00, 0x3C, 0x0F, 0xF8, 0xE0, 0xFC,
};

const GFXglyph NotoSans_Condensed_Light32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 3, 23, 7, 2, -23 },
  { 10, 7, 8, 11, 2, -23 },
  { 17, 14, 23, 16, 1, -23 },
  { 58, 12, 26, 15, 1, -24 },
  { 97, 19, 23, 22, 1, -23 },
  { 152, 15, 23, 17, 1, -23 },
  { 196, 2, 8, 6, 2, -23 },
  { 198, 7, 28, 9, 1, -23 },
  { 223, 6, 28, 9, 1, -23 },
  { 244, 11, 10, 14, 1, -24 },
  { 258, 13, 15, 15, 1, -19 },
  { 283, 4, 8, 7, 1, -4 },
  { 287, 7, 2, 9, 1, -10 },
  { 289, 3, 3, 7, 2, -3 },
  { 291, 10, 23, 11, 1, -23 },
  { 320, 12, 23, 15, 1, -23 },
  { 355, 7, 23, 15, 2, -23 },
  { 376, 12, 23, 15, 1, -23 },
  { 411, 12, 23, 15, 1, -23 },
  { 446, 13, 23, 15, 1, -23 },
  { 484, 11, 23, 15, 2, -23 },
  { 516, 11, 23, 15, 2, -23 },
  { 548, 12, 23, 15, 1, -23 },
  { 583, 12, 23, 15, 1, -23 },
  { 618, 12, 23, 15, 1, -23 },
  { 653, 3, 17, 7, 2, -17 },
  { 660, 4, 21, 7, 1, -17 },
  { 671, 13, 14, 15, 1, -18 },
  { 694, 13, 8, 15, 1, -15 },
  { 707, 13, 14, 15, 1, -18 },
  { 730, 9, 23, 11, 1, -23 },
  { 756, 19, 26, 23, 2, -23 },
  { 818, 15, 23, 15, 0, -23 },
  { 862, 12, 23, 16, 3, -23 },
  { 897, 13, 23, 16, 2, -23 },
  { 935, 13, 23, 18, 3, -23 },
  { 973, 9, 23, 14, 3, -23 },
  { 999, 9, 23, 13, 3, -23 },
  { 1025, 15, 23, 19, 2, -23 },
  { 1069, 13, 23, 18, 3, -23 },
  { 1107, 6, 23, 9, 1, -23 },
  { 1125, 6, 29, 7, -2, -23 },
  { 1147, 12, 23, 15, 3, -23 },
  { 1182, 9, 23, 13, 3, -23 },
  { 1208, 18, 23, 24, 3, -23 },
  { 1260, 13, 23, 19, 3, -23 },
  { 1298, 16, 23, 19, 2, -23 },
  { 1344, 11, 23, 15, 3, -23 },
  { 1376, 16, 28, 19, 2, -23 },
  { 1432, 12, 23, 15, 3, -23 },
  { 1467, 12, 23, 14, 1, -23 },
  { 1502, 13, 23, 13, 0, -23 },
  { 1540, 14, 23, 18, 2, -23 },
  { 1581, 15, 23, 15, 0, -23 },
  { 1625, 24, 23, 24, 0, -23 },
  { 1694, 13, 23, 13, 0, -23 },
  { 1732, 13, 23, 13, 0, -23 },
  { 1770, 11, 23, 13, 1, -23 },
  { 1802, 6, 28, 10, 3, -23 },
  { 1823, 10, 23, 11, 1, -23 },
  { 1852, 6, 28, 10, 1, -23 },
  { 1873, 13, 13, 15, 1, -23 },
  { 1895, 13, 1, 13, 0, 3 },
  { 1897, 6, 5, 8, 1, -24 },
  { 1901, 11, 17, 14, 1, -17 },
  { 1925, 12, 24, 16, 2, -24 },
  { 1961, 9, 17, 12, 2, -17 },
  { 1981, 11, 24, 16, 2, -24 },
  { 2014, 11, 17, 14, 2, -17 },
  { 2038, 9, 24, 8, 0, -24 },
  { 2065, 11, 25, 16, 2, -17 },
  { 2100, 11, 24, 15, 2, -24 },
  { 2133, 3, 23, 7, 2, -23 },
  { 2142, 5, 31, 7, -1, -23 },
  { 2162, 11, 24, 13, 2, -24 },
  { 2195, 2, 24, 6, 2, -24 },
  { 2201, 19, 17, 23, 2, -17 },
  { 2242, 11, 17, 15, 2, -17 },
  { 2266, 12, 17, 15, 2, -17 },
  { 2292, 12, 25, 16, 2, -17 },
  { 2330, 12, 25, 16, 1, -17 },
  { 2368, 8, 17, 10, 2, -17 },
  { 2385, 10, 17, 12, 1, -17 },
  { 2407, 7, 21, 9, 1, -21 },
  { 2426, 11, 17, 15, 2, -17 },
  { 2450, 12, 17, 12, 0, -17 },
  { 2476, 19, 17, 20, 0, -17 },
  { 2517, 11, 17, 13, 1, -17 },
  { 2541, 12, 25, 12, 0, -17 },
  { 2579, 9, 17, 11, 1, -17 },
  { 2599, 9, 28, 11, 1, -23 },
  { 2631, 2, 32, 14, 6, -24 },
  { 2639, 9, 28, 11, 1, -23 },
  { 2671, 13, 3, 15, 1, -13 },
};

const GFXfont NotoSans_Condensed_Light32pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light32pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light32pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _NOTOSANS_CONDENSED_LIGHT32PT7B_H_
