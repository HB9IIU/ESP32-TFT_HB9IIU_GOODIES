#ifndef _NOTOSANS_CONDENSED_LIGHT39PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light39pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0xDB, 0x6D, 0xB6, 0xD9, 0x24, 0x00, 0x5F, 0xF0,
  0xE3, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0x0D, 0x86, 0xC3, 0x61, 0xB0, 0xC0,
  0x03, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60, 0x0C, 0x18, 0x03, 0x04, 0x00,
  0x81, 0x00, 0x20, 0xC0, 0x18, 0x30, 0x7F, 0xFF, 0xDF, 0xFF, 0xF0, 0x60,
  0xC0, 0x18, 0x20, 0x04, 0x08, 0x01, 0x06, 0x00, 0xC1, 0x80, 0x30, 0x60,
  0x0C, 0x18, 0x03, 0x06, 0x0F, 0xFF, 0xF8, 0x20, 0x40, 0x08, 0x30, 0x06,
  0x0C, 0x01, 0x83, 0x00, 0x60, 0xC0, 0x18, 0x30, 0x06, 0x08, 0x01, 0x02,
  0x00, 0x41, 0x80, 0x02, 0x00, 0x08, 0x00, 0x20, 0x03, 0xF8, 0x3F, 0xF9,
  0xC8, 0x6E, 0x20, 0x30, 0x80, 0xC2, 0x03, 0x08, 0x0C, 0x20, 0x30, 0x80,
  0xE2, 0x01, 0xC8, 0x03, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x0B, 0xC0, 0x23,
  0x80, 0x87, 0x02, 0x0C, 0x08, 0x30, 0x20, 0xC0, 0x83, 0x02, 0x1E, 0x08,
  0x6F, 0x2F, 0x3F, 0xF8, 0x07, 0x00, 0x08, 0x00, 0x20, 0x00, 0x80, 0x3E,
  0x00, 0xC0, 0xEE, 0x03, 0x01, 0x8C, 0x06, 0x06, 0x08, 0x18, 0x0C, 0x18,
  0x30, 0x18, 0x30, 0x60, 0x30, 0x61, 0x80, 0x60, 0xC3, 0x00, 0xC1, 0x8C,
  0x01, 0x83, 0x18, 0x03, 0x06, 0x30, 0x06, 0x0C, 0xC7, 0x8C, 0x19, 0x9F,
  0x98, 0x66, 0x61, 0x98, 0xCC, 0xC3, 0x3B, 0x19, 0x86, 0x3E, 0x62, 0x04,
  0x00, 0xCC, 0x0C, 0x03, 0x18, 0x18, 0x06, 0x30, 0x30, 0x0C, 0x60, 0x60,
  0x30, 0xC0, 0xC0, 0x60, 0x81, 0x01, 0x81, 0x86, 0x03, 0x03, 0x0C, 0x06,
  0x06, 0x18, 0x18, 0x06, 0x60, 0x30, 0x07, 0x80, 0x0F, 0x80, 0x07, 0xF0,
  0x03, 0x86, 0x00, 0xC1, 0x80, 0x30, 0x30, 0x0C, 0x0C, 0x03, 0x07, 0x00,
  0xC1, 0x80, 0x30, 0x60, 0x06, 0x38, 0x01, 0x8C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x03, 0xB0, 0x01, 0xCE, 0x06, 0x61, 0xC1, 0xB0, 0x30,
  0xEC, 0x06, 0x33, 0x01, 0xCC, 0xC0, 0x37, 0x30, 0x07, 0x8C, 0x01, 0xE3,
  0x00, 0x78, 0xE0, 0x1E, 0x18, 0x1C, 0xC7, 0xFE, 0x38, 0xFF, 0x07, 0xED,
  0xB6, 0xDB, 0x6C, 0x06, 0x18, 0x30, 0xC1, 0x86, 0x0C, 0x38, 0x60, 0xC1,
  0x87, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x70,
  0x60, 0xC1, 0x81, 0x83, 0x07, 0x06, 0x06, 0x0C, 0x0C, 0xE0, 0x60, 0x30,
  0x38, 0x18, 0x1C, 0x0C, 0x0C, 0x06, 0x06, 0x06, 0x06, 0x07, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x07, 0x06, 0x06, 0x06, 0x0E,
  0x0C, 0x0C, 0x18, 0x18, 0x30, 0x70, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x0C, 0x08, 0x60, 0xF9, 0x3F, 0xFF, 0xC0, 0xC0, 0x0F, 0x00, 0x6C, 0x06,
  0x30, 0x61, 0x87, 0x06, 0x00, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x39, 0xCC, 0x63, 0x31, 0x8C, 0xC0, 0xFF,
  0xFF, 0xC0, 0x5F, 0xF0, 0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x00, 0x30, 0x07, 0x00,
  0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x18, 0x01, 0x80, 0x38, 0x03,
  0x00, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xC0, 0x0C, 0x00, 0x0F, 0xC0,
  0x7F, 0x83, 0x87, 0x0C, 0x0C, 0x60, 0x19, 0x80, 0x66, 0x01, 0xB8, 0x07,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1F, 0x80,
  0x66, 0x01, 0x98, 0x06, 0x70, 0x30, 0xE1, 0xC1, 0xFE, 0x03, 0xF0, 0x03,
  0x07, 0x0F, 0x1B, 0x73, 0xE3, 0x43, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x1F, 0xC1, 0xFF, 0x8E, 0x07, 0x10, 0x0C, 0x00, 0x38,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E, 0x00, 0x30,
  0x01, 0x80, 0x0E, 0x00, 0x70, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x3F, 0xC1, 0xFF, 0x8E, 0x07, 0x20, 0x0E, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00,
  0x18, 0x03, 0xC0, 0x7C, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x60,
  0x01, 0xC0, 0x07, 0x00, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x3A,
  0x01, 0xCF, 0xFE, 0x3F, 0xF0, 0x00, 0x38, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x58, 0x00, 0xD8, 0x01, 0x98, 0x01, 0x98, 0x03, 0x18, 0x03, 0x18, 0x06,
  0x18, 0x06, 0x18, 0x0C, 0x18, 0x0C, 0x18, 0x18, 0x18, 0x38, 0x18, 0x30,
  0x18, 0x60, 0x18, 0x60, 0x18, 0xC0, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00, 0x18, 0x00,
  0x18, 0x7F, 0xF1, 0xFF, 0xC6, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1B, 0xE0, 0x7F, 0xE1,
  0x81, 0xC0, 0x03, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x01, 0xC0, 0x06, 0x00, 0x3A, 0x01, 0xCF, 0xFE,
  0x1F, 0xF0, 0x03, 0xF8, 0x3F, 0xE1, 0xC0, 0x06, 0x00, 0x30, 0x00, 0xC0,
  0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0C, 0x00, 0x31, 0xF8, 0xDF,
  0xF3, 0x40, 0xEE, 0x01, 0xB8, 0x07, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x36, 0x00, 0xD8, 0x07, 0x70, 0x18, 0xE0, 0xE1,
  0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38,
  0x00, 0xC0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0E, 0x00, 0x30,
  0x00, 0xC0, 0x06, 0x00, 0x18, 0x00, 0x60, 0x03, 0x00, 0x0C, 0x00, 0x70,
  0x01, 0x80, 0x06, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0x03, 0x98, 0x06, 0x60,
  0x1B, 0x80, 0x7C, 0x01, 0xF8, 0x06, 0x60, 0x19, 0xC0, 0xE3, 0x03, 0x07,
  0x38, 0x0F, 0xC0, 0x1E, 0x01, 0xDE, 0x0E, 0x1C, 0x70, 0x3B, 0x80, 0x6C,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x1D,
  0xC0, 0xE3, 0xFF, 0x07, 0xF8, 0x1F, 0xC0, 0xFF, 0x87, 0x07, 0x18, 0x0C,
  0xE0, 0x1B, 0x00, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0xF7, 0x02, 0xCF, 0x7B, 0x1F, 0x8C, 0x18,
  0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00,
  0x60, 0x03, 0x87, 0xFC, 0x1F, 0xC0, 0xDF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x0B, 0xFE, 0x31, 0xCE, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xCE, 0x63, 0x19, 0x8C, 0x66, 0x00, 0x00, 0x01, 0x00, 0x03, 0x00,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x7F, 0x1F, 0xF3, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0,
  0x18, 0x03, 0x00, 0xE0, 0x18, 0x03, 0x00, 0xC0, 0x38, 0x0E, 0x03, 0x80,
  0x60, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x08, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xC0,
  0x07, 0x80, 0xE0, 0x0E, 0x00, 0x30, 0x1C, 0x00, 0x18, 0x18, 0x00, 0x1C,
  0x30, 0x00, 0x0C, 0x30, 0x00, 0x04, 0x60, 0x3F, 0x06, 0x60, 0x77, 0x86,
  0x60, 0xC1, 0x86, 0xC1, 0x81, 0x02, 0xC1, 0x81, 0x02, 0xC1, 0x83, 0x03,
  0xC1, 0x03, 0x03, 0xC3, 0x03, 0x03, 0xC3, 0x03, 0x02, 0xC3, 0x03, 0x06,
  0xC1, 0x03, 0x06, 0xC1, 0x83, 0x06, 0xC1, 0x87, 0x86, 0xC1, 0xCD, 0x8C,
  0x60, 0xFC, 0xF8, 0x60, 0x30, 0x70, 0x60, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x18, 0x00, 0x00, 0x0C, 0x00, 0x40, 0x07, 0x83, 0x80,
  0x03, 0xFF, 0x80, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1E,
  0x00, 0x06, 0x80, 0x01, 0xB0, 0x00, 0xCC, 0x00, 0x33, 0x00, 0x0C, 0x60,
  0x03, 0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0x30, 0x0E, 0x0C, 0x03,
  0x03, 0x00, 0xC0, 0xE0, 0x30, 0x18, 0x1F, 0xFE, 0x07, 0xFF, 0x81, 0x80,
  0x70, 0xE0, 0x0C, 0x30, 0x03, 0x0C, 0x00, 0xE3, 0x00, 0x19, 0xC0, 0x06,
  0x60, 0x01, 0x98, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xC1, 0xFF,
  0xE3, 0x01, 0xE6, 0x00, 0xEC, 0x00, 0xD8, 0x01, 0xB0, 0x03, 0x60, 0x06,
  0xC0, 0x0D, 0x80, 0x1B, 0x00, 0x76, 0x01, 0xCF, 0xFF, 0x1F, 0xFC, 0x30,
  0x3E, 0x60, 0x0E, 0xC0, 0x0D, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1D, 0x80, 0x73, 0xFF, 0xC7,
  0xFF, 0x00, 0x01, 0xFE, 0x07, 0xFF, 0x0E, 0x02, 0x1C, 0x00, 0x38, 0x00,
  0x30, 0x00, 0x70, 0x00, 0x60, 0x00, 0x60, 0x00, 0x60, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xC0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0x60, 0x00, 0x60, 0x00, 0x70, 0x00, 0x30, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x01, 0x07, 0xFF, 0x03, 0xFE, 0xFF, 0x80,
  0x7F, 0xF8, 0x30, 0x1E, 0x18, 0x03, 0x8C, 0x00, 0xE6, 0x00, 0x33, 0x00,
  0x1D, 0x80, 0x06, 0xC0, 0x03, 0x60, 0x01, 0xB0, 0x00, 0xD8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xB0, 0x00, 0xD8, 0x00, 0x6C, 0x00, 0x76, 0x00, 0x33, 0x00, 0x19, 0x80,
  0x1C, 0xC0, 0x1C, 0x60, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x01, 0xFF,
  0x00, 0xFF, 0xF8, 0x3C, 0x03, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x60, 0x00,
  0x1C, 0x00, 0x03, 0x00, 0x00, 0x60, 0x00, 0x0C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0C, 0x00, 0x01, 0x80, 0x00, 0x30, 0x07, 0xFE, 0x00, 0xFF,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xB0, 0x00, 0x76, 0x00, 0x0E,
  0xE0, 0x01, 0xCC, 0x00, 0x39, 0xC0, 0x07, 0x1C, 0x00, 0xE1, 0xC0, 0x1C,
  0x1F, 0xFF, 0x80, 0xFF, 0xC0, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xFF, 0xFC, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x61,
  0xF7, 0xF0, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x0F, 0xFB, 0xE0, 0xC0, 0x0F, 0x80,
  0x3B, 0x00, 0x66, 0x01, 0xCC, 0x07, 0x18, 0x0C, 0x30, 0x30, 0x60, 0xE0,
  0xC1, 0x81, 0x86, 0x03, 0x1C, 0x06, 0x30, 0x0C, 0xE0, 0x1B, 0xC0, 0x37,
  0xC0, 0x79, 0x80, 0xE3, 0x81, 0x83, 0x03, 0x07, 0x06, 0x07, 0x0C, 0x06,
  0x18, 0x0E, 0x30, 0x0C, 0x60, 0x1C, 0xC0, 0x19, 0x80, 0x3B, 0x00, 0x36,
  0x00, 0x70, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xBD, 0x80, 0x03, 0x7B, 0x00,
  0x06, 0xF6, 0x00, 0x19, 0xE6, 0x00, 0x33, 0xCC, 0x00, 0x67, 0x98, 0x01,
  0x8F, 0x18, 0x03, 0x1E, 0x30, 0x06, 0x3C, 0x60, 0x1C, 0x78, 0x60, 0x30,
  0xF0, 0xC0, 0x61, 0xE1, 0x80, 0xC3, 0xC1, 0x83, 0x07, 0x83, 0x06, 0x0F,
  0x06, 0x0C, 0x1E, 0x06, 0x30, 0x3C, 0x0C, 0x60, 0x78, 0x18, 0xC0, 0xF0,
  0x1B, 0x01, 0xE0, 0x36, 0x03, 0xC0, 0x6C, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1E, 0x01, 0xC0, 0x30, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3D, 0x80, 0x1E, 0xC0, 0x0F, 0x30, 0x07, 0x98, 0x03, 0xC6, 0x01,
  0xE3, 0x00, 0xF0, 0xC0, 0x78, 0x60, 0x3C, 0x18, 0x1E, 0x0C, 0x0F, 0x03,
  0x07, 0x81, 0xC3, 0xC0, 0x61, 0xE0, 0x38, 0xF0, 0x0C, 0x78, 0x07, 0x3C,
  0x01, 0x9E, 0x00, 0xEF, 0x00, 0x37, 0x80, 0x1F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xF8, 0x00, 0x70, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x78, 0x1C,
  0x0C, 0x01, 0xC3, 0x80, 0x18, 0xE0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x07,
  0x60, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xB0, 0x00, 0x36, 0x00, 0x0E, 0xC0, 0x01, 0x8C, 0x00, 0x31,
  0x80, 0x0E, 0x18, 0x03, 0x83, 0x80, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x03, 0xFF, 0x8C, 0x0F, 0x30, 0x0E, 0xC0, 0x1B, 0x00, 0x7C, 0x01,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x06, 0xC0, 0x1B, 0x00,
  0xCC, 0x1F, 0x3F, 0xF0, 0xFE, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0x03, 0xFC, 0x01, 0xFF, 0xC0, 0x78, 0x1C, 0x0C, 0x01, 0xC3, 0x80,
  0x1C, 0xE0, 0x01, 0x98, 0x00, 0x33, 0x00, 0x07, 0x60, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xB0, 0x00,
  0x36, 0x00, 0x0E, 0xC0, 0x01, 0x8C, 0x00, 0x31, 0x80, 0x0E, 0x18, 0x03,
  0x83, 0x80, 0xE0, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x38,
  0x00, 0x03, 0x80, 0x00, 0x30, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x06,
  0x00, 0xFF, 0x81, 0xFF, 0xC3, 0x03, 0xC6, 0x01, 0xCC, 0x01, 0x98, 0x03,
  0xB0, 0x07, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x3B, 0x00, 0x76, 0x00, 0xCC,
  0x03, 0x98, 0x0E, 0x3F, 0xF8, 0x7F, 0xC0, 0xC1, 0x81, 0x81, 0x83, 0x03,
  0x06, 0x03, 0x0C, 0x06, 0x18, 0x0E, 0x30, 0x0C, 0x60, 0x1C, 0xC0, 0x19,
  0x80, 0x3B, 0x00, 0x36, 0x00, 0x70, 0x0F, 0xF0, 0xFF, 0xE7, 0x01, 0x98,
  0x00, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x80, 0x06,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x06,
  0x00, 0x3A, 0x01, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01,
  0x80, 0x01, 0x80, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0,
  0x03, 0x60, 0x07, 0x70, 0x06, 0x38, 0x0E, 0x3F, 0xFC, 0x0F, 0xF0, 0xC0,
  0x01, 0xF8, 0x00, 0x66, 0x00, 0x19, 0x80, 0x06, 0x60, 0x03, 0x9C, 0x00,
  0xC3, 0x00, 0x30, 0xC0, 0x0C, 0x38, 0x07, 0x06, 0x01, 0x81, 0x80, 0x60,
  0x60, 0x38, 0x1C, 0x0C, 0x03, 0x03, 0x00, 0xC0, 0xC0, 0x30, 0x70, 0x0E,
  0x18, 0x01, 0x86, 0x00, 0x61, 0x80, 0x18, 0xC0, 0x03, 0x30, 0x00, 0xCC,
  0x00, 0x37, 0x00, 0x0D, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0xE0, 0x07, 0x00, 0x3B, 0x00, 0x38, 0x01, 0xD8, 0x01, 0xC0,
  0x0C, 0xC0, 0x0E, 0x00, 0x67, 0x00, 0xD8, 0x03, 0x18, 0x06, 0xC0, 0x38,
  0xC0, 0x36, 0x01, 0x86, 0x01, 0xB0, 0x0C, 0x30, 0x0D, 0x80, 0x60, 0xC0,
  0xC6, 0x07, 0x06, 0x06, 0x30, 0x30, 0x30, 0x31, 0x81, 0x81, 0x81, 0x8C,
  0x0C, 0x0E, 0x18, 0x30, 0x60, 0x30, 0xC1, 0x87, 0x01, 0x86, 0x0C, 0x30,
  0x0C, 0x30, 0x61, 0x80, 0x71, 0x81, 0x8C, 0x01, 0x98, 0x0C, 0xE0, 0x0C,
  0xC0, 0x66, 0x00, 0x66, 0x03, 0x30, 0x03, 0x30, 0x19, 0x80, 0x1D, 0x00,
  0x6C, 0x00, 0x78, 0x03, 0xC0, 0x03, 0xC0, 0x1E, 0x00, 0x1E, 0x00, 0xF0,
  0x00, 0xF0, 0x03, 0x80, 0x03, 0x00, 0x1C, 0x00, 0x70, 0x07, 0x30, 0x06,
  0x30, 0x0E, 0x18, 0x0C, 0x18, 0x0C, 0x1C, 0x18, 0x0C, 0x18, 0x0E, 0x30,
  0x06, 0x30, 0x06, 0x70, 0x03, 0x60, 0x03, 0xE0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x03, 0xE0, 0x03, 0x60, 0x06, 0x60, 0x06, 0x30, 0x0C, 0x30,
  0x0C, 0x18, 0x1C, 0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x06,
  0x60, 0x06, 0xE0, 0x03, 0xC0, 0x07, 0x60, 0x06, 0x60, 0x06, 0x70, 0x0E,
  0x30, 0x0C, 0x30, 0x0C, 0x18, 0x18, 0x18, 0x18, 0x1C, 0x38, 0x0C, 0x30,
  0x0C, 0x30, 0x06, 0x60, 0x06, 0x60, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x7F, 0xFD, 0xFF, 0xF0, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x0C,
  0x00, 0x30, 0x01, 0x80, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x60, 0x01, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xC0,
  0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03, 0x00, 0x30, 0x03, 0x00, 0x18,
  0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0x60, 0x06, 0x00, 0x60, 0x03,
  0x00, 0x30, 0x03, 0x80, 0x18, 0x01, 0x80, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0x60, 0x06, 0x00, 0x60, 0x03, 0xFF, 0xFF, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x06,
  0x60, 0x06, 0x60, 0x0C, 0x30, 0x0C, 0x30, 0x18, 0x18, 0x18, 0x18, 0x30,
  0x0C, 0x30, 0x0C, 0x60, 0x06, 0x60, 0x06, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC3, 0x87, 0x0C, 0x18, 0x30, 0x1F, 0xC7, 0xFE, 0x20, 0x60, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFF, 0x3F, 0xB7, 0x03,
  0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x7C, 0x07, 0xE0, 0xF7, 0x3B,
  0x3F, 0x10, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x1F, 0x0D, 0xFF, 0x36, 0x0C, 0xF0,
  0x1B, 0x80, 0x6E, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x6E,
  0x01, 0xBC, 0x0E, 0xDF, 0xF3, 0x3F, 0x80, 0x07, 0xF1, 0xFE, 0x38, 0x27,
  0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x03,
  0xFF, 0x0F, 0xE0, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C,
  0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x3E, 0x31, 0xFE, 0xCE, 0x0F,
  0x70, 0x1D, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xE0, 0x0D, 0x80,
  0x76, 0x01, 0xDC, 0x0F, 0x3F, 0xEC, 0x7F, 0x10, 0x0F, 0xC0, 0x7F, 0x83,
  0x87, 0x1C, 0x0C, 0x60, 0x19, 0x80, 0x6C, 0x01, 0xB0, 0x06, 0xC0, 0x1B,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0x00,
  0x60, 0x01, 0xC0, 0x03, 0x80, 0x87, 0xFE, 0x0F, 0xF0, 0x03, 0xC0, 0xFC,
  0x38, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x07, 0xF3, 0xFE,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x00, 0x0F, 0xCC, 0x7F, 0xB3, 0x83, 0xDC, 0x07, 0x60, 0x1F,
  0x80, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x03, 0x60, 0x1D, 0x80, 0x77, 0x03,
  0xCF, 0xFB, 0x1F, 0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x70, 0x01, 0x90, 0x0E, 0x7F, 0xF0, 0xFF, 0x80, 0xC0, 0x06, 0x00, 0x30,
  0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x3E,
  0x37, 0xF9, 0xB0, 0xEF, 0x03, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0C, 0x5B, 0xE0, 0x00,
  0xDB, 0x6D, 0xB6, 0xDB, 0x6D, 0xB6, 0xDB, 0x6C, 0x04, 0x30, 0xC3, 0x00,
  0x00, 0x00, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC7, 0xFB,
  0xE0, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x07, 0xC0, 0x6C, 0x0C, 0xC1, 0xCC, 0x18, 0xC3, 0x0C,
  0x70, 0xC6, 0x0C, 0xC0, 0xDE, 0x0F, 0x60, 0xF7, 0x0E, 0x30, 0xC3, 0x8C,
  0x18, 0xC1, 0xCC, 0x0C, 0xC0, 0xEC, 0x06, 0xC0, 0x7C, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xCF, 0xC3, 0xF3, 0x7F, 0x9F, 0xEF,
  0x06, 0xC1, 0xF8, 0x1E, 0x03, 0xE0, 0x38, 0x0F, 0x00, 0xE0, 0x3C, 0x03,
  0x00, 0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00,
  0xF0, 0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0,
  0x0C, 0x03, 0xC0, 0x30, 0x0F, 0x00, 0xC0, 0x3C, 0x03, 0x00, 0xF0, 0x0C,
  0x03, 0xC0, 0x30, 0x0C, 0xC7, 0xC6, 0xFF, 0xB6, 0x1D, 0xC0, 0x7E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0x80, 0x0F, 0xC0, 0x3F, 0xE0, 0xE0, 0xE3, 0x80, 0xC6, 0x01,
  0xDC, 0x01, 0xB0, 0x03, 0x60, 0x06, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xB0, 0x03, 0x70, 0x06, 0x60, 0x0C, 0xE0,
  0x30, 0xC0, 0xE0, 0xFF, 0x80, 0xFE, 0x00, 0xC7, 0xC3, 0x3F, 0xCD, 0x83,
  0xBC, 0x06, 0xE0, 0x1B, 0x80, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF8, 0x07, 0xE0,
  0x1B, 0x80, 0x6D, 0x03, 0xB7, 0xFC, 0xCF, 0xE3, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x00,
  0x0F, 0xCC, 0x7F, 0xB3, 0x83, 0xDC, 0x07, 0x60, 0x1F, 0x80, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF8, 0x03, 0x60, 0x1D, 0x80, 0x77, 0x02, 0xCF, 0xFB, 0x1F,
  0xCC, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x00, 0x30, 0xC7, 0xE7, 0xF6, 0x1E, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x00, 0x0F, 0xC3, 0xFF, 0x70, 0x26, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x80, 0x3C, 0x00,
  0xE0, 0x07, 0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x80, 0x6F, 0xFE, 0x7F,
  0xC0, 0x10, 0x18, 0x0C, 0x06, 0x03, 0x03, 0xFF, 0xFE, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x70, 0x1D, 0x8F, 0xC0, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07, 0xC0, 0x3F, 0x03,
  0xF8, 0x16, 0xFF, 0xB3, 0xF1, 0x80, 0xC0, 0x0F, 0x80, 0x36, 0x00, 0xD8,
  0x07, 0x70, 0x18, 0xC0, 0x63, 0x03, 0x8C, 0x0C, 0x38, 0x30, 0x60, 0xC1,
  0x86, 0x06, 0x18, 0x0C, 0x60, 0x31, 0x80, 0xCC, 0x03, 0x30, 0x06, 0xC0,
  0x1E, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0xE0, 0x18, 0x06, 0xC0, 0x30,
  0x0D, 0x80, 0xF0, 0x1B, 0x01, 0xE0, 0x37, 0x03, 0xC0, 0xC6, 0x04, 0x81,
  0x8C, 0x19, 0x83, 0x18, 0x33, 0x06, 0x38, 0x66, 0x18, 0x30, 0xC4, 0x30,
  0x63, 0x0C, 0x60, 0xC6, 0x18, 0xC1, 0x8C, 0x31, 0x81, 0x98, 0x66, 0x03,
  0x60, 0x6C, 0x06, 0xC0, 0xD8, 0x0D, 0x81, 0xB0, 0x0B, 0x03, 0x40, 0x1C,
  0x03, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x19, 0x80, 0xE7,
  0x03, 0x0C, 0x1C, 0x38, 0x60, 0x63, 0x81, 0xCC, 0x03, 0x60, 0x0F, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x0D, 0x80, 0x37, 0x01, 0x8C, 0x06, 0x38,
  0x30, 0x60, 0xC1, 0xC6, 0x03, 0x38, 0x0E, 0xC0, 0x1C, 0xE0, 0x0E, 0xC0,
  0x19, 0x80, 0x33, 0x80, 0x63, 0x01, 0x86, 0x03, 0x0C, 0x06, 0x0C, 0x1C,
  0x18, 0x30, 0x30, 0x60, 0x60, 0xC0, 0x63, 0x00, 0xC6, 0x01, 0x8C, 0x01,
  0xB8, 0x03, 0x60, 0x06, 0xC0, 0x0D, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x07, 0x00, 0x0C, 0x00, 0x18, 0x00,
  0x60, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x7F, 0xEF, 0xFC, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x06, 0x01, 0x80, 0x30, 0x0C, 0x01, 0x80, 0x7F, 0xFF, 0xFE, 0x01,
  0xC1, 0xF0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0xF0, 0x3C, 0x03, 0x80, 0x60,
  0x1C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x38, 0x07, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xE0,
  0x3C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x03, 0xC0, 0xF0, 0x70, 0x38,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x70, 0xF8, 0x38, 0x00, 0x1E, 0x01, 0x7F, 0x83, 0xC3, 0xFF,
  0x80, 0x7C,
};

const GFXglyph NotoSans_Condensed_Light39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 3, 28, 9, 3, -28 },
  { 12, 9, 10, 13, 2, -28 },
  { 24, 18, 28, 20, 1, -28 },
  { 87, 14, 32, 18, 2, -30 },
  { 143, 23, 28, 26, 2, -28 },
  { 224, 18, 28, 20, 2, -28 },
  { 287, 3, 10, 7, 2, -28 },
  { 291, 7, 34, 11, 2, -28 },
  { 321, 8, 34, 11, 1, -28 },
  { 355, 13, 13, 17, 2, -30 },
  { 377, 16, 18, 18, 1, -23 },
  { 413, 5, 9, 8, 1, -4 },
  { 419, 9, 2, 11, 1, -12 },
  { 422, 3, 4, 8, 3, -4 },
  { 424, 12, 28, 14, 1, -28 },
  { 466, 14, 28, 18, 2, -28 },
  { 515, 8, 28, 18, 3, -28 },
  { 543, 14, 28, 18, 2, -28 },
  { 592, 14, 28, 18, 2, -28 },
  { 641, 16, 28, 18, 1, -28 },
  { 697, 14, 28, 18, 2, -28 },
  { 746, 14, 28, 18, 2, -28 },
  { 795, 14, 28, 18, 2, -28 },
  { 844, 14, 28, 18, 2, -28 },
  { 893, 14, 28, 18, 2, -28 },
  { 942, 3, 21, 8, 3, -21 },
  { 950, 5, 26, 8, 1, -21 },
  { 967, 16, 18, 18, 1, -23 },
  { 1003, 16, 10, 18, 1, -19 },
  { 1023, 16, 18, 18, 1, -23 },
  { 1059, 11, 28, 13, 1, -28 },
  { 1098, 24, 32, 28, 2, -28 },
  { 1194, 18, 28, 18, 0, -28 },
  { 1257, 15, 28, 20, 3, -28 },
  { 1310, 16, 28, 19, 2, -28 },
  { 1366, 17, 28, 22, 3, -28 },
  { 1426, 12, 28, 17, 3, -28 },
  { 1468, 12, 28, 16, 3, -28 },
  { 1510, 19, 28, 23, 2, -28 },
  { 1577, 16, 28, 22, 3, -28 },
  { 1633, 7, 28, 10, 2, -28 },
  { 1658, 7, 35, 9, -2, -28 },
  { 1689, 15, 28, 18, 3, -28 },
  { 1742, 12, 28, 16, 3, -28 },
  { 1784, 23, 28, 29, 3, -28 },
  { 1865, 17, 28, 23, 3, -28 },
  { 1925, 19, 28, 23, 2, -28 },
  { 1992, 14, 28, 18, 3, -28 },
  { 2041, 19, 35, 23, 2, -28 },
  { 2125, 15, 28, 19, 3, -28 },
  { 2178, 14, 28, 17, 2, -28 },
  { 2227, 16, 28, 16, 0, -28 },
  { 2283, 16, 28, 22, 3, -28 },
  { 2339, 18, 28, 18, 0, -28 },
  { 2402, 29, 28, 29, 0, -28 },
  { 2504, 16, 28, 16, 0, -28 },
  { 2560, 16, 28, 16, 0, -28 },
  { 2616, 14, 28, 16, 1, -28 },
  { 2665, 8, 34, 12, 3, -28 },
  { 2699, 12, 28, 14, 1, -28 },
  { 2741, 8, 34, 12, 1, -28 },
  { 2775, 16, 15, 18, 1, -28 },
  { 2805, 16, 2, 16, 0, 3 },
  { 2809, 6, 6, 10, 2, -30 },
  { 2814, 12, 21, 17, 2, -21 },
  { 2846, 14, 30, 19, 3, -30 },
  { 2899, 12, 21, 15, 2, -21 },
  { 2931, 14, 30, 19, 2, -30 },
  { 2984, 14, 21, 17, 2, -21 },
  { 3021, 11, 30, 10, 0, -30 },
  { 3063, 14, 30, 19, 2, -21 },
  { 3116, 13, 30, 19, 3, -30 },
  { 3165, 3, 29, 8, 3, -29 },
  { 3176, 6, 38, 8, -1, -29 },
  { 3205, 12, 30, 16, 3, -30 },
  { 3250, 2, 30, 8, 3, -30 },
  { 3258, 22, 21, 28, 3, -21 },
  { 3316, 13, 21, 19, 3, -21 },
  { 3351, 15, 21, 18, 2, -21 },
  { 3391, 14, 30, 19, 3, -21 },
  { 3444, 14, 30, 19, 2, -21 },
  { 3497, 9, 21, 12, 3, -21 },
  { 3521, 12, 21, 14, 1, -21 },
  { 3553, 9, 26, 10, 1, -26 },
  { 3583, 13, 21, 19, 3, -21 },
  { 3618, 14, 21, 15, 0, -21 },
  { 3655, 23, 21, 24, 0, -21 },
  { 3716, 14, 21, 15, 1, -21 },
  { 3753, 15, 30, 15, 0, -21 },
  { 3810, 11, 21, 13, 1, -21 },
  { 3839, 10, 34, 14, 2, -28 },
  { 3882, 1, 39, 17, 8, -30 },
  { 3887, 10, 34, 14, 2, -28 },
  { 3930, 16, 4, 18, 1, -16 },
};

const GFXfont NotoSans_Condensed_Light39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light39pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_CONDENSED_LIGHT39PT7B_H_
