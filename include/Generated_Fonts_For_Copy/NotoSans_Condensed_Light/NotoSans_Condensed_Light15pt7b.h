#ifndef _NOTOSANS_CONDENSED_LIGHT15PT7B_H_
#define _NOTOSANS_CONDENSED_LIGHT15PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans_Condensed-Light.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_Condensed_Light15pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0x20, 0xB6, 0xD0, 0x14, 0x28, 0x93, 0xF2, 0x44, 0x8A, 0x7F,
  0x28, 0x91, 0x20, 0x27, 0xE9, 0x4A, 0x30, 0xE5, 0x2D, 0xD8, 0x40, 0xC2,
  0xA4, 0xA4, 0xA8, 0xAA, 0xAD, 0x55, 0x15, 0x25, 0x25, 0x23, 0x61, 0x22,
  0x42, 0x86, 0x0C, 0x29, 0x4A, 0x8D, 0x1B, 0xD8, 0xF0, 0x2A, 0x49, 0x24,
  0x92, 0x26, 0xA5, 0x55, 0x55, 0x80, 0x25, 0xD8, 0xA9, 0x00, 0x21, 0x09,
  0xF2, 0x10, 0x80, 0xF0, 0xF0, 0x80, 0x08, 0x44, 0x21, 0x10, 0x88, 0x42,
  0x20, 0x74, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x5C, 0x2E, 0x92, 0x49, 0x24,
  0x80, 0x74, 0x42, 0x10, 0x88, 0x44, 0x44, 0x3E, 0x74, 0x42, 0x11, 0x38,
  0x21, 0x08, 0x7C, 0x08, 0x10, 0x61, 0x42, 0x89, 0x12, 0x44, 0x7E, 0x10,
  0x20, 0xFC, 0x21, 0x0E, 0x4C, 0x21, 0x08, 0x7C, 0x3A, 0x21, 0x0B, 0x66,
  0x31, 0x8C, 0x5C, 0xF8, 0x42, 0x21, 0x08, 0x84, 0x22, 0x10, 0x74, 0x63,
  0x15, 0x32, 0x71, 0x8C, 0x5C, 0x74, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0xB8,
  0x81, 0x83, 0xC0, 0x08, 0xD9, 0x04, 0x18, 0x20, 0xF8, 0x01, 0xF0, 0x86,
  0x0C, 0x11, 0x32, 0x00, 0xF0, 0x82, 0x11, 0x10, 0x88, 0x00, 0x18, 0x1C,
  0x11, 0x10, 0x51, 0x99, 0x4D, 0x26, 0x93, 0x49, 0x9B, 0x40, 0x10, 0x07,
  0x80, 0x10, 0x20, 0xA1, 0x42, 0x88, 0x9F, 0x22, 0x45, 0x06, 0x08, 0xF2,
  0x28, 0x61, 0x8B, 0xE8, 0x61, 0x86, 0x1F, 0x80, 0x3D, 0x08, 0x20, 0x82,
  0x08, 0x20, 0x81, 0x03, 0xC0, 0xF1, 0x12, 0x14, 0x28, 0x30, 0x60, 0xC2,
  0x85, 0x0B, 0xE0, 0xFC, 0x21, 0x08, 0x7E, 0x10, 0x84, 0x3E, 0xFC, 0x21,
  0x08, 0x7E, 0x10, 0x84, 0x20, 0x3C, 0x86, 0x04, 0x08, 0x11, 0xA0, 0xC1,
  0x82, 0x84, 0xF8, 0x86, 0x18, 0x61, 0x87, 0xF8, 0x61, 0x86, 0x18, 0x40,
  0xD5, 0x55, 0x5C, 0x24, 0x92, 0x49, 0x24, 0x93, 0x80, 0x86, 0x29, 0x24,
  0xA3, 0x89, 0x24, 0x8A, 0x28, 0x40, 0x84, 0x21, 0x08, 0x42, 0x10, 0x84,
  0x3E, 0xC0, 0xE0, 0xF0, 0x74, 0x5A, 0x2D, 0x16, 0x4B, 0x29, 0x94, 0xC4,
  0x62, 0x20, 0x83, 0x87, 0x0D, 0x1A, 0x32, 0x64, 0xC5, 0x8B, 0x0E, 0x18,
  0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x82, 0x88, 0xF0, 0xF4, 0x63,
  0x18, 0xC7, 0xD0, 0x84, 0x20, 0x38, 0x8A, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x82, 0x89, 0xF0, 0x40, 0x40, 0x80, 0xF2, 0x28, 0xA1, 0x8B, 0xE9, 0x24,
  0x8A, 0x28, 0x40, 0x7C, 0x21, 0x08, 0x30, 0x61, 0x08, 0x7C, 0xFC, 0x41,
  0x04, 0x10, 0x41, 0x04, 0x10, 0x41, 0x00, 0x86, 0x18, 0x61, 0x86, 0x18,
  0x61, 0x86, 0x17, 0x80, 0x83, 0x05, 0x12, 0x24, 0x49, 0x0A, 0x14, 0x28,
  0x60, 0x40, 0x84, 0x30, 0x85, 0x10, 0xA5, 0x24, 0xA4, 0x94, 0x92, 0x51,
  0x8C, 0x31, 0x86, 0x30, 0xC2, 0x00, 0x85, 0x14, 0x8A, 0x30, 0x43, 0x0A,
  0x49, 0x18, 0x40, 0x86, 0x14, 0x92, 0x28, 0xC3, 0x04, 0x10, 0x41, 0x00,
  0x7C, 0x20, 0x82, 0x10, 0x42, 0x08, 0x41, 0x0F, 0xC0, 0xF2, 0x49, 0x24,
  0x92, 0x4E, 0x82, 0x10, 0x82, 0x10, 0x82, 0x10, 0x42, 0xF1, 0x11, 0x11,
  0x11, 0x11, 0x11, 0xF0, 0x10, 0x20, 0xA1, 0x44, 0x58, 0xC0, 0xFC, 0x90,
  0xF1, 0x17, 0x99, 0x9F, 0x82, 0x08, 0x3E, 0x8A, 0x18, 0x61, 0x86, 0x2F,
  0x80, 0x78, 0x88, 0x88, 0x87, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8C, 0x5E,
  0x74, 0x63, 0xF8, 0x42, 0x0F, 0x34, 0x4F, 0x44, 0x44, 0x44, 0x40, 0x7C,
  0x63, 0x18, 0xC6, 0x2F, 0x08, 0x62, 0xE0, 0x84, 0x21, 0xF8, 0xC6, 0x31,
  0x8C, 0x62, 0x9F, 0xE0, 0x41, 0x55, 0x55, 0x58, 0x84, 0x21, 0x39, 0x53,
  0x94, 0x94, 0xA2, 0xFF, 0xE0, 0xF7, 0x44, 0x62, 0x31, 0x18, 0x8C, 0x46,
  0x23, 0x11, 0xFC, 0x63, 0x18, 0xC6, 0x31, 0x74, 0x63, 0x18, 0xC6, 0x2E,
  0xFA, 0x28, 0x61, 0x86, 0x18, 0xBE, 0x82, 0x08, 0x20, 0x7C, 0x63, 0x18,
  0xC6, 0x2F, 0x08, 0x42, 0x10, 0xF8, 0x88, 0x88, 0x88, 0xF8, 0x8C, 0x21,
  0x1E, 0x44, 0xF4, 0x44, 0x44, 0x47, 0x8C, 0x63, 0x18, 0xC6, 0x2F, 0x8E,
  0x24, 0x92, 0x51, 0x43, 0x08, 0x88, 0xC4, 0x55, 0x2A, 0xA5, 0x52, 0x98,
  0x88, 0x44, 0xCD, 0x23, 0x0C, 0x30, 0xC4, 0xA3, 0x86, 0x24, 0x92, 0x50,
  0xC3, 0x08, 0x20, 0x82, 0x20, 0x78, 0x84, 0x42, 0x21, 0x1F, 0x34, 0x44,
  0x44, 0x84, 0x44, 0x44, 0x30, 0xFF, 0xFE, 0x84, 0x44, 0x44, 0x32, 0x44,
  0x44, 0xC0, 0xF8,
};

const GFXglyph NotoSans_Condensed_Light15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 11, 3, 1, -11 },
  { 3, 3, 4, 5, 1, -11 },
  { 5, 7, 11, 8, 0, -11 },
  { 15, 5, 12, 7, 1, -11 },
  { 23, 8, 11, 10, 1, -11 },
  { 34, 7, 11, 8, 1, -11 },
  { 44, 1, 4, 3, 1, -11 },
  { 45, 3, 13, 4, 1, -11 },
  { 50, 2, 13, 4, 1, -11 },
  { 54, 5, 5, 6, 1, -11 },
  { 58, 5, 7, 7, 1, -9 },
  { 63, 1, 4, 3, 1, -2 },
  { 64, 4, 1, 4, 0, -5 },
  { 65, 1, 1, 3, 1, -1 },
  { 66, 5, 11, 5, 0, -11 },
  { 73, 5, 11, 7, 1, -11 },
  { 80, 3, 11, 7, 1, -11 },
  { 85, 5, 11, 7, 1, -11 },
  { 92, 5, 11, 7, 1, -11 },
  { 99, 7, 11, 7, 0, -11 },
  { 109, 5, 11, 7, 1, -11 },
  { 116, 5, 11, 7, 1, -11 },
  { 123, 5, 11, 7, 1, -11 },
  { 130, 5, 11, 7, 1, -11 },
  { 137, 5, 11, 7, 1, -11 },
  { 144, 1, 8, 3, 1, -8 },
  { 145, 1, 10, 3, 1, -8 },
  { 147, 5, 7, 7, 1, -9 },
  { 152, 5, 4, 7, 1, -7 },
  { 155, 5, 7, 7, 1, -9 },
  { 160, 5, 11, 5, 0, -11 },
  { 167, 9, 12, 11, 1, -11 },
  { 181, 7, 11, 7, 0, -11 },
  { 191, 6, 11, 8, 1, -11 },
  { 200, 6, 11, 7, 1, -11 },
  { 209, 7, 11, 8, 1, -11 },
  { 219, 5, 11, 7, 1, -11 },
  { 226, 5, 11, 6, 1, -11 },
  { 233, 7, 11, 9, 1, -11 },
  { 243, 6, 11, 9, 1, -11 },
  { 252, 2, 11, 4, 1, -11 },
  { 255, 3, 14, 3, -1, -11 },
  { 261, 6, 11, 7, 1, -11 },
  { 270, 5, 11, 6, 1, -11 },
  { 277, 9, 11, 11, 1, -11 },
  { 290, 7, 11, 9, 1, -11 },
  { 300, 7, 11, 9, 1, -11 },
  { 310, 5, 11, 7, 1, -11 },
  { 317, 7, 14, 9, 1, -11 },
  { 330, 6, 11, 7, 1, -11 },
  { 339, 5, 11, 7, 1, -11 },
  { 346, 6, 11, 6, 0, -11 },
  { 355, 6, 11, 9, 1, -11 },
  { 364, 7, 11, 7, 0, -11 },
  { 374, 11, 11, 11, 0, -11 },
  { 390, 6, 11, 6, 0, -11 },
  { 399, 6, 11, 6, 0, -11 },
  { 408, 6, 11, 6, 0, -11 },
  { 417, 3, 13, 5, 1, -11 },
  { 422, 5, 11, 5, 0, -11 },
  { 429, 4, 13, 5, 0, -11 },
  { 436, 7, 6, 7, 0, -11 },
  { 442, 6, 1, 6, 0, 1 },
  { 443, 2, 2, 4, 1, -11 },
  { 444, 4, 8, 7, 1, -8 },
  { 448, 6, 11, 7, 1, -11 },
  { 457, 4, 8, 6, 1, -8 },
  { 461, 5, 11, 7, 1, -11 },
  { 468, 5, 8, 7, 1, -8 },
  { 473, 4, 11, 4, 0, -11 },
  { 479, 5, 12, 7, 1, -8 },
  { 487, 5, 11, 7, 1, -11 },
  { 494, 1, 11, 3, 1, -11 },
  { 496, 2, 15, 3, 0, -11 },
  { 500, 5, 11, 6, 1, -11 },
  { 507, 1, 11, 3, 1, -11 },
  { 509, 9, 8, 11, 1, -8 },
  { 518, 5, 8, 7, 1, -8 },
  { 523, 5, 8, 7, 1, -8 },
  { 528, 6, 12, 7, 1, -8 },
  { 537, 5, 12, 7, 1, -8 },
  { 545, 4, 8, 5, 1, -8 },
  { 549, 4, 8, 6, 1, -8 },
  { 553, 4, 10, 4, 0, -10 },
  { 558, 5, 8, 7, 1, -8 },
  { 563, 6, 8, 6, 0, -8 },
  { 569, 9, 8, 9, 0, -8 },
  { 578, 6, 8, 6, 0, -8 },
  { 584, 6, 12, 6, 0, -8 },
  { 593, 5, 8, 5, 0, -8 },
  { 598, 4, 13, 5, 1, -11 },
  { 605, 1, 15, 7, 3, -11 },
  { 607, 4, 13, 5, 1, -11 },
  { 614, 5, 1, 7, 1, -6 },
};

const GFXfont NotoSans_Condensed_Light15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_Condensed_Light15pt7bBitmaps,
  (GFXglyph *)NotoSans_Condensed_Light15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_CONDENSED_LIGHT15PT7B_H_
