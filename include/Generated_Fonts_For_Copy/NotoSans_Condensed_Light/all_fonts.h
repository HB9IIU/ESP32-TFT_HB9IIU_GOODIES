#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_Condensed_Light
// Headers: 67

#include "NotoSans_Condensed_Light6pt7b.h"
#include "NotoSans_Condensed_Light7pt7b.h"
#include "NotoSans_Condensed_Light8pt7b.h"
#include "NotoSans_Condensed_Light9pt7b.h"
#include "NotoSans_Condensed_Light10pt7b.h"
#include "NotoSans_Condensed_Light11pt7b.h"
#include "NotoSans_Condensed_Light12pt7b.h"
#include "NotoSans_Condensed_Light13pt7b.h"
#include "NotoSans_Condensed_Light14pt7b.h"
#include "NotoSans_Condensed_Light15pt7b.h"
#include "NotoSans_Condensed_Light16pt7b.h"
#include "NotoSans_Condensed_Light17pt7b.h"
#include "NotoSans_Condensed_Light18pt7b.h"
#include "NotoSans_Condensed_Light19pt7b.h"
#include "NotoSans_Condensed_Light20pt7b.h"
#include "NotoSans_Condensed_Light21pt7b.h"
#include "NotoSans_Condensed_Light22pt7b.h"
#include "NotoSans_Condensed_Light23pt7b.h"
#include "NotoSans_Condensed_Light24pt7b.h"
#include "NotoSans_Condensed_Light25pt7b.h"
#include "NotoSans_Condensed_Light26pt7b.h"
#include "NotoSans_Condensed_Light27pt7b.h"
#include "NotoSans_Condensed_Light28pt7b.h"
#include "NotoSans_Condensed_Light29pt7b.h"
#include "NotoSans_Condensed_Light30pt7b.h"
#include "NotoSans_Condensed_Light31pt7b.h"
#include "NotoSans_Condensed_Light32pt7b.h"
#include "NotoSans_Condensed_Light33pt7b.h"
#include "NotoSans_Condensed_Light34pt7b.h"
#include "NotoSans_Condensed_Light35pt7b.h"
#include "NotoSans_Condensed_Light36pt7b.h"
#include "NotoSans_Condensed_Light37pt7b.h"
#include "NotoSans_Condensed_Light38pt7b.h"
#include "NotoSans_Condensed_Light39pt7b.h"
#include "NotoSans_Condensed_Light40pt7b.h"
#include "NotoSans_Condensed_Light41pt7b.h"
#include "NotoSans_Condensed_Light42pt7b.h"
#include "NotoSans_Condensed_Light43pt7b.h"
#include "NotoSans_Condensed_Light44pt7b.h"
#include "NotoSans_Condensed_Light45pt7b.h"
#include "NotoSans_Condensed_Light46pt7b.h"
#include "NotoSans_Condensed_Light47pt7b.h"
#include "NotoSans_Condensed_Light48pt7b.h"
#include "NotoSans_Condensed_Light49pt7b.h"
#include "NotoSans_Condensed_Light50pt7b.h"
#include "NotoSans_Condensed_Light51pt7b.h"
#include "NotoSans_Condensed_Light52pt7b.h"
#include "NotoSans_Condensed_Light53pt7b.h"
#include "NotoSans_Condensed_Light54pt7b.h"
#include "NotoSans_Condensed_Light55pt7b.h"
#include "NotoSans_Condensed_Light56pt7b.h"
#include "NotoSans_Condensed_Light57pt7b.h"
#include "NotoSans_Condensed_Light58pt7b.h"
#include "NotoSans_Condensed_Light59pt7b.h"
#include "NotoSans_Condensed_Light60pt7b.h"
#include "NotoSans_Condensed_Light61pt7b.h"
#include "NotoSans_Condensed_Light62pt7b.h"
#include "NotoSans_Condensed_Light63pt7b.h"
#include "NotoSans_Condensed_Light64pt7b.h"
#include "NotoSans_Condensed_Light65pt7b.h"
#include "NotoSans_Condensed_Light66pt7b.h"
#include "NotoSans_Condensed_Light67pt7b.h"
#include "NotoSans_Condensed_Light68pt7b.h"
#include "NotoSans_Condensed_Light69pt7b.h"
#include "NotoSans_Condensed_Light70pt7b.h"
#include "NotoSans_Condensed_Light71pt7b.h"
#include "NotoSans_Condensed_Light72pt7b.h"
