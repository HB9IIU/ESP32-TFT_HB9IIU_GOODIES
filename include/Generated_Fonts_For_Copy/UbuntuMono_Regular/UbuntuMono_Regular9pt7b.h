#ifndef _UBUNTUMONO_REGULAR9PT7B_H_
#define _UBUNTUMONO_REGULAR9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular9pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xF0, 0x55, 0xF5, 0xF6, 0x27, 0x87, 0x17, 0x20, 0xDD, 0xE5,
  0x79, 0x66, 0x67, 0x97, 0xC0, 0x5A, 0xA5, 0x95, 0x56, 0x57, 0x00, 0x22,
  0xF2, 0x20, 0x70, 0xC0, 0x80, 0x29, 0x29, 0x20, 0x65, 0xB9, 0x56, 0x59,
  0x25, 0xC0, 0xD4, 0xA9, 0xC0, 0xC5, 0x13, 0x80, 0x33, 0x59, 0xF1, 0xF3,
  0x13, 0x80, 0x34, 0x79, 0x97, 0xE5, 0x25, 0x00, 0x79, 0x67, 0x97, 0x69,
  0x97, 0x16, 0x90, 0x41, 0xC0, 0x3C, 0x30, 0xF0, 0xF0, 0x43, 0x60, 0xC5,
  0x21, 0x80, 0x75, 0xBB, 0xB4, 0x70, 0x26, 0x55, 0xF9, 0xF9, 0xE9, 0x9F,
  0x74, 0x88, 0x47, 0xE9, 0x99, 0x9E, 0xF3, 0xC9, 0xC0, 0xF2, 0x79, 0x00,
  0x74, 0x89, 0x57, 0x99, 0xF9, 0x99, 0xE9, 0x25, 0xC0, 0x71, 0x11, 0x16,
  0xBA, 0x6B, 0x40, 0x92, 0x49, 0xC0, 0x55, 0xBB, 0x99, 0x9D, 0xBB, 0x99,
  0x79, 0x99, 0x97, 0xF6, 0xF9, 0x00, 0x79, 0x99, 0x97, 0x30, 0xE9, 0x9E,
  0xA9, 0x74, 0x63, 0x17, 0xF2, 0x22, 0x22, 0x99, 0x99, 0x97, 0x99, 0x55,
  0x62, 0x99, 0xBB, 0x55, 0x96, 0x26, 0x59, 0x95, 0x62, 0x22, 0x71, 0x24,
  0x4F, 0xEA, 0xAC, 0x92, 0x24, 0x88, 0xD5, 0x5C, 0x25, 0x90, 0xF0, 0x90,
  0xE7, 0xF0, 0x93, 0xDB, 0xC0, 0x78, 0x87, 0x11, 0x79, 0x97, 0x7F, 0x87,
  0x73, 0xC9, 0x00, 0x79, 0x71, 0x70, 0x93, 0xDB, 0x40, 0x40, 0xC2, 0x23,
  0x4D, 0x5C, 0x92, 0xED, 0x40, 0xC2, 0x22, 0x23, 0xFB, 0x99, 0xF6, 0xD0,
  0x79, 0x97, 0xF6, 0xF8, 0x79, 0x97, 0x10, 0xF2, 0x40, 0xF1, 0xF0, 0x9E,
  0x46, 0xB6, 0xF0, 0x95, 0x62, 0x9B, 0x75, 0x56, 0x69, 0x95, 0x62, 0xC0,
  0xEA, 0x70, 0x69, 0x44, 0x98, 0xFE, 0xC9, 0x14, 0xB0, 0x5B,
};

const GFXglyph UbuntuMono_Regular9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 2, 2, 5, 1, -6 },
  { 3, 4, 6, 5, 0, -6 },
  { 6, 4, 7, 5, 0, -6 },
  { 10, 4, 6, 5, 0, -6 },
  { 13, 4, 6, 5, 0, -6 },
  { 16, 1, 2, 5, 2, -6 },
  { 17, 2, 8, 5, 1, -6 },
  { 19, 2, 8, 5, 1, -6 },
  { 21, 3, 3, 5, 1, -6 },
  { 23, 4, 5, 5, 0, -5 },
  { 26, 2, 2, 5, 1, -1 },
  { 27, 2, 1, 5, 1, -3 },
  { 28, 1, 1, 5, 2, -1 },
  { 29, 3, 7, 5, 1, -6 },
  { 32, 4, 6, 5, 0, -6 },
  { 35, 3, 6, 5, 1, -6 },
  { 38, 3, 6, 5, 1, -6 },
  { 41, 3, 6, 5, 1, -6 },
  { 44, 4, 6, 5, 0, -6 },
  { 47, 3, 6, 5, 1, -6 },
  { 50, 4, 6, 5, 0, -6 },
  { 53, 3, 6, 5, 1, -6 },
  { 56, 4, 6, 5, 0, -6 },
  { 59, 4, 6, 5, 0, -6 },
  { 62, 1, 4, 5, 2, -4 },
  { 63, 2, 5, 5, 1, -4 },
  { 65, 4, 3, 5, 0, -4 },
  { 67, 4, 3, 5, 0, -4 },
  { 69, 4, 3, 5, 0, -4 },
  { 71, 3, 6, 5, 1, -6 },
  { 74, 4, 7, 5, 0, -6 },
  { 78, 4, 6, 5, 0, -6 },
  { 81, 4, 6, 5, 0, -6 },
  { 84, 4, 6, 5, 0, -6 },
  { 87, 4, 6, 5, 0, -6 },
  { 90, 3, 6, 5, 1, -6 },
  { 93, 3, 6, 5, 1, -6 },
  { 96, 4, 6, 5, 0, -6 },
  { 99, 4, 6, 5, 0, -6 },
  { 102, 3, 6, 5, 1, -6 },
  { 105, 4, 6, 5, 0, -6 },
  { 108, 3, 6, 5, 1, -6 },
  { 111, 3, 6, 5, 1, -6 },
  { 114, 4, 6, 5, 0, -6 },
  { 117, 4, 6, 5, 0, -6 },
  { 120, 4, 6, 5, 0, -6 },
  { 123, 3, 6, 5, 1, -6 },
  { 126, 4, 7, 5, 0, -6 },
  { 130, 4, 6, 5, 0, -6 },
  { 133, 4, 6, 5, 0, -6 },
  { 136, 4, 6, 5, 0, -6 },
  { 139, 4, 6, 5, 0, -6 },
  { 142, 4, 6, 5, 0, -6 },
  { 145, 4, 6, 5, 0, -6 },
  { 148, 4, 6, 5, 0, -6 },
  { 151, 4, 6, 5, 0, -6 },
  { 154, 4, 6, 5, 0, -6 },
  { 157, 2, 7, 5, 1, -6 },
  { 159, 3, 7, 5, 1, -6 },
  { 162, 2, 7, 5, 1, -6 },
  { 164, 4, 3, 5, 0, -6 },
  { 166, 4, 1, 5, 0, 1 },
  { 167, 2, 2, 5, 1, -7 },
  { 168, 3, 4, 5, 1, -4 },
  { 170, 3, 6, 5, 1, -6 },
  { 173, 4, 4, 5, 0, -4 },
  { 175, 4, 6, 5, 0, -6 },
  { 178, 4, 4, 5, 0, -4 },
  { 180, 3, 6, 5, 1, -6 },
  { 183, 4, 5, 5, 0, -4 },
  { 186, 3, 6, 5, 1, -6 },
  { 189, 4, 6, 5, 0, -6 },
  { 192, 2, 7, 5, 1, -6 },
  { 194, 3, 6, 5, 1, -6 },
  { 197, 4, 6, 5, 0, -6 },
  { 200, 4, 4, 5, 0, -4 },
  { 202, 3, 4, 5, 1, -4 },
  { 204, 4, 4, 5, 0, -4 },
  { 206, 3, 5, 5, 1, -4 },
  { 208, 4, 5, 5, 0, -4 },
  { 211, 3, 4, 5, 1, -4 },
  { 213, 3, 4, 5, 1, -4 },
  { 215, 3, 5, 5, 1, -5 },
  { 217, 3, 4, 5, 1, -4 },
  { 219, 4, 4, 5, 0, -4 },
  { 221, 4, 4, 5, 0, -4 },
  { 223, 4, 4, 5, 0, -4 },
  { 225, 4, 5, 5, 0, -4 },
  { 228, 3, 4, 5, 1, -4 },
  { 230, 3, 7, 5, 1, -6 },
  { 233, 1, 7, 5, 2, -6 },
  { 234, 3, 7, 5, 1, -6 },
  { 237, 4, 2, 5, 0, -4 },
};

const GFXfont UbuntuMono_Regular9pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular9pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular9pt7bGlyphs,
  0x20, 0x7E, 9
};

#endif // _UBUNTUMONO_REGULAR9PT7B_H_
