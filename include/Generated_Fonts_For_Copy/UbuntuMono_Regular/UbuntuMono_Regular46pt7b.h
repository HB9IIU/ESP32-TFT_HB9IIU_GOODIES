#ifndef _UBUNTUMONO_REGULAR46PT7B_H_
#define _UBUNTUMONO_REGULAR46PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 46pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular46pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x38, 0xE3,
  0x8E, 0x38, 0xE0, 0x00, 0x00, 0x03, 0x9F, 0xFF, 0xF7, 0xCE, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x19,
  0x83, 0x00, 0x01, 0xE0, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x78, 0x03, 0x83,
  0xC0, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0E, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0xE0, 0x0E, 0x0F, 0x00, 0x70, 0x78,
  0x03, 0x83, 0xC0, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07, 0x00, 0x70,
  0x78, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x07, 0x00,
  0x70, 0x78, 0x03, 0x83, 0xC0, 0x3C, 0x1C, 0x01, 0xE0, 0xE0, 0x0F, 0x07,
  0x00, 0x70, 0x78, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0xFF, 0xFC, 0x3E,
  0x03, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x79, 0x00, 0x0F, 0x3C, 0x07, 0xE7, 0xFF,
  0xF8, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x73, 0xF8, 0x03, 0x9C,
  0xE0, 0x39, 0xC7, 0x03, 0xCE, 0x1C, 0x1C, 0x70, 0xE1, 0xC3, 0x87, 0x0E,
  0x1C, 0x38, 0xE0, 0xE1, 0xCF, 0x07, 0x0E, 0x70, 0x38, 0xE7, 0x00, 0xE7,
  0x78, 0x07, 0xF3, 0x80, 0x0F, 0x38, 0x00, 0x01, 0xCF, 0x00, 0x1C, 0xFE,
  0x01, 0xEE, 0x70, 0x0E, 0x71, 0xC0, 0xE7, 0x0E, 0x0F, 0x38, 0x70, 0x71,
  0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE3, 0x83, 0x87, 0x3C, 0x0E, 0x39,
  0xC0, 0x73, 0x9C, 0x01, 0xFD, 0xE0, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x80, 0x3E, 0x3C, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x07, 0x81, 0xC0, 0x1C, 0x1E, 0x00, 0xF0, 0xE0, 0x03, 0xDF,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x70, 0x7F, 0x83, 0x87,
  0xFE, 0x1C, 0x3C, 0xF9, 0xE3, 0xC3, 0xEE, 0x1E, 0x0F, 0xF0, 0xE0, 0x3F,
  0x8F, 0x00, 0xF8, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x0F, 0x01, 0xF8, 0x7E,
  0x3F, 0xE1, 0xFF, 0xEF, 0x87, 0xFE, 0x3C, 0x0F, 0xC0, 0xF0, 0xFF, 0xFF,
  0x77, 0x77, 0x77, 0x77, 0x00, 0x20, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xC0, 0x04, 0x20, 0x03, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xC0,
  0x04, 0x00, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x04, 0x1C,
  0x17, 0x8E, 0x3F, 0xF7, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0xE0, 0x00,
  0xF8, 0x00, 0xEE, 0x00, 0xF7, 0x80, 0xF1, 0xE0, 0xF8, 0xF8, 0x38, 0x38,
  0x08, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80,
  0x00, 0x70, 0x00, 0x0F, 0x0F, 0xCF, 0xE7, 0xF1, 0xF8, 0xFC, 0x1E, 0x1E,
  0x3E, 0x7E, 0x3E, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38,
  0xFB, 0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x7F,
  0xFC, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0x78, 0x0F, 0x1E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x70, 0xFF, 0x1F,
  0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F, 0x8F, 0x8F, 0xF0, 0xE1, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xB8, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x8F, 0x01,
  0xE1, 0xE0, 0x3C, 0x1E, 0x0F, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xFC,
  0x00, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0xFF, 0x01,
  0xFF, 0x81, 0xFB, 0xC0, 0xF1, 0xE0, 0x60, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x1F, 0xFF, 0xCF, 0xFF, 0xE7, 0xFF,
  0xF0, 0x0F, 0xE0, 0x1F, 0xFE, 0x1F, 0xFF, 0x9F, 0x07, 0xCE, 0x01, 0xF2,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x0F, 0xE0, 0x3F, 0xFC, 0x3F, 0xFF, 0x0E, 0x07, 0xC6, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0xC0, 0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7B, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00, 0xE1,
  0xE0, 0x3C, 0x3C, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1E, 0x0E, 0x03,
  0xC3, 0xC0, 0x78, 0x70, 0x0F, 0x1E, 0x01, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x1F, 0xFF, 0x8F, 0xFF,
  0xC7, 0xFF, 0xE3, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xF8, 0x03, 0xFF, 0x81,
  0xFF, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x60,
  0x3F, 0x7F, 0xFF, 0x3F, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xF0, 0x07, 0xFE, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0xFC,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x03, 0xE7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x39, 0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07,
  0x9E, 0x00, 0xF1, 0xE0, 0x3E, 0x3F, 0x0F, 0x83, 0xFF, 0xE0, 0x3F, 0xF8,
  0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0x07, 0xC3, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1F, 0x07, 0x81, 0xFD,
  0xE0, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0xF1, 0xFC, 0x3C, 0x0F, 0xCF, 0x00,
  0x79, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xDC, 0x00,
  0x73, 0xC0, 0x1E, 0x7E, 0x0F, 0xC7, 0xFF, 0xF0, 0x7F, 0xFC, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x0F, 0x87, 0xC0,
  0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0x3B, 0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0x7C, 0x0F, 0xCF, 0xFF,
  0xF0, 0xFF, 0xFE, 0x07, 0xFB, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x03, 0xFC,
  0x07, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xF7,
  0xC7, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x7D, 0xFF,
  0xFB, 0xE3, 0x80, 0x0E, 0x0F, 0x8F, 0xE7, 0xF1, 0xF0, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x1F, 0x1F, 0xCF,
  0xE3, 0xF1, 0xF8, 0x38, 0x3C, 0x7C, 0xFC, 0x7C, 0x38, 0x00, 0x00, 0x00,
  0x40, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40,
  0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00,
  0x1F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0xFE, 0x00, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0xE1, 0xFF,
  0xF1, 0xFF, 0xF3, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x3C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0xC0, 0x3F, 0x80, 0x3E, 0x00,
  0x38, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0x81, 0xF0, 0x7C,
  0x1E, 0x01, 0xC3, 0xC0, 0x1E, 0x38, 0x00, 0xE7, 0x80, 0x0E, 0x78, 0x00,
  0xE7, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF0, 0xF0, 0xFF, 0x1E,
  0x0F, 0xF1, 0xE0, 0xFF, 0x1C, 0x0F, 0xF1, 0xC0, 0xFF, 0x1C, 0x0F, 0xF1,
  0xC0, 0xFF, 0x1C, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF0, 0xF0, 0xF7,
  0x0F, 0xFF, 0x78, 0x7F, 0xF7, 0x81, 0xFC, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8, 0x01, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0x70, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00, 0x71, 0xC0, 0x01,
  0xE3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x07, 0x00, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x70, 0x3C, 0x00, 0xE0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0xF0, 0x0E, 0x00, 0xE0, 0x3C, 0x01, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x1E, 0x1C, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0x80, 0x01, 0xE0,
  0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x78, 0x0F, 0x8F, 0x00, 0xF9,
  0xE0, 0x0F, 0x3C, 0x00, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0x9E, 0x00, 0xF3,
  0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7,
  0x80, 0x7C, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF0, 0x1F, 0x9F,
  0xFF, 0xF3, 0xFF, 0xF8, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xF8,
  0x1F, 0xFF, 0x87, 0xC0, 0xE1, 0xF0, 0x04, 0x7C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x00, 0x00, 0xF8, 0x02, 0x1F, 0x81, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0x7F, 0x80, 0x7F, 0xC0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x78, 0x1F, 0x8F,
  0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x01, 0xDE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x7C, 0xF0,
  0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0x7F,
  0xFF, 0xBF, 0xFF, 0xDE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF,
  0xE7, 0xFF, 0xF3, 0xFF, 0xF9, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xFE, 0xFF,
  0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xC0, 0xE1, 0xF0, 0x04, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x03, 0xCF, 0x00, 0x78,
  0xF8, 0x0F, 0x1F, 0x81, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x7F, 0x80,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0x87, 0xFF, 0xC3, 0xFF, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x40, 0x1E, 0x78, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x01, 0xFE, 0x00,
  0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x00, 0xF0, 0xF0, 0x1E,
  0x0F, 0x03, 0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF0, 0xF0, 0x0F, 0x1E,
  0x00, 0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F,
  0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8,
  0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1C, 0x01,
  0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x07, 0xC3, 0xF0, 0x7E, 0x1F,
  0x83, 0xF0, 0xFC, 0x1F, 0x87, 0x71, 0xDC, 0x3B, 0x8E, 0xE1, 0xDC, 0x77,
  0x9E, 0x73, 0x3C, 0xF3, 0xB8, 0xE7, 0x9D, 0xC7, 0x38, 0x7C, 0x39, 0xC3,
  0xE1, 0xCE, 0x1F, 0x0E, 0x70, 0x70, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1C,
  0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39, 0xC0, 0x01, 0xCE, 0x00,
  0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xE0,
  0xF0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xE0,
  0x1F, 0xF8, 0x0F, 0xDE, 0x07, 0xEF, 0x03, 0xF3, 0xC1, 0xF9, 0xE0, 0xFC,
  0x78, 0x7E, 0x1C, 0x3F, 0x0F, 0x1F, 0x83, 0x8F, 0xC1, 0xC7, 0xE0, 0xF3,
  0xF0, 0x39, 0xF8, 0x1E, 0xFC, 0x07, 0x7E, 0x03, 0xFF, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xF0,
  0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F, 0x83, 0xE0,
  0x3E, 0x1E, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x78, 0x00, 0xF3,
  0xC0, 0x07, 0x9C, 0x00, 0x1D, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7B, 0x80, 0x03, 0xDE,
  0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x78, 0xF0, 0x07,
  0x87, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x7F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0x7C, 0xF0,
  0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0xEF, 0x01, 0xF3,
  0xFF, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xE0, 0x3E, 0x0F, 0x83, 0xE0, 0x3E, 0x1E, 0x00, 0xF1, 0xE0, 0x03, 0xCF,
  0x00, 0x1E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9C, 0x00, 0x1D, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F,
  0x3C, 0x00, 0x78, 0xF0, 0x07, 0x87, 0xC0, 0x7C, 0x1F, 0x07, 0xC0, 0x7F,
  0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0x38, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0x80, 0xF8, 0xE0, 0x0F,
  0x38, 0x03, 0xCE, 0x00, 0x7B, 0x80, 0x1E, 0xE0, 0x07, 0xB8, 0x01, 0xEE,
  0x00, 0x7B, 0x80, 0x3C, 0xE0, 0x0F, 0x38, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFF, 0xF0, 0x38, 0x1E, 0x0E, 0x07, 0x83, 0x80, 0xF0, 0xE0, 0x3C,
  0x38, 0x07, 0x8E, 0x00, 0xE3, 0x80, 0x3C, 0xE0, 0x07, 0xB8, 0x01, 0xEE,
  0x00, 0x3F, 0x80, 0x0F, 0x07, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0x81,
  0xE7, 0x80, 0x27, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x1F, 0x80, 0x0F, 0xF0, 0x1F, 0xFF, 0xFF, 0xBF,
  0xFF, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1E, 0xE0, 0x03, 0x9E, 0x00, 0xF3, 0xE0, 0x3E, 0x3E, 0x0F, 0x87, 0xFF,
  0xF0, 0x3F, 0xF8, 0x01, 0xFC, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xF7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03,
  0xC7, 0x00, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x80, 0x38, 0x38, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x38,
  0xE0, 0x01, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x7B, 0x80,
  0x03, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xE7, 0x00, 0x07, 0x38, 0x00, 0x39,
  0xC0, 0x01, 0xCE, 0x00, 0x0E, 0x70, 0x00, 0x73, 0x80, 0x03, 0x9C, 0x00,
  0x1C, 0xE0, 0xE0, 0xE7, 0x0F, 0x87, 0x38, 0x7C, 0x39, 0xC3, 0xE1, 0xCE,
  0x3B, 0x9E, 0x79, 0xDC, 0xF3, 0xCC, 0xE7, 0x1E, 0xE3, 0xB8, 0x77, 0x1D,
  0xC3, 0xB8, 0xEE, 0x1F, 0x83, 0xF0, 0xFC, 0x1F, 0x87, 0xE0, 0xFC, 0x3E,
  0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0x80, 0x78, 0x00,
  0xF3, 0xE0, 0x0F, 0x8F, 0x00, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07,
  0x83, 0xC0, 0x3E, 0x1E, 0x00, 0xF1, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x1E, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x83, 0xC0, 0x78, 0x0F, 0x07, 0xC0,
  0x7C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xF0,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0xC0,
  0x1F, 0x1E, 0x00, 0xF0, 0xF8, 0x0F, 0x83, 0xC0, 0x78, 0x1F, 0x07, 0xC0,
  0x78, 0x3C, 0x03, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x3D, 0xE0, 0x01, 0xFF,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0,
  0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00,
  0xE0, 0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xE0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x0F, 0x03, 0x80, 0xE0,
  0xF0, 0x1E, 0x3C, 0x01, 0xE7, 0x80, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x79,
  0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x20,
  0x70, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x02, 0x1F, 0xF0, 0x1F, 0xFE, 0x0F,
  0xFF, 0x86, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x07, 0xFF, 0x9F, 0xFF, 0xDF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0x80,
  0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xDF, 0xFF, 0xE7,
  0xFF, 0xF0, 0xFF, 0xE0, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F,
  0xC1, 0xF3, 0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x3E, 0xF0, 0x3F, 0x3F, 0xFF, 0x8F,
  0xFF, 0xC0, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0xFF, 0xF8, 0x3F, 0xFF, 0x0F,
  0xC0, 0x63, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x08, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0xCF, 0x0F, 0xFF, 0xC7,
  0xFF, 0xF3, 0xE0, 0xFD, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xF0, 0x0F, 0x3F, 0x03, 0xC7,
  0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xF8, 0x01, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x1F, 0x87, 0xC7, 0xC0, 0x3C, 0xF0, 0x07, 0xBC, 0x00, 0x77, 0x80,
  0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0,
  0x30, 0x7F, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F,
  0xFC, 0x0F, 0xFF, 0x81, 0xF0, 0x30, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x7F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x03, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xF8, 0x0F, 0x7C, 0x03, 0xDE,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F,
  0x3E, 0x0F, 0xCF, 0xFF, 0xF1, 0xFF, 0xFC, 0x1F, 0xCF, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x88, 0x07, 0xC7, 0xFF,
  0xF1, 0xFF, 0xF0, 0x1F, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3,
  0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0F, 0x03, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC1, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0x78, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF, 0xF9, 0xFF,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1C, 0x00, 0x79, 0xC1, 0xF3, 0xFF, 0xCF, 0xFF, 0x03,
  0xF8, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x03, 0xEF, 0x00, 0xF9, 0xE0, 0x3E, 0x3C,
  0x0F, 0x87, 0x83, 0xE0, 0xF0, 0xF8, 0x1E, 0x3E, 0x03, 0xCF, 0x80, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3D, 0xF0, 0x07, 0x9F, 0x00, 0xF0,
  0xF0, 0x1E, 0x0F, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x0F, 0x00, 0xF1, 0xE0,
  0x0F, 0x3C, 0x01, 0xF7, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E,
  0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70,
  0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x04, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFC, 0x3F, 0x1F,
  0x1F, 0xF7, 0xFB, 0xFF, 0xFF, 0x70, 0xF8, 0xFE, 0x0E, 0x0F, 0xC1, 0xC1,
  0xF8, 0x38, 0x3F, 0x07, 0x07, 0xE0, 0xE0, 0xFC, 0x1C, 0x1F, 0x83, 0x83,
  0xF0, 0x70, 0x7E, 0x0E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0E,
  0x1F, 0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xF7, 0x80,
  0x7B, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x78, 0x03, 0xF8, 0x01,
  0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07, 0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0xBC,
  0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x1E, 0x7C,
  0x07, 0xC7, 0xC1, 0xF0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F, 0xBC, 0x01,
  0xEF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1E, 0xF0,
  0x0F, 0xBF, 0x07, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0xF3, 0xF0, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xFC,
  0xFC, 0x0F, 0x7C, 0x03, 0xDE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x7C, 0x03, 0xCF, 0x83, 0xF1, 0xFF, 0xFC,
  0x3F, 0xFF, 0x03, 0xF3, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0F,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x00, 0x07, 0xFC, 0x0F, 0xFF, 0x8F, 0xFF, 0xCF, 0x80, 0x47,
  0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x40, 0x07, 0xF8, 0x0F, 0xBF, 0xFF, 0xDF, 0xFF, 0xC1, 0xFF, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x03, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x80, 0xFF, 0xE0, 0x3F,
  0xFC, 0x03, 0xFC, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1E, 0xF0,
  0x0F, 0x78, 0x07, 0xBE, 0x03, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x7F, 0xC0,
  0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x01, 0xE3, 0xC0,
  0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0,
  0x78, 0x3C, 0x03, 0xC1, 0xE0, 0x1E, 0x0E, 0x00, 0x78, 0xF0, 0x03, 0xC7,
  0x80, 0x0F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x38, 0x39,
  0xC1, 0xC1, 0xCE, 0x1F, 0x0E, 0x70, 0xF8, 0x73, 0x87, 0xC3, 0x9E, 0x77,
  0x3C, 0xF3, 0xB9, 0xE3, 0x9D, 0xCE, 0x1D, 0xC7, 0x70, 0xEE, 0x3B, 0x87,
  0x60, 0xDC, 0x3F, 0x07, 0xE1, 0xF8, 0x3E, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xC0, 0x1C, 0x00, 0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x80, 0xF0,
  0x3E, 0x0F, 0x00, 0xF0, 0x78, 0x03, 0xC7, 0x80, 0x0F, 0x78, 0x00, 0x7F,
  0x80, 0x01, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF8, 0x00,
  0x3D, 0xE0, 0x01, 0xE7, 0x00, 0x1E, 0x3C, 0x01, 0xE0, 0xF0, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x00,
  0xF0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xE3, 0xC0, 0x3C,
  0x78, 0x07, 0x8F, 0x00, 0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x83, 0xC0, 0xF0,
  0x3C, 0x1C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x0F, 0x1C, 0x01, 0xE7, 0x80,
  0x1E, 0xF0, 0x03, 0xDC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0x3F,
  0xFF, 0x9F, 0xFF, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x01, 0xFF, 0x03, 0xFF,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xFF, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x7F, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF,
  0x00, 0x1E, 0x00, 0x47, 0xF0, 0x1D, 0xFF, 0x83, 0xF8, 0xF8, 0xFE, 0x0F,
  0xFD, 0xC0, 0x7F, 0x10, 0x03, 0xC0,
};

const GFXglyph UbuntuMono_Regular46pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 23, 0, -1 },
  { 1, 6, 28, 23, 8, -28 },
  { 22, 11, 11, 23, 6, -31 },
  { 38, 21, 28, 23, 1, -28 },
  { 112, 19, 36, 23, 2, -32 },
  { 198, 21, 28, 23, 1, -28 },
  { 272, 21, 28, 23, 1, -28 },
  { 346, 4, 12, 23, 9, -31 },
  { 352, 13, 40, 23, 5, -32 },
  { 417, 13, 40, 23, 5, -32 },
  { 482, 17, 17, 23, 3, -28 },
  { 519, 19, 20, 23, 2, -21 },
  { 567, 9, 12, 23, 7, -6 },
  { 581, 11, 4, 23, 6, -14 },
  { 587, 7, 6, 23, 8, -6 },
  { 593, 17, 40, 23, 3, -32 },
  { 678, 19, 28, 23, 2, -28 },
  { 745, 17, 28, 23, 3, -28 },
  { 805, 17, 28, 23, 3, -28 },
  { 865, 17, 28, 23, 3, -28 },
  { 925, 19, 28, 23, 2, -28 },
  { 992, 17, 28, 23, 3, -28 },
  { 1052, 19, 28, 23, 2, -28 },
  { 1119, 18, 28, 23, 3, -28 },
  { 1182, 19, 28, 23, 2, -28 },
  { 1249, 19, 28, 23, 2, -28 },
  { 1316, 7, 21, 23, 8, -21 },
  { 1335, 9, 27, 23, 6, -21 },
  { 1366, 19, 19, 23, 2, -21 },
  { 1412, 19, 11, 23, 2, -17 },
  { 1439, 19, 19, 23, 2, -21 },
  { 1485, 15, 28, 23, 4, -28 },
  { 1538, 20, 34, 23, 2, -28 },
  { 1623, 23, 28, 23, 0, -28 },
  { 1704, 19, 28, 23, 2, -28 },
  { 1771, 19, 28, 23, 2, -28 },
  { 1838, 19, 28, 23, 2, -28 },
  { 1905, 17, 28, 23, 4, -28 },
  { 1965, 16, 28, 23, 4, -28 },
  { 2021, 19, 28, 23, 2, -28 },
  { 2088, 19, 28, 23, 2, -28 },
  { 2155, 15, 28, 23, 4, -28 },
  { 2208, 17, 28, 23, 2, -28 },
  { 2268, 20, 28, 23, 3, -28 },
  { 2338, 17, 28, 23, 4, -28 },
  { 2398, 21, 28, 23, 1, -28 },
  { 2472, 17, 28, 23, 3, -28 },
  { 2532, 21, 28, 23, 1, -28 },
  { 2606, 18, 28, 23, 3, -28 },
  { 2669, 21, 35, 23, 1, -28 },
  { 2761, 18, 28, 23, 3, -28 },
  { 2824, 17, 28, 23, 3, -28 },
  { 2884, 19, 28, 23, 2, -28 },
  { 2951, 19, 28, 23, 2, -28 },
  { 3018, 21, 28, 23, 1, -28 },
  { 3092, 21, 28, 23, 1, -28 },
  { 3166, 21, 28, 23, 1, -28 },
  { 3240, 21, 28, 23, 1, -28 },
  { 3314, 19, 28, 23, 2, -28 },
  { 3381, 11, 40, 23, 7, -32 },
  { 3436, 17, 40, 23, 3, -32 },
  { 3521, 11, 40, 23, 5, -32 },
  { 3576, 19, 16, 23, 2, -28 },
  { 3614, 23, 3, 23, 0, 4 },
  { 3623, 8, 8, 23, 7, -32 },
  { 3631, 17, 21, 23, 3, -21 },
  { 3676, 18, 32, 23, 3, -32 },
  { 3748, 19, 21, 23, 2, -21 },
  { 3798, 18, 32, 23, 2, -32 },
  { 3870, 19, 21, 23, 2, -21 },
  { 3920, 19, 32, 23, 3, -32 },
  { 3996, 18, 29, 23, 2, -21 },
  { 4062, 17, 32, 23, 3, -32 },
  { 4130, 19, 30, 23, 2, -30 },
  { 4202, 15, 38, 23, 3, -30 },
  { 4274, 19, 32, 23, 3, -32 },
  { 4350, 19, 32, 23, 2, -32 },
  { 4426, 19, 21, 23, 2, -21 },
  { 4476, 17, 21, 23, 3, -21 },
  { 4521, 19, 21, 23, 2, -21 },
  { 4571, 18, 29, 23, 3, -21 },
  { 4637, 18, 29, 23, 2, -21 },
  { 4703, 15, 21, 23, 5, -21 },
  { 4743, 17, 21, 23, 3, -21 },
  { 4788, 18, 28, 23, 3, -28 },
  { 4851, 17, 21, 23, 3, -21 },
  { 4896, 21, 21, 23, 1, -21 },
  { 4952, 21, 21, 23, 1, -21 },
  { 5008, 21, 21, 23, 1, -21 },
  { 5064, 19, 29, 23, 2, -21 },
  { 5133, 17, 21, 23, 3, -21 },
  { 5178, 16, 40, 23, 4, -32 },
  { 5258, 3, 40, 23, 10, -32 },
  { 5273, 16, 40, 23, 3, -32 },
  { 5353, 19, 7, 23, 2, -16 },
};

const GFXfont UbuntuMono_Regular46pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular46pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular46pt7bGlyphs,
  0x20, 0x7E, 46
};

#endif // _UBUNTUMONO_REGULAR46PT7B_H_
