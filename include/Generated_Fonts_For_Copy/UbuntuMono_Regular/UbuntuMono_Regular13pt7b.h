#ifndef _UBUNTUMONO_REGULAR13PT7B_H_
#define _UBUNTUMONO_REGULAR13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular13pt7bBitmaps[] PROGMEM = {
  0x00, 0x55, 0x53, 0xB6, 0x80, 0x24, 0xAF, 0xCA, 0x4B, 0xF5, 0x14, 0x23,
  0xA1, 0x0E, 0x18, 0x21, 0xF1, 0x00, 0x66, 0xAA, 0x9C, 0x2C, 0xD5, 0x53,
  0x31, 0x24, 0x9C, 0x75, 0x6C, 0x9D, 0xE0, 0x12, 0x44, 0xCC, 0x44, 0x21,
  0x46, 0x21, 0x11, 0x12, 0x6C, 0x25, 0xD8, 0xA5, 0x00, 0x21, 0x3E, 0x42,
  0x00, 0x4B, 0x00, 0xE0, 0xC0, 0x10, 0x84, 0x42, 0x11, 0x08, 0x44, 0x20,
  0x74, 0xA3, 0x5A, 0xC6, 0x4E, 0x27, 0x08, 0x42, 0x10, 0x9F, 0xF4, 0x84,
  0x22, 0x22, 0x1F, 0xF0, 0x84, 0xC1, 0x84, 0x7E, 0x08, 0x62, 0x92, 0x4B,
  0xF0, 0x82, 0x7A, 0x21, 0xE1, 0x84, 0x7E, 0x32, 0x21, 0xE9, 0xC6, 0x6E,
  0xF8, 0xC4, 0x42, 0x11, 0x08, 0x74, 0xE3, 0xAF, 0x46, 0x3E, 0x74, 0xA3,
  0x1F, 0x88, 0xDC, 0xC0, 0xC0, 0xC0, 0xD8, 0x1B, 0xA0, 0xE1, 0x80, 0xF8,
  0x01, 0xF0, 0x83, 0x82, 0xE8, 0x00, 0xF1, 0x11, 0x24, 0x06, 0x74, 0x63,
  0x7A, 0xE6, 0xB7, 0xC3, 0x80, 0x30, 0xC2, 0x92, 0x49, 0xF4, 0x61, 0xF4,
  0xA5, 0xE9, 0xC6, 0x7E, 0x7E, 0x21, 0x08, 0x43, 0x0F, 0xE4, 0xA3, 0x18,
  0xC6, 0x5C, 0xFC, 0x21, 0xE8, 0x42, 0x1F, 0xFC, 0x21, 0xE8, 0x42, 0x10,
  0x7E, 0x61, 0x08, 0xC7, 0x2F, 0x8C, 0x63, 0xF8, 0xC6, 0x31, 0xF2, 0x22,
  0x22, 0x2F, 0x71, 0x11, 0x11, 0x9F, 0x9C, 0xA9, 0x8A, 0x4A, 0x71, 0x84,
  0x21, 0x08, 0x42, 0x1F, 0x4D, 0x36, 0xDD, 0x55, 0x18, 0x61, 0x8E, 0x73,
  0x5A, 0xCE, 0x73, 0x39, 0x34, 0x61, 0x85, 0x14, 0xCE, 0xF4, 0x63, 0x1F,
  0x42, 0x10, 0x39, 0x34, 0x61, 0x85, 0x14, 0xCE, 0x10, 0x30, 0xF4, 0xA3,
  0x2F, 0x4A, 0x51, 0x74, 0x21, 0xC3, 0x06, 0x3E, 0xFC, 0x41, 0x04, 0x10,
  0x41, 0x04, 0x8C, 0x63, 0x18, 0xC6, 0x6E, 0x85, 0x14, 0x52, 0x68, 0xA3,
  0x0C, 0x86, 0x14, 0x55, 0x75, 0xB4, 0xD3, 0x45, 0x23, 0x8C, 0x30, 0xA4,
  0x91, 0xC5, 0x16, 0x8E, 0x30, 0x41, 0x04, 0xF8, 0x84, 0x44, 0x22, 0x1F,
  0xF2, 0x49, 0x24, 0x9C, 0x84, 0x10, 0x84, 0x10, 0x84, 0x10, 0x84, 0xE4,
  0x92, 0x49, 0x3C, 0x63, 0xA5, 0x10, 0xFC, 0x90, 0xF0, 0xFF, 0x18, 0xFC,
  0x84, 0x21, 0xE9, 0xC6, 0x33, 0xF0, 0x7C, 0x21, 0x08, 0x3C, 0x18, 0xC6,
  0xF9, 0xCE, 0x73, 0x78, 0x74, 0x7F, 0x08, 0x38, 0x3A, 0x11, 0xF4, 0x21,
  0x08, 0x40, 0x7C, 0xE7, 0x39, 0xBC, 0x5E, 0x84, 0x21, 0xE9, 0x46, 0x31,
  0x88, 0x60, 0x38, 0xC6, 0x31, 0x87, 0x30, 0xF1, 0x11, 0x11, 0x1E, 0x84,
  0x21, 0x3B, 0x62, 0x92, 0x88, 0xE3, 0x18, 0xC6, 0x31, 0x84, 0x38, 0xFD,
  0x6B, 0x58, 0xC4, 0xF4, 0xA3, 0x18, 0xC4, 0x74, 0xE3, 0x19, 0xB8, 0xF4,
  0xE3, 0x19, 0xFA, 0x10, 0x7C, 0x63, 0x18, 0xBC, 0x63, 0xFC, 0x21, 0x08,
  0x40, 0x74, 0x38, 0x60, 0xF8, 0x42, 0x3E, 0x84, 0x21, 0x07, 0x9C, 0xE7,
  0x39, 0xBC, 0x45, 0x14, 0x8A, 0x30, 0xC0, 0x86, 0x55, 0x5D, 0x6D, 0x20,
  0x4C, 0xA3, 0x0C, 0x69, 0x10, 0x45, 0x36, 0x8A, 0x28, 0x41, 0x18, 0xF0,
  0x88, 0x8C, 0x7C, 0x3B, 0x10, 0x84, 0x61, 0x08, 0x43, 0x0E, 0xFF, 0xE0,
  0xE2, 0x22, 0x21, 0x22, 0x22, 0xE0, 0x66, 0x60,
};

const GFXglyph UbuntuMono_Regular13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 2, 8, 7, 2, -8 },
  { 3, 3, 3, 7, 2, -9 },
  { 5, 6, 8, 7, 0, -8 },
  { 11, 5, 10, 7, 1, -9 },
  { 18, 6, 8, 7, 0, -8 },
  { 24, 6, 8, 7, 0, -8 },
  { 30, 1, 3, 7, 3, -9 },
  { 31, 4, 10, 7, 1, -8 },
  { 36, 4, 10, 7, 1, -8 },
  { 41, 5, 5, 7, 1, -8 },
  { 45, 5, 5, 7, 1, -6 },
  { 49, 3, 3, 7, 2, -1 },
  { 51, 3, 1, 7, 2, -4 },
  { 52, 2, 1, 7, 2, -1 },
  { 53, 5, 11, 7, 1, -9 },
  { 60, 5, 8, 7, 1, -8 },
  { 65, 5, 8, 7, 1, -8 },
  { 70, 5, 8, 7, 1, -8 },
  { 75, 5, 8, 7, 1, -8 },
  { 80, 6, 8, 7, 0, -8 },
  { 86, 5, 8, 7, 1, -8 },
  { 91, 5, 8, 7, 1, -8 },
  { 96, 5, 8, 7, 1, -8 },
  { 101, 5, 8, 7, 1, -8 },
  { 106, 5, 8, 7, 1, -8 },
  { 111, 2, 5, 7, 2, -5 },
  { 113, 2, 7, 7, 2, -5 },
  { 115, 5, 5, 7, 1, -6 },
  { 119, 5, 4, 7, 1, -6 },
  { 122, 5, 5, 7, 1, -6 },
  { 126, 4, 8, 7, 1, -8 },
  { 130, 5, 10, 7, 1, -8 },
  { 137, 6, 8, 7, 0, -8 },
  { 143, 5, 8, 7, 1, -8 },
  { 148, 5, 8, 7, 1, -8 },
  { 153, 5, 8, 7, 1, -8 },
  { 158, 5, 8, 7, 1, -8 },
  { 163, 5, 8, 7, 1, -8 },
  { 168, 5, 8, 7, 1, -8 },
  { 173, 5, 8, 7, 1, -8 },
  { 178, 4, 8, 7, 1, -8 },
  { 182, 4, 8, 7, 1, -8 },
  { 186, 5, 8, 7, 1, -8 },
  { 191, 5, 8, 7, 1, -8 },
  { 196, 6, 8, 7, 0, -8 },
  { 202, 5, 8, 7, 1, -8 },
  { 207, 6, 8, 7, 0, -8 },
  { 213, 5, 8, 7, 1, -8 },
  { 218, 6, 10, 7, 0, -8 },
  { 226, 5, 8, 7, 1, -8 },
  { 231, 5, 8, 7, 1, -8 },
  { 236, 6, 8, 7, 0, -8 },
  { 242, 5, 8, 7, 1, -8 },
  { 247, 6, 8, 7, 0, -8 },
  { 253, 6, 8, 7, 0, -8 },
  { 259, 6, 8, 7, 0, -8 },
  { 265, 6, 8, 7, 0, -8 },
  { 271, 5, 8, 7, 1, -8 },
  { 276, 3, 10, 7, 2, -8 },
  { 280, 5, 11, 7, 1, -9 },
  { 287, 3, 10, 7, 2, -8 },
  { 291, 5, 4, 7, 1, -8 },
  { 294, 6, 1, 7, 0, 1 },
  { 295, 2, 2, 7, 2, -9 },
  { 296, 5, 6, 7, 1, -6 },
  { 300, 5, 9, 7, 1, -9 },
  { 306, 5, 6, 7, 1, -6 },
  { 310, 5, 9, 7, 1, -9 },
  { 316, 5, 6, 7, 1, -6 },
  { 320, 5, 9, 7, 1, -9 },
  { 326, 5, 8, 7, 1, -6 },
  { 331, 5, 9, 7, 1, -9 },
  { 337, 5, 8, 7, 1, -8 },
  { 342, 4, 10, 7, 1, -8 },
  { 347, 5, 9, 7, 1, -9 },
  { 353, 5, 9, 7, 1, -9 },
  { 359, 5, 6, 7, 1, -6 },
  { 363, 5, 6, 7, 1, -6 },
  { 367, 5, 6, 7, 1, -6 },
  { 371, 5, 8, 7, 1, -6 },
  { 376, 5, 8, 7, 1, -6 },
  { 381, 5, 6, 7, 1, -6 },
  { 385, 5, 6, 7, 1, -6 },
  { 389, 5, 8, 7, 1, -8 },
  { 394, 5, 6, 7, 1, -6 },
  { 398, 6, 6, 7, 0, -6 },
  { 403, 6, 6, 7, 0, -6 },
  { 408, 6, 6, 7, 0, -6 },
  { 413, 6, 8, 7, 0, -6 },
  { 419, 5, 6, 7, 1, -6 },
  { 423, 5, 11, 7, 1, -9 },
  { 430, 1, 11, 7, 3, -9 },
  { 432, 4, 11, 7, 1, -9 },
  { 438, 6, 2, 7, 0, -4 },
};

const GFXfont UbuntuMono_Regular13pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular13pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular13pt7bGlyphs,
  0x20, 0x7E, 13
};

#endif // _UBUNTUMONO_REGULAR13PT7B_H_
