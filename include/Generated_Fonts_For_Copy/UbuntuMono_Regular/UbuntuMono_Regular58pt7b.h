#ifndef _UBUNTUMONO_REGULAR58PT7B_H_
#define _UBUNTUMONO_REGULAR58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular58pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x1C, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0x7F, 0x7F, 0x7F, 0x7E,
  0x3C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xE7, 0x83, 0xCF, 0x07,
  0x9E, 0x0F, 0x3C, 0x1E, 0x78, 0x3C, 0xF0, 0x79, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xCE, 0x03, 0x80, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07,
  0xC0, 0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x3E, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x78,
  0x01, 0xE0, 0x3C, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F,
  0x00, 0x3C, 0x07, 0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xE0, 0x78, 0x01, 0xE0, 0x3C, 0x00, 0xF0,
  0x1E, 0x00, 0x78, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0x80, 0x1E,
  0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFE, 0x00, 0xC3, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0xC0, 0x00, 0xF9, 0xF0,
  0x07, 0xF3, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x03, 0xC7, 0xF8, 0x00, 0x78, 0xFF, 0x80, 0x1E, 0x3C, 0x78, 0x07, 0x87,
  0x0F, 0x00, 0xF1, 0xE0, 0xE0, 0x3C, 0x3C, 0x1E, 0x0F, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x0F, 0x0F, 0x03, 0xC1, 0xE3, 0xC0, 0x78,
  0x3C, 0xF0, 0x0F, 0x07, 0x1E, 0x00, 0xE1, 0xE7, 0x80, 0x1E, 0x3C, 0xF0,
  0x01, 0xFF, 0x3C, 0x00, 0x3F, 0xCF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x0F, 0x3F, 0xC0, 0x03, 0xCF, 0xF8, 0x00, 0xF3, 0xC7,
  0x80, 0x1E, 0x78, 0x70, 0x07, 0x8E, 0x0F, 0x01, 0xF3, 0xC1, 0xE0, 0x3C,
  0x78, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x1E, 0x03, 0x83, 0xC3, 0xC0, 0x70, 0x78, 0xF0, 0x0F, 0x0E, 0x1E, 0x01,
  0xE3, 0xC7, 0x80, 0x1F, 0xF1, 0xE0, 0x01, 0xFE, 0x3C, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF8,
  0x01, 0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x0F, 0x80, 0x7C, 0x03,
  0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x03, 0xC0,
  0xF8, 0x01, 0xF0, 0x78, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x0F, 0x03, 0xFE, 0x07, 0x83,
  0xFF, 0x83, 0xC3, 0xE7, 0xE1, 0xE3, 0xE1, 0xF8, 0xF1, 0xF0, 0x7E, 0xF1,
  0xF0, 0x1F, 0xF8, 0xF8, 0x07, 0xFC, 0x7C, 0x03, 0xFE, 0x3E, 0x00, 0xFE,
  0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xE3, 0xF0, 0x0F,
  0xF8, 0xFE, 0x3F, 0xFC, 0x3F, 0xFF, 0x9F, 0x1F, 0xFF, 0x8F, 0x83, 0xFF,
  0x83, 0xE0, 0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0xE7, 0x39, 0xC0, 0x00, 0x08, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3E, 0x00,
  0x38, 0x00, 0x20, 0x20, 0x00, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0,
  0x00, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x04, 0x07, 0x81, 0x1E, 0x0E, 0x0F, 0x3F,
  0x1C, 0x7E, 0x7F, 0xBB, 0xFD, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3D, 0xE0, 0x00, 0xFB, 0xE0, 0x03, 0xE3,
  0xE0, 0x0F, 0xC7, 0xE0, 0x1F, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x38, 0x0E,
  0x00, 0x20, 0x18, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x81, 0xF8, 0x7F, 0x8F,
  0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F, 0x03, 0xE0, 0xF8, 0x3F, 0x1F, 0xCF,
  0xF1, 0xFC, 0x3E, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x3E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF,
  0x01, 0xF8, 0x3F, 0x07, 0xE0, 0x3F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x0E, 0x0F, 0xFC, 0x3E, 0x1F, 0xF8,
  0xFE, 0x3F, 0xF1, 0xFC, 0x7F, 0xE3, 0xF8, 0xFF, 0xC7, 0xF1, 0xFF, 0x87,
  0xC3, 0xFF, 0x07, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07,
  0xC7, 0xC0, 0x1F, 0x0F, 0xC0, 0x7E, 0x0F, 0xC1, 0xF8, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x00, 0xFF, 0xF8, 0x0F, 0xF7, 0xC0, 0x7E, 0x3E, 0x03, 0xC1, 0xF0, 0x08,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xFF, 0x00, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xE0, 0x7F, 0x07, 0x00,
  0x3F, 0x08, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xC0, 0x7F, 0x02, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x90, 0x00, 0x3F, 0x3C, 0x03, 0xFC,
  0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7B, 0xE0, 0x00, 0x7D,
  0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x3E, 0x00, 0x3C,
  0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x07, 0xC1, 0xE0, 0x03, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x87, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE4, 0x00, 0x3F, 0xBC, 0x03, 0xFC, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x3F, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF3,
  0xFC, 0x07, 0xE7, 0xC0, 0x07, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F, 0xC0,
  0x3F, 0x0F, 0xC1, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x80, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F,
  0x1F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3C, 0xF0, 0x00, 0x79,
  0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x1F, 0x0F,
  0xE0, 0x7C, 0x0F, 0xF1, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFC, 0xFF, 0x83, 0xF0, 0x3F, 0x87, 0x80, 0x1F, 0x9F, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0xDF, 0x80, 0x3F,
  0x3F, 0x80, 0xFE, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0x7E, 0x00, 0x3E, 0xFE, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xC0, 0x3F,
  0xFF, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x3F, 0x9F, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF3, 0xFF,
  0xFF, 0xFF, 0x7F, 0xBF, 0x8F, 0x80, 0x07, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF,
  0x1F, 0xF0, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C,
  0x0F, 0xE0, 0xFE, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x1E,
  0x03, 0xE0, 0x7C, 0x3F, 0xCF, 0xF8, 0x7F, 0x07, 0xC0, 0x70, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00,
  0x00, 0x07, 0xF8, 0x07, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0x81,
  0xFC, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80,
  0x03, 0xE7, 0x80, 0x00, 0xF7, 0xC0, 0x1F, 0xFB, 0xE0, 0x3F, 0xFD, 0xF0,
  0x3F, 0xFE, 0xF0, 0x3F, 0xFF, 0x78, 0x3F, 0x07, 0xFC, 0x1F, 0x03, 0xFE,
  0x1F, 0x01, 0xFF, 0x0F, 0x80, 0xFF, 0x87, 0xC0, 0x7F, 0xC3, 0xC0, 0x3F,
  0xE1, 0xE0, 0x1F, 0xF0, 0xF0, 0x0F, 0xF8, 0x78, 0x07, 0xFC, 0x3E, 0x03,
  0xDE, 0x1F, 0x01, 0xEF, 0x0F, 0x80, 0xF7, 0xC3, 0xE0, 0x7B, 0xE1, 0xF8,
  0x3D, 0xF0, 0x7F, 0xFE, 0x7C, 0x1F, 0xFF, 0x3E, 0x07, 0xFF, 0x9F, 0x00,
  0xFF, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x08, 0x01, 0xFF, 0xFC, 0x00,
  0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0x8F, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0,
  0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00,
  0x3E, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00,
  0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF0, 0x3F,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x80,
  0x7F, 0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0x79, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F,
  0x9F, 0x00, 0x3E, 0x3E, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xC0, 0x1F, 0xCF, 0x80, 0x0F, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x0F, 0xBE, 0x00, 0x3F, 0x7C, 0x03, 0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x3E, 0x1F, 0xC0,
  0x04, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x06, 0x0F, 0xF0, 0x1E, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0xE0, 0xF8, 0x03,
  0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFF, 0x03, 0xC3,
  0xF8, 0x00, 0x87, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3D,
  0xF0, 0x00, 0x7B, 0xF0, 0x00, 0xF3, 0xE0, 0x01, 0xE7, 0xE0, 0x03, 0xC7,
  0xF0, 0x07, 0x87, 0xF8, 0x1F, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F,
  0xFF, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x90, 0x00, 0xFD, 0xC0, 0x0F,
  0xCF, 0x81, 0xFE, 0xFF, 0xFF, 0xE3, 0xFF, 0xFE, 0x07, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xF8, 0xF0,
  0x01, 0xF8, 0xF0, 0x03, 0xF0, 0xF0, 0x03, 0xE0, 0xF0, 0x07, 0xC0, 0xF0,
  0x0F, 0xC0, 0xF0, 0x1F, 0x80, 0xF0, 0x3F, 0x00, 0xF0, 0x7E, 0x00, 0xF0,
  0xFC, 0x00, 0xF0, 0xF8, 0x00, 0xF1, 0xF8, 0x00, 0xF3, 0xF0, 0x00, 0xF7,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xF3,
  0xF8, 0x00, 0xF1, 0xFC, 0x00, 0xF0, 0xFE, 0x00, 0xF0, 0x7F, 0x00, 0xF0,
  0x3F, 0x80, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xE0, 0xF0,
  0x03, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xFC, 0xF0,
  0x00, 0xFC, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F,
  0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xFC, 0x07, 0xF0,
  0xFE, 0x03, 0xF8, 0x77, 0x01, 0xDC, 0x3B, 0xC1, 0xEF, 0x3D, 0xE0, 0xF7,
  0x9E, 0x70, 0x73, 0xCF, 0x3C, 0x79, 0xE7, 0x9E, 0x3C, 0xF3, 0xC7, 0x1C,
  0x79, 0xE3, 0xCE, 0x3C, 0xF1, 0xEF, 0x1E, 0x78, 0x77, 0x0F, 0x3C, 0x3F,
  0x87, 0x9E, 0x1F, 0xC3, 0xCF, 0x07, 0xC1, 0xE7, 0x83, 0xE0, 0xF3, 0xC1,
  0xF0, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xF0, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x3F,
  0xF7, 0x80, 0x7F, 0xEF, 0x80, 0xFF, 0xCF, 0x01, 0xFF, 0x9F, 0x03, 0xFF,
  0x1E, 0x07, 0xFE, 0x3E, 0x0F, 0xFC, 0x3C, 0x1F, 0xF8, 0x7C, 0x3F, 0xF0,
  0x78, 0x7F, 0xE0, 0xF8, 0xFF, 0xC0, 0xF1, 0xFF, 0x81, 0xE3, 0xFF, 0x01,
  0xE7, 0xFE, 0x03, 0xCF, 0xFC, 0x03, 0xDF, 0xF8, 0x07, 0xBF, 0xF0, 0x0F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0xF8, 0x07,
  0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x07,
  0xEF, 0x80, 0x7F, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F,
  0xFF, 0xC0, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xDF,
  0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0,
  0xFC, 0x01, 0xF8, 0x3F, 0x83, 0xF8, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xE0, 0x3F,
  0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xF8,
  0x07, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xE0, 0xF8,
  0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x00,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xF8,
  0x0F, 0x87, 0xC0, 0x02, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x98, 0x00, 0x3F, 0x3E, 0x01, 0xFE, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x07, 0xEF,
  0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x1F, 0x81, 0xFC, 0x3F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x7C, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xF8,
  0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x79, 0xE0, 0xF8, 0x3C, 0xF0, 0x7C, 0x1E,
  0x78, 0x3E, 0x0F, 0x3C, 0x3F, 0x87, 0x9E, 0x1F, 0xC3, 0xCF, 0x0E, 0xE1,
  0xE7, 0x8F, 0x78, 0xF3, 0xC7, 0x3C, 0x79, 0xE3, 0x8E, 0x3C, 0xF3, 0xC7,
  0x9E, 0x79, 0xE3, 0xCF, 0x3C, 0xE0, 0xE7, 0x9E, 0xF0, 0x7B, 0xCF, 0x78,
  0x3D, 0xC3, 0xB8, 0x0E, 0xE1, 0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x7E,
  0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xFC, 0x00,
  0x7E, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x07, 0xC7, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0,
  0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x01,
  0xF0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0xFB, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x07, 0xDF, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03, 0xE0, 0xF8,
  0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x07, 0xC0, 0xF8, 0x03,
  0xE0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9E, 0x00, 0x03, 0xC2, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10,
  0x0E, 0x07, 0xC1, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0x80, 0x40,
  0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x0C,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0x0F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F, 0x7C, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7D, 0xF0, 0x01,
  0xF7, 0xF0, 0x07, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0,
  0x1F, 0xFE, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xE1, 0xFE, 0x0F, 0xE3, 0xF0, 0x07, 0xE7, 0xC0, 0x07,
  0xCF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8,
  0x00, 0xFD, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0xE7, 0xC0, 0x7F, 0x8F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFE, 0x00,
  0xC7, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF8, 0x01, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x1F, 0xC7, 0xC0, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F, 0x83, 0xFC, 0xFC, 0x01, 0xF9, 0xF0,
  0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x7E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xFC, 0x00, 0xF8, 0xFE, 0x01, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x1F,
  0xC0, 0xFC, 0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x0C, 0x0F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x01, 0xF8, 0x1E, 0x03,
  0xF0, 0x02, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x07,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFC, 0x07, 0xE7, 0xE0,
  0x07, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xF0, 0x03, 0xE7, 0xF0, 0x3F, 0xC7,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x38, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0x81, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7D, 0xFE, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xBE, 0x00, 0xFD, 0xF0, 0x03, 0xEF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x08, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x1F, 0xFF, 0xC7,
  0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFD, 0xE0, 0x7E, 0x7F, 0xFF, 0x3F,
  0xFF, 0xC7, 0xFF, 0xC0, 0x3F, 0xC0, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0,
  0xF8, 0x0F, 0xC0, 0xF8, 0x3F, 0x80, 0xF8, 0x7F, 0x00, 0xF8, 0xFC, 0x00,
  0xF9, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xF8, 0xFC, 0x00,
  0xF8, 0x7E, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x20, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x03,
  0xFC, 0x1F, 0xC1, 0xF8, 0x7F, 0xFB, 0xFE, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xEF, 0x87, 0xF1, 0xF7, 0xC1, 0xE0, 0x7F, 0xE0, 0xF8, 0x3F, 0xF0,
  0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x1F, 0x03, 0xFE, 0x0F, 0x81, 0xFF,
  0x07, 0xC0, 0xFF, 0x83, 0xE0, 0x7F, 0xC1, 0xF0, 0x3F, 0xE0, 0xF8, 0x1F,
  0xF0, 0x7C, 0x0F, 0xF8, 0x3E, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xE0, 0x0F, 0xFC, 0x07, 0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF,
  0xCF, 0x80, 0x7F, 0x7C, 0x01, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0x01, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xFC,
  0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0xC0, 0x07, 0xE3, 0xE0, 0x03, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x07,
  0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0x0F, 0x80, 0x7F, 0x1F, 0x00, 0x7F, 0x3E, 0x00, 0x3E, 0x7C, 0x00,
  0x7E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x80, 0x0F, 0x9F, 0x80, 0x3F, 0x3F, 0xC1, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xE7, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xF1, 0xFC, 0x03, 0xE7, 0xF0, 0x07, 0xCF, 0x80, 0x0F, 0xBF, 0x00, 0x1F,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xE0,
  0x03, 0xE7, 0xE0, 0x07, 0xC7, 0xF0, 0x7F, 0x87, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xF8, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x8F, 0xFF,
  0xFC, 0x7F, 0xFF, 0xC7, 0xE0, 0x06, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0xA0, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFE, 0x03, 0xFF, 0x80, 0x01, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFE, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x80, 0x80, 0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xF0, 0x01, 0xFE, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF,
  0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0, 0x0F,
  0xBF, 0x00, 0x7D, 0xFC, 0x03, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC0, 0x7F, 0xE0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00,
  0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0xF8, 0xF8,
  0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3C, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3C, 0xF0, 0x00,
  0x07, 0x9E, 0x03, 0xC0, 0xF3, 0xC0, 0xF8, 0x1E, 0x78, 0x1F, 0x03, 0xCF,
  0x83, 0xE0, 0x79, 0xF0, 0xFE, 0x1F, 0x3E, 0x1F, 0xC3, 0xC3, 0xC3, 0xB8,
  0x78, 0x78, 0xF7, 0x8F, 0x0F, 0x1E, 0xF1, 0xE1, 0xE3, 0x8E, 0x3C, 0x3E,
  0xF1, 0xE7, 0x87, 0xDE, 0x3D, 0xE0, 0x7B, 0x83, 0xBC, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x0F, 0xF0, 0x3F, 0x80, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x0F, 0x81, 0xF8, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x7C, 0x01,
  0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xE0, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x80, 0x07, 0xC7,
  0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x1F,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x03,
  0xE0, 0x07, 0xC1, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0x78, 0x00, 0x1E, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xDE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0xFF,
  0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xF0,
  0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0xFF, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xFF,
  0x80, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x06,
  0x0F, 0xF8, 0x03, 0xCF, 0xFF, 0x03, 0xCF, 0xFF, 0xE1, 0xE7, 0x87, 0xFF,
  0xF3, 0x80, 0xFF, 0xF3, 0xC0, 0x1F, 0xF0, 0x60, 0x03, 0xE0,
};

const GFXglyph UbuntuMono_Regular58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 36, 29, 10, -36 },
  { 37, 15, 14, 29, 7, -39 },
  { 64, 25, 36, 29, 2, -36 },
  { 177, 23, 46, 29, 3, -40 },
  { 310, 27, 36, 29, 1, -36 },
  { 432, 25, 36, 29, 2, -36 },
  { 545, 5, 15, 29, 12, -39 },
  { 555, 15, 51, 29, 7, -41 },
  { 651, 15, 51, 29, 7, -41 },
  { 747, 23, 21, 29, 3, -36 },
  { 808, 23, 26, 29, 3, -28 },
  { 883, 11, 16, 29, 9, -8 },
  { 905, 13, 5, 29, 8, -17 },
  { 914, 9, 8, 29, 10, -8 },
  { 923, 21, 51, 29, 4, -41 },
  { 1057, 23, 36, 29, 3, -36 },
  { 1161, 21, 36, 29, 4, -36 },
  { 1256, 23, 36, 29, 3, -36 },
  { 1360, 23, 36, 29, 3, -36 },
  { 1464, 25, 36, 29, 2, -36 },
  { 1577, 22, 36, 29, 4, -36 },
  { 1676, 23, 36, 29, 3, -36 },
  { 1780, 22, 36, 29, 4, -36 },
  { 1879, 23, 36, 29, 3, -36 },
  { 1983, 23, 36, 29, 3, -36 },
  { 2087, 9, 27, 29, 10, -27 },
  { 2118, 12, 35, 29, 7, -27 },
  { 2171, 24, 23, 29, 3, -26 },
  { 2240, 23, 15, 29, 3, -23 },
  { 2284, 24, 23, 29, 3, -26 },
  { 2353, 19, 36, 29, 5, -36 },
  { 2439, 25, 44, 29, 2, -36 },
  { 2577, 27, 36, 29, 1, -36 },
  { 2699, 23, 36, 29, 3, -36 },
  { 2803, 24, 36, 29, 3, -36 },
  { 2911, 24, 36, 29, 3, -36 },
  { 3019, 22, 36, 29, 5, -36 },
  { 3118, 21, 36, 29, 5, -36 },
  { 3213, 23, 36, 29, 3, -36 },
  { 3317, 23, 36, 29, 3, -36 },
  { 3421, 19, 36, 29, 5, -36 },
  { 3507, 21, 36, 29, 3, -36 },
  { 3602, 24, 36, 29, 4, -36 },
  { 3710, 22, 36, 29, 5, -36 },
  { 3809, 25, 36, 29, 2, -36 },
  { 3922, 23, 36, 29, 3, -36 },
  { 4026, 25, 36, 29, 2, -36 },
  { 4139, 22, 36, 29, 4, -36 },
  { 4238, 25, 45, 29, 2, -36 },
  { 4379, 24, 36, 29, 3, -36 },
  { 4487, 23, 36, 29, 3, -36 },
  { 4591, 25, 36, 29, 2, -36 },
  { 4704, 23, 36, 29, 3, -36 },
  { 4808, 27, 36, 29, 1, -36 },
  { 4930, 25, 36, 29, 2, -36 },
  { 5043, 27, 36, 29, 1, -36 },
  { 5165, 27, 36, 29, 1, -36 },
  { 5287, 23, 36, 29, 3, -36 },
  { 5391, 14, 51, 29, 8, -41 },
  { 5481, 21, 51, 29, 4, -41 },
  { 5615, 14, 51, 29, 7, -41 },
  { 5705, 25, 20, 29, 2, -36 },
  { 5768, 29, 4, 29, 0, 6 },
  { 5783, 10, 10, 29, 9, -40 },
  { 5796, 22, 27, 29, 3, -27 },
  { 5871, 23, 40, 29, 4, -40 },
  { 5986, 23, 27, 29, 3, -27 },
  { 6064, 23, 40, 29, 2, -40 },
  { 6179, 24, 27, 29, 2, -27 },
  { 6260, 24, 40, 29, 4, -40 },
  { 6380, 23, 37, 29, 2, -27 },
  { 6487, 21, 40, 29, 4, -40 },
  { 6592, 23, 38, 29, 3, -38 },
  { 6702, 18, 48, 29, 4, -38 },
  { 6810, 24, 40, 29, 4, -40 },
  { 6930, 23, 40, 29, 3, -40 },
  { 7045, 25, 27, 29, 2, -27 },
  { 7130, 21, 27, 29, 4, -27 },
  { 7201, 25, 27, 29, 2, -27 },
  { 7286, 23, 37, 29, 4, -27 },
  { 7393, 23, 37, 29, 2, -27 },
  { 7500, 19, 27, 29, 6, -27 },
  { 7565, 21, 27, 29, 4, -27 },
  { 7636, 22, 35, 29, 4, -35 },
  { 7733, 21, 27, 29, 4, -27 },
  { 7804, 25, 27, 29, 2, -27 },
  { 7889, 27, 27, 29, 1, -27 },
  { 7981, 25, 27, 29, 2, -27 },
  { 8066, 25, 37, 29, 2, -27 },
  { 8182, 21, 27, 29, 4, -27 },
  { 8253, 20, 51, 29, 5, -41 },
  { 8381, 5, 51, 29, 12, -41 },
  { 8413, 20, 51, 29, 4, -41 },
  { 8541, 25, 8, 29, 2, -19 },
};

const GFXfont UbuntuMono_Regular58pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular58pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular58pt7bGlyphs,
  0x20, 0x7E, 58
};

#endif // _UBUNTUMONO_REGULAR58PT7B_H_
