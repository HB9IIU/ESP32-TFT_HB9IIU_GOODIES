#ifndef _UBUNTUMONO_REGULAR53PT7B_H_
#define _UBUNTUMONO_REGULAR53PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 53pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular53pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xE7, 0xEF, 0xFF, 0xFF, 0xFE, 0x78, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xDE, 0x0E, 0xF0, 0x77, 0x03, 0xB8, 0x1C,
  0xC0, 0xE6, 0x07, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0,
  0x3C, 0x00, 0xF0, 0x3C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0xF0, 0x03, 0xC0,
  0xF0, 0x03, 0xC1, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x81,
  0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0x03, 0xC0, 0x0E, 0x07,
  0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07, 0x80, 0x1E, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0x80, 0x3F,
  0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xC3, 0xF8, 0x06, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7D, 0x00, 0x07, 0xCF, 0x00, 0xFE, 0xFF, 0xFF, 0xE7, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x0F, 0x1F, 0xE0, 0x0F, 0x1F, 0xF0, 0x07, 0x8E, 0x3C, 0x07, 0x8F, 0x0E,
  0x03, 0x87, 0x07, 0x03, 0xC3, 0x83, 0x83, 0xC1, 0xC1, 0xE1, 0xE0, 0xE0,
  0xF1, 0xE0, 0x70, 0x70, 0xE0, 0x38, 0x38, 0xF0, 0x1E, 0x1C, 0xF0, 0x07,
  0x9E, 0x78, 0x03, 0xFE, 0x78, 0x00, 0xFF, 0x38, 0x00, 0x3E, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x1C, 0x7C, 0x00, 0x1E, 0x7F, 0x80, 0x0E, 0x7F,
  0xC0, 0x0F, 0x3C, 0xF0, 0x0F, 0x3C, 0x38, 0x07, 0x1E, 0x1C, 0x07, 0x8E,
  0x0E, 0x07, 0x87, 0x07, 0x83, 0xC3, 0x83, 0xC3, 0xC1, 0xC1, 0xC1, 0xC0,
  0xF0, 0xE1, 0xE0, 0x78, 0x71, 0xE0, 0x1E, 0x78, 0xF0, 0x0F, 0xF8, 0xF0,
  0x03, 0xFC, 0x70, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xC0, 0xF0, 0x0F,
  0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF8,
  0x3C, 0x00, 0xF0, 0xF0, 0x01, 0xF3, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x3C, 0x1F, 0xE0, 0x78, 0x7F, 0xE0, 0xF0, 0xF3, 0xE1,
  0xE3, 0xC3, 0xE3, 0xCF, 0x83, 0xE7, 0x1E, 0x03, 0xFE, 0x3C, 0x03, 0xFC,
  0x78, 0x03, 0xF0, 0xF0, 0x07, 0xE1, 0xE0, 0x07, 0xC3, 0xE0, 0x1F, 0xC7,
  0xE0, 0x7F, 0x87, 0xE3, 0xFF, 0x8F, 0xFF, 0xEF, 0x0F, 0xFF, 0x9F, 0x0F,
  0xFC, 0x1E, 0x07, 0xE0, 0x3E, 0xFF, 0xFF, 0xFF, 0x7B, 0xDE, 0xF7, 0xBC,
  0xE7, 0x38, 0x00, 0x10, 0x00, 0xE0, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3E,
  0x00, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x38, 0x00, 0x40, 0x20,
  0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F,
  0x00, 0x78, 0x03, 0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0xC0, 0x1E, 0x00, 0x70, 0x00, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x06, 0x07, 0x02, 0x78,
  0x70, 0xF7, 0xE7, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0x80, 0x01, 0xFC, 0x00, 0x3D, 0xE0, 0x07, 0x9F, 0x00, 0xF8, 0xF8,
  0x1F, 0x0F, 0xC1, 0xF0, 0x7C, 0x0E, 0x07, 0x00, 0x20, 0x20, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x07, 0x83, 0xF8, 0x7F, 0x0F, 0xF1, 0xFE, 0x3F,
  0xC3, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0xFC, 0x7F, 0x0F, 0x80, 0xC0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xFC, 0x03,
  0xFF, 0xF8, 0x1F, 0x87, 0xE0, 0x7C, 0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00,
  0x3E, 0x7C, 0x00, 0x79, 0xF0, 0x01, 0xE7, 0x80, 0x07, 0xDE, 0x00, 0x1F,
  0x78, 0x38, 0x7D, 0xE1, 0xF1, 0xFF, 0x8F, 0xC3, 0xFE, 0x3F, 0x0F, 0xF8,
  0xFC, 0x3F, 0xE1, 0xF0, 0xFF, 0x83, 0x83, 0xDE, 0x00, 0x1F, 0x78, 0x00,
  0x7D, 0xE0, 0x01, 0xF7, 0x80, 0x07, 0xDF, 0x00, 0x1E, 0x7C, 0x00, 0x78,
  0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x87, 0xE0, 0x3F,
  0xFF, 0x80, 0x7F, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xF0,
  0x1F, 0xDE, 0x07, 0xF3, 0xC0, 0x78, 0x78, 0x0C, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0xFF, 0xE0, 0x03, 0xF8, 0x00, 0xFF, 0xF8, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0xC0, 0xFC, 0x38, 0x03, 0xF0, 0x80, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x07, 0xF8, 0x01, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFC, 0x3C, 0x0F, 0xC2, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0xC0,
  0x03, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF4, 0x00, 0x3F, 0x70, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF,
  0xFF, 0x87, 0xFF, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xC3, 0xC0,
  0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x03,
  0xC0, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0,
  0x07, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0xE0, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xF4, 0x00, 0x3F, 0x78, 0x0F, 0xE7, 0xFF, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x3F,
  0xF8, 0x03, 0xFF, 0xC0, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x9F, 0xE0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE,
  0x07, 0xE7, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xC0,
  0x07, 0x9F, 0x00, 0x7C, 0xFC, 0x07, 0xE3, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFE, 0x00, 0xFF, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0, 0x7E,
  0x3E, 0x01, 0xF9, 0xE0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0xC0,
  0x07, 0x9E, 0x00, 0x7C, 0xF8, 0x03, 0xC7, 0xE0, 0x3E, 0x1F, 0x83, 0xE0,
  0xFF, 0xBE, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0x87,
  0xF8, 0xF8, 0x0F, 0xE7, 0x80, 0x1F, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x03,
  0xE7, 0xE0, 0x7F, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x01, 0xFF, 0xF0, 0x03,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F, 0xFF,
  0x87, 0xE0, 0xFE, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0x9F, 0x00, 0x3E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xFC, 0x00, 0x7F, 0xF0, 0x03, 0xEF, 0xC0, 0x7F, 0x7F, 0xFF, 0xF9, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xF9, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x3F, 0xFE, 0x01, 0xFF, 0xE0, 0x07,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0x7F, 0x7E, 0x3C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E,
  0x7F, 0xFF, 0x7F, 0x7E, 0x3C, 0x0F, 0x07, 0xE1, 0xFC, 0xFF, 0x1F, 0xC7,
  0xE0, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC1, 0xF8, 0x7F, 0x3F, 0xC7, 0xF1, 0xFC, 0x3F, 0x07,
  0xC1, 0xE0, 0xF8, 0xFC, 0xFE, 0x3E, 0x0E, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x00, 0x3C, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x40, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF0, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7,
  0x03, 0xF2, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0,
  0x01, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFF, 0x80, 0xFC, 0x1F, 0x83, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x1F, 0x00,
  0x1E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x1F,
  0xF7, 0x81, 0xFF, 0xEF, 0x07, 0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0x0F,
  0xF8, 0xF8, 0x1F, 0xE1, 0xF0, 0x3F, 0xC3, 0xC0, 0x7F, 0x87, 0x80, 0xFF,
  0x0F, 0x01, 0xFE, 0x1E, 0x03, 0xFE, 0x3C, 0x07, 0xFC, 0x7C, 0x0F, 0xF8,
  0xF8, 0x1E, 0xF0, 0xF8, 0x3D, 0xE1, 0xFF, 0xFB, 0xC1, 0xFF, 0xF7, 0xC1,
  0xFF, 0xE7, 0x80, 0xFF, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x80, 0x3F, 0xFF,
  0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x3C, 0x00, 0x03, 0xCF, 0x80, 0x00,
  0xF1, 0xE0, 0x00, 0x78, 0x78, 0x00, 0x1E, 0x1F, 0x00, 0x07, 0x83, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3E, 0x00, 0x3C, 0x07, 0x80, 0x1E, 0x01,
  0xE0, 0x07, 0x80, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x3C,
  0x00, 0xF0, 0x0F, 0x00, 0x3E, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x03, 0xC3, 0xC0, 0x00,
  0xF0, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x01, 0xE7, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0xC0, 0x7F, 0xF8, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00, 0xFC, 0x78, 0x03,
  0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x3C, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x07, 0xCF, 0x00, 0x7C, 0x78, 0x0F, 0xC3, 0xFF, 0xFC,
  0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x3C, 0x01, 0xF9, 0xE0,
  0x03, 0xEF, 0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x00,
  0xFF, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xE0, 0x78, 0x7E, 0x00, 0x21, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x02, 0x0F, 0xE0, 0x3C, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xE0, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0x03, 0xFC, 0x78, 0x03, 0xF3, 0xC0,
  0x0F, 0x9E, 0x00, 0x3E, 0xF0, 0x01, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0xF0, 0x01,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0xF9, 0xE0, 0x0F, 0xCF, 0x01, 0xFC, 0x7F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x1F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8,
  0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xE0, 0x78, 0x7E, 0x00,
  0x21, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x03,
  0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xDF,
  0x00, 0x0F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xF1, 0xF0, 0x03, 0xC7, 0xE0,
  0x0F, 0x0F, 0xE0, 0x7C, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF,
  0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F,
  0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3C, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xB0, 0x03, 0xE7, 0x81, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x0F, 0xF8, 0x00, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x3F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0, 0x07,
  0xC7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xEF, 0xE0, 0x07, 0xC7,
  0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0xF8, 0x0F, 0xC1, 0xF0, 0x0F, 0xC3, 0xE0, 0x0F, 0x87, 0xC0, 0x0F,
  0x8F, 0x80, 0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3C, 0x00,
  0xF8, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F,
  0x8F, 0xE0, 0x3F, 0x1F, 0xC0, 0xFE, 0x3B, 0x81, 0xDC, 0x77, 0x83, 0xB8,
  0xE7, 0x07, 0x79, 0xCE, 0x1C, 0xF3, 0x9E, 0x39, 0xE7, 0x1C, 0x73, 0xCE,
  0x39, 0xE7, 0x9C, 0x7B, 0x8F, 0x38, 0x77, 0x1E, 0x70, 0xFE, 0x3D, 0xE1,
  0xF8, 0x7B, 0xC1, 0xF0, 0xF7, 0x83, 0xE1, 0xEF, 0x07, 0x83, 0xDE, 0x00,
  0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xF7, 0x80, 0x7F, 0xBC, 0x03, 0xFC,
  0xF0, 0x1F, 0xE7, 0x80, 0xFF, 0x1E, 0x07, 0xF8, 0xF0, 0x3F, 0xC3, 0xC1,
  0xFE, 0x1E, 0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3, 0xFC, 0x0F, 0x1F, 0xE0,
  0x78, 0xFF, 0x01, 0xE7, 0xF8, 0x0F, 0x3F, 0xC0, 0x39, 0xFE, 0x01, 0xEF,
  0xF0, 0x07, 0x7F, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03,
  0xF8, 0x3F, 0x07, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x78,
  0x00, 0x7D, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x7C,
  0xF8, 0x00, 0xF9, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF8, 0x3F, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x7F,
  0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xEF,
  0x00, 0x3E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x0F, 0xEF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xE0, 0xFF, 0xF8, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x03, 0xF8, 0x3F,
  0x07, 0xC0, 0x3F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x7D,
  0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xF8, 0x3F, 0x03, 0xFF, 0xFC,
  0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x00, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x38, 0x7F, 0xF0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF0, 0x0F, 0xC3, 0xC0, 0x1F,
  0x8F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF,
  0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x00,
  0x3E, 0x3C, 0x01, 0xF8, 0xF0, 0x1F, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3C,
  0x03, 0xC0, 0xF0, 0x0F, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x3C, 0x3C, 0x00,
  0xF8, 0xF0, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3E,
  0xF0, 0x00, 0x78, 0x01, 0xFE, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xF8, 0x7F,
  0xFF, 0xC3, 0xF0, 0x3E, 0x3E, 0x00, 0x21, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x80, 0x03, 0xE7, 0x80, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF,
  0x07, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xC0,
  0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x7C,
  0xF8, 0x03, 0xE7, 0xE0, 0x7E, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF,
  0xF0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xCF, 0x00, 0x01, 0xE7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0,
  0x00, 0x78, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x3E, 0x1F, 0x00, 0x1E, 0x0F,
  0x80, 0x0F, 0x03, 0xC0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xC0,
  0x3C, 0x01, 0xE0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF0, 0x07, 0xC0, 0x78,
  0x01, 0xE0, 0x7C, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x1E, 0x00, 0x1E, 0x1F,
  0x00, 0x0F, 0x0F, 0x00, 0x07, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3,
  0xC0, 0x00, 0x7D, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0,
  0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x01, 0xEF, 0x07,
  0x83, 0xDE, 0x0F, 0x87, 0xBC, 0x1F, 0x0F, 0x78, 0x7E, 0x1E, 0xF0, 0xFE,
  0x3C, 0xE1, 0xDC, 0x79, 0xC7, 0x38, 0xF3, 0x8E, 0x71, 0xE7, 0x1C, 0x73,
  0xCE, 0x78, 0xE7, 0x9C, 0xE1, 0xCE, 0x39, 0xC3, 0xDC, 0x77, 0x83, 0xB8,
  0xEE, 0x07, 0x71, 0xDC, 0x0F, 0xE3, 0xF8, 0x0F, 0xC7, 0xE0, 0x1F, 0x87,
  0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF0, 0x7C,
  0x00, 0x1E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x03,
  0xC3, 0xE0, 0x03, 0xE3, 0xC0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x07,
  0xC1, 0xF0, 0x0F, 0x80, 0xF0, 0x0F, 0x00, 0xF8, 0x1F, 0x00, 0x78, 0x1E,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xC7, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x3E, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x7C,
  0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x9F,
  0x00, 0x03, 0xEF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7F, 0xFF,
  0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF8, 0x01, 0xF1,
  0xE0, 0x0F, 0x87, 0xC0, 0x3C, 0x0F, 0x81, 0xF0, 0x1E, 0x07, 0x80, 0x7C,
  0x3E, 0x00, 0xF0, 0xF0, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0x70,
  0x00, 0x3C, 0x40, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x70, 0xF8, 0xF8, 0x7C, 0x1E,
  0x0F, 0x07, 0x02, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x18, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x03, 0xFE, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF, 0xF7,
  0xFF, 0xFF, 0x7E, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x7E, 0x00, 0xF7, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF3, 0xF8, 0x0F, 0xFF, 0xE0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFE, 0x0F,
  0xCF, 0x80, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF,
  0x00, 0x7E, 0xF0, 0x1F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0,
  0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE3, 0xFC, 0x03, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0x0F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x38,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x1F, 0xCF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9, 0xF0, 0x07, 0xDF, 0x00, 0x3E, 0xF8,
  0x01, 0xF7, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0x80,
  0x0F, 0xBE, 0x00, 0x7D, 0xF0, 0x03, 0xE7, 0xC0, 0x1F, 0x3F, 0x80, 0xF8,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x1F, 0x83,
  0xF0, 0xF8, 0x03, 0xE7, 0xC0, 0x07, 0x9E, 0x00, 0x1F, 0x78, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x30, 0x7F, 0xFF, 0xC0,
  0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x1F, 0x80, 0xC0, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xF8, 0x0F, 0x9F, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x80, 0x3E, 0x7E, 0x07, 0xF1,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0x9F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x18,
  0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x7F, 0xE0,
  0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x7F, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xFF, 0xFC, 0xF8, 0x0F, 0xDE, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01,
  0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x40, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x07,
  0xF8, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F,
  0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x70, 0x3E, 0xFF, 0xFE, 0xFF,
  0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x1F, 0x78, 0x01, 0xF3, 0xC0, 0x1F, 0x1E, 0x01, 0xF0, 0xF0,
  0x1F, 0x07, 0x81, 0xF0, 0x3C, 0x1F, 0x01, 0xE3, 0xF0, 0x0F, 0x3F, 0x00,
  0x7B, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x07, 0xBF,
  0x00, 0x3C, 0xFC, 0x01, 0xE3, 0xF0, 0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x03,
  0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3C, 0x00,
  0xFD, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0x80, 0xFF, 0xE0, 0x07, 0xFF, 0x00,
  0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x10, 0x07, 0xFF,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x83, 0xE1,
  0xFF, 0xDF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xEF, 0x0F, 0xC7, 0xDE,
  0x0F, 0x07, 0xBC, 0x1E, 0x0F, 0xF8, 0x3C, 0x0F, 0xF0, 0x78, 0x1F, 0xE0,
  0xF0, 0x3F, 0xC1, 0xE0, 0x7F, 0x83, 0xC0, 0xFF, 0x07, 0x81, 0xFE, 0x0F,
  0x03, 0xFC, 0x1E, 0x07, 0xF8, 0x3C, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E, 0x1F, 0xF8, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01, 0xFD, 0xE0, 0x0F, 0xBC,
  0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x83, 0xF0, 0xF8,
  0x07, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x78, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x83, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC,
  0x00, 0xFF, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x1F, 0xCF, 0x00, 0x7E, 0xF0, 0x03, 0xEF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xEF, 0x80, 0x7E, 0xFC, 0x0F, 0xCF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0xF3, 0xF8, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xF8, 0x0F, 0x9F, 0x00, 0x7D, 0xF0,
  0x03, 0xEF, 0x80, 0x1F, 0x78, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0x7C, 0x01, 0xF3,
  0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFC,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xFF, 0xFE,
  0x1F, 0xFF, 0xE3, 0xFF, 0xFC, 0x7E, 0x00, 0xC7, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF6, 0x00, 0x1F, 0x7C, 0x03, 0xF7,
  0xFF, 0xFE, 0x7F, 0xFF, 0xC7, 0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x01, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x01, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0x3F,
  0xC0, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x01,
  0xF7, 0xE0, 0x3E, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF, 0x03, 0xFE,
  0x00, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7B, 0xE0, 0x00, 0xF3, 0xC0, 0x03,
  0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0x7C,
  0x3E, 0x00, 0xF0, 0x3C, 0x03, 0xE0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x3E, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x03, 0xC3, 0xC0, 0x07,
  0xC7, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xDE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x70, 0x3C, 0xF0,
  0x78, 0x1E, 0x78, 0x3E, 0x0E, 0x3C, 0x1F, 0x07, 0x1E, 0x1F, 0x87, 0x8F,
  0x0F, 0xE3, 0xC3, 0x87, 0xF1, 0xE1, 0xE7, 0xB8, 0xF0, 0xF3, 0x9E, 0x78,
  0x79, 0xCF, 0x38, 0x3D, 0xE3, 0x9C, 0x1E, 0xE1, 0xFE, 0x07, 0xF0, 0x7F,
  0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x7C, 0x03,
  0xE0, 0x1E, 0x00, 0xF0, 0x0E, 0x00, 0x78, 0x00, 0xF8, 0x00, 0x7C, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x3E, 0x01, 0xF0,
  0x78, 0x01, 0xF1, 0xF0, 0x03, 0xE7, 0xC0, 0x03, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x07, 0xC7, 0x80, 0x0F, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x03, 0xE0, 0x1F, 0x07, 0x80, 0x1F, 0x1F,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0,
  0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x00, 0x1F, 0x3E, 0x00, 0x78, 0xF8, 0x01,
  0xE3, 0xE0, 0x0F, 0x87, 0x80, 0x3C, 0x1F, 0x00, 0xF0, 0x7C, 0x03, 0xC0,
  0xF0, 0x1F, 0x03, 0xE0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x0F, 0x80, 0x7C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0x9E, 0x00, 0x1E, 0x78,
  0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0xFF, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF,
  0xFF, 0x3F, 0xFF, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xE0, 0x1F, 0xFC, 0x07,
  0xFF, 0x80, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x0F,
  0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x03, 0xFF, 0x80, 0xFF, 0xC0,
  0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x18, 0x3F, 0xC0, 0x38, 0xFF, 0xE0, 0x73,
  0xFF, 0xE1, 0xE7, 0x8F, 0xFF, 0x9E, 0x07, 0xFF, 0x38, 0x03, 0xFC, 0x30,
  0x01, 0xE0,
};

const GFXglyph UbuntuMono_Regular53pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 33, 27, 10, -33 },
  { 30, 13, 13, 27, 7, -36 },
  { 52, 24, 33, 27, 1, -33 },
  { 151, 21, 42, 27, 3, -37 },
  { 262, 25, 33, 27, 1, -33 },
  { 366, 23, 33, 27, 2, -33 },
  { 461, 5, 14, 27, 11, -36 },
  { 470, 14, 46, 27, 6, -37 },
  { 551, 14, 46, 27, 6, -37 },
  { 632, 20, 20, 27, 3, -33 },
  { 682, 22, 24, 27, 2, -26 },
  { 748, 11, 14, 27, 8, -7 },
  { 768, 12, 4, 27, 7, -15 },
  { 774, 8, 7, 27, 9, -7 },
  { 781, 19, 46, 27, 4, -37 },
  { 891, 22, 33, 27, 2, -33 },
  { 982, 19, 33, 27, 4, -33 },
  { 1061, 21, 33, 27, 3, -33 },
  { 1148, 20, 33, 27, 3, -33 },
  { 1231, 23, 33, 27, 2, -33 },
  { 1326, 20, 33, 27, 3, -33 },
  { 1409, 21, 33, 27, 3, -33 },
  { 1496, 21, 33, 27, 3, -33 },
  { 1583, 21, 33, 27, 3, -33 },
  { 1670, 21, 33, 27, 3, -33 },
  { 1757, 8, 24, 27, 9, -24 },
  { 1781, 10, 31, 27, 7, -24 },
  { 1820, 21, 21, 27, 3, -24 },
  { 1876, 22, 14, 27, 2, -21 },
  { 1915, 21, 21, 27, 3, -24 },
  { 1971, 17, 33, 27, 5, -33 },
  { 2042, 23, 40, 27, 2, -33 },
  { 2157, 26, 33, 27, 0, -33 },
  { 2265, 21, 33, 27, 3, -33 },
  { 2352, 22, 33, 27, 2, -33 },
  { 2443, 21, 33, 27, 3, -33 },
  { 2530, 19, 33, 27, 5, -33 },
  { 2609, 18, 33, 27, 5, -33 },
  { 2684, 22, 33, 27, 2, -33 },
  { 2775, 22, 33, 27, 2, -33 },
  { 2866, 17, 33, 27, 5, -33 },
  { 2937, 19, 33, 27, 3, -33 },
  { 3016, 23, 33, 27, 3, -33 },
  { 3111, 19, 33, 27, 5, -33 },
  { 3190, 23, 33, 27, 2, -33 },
  { 3285, 21, 33, 27, 3, -33 },
  { 3372, 23, 33, 27, 2, -33 },
  { 3467, 20, 33, 27, 4, -33 },
  { 3550, 23, 41, 27, 2, -33 },
  { 3668, 22, 33, 27, 3, -33 },
  { 3759, 21, 33, 27, 3, -33 },
  { 3846, 22, 33, 27, 2, -33 },
  { 3937, 21, 33, 27, 3, -33 },
  { 4024, 25, 33, 27, 1, -33 },
  { 4128, 23, 33, 27, 2, -33 },
  { 4223, 24, 33, 27, 1, -33 },
  { 4322, 25, 33, 27, 1, -33 },
  { 4426, 21, 33, 27, 3, -33 },
  { 4513, 12, 46, 27, 8, -37 },
  { 4582, 19, 46, 27, 4, -37 },
  { 4692, 13, 46, 27, 6, -37 },
  { 4767, 22, 18, 27, 2, -33 },
  { 4817, 26, 4, 27, 0, 5 },
  { 4830, 8, 9, 27, 9, -36 },
  { 4839, 20, 25, 27, 3, -25 },
  { 4902, 20, 37, 27, 4, -37 },
  { 4995, 21, 25, 27, 3, -25 },
  { 5061, 21, 37, 27, 2, -37 },
  { 5159, 22, 25, 27, 2, -25 },
  { 5228, 23, 37, 27, 3, -37 },
  { 5335, 21, 34, 27, 2, -25 },
  { 5425, 19, 37, 27, 4, -37 },
  { 5513, 21, 35, 27, 3, -35 },
  { 5605, 16, 44, 27, 4, -35 },
  { 5693, 21, 37, 27, 4, -37 },
  { 5791, 21, 37, 27, 3, -37 },
  { 5889, 23, 25, 27, 2, -25 },
  { 5961, 19, 25, 27, 4, -25 },
  { 6021, 22, 25, 27, 2, -25 },
  { 6090, 20, 34, 27, 4, -25 },
  { 6175, 21, 34, 27, 2, -25 },
  { 6265, 17, 25, 27, 6, -25 },
  { 6319, 20, 25, 27, 3, -25 },
  { 6382, 21, 33, 27, 3, -33 },
  { 6469, 19, 25, 27, 4, -25 },
  { 6529, 23, 25, 27, 2, -25 },
  { 6601, 25, 25, 27, 1, -25 },
  { 6680, 23, 25, 27, 2, -25 },
  { 6752, 22, 34, 27, 2, -25 },
  { 6846, 19, 25, 27, 4, -25 },
  { 6906, 19, 46, 27, 4, -37 },
  { 7016, 4, 46, 27, 11, -37 },
  { 7039, 18, 46, 27, 4, -37 },
  { 7143, 23, 8, 27, 2, -18 },
};

const GFXfont UbuntuMono_Regular53pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular53pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular53pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _UBUNTUMONO_REGULAR53PT7B_H_
