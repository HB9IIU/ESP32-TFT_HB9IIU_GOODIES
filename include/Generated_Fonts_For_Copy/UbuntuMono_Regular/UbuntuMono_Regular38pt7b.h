#ifndef _UBUNTUMONO_REGULAR38PT7B_H_
#define _UBUNTUMONO_REGULAR38PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular38pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0xEF, 0xFF, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F,
  0x83, 0xC1, 0x80, 0x03, 0x87, 0x03, 0x83, 0x01, 0xC3, 0x80, 0xE1, 0xC0,
  0x70, 0xE0, 0x38, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x0E,
  0x03, 0x87, 0x01, 0xC3, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x70, 0xE1, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x1C, 0x07, 0x0E, 0x03, 0x87, 0x01,
  0xC3, 0x80, 0xC1, 0xC0, 0xE1, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x7F, 0x03, 0xFF, 0x8F, 0xFE, 0x3C, 0x04, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFC, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xD8,
  0x0F, 0x7F, 0xFE, 0xFF, 0xF8, 0x7F, 0xC0, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0x3C, 0x03, 0xBF, 0x03, 0xB9, 0x81, 0xD8, 0xE1, 0xCC,
  0x70, 0xC6, 0x18, 0xE3, 0x0C, 0xE1, 0x8E, 0x70, 0xC7, 0x70, 0x73, 0x30,
  0x1F, 0xB8, 0x07, 0xB8, 0x00, 0x1D, 0xE0, 0x1D, 0xF8, 0x0C, 0xCE, 0x0E,
  0xE3, 0x0E, 0x61, 0x87, 0x30, 0xC7, 0x18, 0x63, 0x0C, 0x33, 0x87, 0x1B,
  0x81, 0x9D, 0xC0, 0xFD, 0xC0, 0x3C, 0x07, 0xC0, 0x0F, 0xF8, 0x07, 0xFC,
  0x07, 0x8F, 0x03, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0xC0, 0x70, 0xE0, 0x1C,
  0xE0, 0x0E, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0xE3, 0xF8, 0x61, 0xDE, 0x31,
  0xC7, 0xB8, 0xE1, 0xFC, 0xE0, 0x7C, 0x70, 0x1E, 0x38, 0x07, 0x1E, 0x07,
  0xC7, 0x8F, 0xE3, 0xFF, 0xB8, 0xFF, 0x9C, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x80, 0x38, 0x0F, 0x83, 0xC0, 0xF0, 0x1C, 0x07, 0x01, 0xE0,
  0x38, 0x07, 0x01, 0xC0, 0x38, 0x07, 0x01, 0xE0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x80, 0x20,
  0x0E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1C, 0x03, 0xC0, 0x3C, 0x03, 0x80,
  0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x1C, 0x03, 0x80, 0xF0, 0x3C,
  0x07, 0x01, 0xE0, 0x78, 0x3E, 0x03, 0x80, 0x20, 0x00, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x02, 0x1C, 0x27, 0xBB, 0xDF, 0xAF, 0xCF, 0xFE, 0x01, 0xC0,
  0x06, 0xC0, 0x1D, 0xC0, 0x7B, 0xC1, 0xE3, 0xC1, 0xC7, 0x01, 0x04, 0x00,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x1C, 0x7C, 0xF9, 0xF1,
  0xE1, 0xC7, 0x3E, 0xF1, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x77, 0xFF, 0xF7,
  0x00, 0x00, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03,
  0x80, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x00,
  0x38, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE1, 0xE3, 0xC7, 0x83, 0xCE, 0x03, 0xBC, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC7, 0x1F, 0x8F, 0x3F, 0x3E, 0x7E, 0x3C, 0xFC, 0x71, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x3D, 0xC0, 0x73, 0xC1, 0xE3, 0xC7, 0x87, 0xFF,
  0x07, 0xFC, 0x03, 0xE0, 0x01, 0x80, 0x0E, 0x00, 0xF8, 0x07, 0xE0, 0x7F,
  0x83, 0xCE, 0x04, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x81, 0xFF, 0xF7, 0xFF, 0xDF, 0xFF, 0x0F, 0xC0,
  0x7F, 0xE3, 0xFF, 0xE3, 0x83, 0xC4, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07,
  0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF, 0xFF, 0x1F, 0xC0, 0xFF, 0xE1, 0xFF,
  0xE1, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x38,
  0x01, 0xF0, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0x0F, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE4, 0x07, 0xCF, 0xFF,
  0x3F, 0xFC, 0x1F, 0xE0, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x1D, 0xC0, 0x1C, 0xE0, 0x0E, 0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x06,
  0x0E, 0x07, 0x07, 0x07, 0x03, 0x83, 0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x71,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x3F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8E, 0x00, 0x30, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xFC,
  0x07, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00,
  0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0xC0, 0xFB, 0xFF, 0xCF, 0xFE, 0x0F,
  0xE0, 0x00, 0x78, 0x03, 0xF8, 0x1F, 0xF0, 0x7E, 0x01, 0xE0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x70, 0x00, 0xEF, 0xC3, 0xFF, 0xE7, 0xFF, 0xEF,
  0x03, 0xDC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x1D, 0xC0,
  0x7B, 0xC0, 0xE7, 0xC3, 0xC7, 0xFF, 0x07, 0xFC, 0x03, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0xE0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xFC, 0x07, 0x38, 0x0E, 0x70, 0x1C,
  0xF0, 0x70, 0xFF, 0xC0, 0xFF, 0x01, 0xFF, 0x87, 0x1F, 0x9C, 0x0F, 0x70,
  0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0xFF, 0x83, 0xCF, 0xFF,
  0x8F, 0xFE, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xE7,
  0x03, 0xDE, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3B, 0xC0, 0xF7, 0xFF, 0xE7, 0xFF, 0xC3, 0xF7, 0x80, 0x0E, 0x00, 0x1C,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x7F, 0x0F, 0xF8, 0x1F, 0xE0, 0x3E,
  0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0x07, 0x7F, 0xFF, 0x70,
  0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC7,
  0xCF, 0x9F, 0x1E, 0x1C, 0x73, 0xEF, 0x18, 0x00, 0x00, 0x06, 0x00, 0x3C,
  0x01, 0xF8, 0x1F, 0xE0, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x70, 0x00, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x01,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x40, 0x01,
  0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x07, 0x00, 0x7E, 0x03, 0xF8, 0x3F, 0xC3, 0xFC, 0x0F, 0xE0, 0x1E, 0x00,
  0x10, 0x00, 0x00, 0x1F, 0x83, 0xFF, 0x1F, 0xFC, 0xC1, 0xE0, 0x07, 0x00,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1C, 0x01,
  0xF0, 0x0F, 0x80, 0x7C, 0x01, 0xC0, 0x03, 0xE0, 0x0F, 0xF8, 0x1F, 0xFC,
  0x3E, 0x1E, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x7F,
  0xE1, 0xFF, 0xE3, 0xFF, 0xE3, 0xC7, 0xE7, 0x87, 0xE7, 0x07, 0xE7, 0x07,
  0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x87, 0xE3, 0x87, 0xE3, 0xFF, 0xF1, 0xFF,
  0x70, 0x7E, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xFC,
  0x07, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07,
  0x1C, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x07, 0x01, 0xC0, 0x70, 0x38,
  0x0E, 0x07, 0x01, 0xC0, 0xFF, 0xF8, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xE0,
  0x0E, 0x3C, 0x01, 0xC7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x77, 0x80,
  0x0F, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x39, 0xC0, 0xF3, 0xFF, 0xC7, 0xFF, 0x8F,
  0xFF, 0x9C, 0x0F, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFE, 0x07, 0xDF, 0xFF, 0xBF, 0xFC, 0x7F, 0xE0, 0x01, 0xF8,
  0x1F, 0xFC, 0x7F, 0xF9, 0xF0, 0x33, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03,
  0xE0, 0x63, 0xFF, 0xC3, 0xFF, 0x81, 0xFC, 0xFF, 0x81, 0xFF, 0xC3, 0xFF,
  0xC7, 0x07, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x77, 0x01, 0xEE, 0x0F, 0x9F, 0xFE,
  0x3F, 0xF8, 0x7F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0x3F,
  0xFC, 0xFF, 0xF3, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0xFF, 0xBF, 0xFE, 0xFF, 0xFB, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0x03, 0xF8, 0x1F, 0xFC, 0x7F, 0xF9, 0xF0, 0x73,
  0xC0, 0x4F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0E,
  0xE0, 0x1D, 0xE0, 0x3B, 0xE0, 0x73, 0xE0, 0xE3, 0xFF, 0xC3, 0xFF, 0x81,
  0xFC, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFC, 0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x03, 0xD0, 0x0E,
  0x70, 0x7B, 0xFF, 0xC7, 0xFF, 0x07, 0xE0, 0xF0, 0x0F, 0x78, 0x0F, 0x3C,
  0x0F, 0x1E, 0x07, 0x0F, 0x07, 0x87, 0x87, 0x83, 0xC7, 0x81, 0xE3, 0x80,
  0xF3, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xBC,
  0x03, 0xCF, 0x01, 0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x0E, 0x1E,
  0x07, 0x8F, 0x01, 0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x0E, 0x1C, 0x07, 0x0F, 0x07, 0x87, 0x83,
  0xE7, 0xC1, 0xF3, 0xF0, 0xF9, 0xF8, 0xFC, 0xEC, 0x6E, 0x76, 0x37, 0x3B,
  0xBB, 0x9C, 0xD9, 0xCE, 0x6C, 0x67, 0x3E, 0x33, 0x0E, 0x19, 0x87, 0x0C,
  0xC0, 0x06, 0x60, 0x03, 0x70, 0x01, 0xB8, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFB, 0x83, 0xF7, 0x07, 0xE7, 0x0F,
  0xCE, 0x1F, 0x8E, 0x3F, 0x1C, 0x7E, 0x1C, 0xFC, 0x39, 0xF8, 0x33, 0xF0,
  0x77, 0xE0, 0x6F, 0xC0, 0xFF, 0x81, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x03,
  0xF8, 0x07, 0xF0, 0x07, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83,
  0xC7, 0x80, 0xF3, 0x80, 0x79, 0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F,
  0xE0, 0x0F, 0x70, 0x07, 0xB8, 0x03, 0x9C, 0x01, 0xCF, 0x01, 0xE3, 0xC1,
  0xE0, 0xFF, 0xE0, 0x3F, 0xE0, 0x07, 0xC0, 0xFF, 0xC3, 0xFF, 0xCF, 0xFF,
  0xB8, 0x1E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x03, 0xF8, 0x1E, 0xFF, 0xFB, 0xFF, 0xCF, 0xF8, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07, 0xFF, 0x07, 0x83, 0xC7, 0x80, 0xF3,
  0x80, 0x79, 0xC0, 0x1C, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xB8, 0x03, 0x9C, 0x01, 0xCF, 0x01, 0xE3, 0xC1, 0xE0, 0xFF, 0xE0,
  0x3F, 0xE0, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x30, 0xFF, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0,
  0x78, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x3C, 0xE0, 0x78, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xC0, 0xE0,
  0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x1C, 0xE0,
  0x1C, 0xE0, 0x0E, 0xE0, 0x0E, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xF3, 0xE0,
  0xC7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3A, 0x00, 0xF7, 0x03, 0xDF, 0xFF, 0x9F, 0xFE,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0xF7, 0x83, 0xCF, 0xFF, 0x8F, 0xFE,
  0x07, 0xF0, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x3C, 0x01, 0xE3,
  0x80, 0x38, 0x70, 0x07, 0x0E, 0x00, 0xE1, 0xE0, 0x3C, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x07, 0x07, 0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03,
  0xC7, 0x80, 0x38, 0xE0, 0x07, 0x1C, 0x00, 0xF7, 0x80, 0x0E, 0xE0, 0x01,
  0xDC, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0E, 0xC0, 0x06, 0x60, 0x03, 0x30, 0xE1, 0x98, 0x70, 0xCC, 0x7C,
  0xE7, 0x36, 0x73, 0x9B, 0x39, 0xDD, 0xDC, 0xEC, 0x6E, 0x76, 0x37, 0x3F,
  0x1F, 0x9F, 0x0F, 0xCF, 0x83, 0xE7, 0xC1, 0xE1, 0xE0, 0xF0, 0xE0, 0x38,
  0x70, 0x1C, 0x70, 0x07, 0x3C, 0x07, 0x8E, 0x03, 0x87, 0x83, 0xC1, 0xC1,
  0xC0, 0xF1, 0xE0, 0x38, 0xE0, 0x1E, 0xF0, 0x07, 0x70, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x1E, 0xF0,
  0x0E, 0x38, 0x0F, 0x1E, 0x07, 0x07, 0x07, 0x83, 0xC3, 0x80, 0xE3, 0xC0,
  0x79, 0xC0, 0x1D, 0xE0, 0x0F, 0x70, 0x01, 0xCF, 0x00, 0x39, 0xE0, 0x0F,
  0x1C, 0x01, 0xC3, 0xC0, 0x78, 0x38, 0x0E, 0x07, 0x83, 0xC0, 0x70, 0x70,
  0x0F, 0x1E, 0x00, 0xE3, 0x80, 0x1E, 0xF0, 0x01, 0xDC, 0x00, 0x3F, 0x80,
  0x03, 0xE0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00,
  0x07, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x07, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x38, 0xFF,
  0xFF, 0xF0, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1F, 0xFF, 0xFF, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x77,
  0x00, 0xEE, 0x03, 0x8E, 0x0F, 0x1E, 0x1C, 0x1C, 0x78, 0x3C, 0xE0, 0x3B,
  0x80, 0x3F, 0x00, 0x74, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x20, 0xC1, 0xC1, 0xC1, 0xC3, 0x83, 0x00, 0x1F, 0xE0, 0xFF,
  0xE3, 0xFF, 0x8C, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC3, 0xFF, 0x3F,
  0xFD, 0xFF, 0xF7, 0x81, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x77, 0x81, 0xDF,
  0xFF, 0x3F, 0xFC, 0x3F, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xEF, 0xC3, 0xFF, 0x8F, 0xFF,
  0x3C, 0x1E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x0F, 0xBF, 0xFC, 0xFF,
  0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xFC, 0xFF, 0xFB, 0xF0, 0x27, 0x80,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x81, 0x9F, 0xFF, 0x0F, 0xFE, 0x07,
  0xF8, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x0F, 0xDC, 0x7F, 0xF3, 0xFF, 0xDE, 0x0F, 0xF0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0xC0, 0x77, 0xC1, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0x07,
  0xE0, 0x3F, 0xF0, 0xFF, 0xF3, 0xC1, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1F, 0x03, 0x1F, 0xFE, 0x1F, 0xFC, 0x0F, 0xE0, 0x00, 0xFC, 0x03,
  0xFF, 0x07, 0xFF, 0x07, 0x83, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E,
  0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xDE, 0x07, 0xF0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1D,
  0xE0, 0xF7, 0xFF, 0xCF, 0xFF, 0x0F, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x40, 0x7D, 0xFF, 0xE7, 0xFF, 0x0F, 0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0x87, 0xFF, 0x3F,
  0xFD, 0xC1, 0xFE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x01, 0xFE, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x40, 0xFF, 0x80, 0xFF, 0x00,
  0xFC, 0x01, 0xC0, 0x3E, 0x03, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xEC, 0x1E, 0xFF, 0xEF, 0xFC, 0x3F, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x3D, 0xC0, 0xF3, 0x83, 0xC7, 0x0F, 0x0E, 0x3C,
  0x1C, 0xF0, 0x3B, 0xC0, 0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xBC, 0x07,
  0x1E, 0x0E, 0x1E, 0x1C, 0x1E, 0x38, 0x1C, 0x70, 0x1C, 0xE0, 0x3D, 0xC0,
  0x3C, 0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x81, 0xFF, 0x01, 0xFE,
  0x01, 0xF8, 0x7C, 0x78, 0xFF, 0xFC, 0xFF, 0xFE, 0xC3, 0x8E, 0xC3, 0x87,
  0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87, 0xC3, 0x87,
  0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0x7F, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xFE, 0x07, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xC0, 0x07, 0xC0, 0x3F, 0xE0,
  0xFF, 0xE3, 0xC1, 0xEF, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFE, 0x03, 0xDE, 0x0F,
  0x1F, 0xFC, 0x1F, 0xF0, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x8F, 0xFF, 0x38,
  0x3E, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xFF, 0x07, 0xBF, 0xFC, 0xFF, 0xE3,
  0xBF, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xDF, 0x07, 0xF0, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x77, 0x83, 0xCF, 0xFF, 0x1F, 0xFC, 0x3F, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x1F, 0xF7, 0xFF, 0xFF, 0xFD, 0xE0,
  0x2E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00,
  0x1F, 0xE3, 0xFF, 0xDF, 0xFD, 0xE0, 0x2E, 0x00, 0x70, 0x03, 0xE0, 0x0F,
  0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xF0, 0x03, 0x80, 0x1F, 0x01,
  0xFF, 0xFF, 0xFF, 0xF1, 0xFE, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x10, 0x7F, 0xE0, 0x7F, 0xC0,
  0x7F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF8,
  0x1F, 0xE0, 0xEF, 0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0xF0, 0x07, 0xB8, 0x03,
  0x9C, 0x01, 0xCF, 0x00, 0xE7, 0x80, 0xE1, 0xC0, 0x70, 0xF0, 0x38, 0x38,
  0x38, 0x1C, 0x1C, 0x0F, 0x1E, 0x03, 0x8E, 0x01, 0xC7, 0x00, 0xF7, 0x00,
  0x3B, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1C, 0x3F, 0x0E, 0x1F,
  0x87, 0x0E, 0xC7, 0xC6, 0x73, 0x63, 0x39, 0xB3, 0x9D, 0xDD, 0xCE, 0xC6,
  0xE7, 0x63, 0x61, 0xF1, 0xF0, 0xF0, 0x78, 0x78, 0x3C, 0x38, 0x1E, 0x1C,
  0x07, 0x00, 0x70, 0x07, 0x3C, 0x07, 0x0F, 0x07, 0x83, 0x87, 0x80, 0xE3,
  0x80, 0x7B, 0x80, 0x1F, 0xC0, 0x07, 0xC0, 0x01, 0xC0, 0x01, 0xF0, 0x01,
  0xFC, 0x00, 0xEE, 0x00, 0xE3, 0x80, 0xE0, 0xE0, 0xF0, 0x78, 0x70, 0x1C,
  0x70, 0x07, 0x78, 0x03, 0xC0, 0x70, 0x07, 0x3C, 0x03, 0x8E, 0x01, 0xC7,
  0x01, 0xE3, 0x80, 0xE1, 0xE0, 0x70, 0x70, 0x38, 0x3C, 0x38, 0x0E, 0x1C,
  0x07, 0x0E, 0x03, 0xCE, 0x00, 0xE7, 0x00, 0x73, 0x80, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x30, 0x00, 0x38, 0x00,
  0x38, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xF8, 0x3F, 0xC1, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x80, 0xF8, 0x07, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x1C, 0x00, 0xFF, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x07, 0xF8,
  0x01, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xF8, 0x07, 0xC0, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x1F,
  0xE0, 0xFC, 0x00, 0x1E, 0x03, 0x1F, 0xC1, 0x9F, 0xF1, 0xCE, 0x3F, 0xE6,
  0x0F, 0xE3, 0x01, 0xE0,
};

const GFXglyph UbuntuMono_Regular38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 19, 0, -1 },
  { 1, 5, 24, 19, 7, -24 },
  { 16, 9, 9, 19, 5, -26 },
  { 27, 17, 24, 19, 1, -24 },
  { 78, 15, 30, 19, 2, -26 },
  { 135, 17, 24, 19, 1, -24 },
  { 186, 17, 24, 19, 1, -24 },
  { 237, 3, 10, 19, 8, -26 },
  { 241, 11, 33, 19, 4, -27 },
  { 287, 11, 33, 19, 4, -27 },
  { 333, 15, 14, 19, 2, -24 },
  { 360, 15, 17, 19, 2, -19 },
  { 392, 7, 10, 19, 6, -5 },
  { 401, 9, 3, 19, 5, -11 },
  { 405, 5, 5, 19, 7, -5 },
  { 409, 13, 33, 19, 3, -27 },
  { 463, 15, 24, 19, 2, -24 },
  { 508, 14, 24, 19, 3, -24 },
  { 550, 15, 24, 19, 2, -24 },
  { 595, 15, 24, 19, 2, -24 },
  { 640, 17, 24, 19, 1, -24 },
  { 691, 14, 24, 19, 3, -24 },
  { 733, 15, 24, 19, 2, -24 },
  { 778, 15, 24, 19, 2, -24 },
  { 823, 15, 24, 19, 2, -24 },
  { 868, 15, 24, 19, 2, -24 },
  { 913, 5, 17, 19, 7, -17 },
  { 924, 7, 22, 19, 5, -17 },
  { 944, 15, 15, 19, 2, -17 },
  { 973, 15, 11, 19, 2, -16 },
  { 994, 15, 15, 19, 2, -17 },
  { 1023, 13, 24, 19, 3, -24 },
  { 1062, 16, 29, 19, 2, -24 },
  { 1120, 19, 24, 19, 0, -24 },
  { 1177, 15, 24, 19, 2, -24 },
  { 1222, 15, 24, 19, 2, -24 },
  { 1267, 15, 24, 19, 2, -24 },
  { 1312, 14, 24, 19, 3, -24 },
  { 1354, 14, 24, 19, 3, -24 },
  { 1396, 15, 24, 19, 2, -24 },
  { 1441, 15, 24, 19, 2, -24 },
  { 1486, 13, 24, 19, 3, -24 },
  { 1525, 14, 24, 19, 2, -24 },
  { 1567, 17, 24, 19, 2, -24 },
  { 1618, 14, 24, 19, 3, -24 },
  { 1660, 17, 24, 19, 1, -24 },
  { 1711, 15, 24, 19, 2, -24 },
  { 1756, 17, 24, 19, 1, -24 },
  { 1807, 14, 24, 19, 3, -24 },
  { 1849, 17, 30, 19, 1, -24 },
  { 1913, 16, 24, 19, 2, -24 },
  { 1961, 15, 24, 19, 2, -24 },
  { 2006, 17, 24, 19, 1, -24 },
  { 2057, 15, 24, 19, 2, -24 },
  { 2102, 19, 24, 19, 0, -24 },
  { 2159, 17, 24, 19, 1, -24 },
  { 2210, 17, 24, 19, 1, -24 },
  { 2261, 19, 24, 19, 0, -24 },
  { 2318, 15, 24, 19, 2, -24 },
  { 2363, 10, 33, 19, 5, -27 },
  { 2405, 13, 33, 19, 3, -27 },
  { 2459, 10, 33, 19, 4, -27 },
  { 2501, 15, 13, 19, 2, -24 },
  { 2526, 19, 3, 19, 0, 4 },
  { 2534, 7, 7, 19, 6, -27 },
  { 2541, 14, 18, 19, 2, -18 },
  { 2573, 14, 26, 19, 3, -26 },
  { 2619, 15, 18, 19, 2, -18 },
  { 2653, 14, 26, 19, 2, -26 },
  { 2699, 15, 18, 19, 2, -18 },
  { 2733, 16, 26, 19, 2, -26 },
  { 2785, 14, 24, 19, 2, -18 },
  { 2827, 13, 26, 19, 3, -26 },
  { 2870, 15, 25, 19, 2, -25 },
  { 2917, 12, 31, 19, 3, -25 },
  { 2964, 15, 26, 19, 3, -26 },
  { 3013, 15, 26, 19, 2, -26 },
  { 3062, 16, 18, 19, 2, -18 },
  { 3098, 13, 18, 19, 3, -18 },
  { 3128, 15, 18, 19, 2, -18 },
  { 3162, 14, 24, 19, 3, -18 },
  { 3204, 14, 24, 19, 2, -18 },
  { 3246, 13, 18, 19, 4, -18 },
  { 3276, 13, 18, 19, 3, -18 },
  { 3306, 15, 23, 19, 2, -23 },
  { 3350, 13, 18, 19, 3, -18 },
  { 3380, 17, 18, 19, 1, -18 },
  { 3419, 17, 18, 19, 1, -18 },
  { 3458, 17, 18, 19, 1, -18 },
  { 3497, 17, 24, 19, 1, -18 },
  { 3548, 13, 18, 19, 3, -18 },
  { 3578, 13, 33, 19, 3, -27 },
  { 3632, 3, 33, 19, 8, -27 },
  { 3645, 13, 33, 19, 3, -27 },
  { 3699, 17, 6, 19, 1, -13 },
};

const GFXfont UbuntuMono_Regular38pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular38pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular38pt7bGlyphs,
  0x20, 0x7E, 38
};

#endif // _UBUNTUMONO_REGULAR38PT7B_H_
