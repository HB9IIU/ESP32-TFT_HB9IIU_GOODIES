#ifndef _UBUNTUMONO_REGULAR54PT7B_H_
#define _UBUNTUMONO_REGULAR54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular54pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x78, 0xF0, 0xE1, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x01,
  0xE7, 0xEF, 0xFF, 0xFF, 0xFE, 0x78, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0,
  0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xDC, 0x1C,
  0xC0, 0x66, 0x03, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x78, 0x1E, 0x00, 0x3C,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x80,
  0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0,
  0x01, 0xE0, 0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x00, 0xF0,
  0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3,
  0xF8, 0x07, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7D, 0x00, 0x07, 0xEF, 0x00, 0x7E,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0x1F, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x0F, 0x1F, 0xE0, 0x07, 0x9F, 0xF0, 0x07,
  0x8F, 0x3C, 0x03, 0x8F, 0x0E, 0x03, 0xC7, 0x87, 0x03, 0xC3, 0x83, 0xC1,
  0xE1, 0xC1, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0x78, 0xF0, 0x38, 0x3C,
  0xF0, 0x1E, 0x1C, 0x70, 0x0F, 0x0E, 0x78, 0x03, 0xCF, 0x78, 0x01, 0xFF,
  0x3C, 0x00, 0x7F, 0xBC, 0x00, 0x1F, 0x1C, 0x7C, 0x00, 0x1E, 0xFF, 0x00,
  0x1E, 0x7F, 0xC0, 0x0F, 0x79, 0xE0, 0x0F, 0x38, 0x78, 0x0F, 0x1C, 0x3C,
  0x07, 0x9E, 0x0E, 0x07, 0x8F, 0x07, 0x03, 0x87, 0x83, 0x83, 0xC3, 0xC1,
  0xC3, 0xC1, 0xE0, 0xE1, 0xE0, 0x70, 0xF1, 0xE0, 0x38, 0x78, 0xE0, 0x1E,
  0x78, 0xF0, 0x07, 0xFC, 0xF0, 0x03, 0xFC, 0x70, 0x00, 0x78, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x3C,
  0x07, 0x80, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x0F,
  0x3E, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3C, 0x1F,
  0xF0, 0x38, 0x3F, 0xF8, 0x38, 0x3C, 0xFC, 0x78, 0x7C, 0x7E, 0x78, 0x78,
  0x3F, 0x78, 0xF8, 0x1F, 0xF0, 0xF0, 0x0F, 0xF0, 0xF0, 0x07, 0xF0, 0xF0,
  0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xFC, 0x07, 0xF8, 0x7E,
  0x3F, 0xF8, 0x7F, 0xFF, 0x7C, 0x3F, 0xFE, 0x3C, 0x1F, 0xFC, 0x3E, 0x07,
  0xF0, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0x9C, 0xE7, 0x38, 0x00,
  0x08, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xC0,
  0x07, 0x80, 0x02, 0x00, 0x20, 0x00, 0xE0, 0x01, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC,
  0x07, 0xF0, 0x07, 0xC0, 0x0E, 0x00, 0x08, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x30, 0x38,
  0x19, 0xE1, 0xC3, 0xCF, 0xCE, 0x7E, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0x80,
  0x7F, 0x00, 0x01, 0xF0, 0x00, 0x1D, 0xC0, 0x01, 0xEF, 0x00, 0x1E, 0x3C,
  0x01, 0xF1, 0xF0, 0x1F, 0x8F, 0xC0, 0xF8, 0x3E, 0x03, 0x80, 0xE0, 0x04,
  0x04, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xC0, 0x00,
  0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C, 0x00, 0x07,
  0x81, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F, 0xC3, 0xF8, 0x1E, 0x07, 0xC3,
  0xF3, 0xFC, 0x7F, 0x07, 0xC0, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x7C, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01,
  0xF8, 0x3F, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x7C,
  0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xC0, 0x01, 0xE7, 0x83,
  0x83, 0xCF, 0x0F, 0x87, 0x9E, 0x1F, 0x0F, 0x7C, 0x7F, 0x1F, 0xF8, 0x7E,
  0x3F, 0xF0, 0xF8, 0x7D, 0xE0, 0xE0, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xCF, 0x00, 0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF8, 0x3F, 0x01,
  0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x01,
  0xFF, 0x80, 0x7F, 0xF8, 0x0F, 0xE7, 0x80, 0x78, 0x78, 0x06, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x03,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xC0, 0xFE, 0x38,
  0x01, 0xF0, 0x80, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83,
  0xC0, 0xFE, 0x10, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x80, 0x03, 0xE7, 0x80, 0x7F, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0x78,
  0x00, 0x7C, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80,
  0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x78, 0x0F,
  0x00, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0xC0,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0,
  0x00, 0x01, 0xE0, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xE8, 0x00,
  0x7E, 0xF0, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x03, 0xFF,
  0xC0, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x9F, 0xE0,
  0x3F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFE, 0x07, 0xF7, 0x80,
  0x0F, 0xBC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFB, 0xC0, 0x07, 0xDF, 0x00,
  0x3C, 0xFC, 0x03, 0xE3, 0xF0, 0x7F, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF0,
  0x7F, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xF7,
  0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x03, 0xE7, 0xE0, 0x1E, 0x1F, 0x83,
  0xE0, 0x7F, 0xBE, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0xFF, 0xFE, 0x0F,
  0x87, 0xF8, 0xF8, 0x07, 0xE7, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x3F, 0xF8,
  0x03, 0xF7, 0xE0, 0x3F, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0x81, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFF, 0xE0, 0x7F,
  0xFF, 0x87, 0xF0, 0x7E, 0x3E, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1E,
  0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80,
  0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xEF, 0xC0, 0x7F, 0x3F, 0xFF, 0xF9,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07, 0xF9, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0xFE, 0xFE, 0xFE, 0xFE, 0xFE,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0xFE, 0xFE, 0xFE, 0xFE, 0xFE, 0x7C, 0x0F, 0x83, 0xF8, 0x7F, 0x0F, 0xE1,
  0xFC, 0x3F, 0x83, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x7F, 0x0F, 0xE1, 0xFE, 0x3F,
  0xC7, 0xF8, 0x7E, 0x03, 0xC0, 0xF8, 0xFE, 0x7F, 0x8F, 0xE1, 0xF0, 0x38,
  0x00, 0x00, 0x00, 0x18, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFF,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x18, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0xFF, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x0F, 0xF0, 0x3F, 0xFE, 0x3F, 0xFF, 0x9F, 0xFF, 0xE7, 0x03,
  0xFA, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x01,
  0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x07, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xC0, 0x1F, 0xF7,
  0x80, 0xFF, 0xEF, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0x0F, 0xF8,
  0x7C, 0x1F, 0xF1, 0xF0, 0x3F, 0xE3, 0xE0, 0x7F, 0xC7, 0x80, 0xFF, 0x8F,
  0x01, 0xFF, 0x1E, 0x03, 0xFE, 0x3C, 0x07, 0xFC, 0x7C, 0x0F, 0xF8, 0x78,
  0x1E, 0xF0, 0xFC, 0x3D, 0xE0, 0xFF, 0xFB, 0xE1, 0xFF, 0xF7, 0xC1, 0xFF,
  0xE7, 0x80, 0x7F, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFF, 0x00,
  0x3F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xBC,
  0x00, 0x00, 0xF7, 0x80, 0x00, 0x3C, 0xF8, 0x00, 0x07, 0x8F, 0x00, 0x00,
  0xF1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x78,
  0x00, 0x3C, 0x0F, 0x80, 0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1E, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x07, 0x80, 0x1F, 0x00, 0xF0, 0x01, 0xE0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x07, 0xC0, 0x01, 0xE0,
  0xF8, 0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC3, 0xC0, 0x00, 0x78, 0xF8, 0x00,
  0x0F, 0x9F, 0x00, 0x01, 0xF3, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xC0,
  0x7F, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0x00,
  0xFE, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x01, 0xF7,
  0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78, 0x07,
  0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x3C,
  0x01, 0xFD, 0xE0, 0x03, 0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0,
  0x03, 0xFF, 0x00, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0,
  0x7F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xE0, 0xFF, 0x03, 0xC1, 0xF8, 0x01, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x20,
  0xFF, 0x03, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x7F, 0xFE, 0x00,
  0x3F, 0xE0, 0x7F, 0xE0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0xF0, 0x1F, 0xC3, 0xC0, 0x1F, 0x8F, 0x00, 0x3F, 0x3C, 0x00, 0x7C,
  0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x07, 0xBC, 0x00, 0x1E, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x3E, 0xF0, 0x00, 0xFB, 0xC0,
  0x07, 0xCF, 0x00, 0x3F, 0x3C, 0x01, 0xF8, 0xF0, 0x1F, 0xC3, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x9F, 0xFF, 0xF3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xE0, 0xFF, 0x03, 0xC1, 0xF8, 0x01, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xFB, 0xC0, 0x01,
  0xF7, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xFC, 0x01, 0xF0,
  0xFE, 0x03, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x3F, 0xE0, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00,
  0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE6, 0x00, 0x7E, 0x78, 0x0F,
  0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x83, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8,
  0x1F, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF9,
  0xF0, 0x00, 0xFB, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x3C, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07,
  0xC3, 0xF0, 0x1F, 0x87, 0xE0, 0x3F, 0x9F, 0xC0, 0x7F, 0x3F, 0xC1, 0xFE,
  0x7B, 0x83, 0xBC, 0xF7, 0x07, 0x79, 0xEF, 0x1E, 0xF3, 0xCE, 0x38, 0xE7,
  0x9C, 0x71, 0xCE, 0x3D, 0xE3, 0x9C, 0x3B, 0x87, 0x38, 0x77, 0x0E, 0x70,
  0xFE, 0x1C, 0xE0, 0xF8, 0x3F, 0xC1, 0xF0, 0x7F, 0x83, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F, 0xF7, 0x80, 0x7F,
  0xBE, 0x03, 0xFC, 0xF0, 0x1F, 0xE3, 0xC0, 0xFF, 0x1E, 0x07, 0xF8, 0x78,
  0x3F, 0xC3, 0xC1, 0xFE, 0x0F, 0x0F, 0xF0, 0x78, 0x7F, 0x81, 0xE3, 0xFC,
  0x0F, 0x1F, 0xE0, 0x7C, 0xFF, 0x01, 0xE7, 0xF8, 0x0F, 0x3F, 0xC0, 0x3D,
  0xFE, 0x01, 0xEF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x80,
  0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x1F, 0x3E,
  0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0x78, 0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0, 0x07, 0xC3,
  0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x8F, 0x00, 0xFE, 0x78, 0x01, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x1E, 0xF0,
  0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0x78, 0x00, 0xFB, 0xC0, 0x07, 0xDE, 0x00, 0x7C, 0xF0, 0x0F, 0xE7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE1, 0xFF, 0xFE, 0x0F, 0xFF, 0x80, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x07, 0xC0, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0,
  0x07, 0xC3, 0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x38, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xF0, 0xF0, 0x0F, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00,
  0x7C, 0xF0, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0xF8, 0xF0,
  0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFE,
  0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x83,
  0xC0, 0x1F, 0x0F, 0x00, 0x3C, 0x3C, 0x00, 0xF8, 0xF0, 0x01, 0xF3, 0xC0,
  0x03, 0xCF, 0x00, 0x0F, 0xBC, 0x00, 0x1E, 0xF0, 0x00, 0x7C, 0x01, 0xFF,
  0x00, 0x3F, 0xFF, 0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xC3, 0xF0, 0x1E, 0x3E,
  0x00, 0x31, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x80, 0x03, 0xF7,
  0x80, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x07, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x3E, 0xF8,
  0x03, 0xE7, 0xF0, 0x7F, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x01, 0xFF, 0xF0,
  0x03, 0xFE, 0x00, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x7C, 0x78, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x1F, 0x0F, 0x80,
  0x0F, 0x83, 0xC0, 0x07, 0x81, 0xF0, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x3C,
  0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x78, 0x01,
  0xE0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xE3, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x0F, 0x83, 0xFC, 0x1F, 0x07, 0xF8, 0x3E, 0x0E, 0x70, 0xFE, 0x1C,
  0xE1, 0xDC, 0x39, 0xC3, 0xB8, 0x73, 0x8F, 0x78, 0xE7, 0x1C, 0x73, 0xCF,
  0x38, 0xE7, 0x9E, 0xF1, 0xEF, 0x3D, 0xC1, 0xDE, 0x7B, 0x83, 0xBC, 0xFF,
  0x07, 0xF9, 0xFC, 0x07, 0xF3, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xC0,
  0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x7C, 0x00,
  0x1F, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xE0, 0x03,
  0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0x83,
  0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x03, 0xE0,
  0x0F, 0x81, 0xE0, 0x03, 0xC1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0x78, 0xF8,
  0x00, 0x3E, 0x78, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE3, 0xC0, 0x01, 0xE1, 0xF0, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x7C, 0x03, 0xF0, 0x3C, 0x00, 0xF8, 0x3E, 0x00, 0x7E, 0x1E, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7D, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0, 0x07, 0x83,
  0xC0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x83, 0xE0, 0x0F,
  0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x3C,
  0x20, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x38, 0x3E, 0x1F, 0x83, 0xE0, 0xF8,
  0x3C, 0x0E, 0x02, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x18, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0x3F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7E, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x7E, 0x00, 0xF7, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x03, 0xFF, 0x80, 0x70, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x1F, 0xC0, 0x7F, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF,
  0xF8, 0xFE, 0x0F, 0xE7, 0xC0, 0x1F, 0x3C, 0x00, 0x7D, 0xE0, 0x03, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0xFB, 0xC0, 0x0F, 0xDE, 0x00, 0xFC, 0xF0, 0x1F, 0xC7, 0xFF, 0xFE,
  0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xFC, 0x03, 0x3F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xFC, 0x01, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x0F,
  0xE7, 0x83, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xFF, 0xFF, 0x3F, 0x83, 0xF9,
  0xF0, 0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00,
  0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00, 0x3D, 0xF8, 0x01,
  0xE7, 0xE0, 0x0F, 0x3F, 0x80, 0x78, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x07,
  0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F,
  0xFF, 0x80, 0xFF, 0xFF, 0x81, 0xF8, 0x1F, 0x87, 0xC0, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7B, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x01, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0x80, 0xC0, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00,
  0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE,
  0x3F, 0xFF, 0xF3, 0xF8, 0x0F, 0x9F, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x7C, 0x00,
  0x7B, 0xE0, 0x03, 0xDF, 0x80, 0x1E, 0x7F, 0x07, 0xF1, 0xFF, 0xFF, 0x87,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE0, 0x3F, 0x8F, 0x00, 0x00, 0x78, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x18, 0x03, 0xF8, 0xFF,
  0xFF, 0x87, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x70, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x3F, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE7, 0xFF, 0xFC,
  0xF8, 0x0F, 0xDE, 0x00, 0xFB, 0xC0, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1E, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x60,
  0x1F, 0xFF, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xF8, 0x00, 0x1E,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3,
  0xFF, 0xF9, 0xFF, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0xE0, 0x7E, 0xFF,
  0xFE, 0x7F, 0xFE, 0x3F, 0xFE, 0x03, 0xFC, 0x00, 0x70, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x01, 0xF3, 0xC0, 0x0F, 0xCF, 0x00,
  0x7E, 0x3C, 0x03, 0xF0, 0xF0, 0x1F, 0x83, 0xC0, 0xFC, 0x0F, 0x07, 0xE0,
  0x3C, 0x3F, 0x00, 0xF1, 0xF0, 0x03, 0xDF, 0x80, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xDF, 0x80, 0x0F, 0x3F, 0x00, 0x3C, 0x3E,
  0x00, 0xF0, 0x7C, 0x03, 0xC0, 0xFC, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xE0,
  0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x00, 0x1F, 0x3C, 0x00, 0x7E, 0xF0,
  0x00, 0xF8, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x18, 0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x83, 0xE1, 0xFF, 0xDF, 0xF3, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0x07, 0xC3, 0xFE, 0x0F, 0x07, 0xFC, 0x0F, 0x07,
  0xF8, 0x1E, 0x0F, 0xF0, 0x3C, 0x1F, 0xE0, 0x78, 0x3F, 0xC0, 0xF0, 0x7F,
  0x81, 0xE0, 0xFF, 0x03, 0xC1, 0xFE, 0x07, 0x83, 0xFC, 0x0F, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1E, 0x0F, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F,
  0xFF, 0xEF, 0x00, 0xFD, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x01, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF,
  0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0x78, 0x00, 0x3C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF1, 0xF0,
  0x07, 0xC3, 0xF8, 0x3F, 0x83, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x01, 0xFF,
  0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xE1,
  0xFF, 0xFF, 0x8F, 0x00, 0xFC, 0x78, 0x03, 0xF3, 0xC0, 0x0F, 0xDE, 0x00,
  0x3E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xF7, 0x80, 0x0F, 0xBC, 0x00, 0x7D, 0xF0, 0x07, 0xCF, 0xE0, 0xFE, 0x7F,
  0xFF, 0xE3, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xF3, 0xF8, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFE, 0x3F, 0xFF, 0xF3, 0xF8, 0x07, 0x9F,
  0x80, 0x3D, 0xF8, 0x01, 0xEF, 0x80, 0x0F, 0x78, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0,
  0x01, 0xFF, 0x00, 0x0F, 0x78, 0x00, 0x7B, 0xE0, 0x03, 0xDF, 0x00, 0x1E,
  0x7C, 0x01, 0xF3, 0xF8, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x01, 0xFC, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFE, 0xFC, 0x01, 0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x03, 0xFF, 0xF8, 0xFF, 0xFF, 0x3F, 0xFF, 0xEF, 0xC0,
  0x19, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xE0, 0x00,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0xFC,
  0x00, 0x01, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x01, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x1F,
  0xFF, 0x00, 0x1F, 0xE0, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0,
  0x07, 0xBE, 0x00, 0xF7, 0xE0, 0x1E, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F,
  0xFF, 0x03, 0xFF, 0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFB, 0xC0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x0F, 0x8F, 0x00, 0x1E,
  0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x3C, 0x01, 0xE0, 0x7C, 0x07, 0xC0,
  0xF8, 0x0F, 0x00, 0xF8, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xC7, 0x80, 0x07, 0x9F, 0x00, 0x0F, 0xBC, 0x00, 0x0F,
  0x78, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x73, 0xC0, 0x00, 0x79, 0xE0,
  0x70, 0x3C, 0xF0, 0x7C, 0x1E, 0x78, 0x3E, 0x0F, 0x3C, 0x1F, 0x07, 0x9E,
  0x0F, 0xC3, 0xCF, 0x0F, 0xE1, 0xE3, 0xC7, 0x70, 0xE1, 0xE3, 0xBC, 0xF0,
  0xF3, 0xDE, 0x78, 0x79, 0xC7, 0x3C, 0x3D, 0xE3, 0xDE, 0x1E, 0xE1, 0xEE,
  0x07, 0x70, 0x77, 0x03, 0xF8, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0xFC, 0x07,
  0xE0, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x3C, 0xF8, 0x00, 0xF8, 0xF8, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0,
  0x1E, 0x01, 0xF0, 0x7C, 0x01, 0xF1, 0xF0, 0x01, 0xF7, 0xC0, 0x03, 0xEF,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xC7, 0xC0,
  0x0F, 0x07, 0x80, 0x3E, 0x0F, 0x80, 0xF8, 0x0F, 0x83, 0xE0, 0x0F, 0x87,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x7C,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x7C, 0x1F, 0x00,
  0xF8, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x78, 0x1E,
  0x00, 0xF8, 0x3C, 0x00, 0xF0, 0xF8, 0x01, 0xF1, 0xE0, 0x03, 0xE3, 0xC0,
  0x03, 0xCF, 0x80, 0x07, 0xDE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80, 0x7F, 0xF8, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x7F, 0xF8, 0x0F, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xC0, 0x00, 0x0F, 0x80, 0x0C, 0x3F, 0xC0, 0x3C, 0xFF, 0xE0, 0x7B,
  0xFF, 0xF1, 0xE7, 0x8F, 0xFF, 0xDE, 0x07, 0xFF, 0x3C, 0x03, 0xFC, 0x30,
  0x01, 0xF0,
};

const GFXglyph UbuntuMono_Regular54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 27, 0, -1 },
  { 1, 7, 33, 27, 10, -33 },
  { 30, 13, 13, 27, 7, -37 },
  { 52, 25, 33, 27, 1, -33 },
  { 156, 21, 42, 27, 3, -37 },
  { 267, 25, 33, 27, 1, -33 },
  { 371, 24, 33, 27, 2, -33 },
  { 470, 5, 14, 27, 11, -37 },
  { 479, 15, 47, 27, 6, -38 },
  { 568, 15, 47, 27, 6, -38 },
  { 657, 21, 20, 27, 3, -33 },
  { 710, 23, 24, 27, 2, -26 },
  { 779, 11, 14, 27, 8, -7 },
  { 799, 11, 4, 27, 8, -16 },
  { 805, 8, 7, 27, 10, -7 },
  { 812, 19, 47, 27, 4, -38 },
  { 924, 23, 33, 27, 2, -33 },
  { 1019, 20, 33, 27, 4, -33 },
  { 1102, 21, 33, 27, 3, -33 },
  { 1189, 21, 33, 27, 3, -33 },
  { 1276, 23, 33, 27, 2, -33 },
  { 1371, 20, 33, 27, 4, -33 },
  { 1454, 21, 33, 27, 3, -33 },
  { 1541, 22, 33, 27, 3, -33 },
  { 1632, 21, 33, 27, 3, -33 },
  { 1719, 21, 33, 27, 3, -33 },
  { 1806, 8, 24, 27, 10, -24 },
  { 1830, 11, 31, 27, 7, -24 },
  { 1873, 22, 21, 27, 3, -24 },
  { 1931, 23, 14, 27, 2, -21 },
  { 1972, 22, 21, 27, 3, -24 },
  { 2030, 17, 33, 27, 5, -33 },
  { 2101, 23, 40, 27, 2, -33 },
  { 2216, 27, 33, 27, 0, -33 },
  { 2328, 21, 33, 27, 3, -33 },
  { 2415, 23, 33, 27, 2, -33 },
  { 2510, 22, 33, 27, 3, -33 },
  { 2601, 20, 33, 27, 5, -33 },
  { 2684, 19, 33, 27, 5, -33 },
  { 2763, 23, 33, 27, 2, -33 },
  { 2858, 23, 33, 27, 2, -33 },
  { 2953, 17, 33, 27, 5, -33 },
  { 3024, 20, 33, 27, 3, -33 },
  { 3107, 24, 33, 27, 3, -33 },
  { 3206, 20, 33, 27, 5, -33 },
  { 3289, 23, 33, 27, 2, -33 },
  { 3384, 21, 33, 27, 3, -33 },
  { 3471, 23, 33, 27, 2, -33 },
  { 3566, 21, 33, 27, 4, -33 },
  { 3653, 23, 41, 27, 2, -33 },
  { 3771, 22, 33, 27, 3, -33 },
  { 3862, 21, 33, 27, 3, -33 },
  { 3949, 23, 33, 27, 2, -33 },
  { 4044, 21, 33, 27, 3, -33 },
  { 4131, 25, 33, 27, 1, -33 },
  { 4235, 23, 33, 27, 2, -33 },
  { 4330, 25, 33, 27, 1, -33 },
  { 4434, 25, 33, 27, 1, -33 },
  { 4538, 22, 33, 27, 3, -33 },
  { 4629, 13, 47, 27, 8, -38 },
  { 4706, 19, 47, 27, 4, -38 },
  { 4818, 13, 47, 27, 6, -38 },
  { 4895, 23, 18, 27, 2, -33 },
  { 4947, 27, 4, 27, 0, 5 },
  { 4961, 9, 9, 27, 9, -37 },
  { 4972, 20, 25, 27, 3, -25 },
  { 5035, 21, 37, 27, 4, -37 },
  { 5133, 21, 25, 27, 3, -25 },
  { 5199, 21, 37, 27, 2, -37 },
  { 5297, 23, 25, 27, 2, -25 },
  { 5369, 23, 37, 27, 3, -37 },
  { 5476, 21, 34, 27, 2, -25 },
  { 5566, 19, 37, 27, 4, -37 },
  { 5654, 21, 35, 27, 3, -35 },
  { 5746, 17, 44, 27, 4, -35 },
  { 5840, 22, 37, 27, 4, -37 },
  { 5942, 21, 37, 27, 3, -37 },
  { 6040, 23, 25, 27, 2, -25 },
  { 6112, 19, 25, 27, 4, -25 },
  { 6172, 23, 25, 27, 2, -25 },
  { 6244, 21, 34, 27, 4, -25 },
  { 6334, 21, 34, 27, 2, -25 },
  { 6424, 18, 25, 27, 6, -25 },
  { 6481, 19, 25, 27, 4, -25 },
  { 6541, 21, 33, 27, 3, -33 },
  { 6628, 19, 25, 27, 4, -25 },
  { 6688, 23, 25, 27, 2, -25 },
  { 6760, 25, 25, 27, 1, -25 },
  { 6839, 23, 25, 27, 2, -25 },
  { 6911, 23, 34, 27, 2, -25 },
  { 7009, 19, 25, 27, 4, -25 },
  { 7069, 19, 47, 27, 4, -38 },
  { 7181, 5, 47, 27, 11, -38 },
  { 7211, 19, 47, 27, 4, -38 },
  { 7323, 23, 8, 27, 2, -18 },
};

const GFXfont UbuntuMono_Regular54pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular54pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular54pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _UBUNTUMONO_REGULAR54PT7B_H_
