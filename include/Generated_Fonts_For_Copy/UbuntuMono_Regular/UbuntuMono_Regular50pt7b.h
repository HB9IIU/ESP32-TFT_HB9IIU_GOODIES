#ifndef _UBUNTUMONO_REGULAR50PT7B_H_
#define _UBUNTUMONO_REGULAR50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular50pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9E, 0x1C, 0x38, 0x70, 0xE1, 0xC0, 0x00, 0x00, 0x00, 0x38, 0xFB,
  0xFF, 0xFF, 0xEF, 0x8E, 0x00, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xF7,
  0x07, 0x38, 0x39, 0xC1, 0xCE, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xC0,
  0x60, 0x00, 0xF0, 0x78, 0x01, 0xC0, 0xF0, 0x07, 0x81, 0xC0, 0x0F, 0x03,
  0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x38, 0x1E, 0x00, 0xF0, 0x38, 0x01, 0xE0, 0xF0, 0x03, 0xC1, 0xE0, 0x07,
  0x83, 0xC0, 0x0E, 0x07, 0x80, 0x3C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0x03, 0xC0, 0x1E, 0x07,
  0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x78, 0x03, 0xC0, 0xF0,
  0x07, 0x81, 0xC0, 0x0F, 0x07, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00,
  0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF1,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xC0, 0x31, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xFC, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF4, 0x00, 0x3F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F,
  0xFF, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x1F, 0x00, 0x1C, 0x7F, 0x00, 0x79,
  0xFF, 0x00, 0xE3, 0x9E, 0x03, 0xCF, 0x1C, 0x0F, 0x1C, 0x3C, 0x1C, 0x38,
  0x38, 0x78, 0x70, 0x70, 0xE0, 0xE0, 0xE3, 0xC1, 0xC1, 0xCF, 0x03, 0x87,
  0x9C, 0x07, 0x8E, 0x78, 0x07, 0x3C, 0xE0, 0x0F, 0xFB, 0x80, 0x0F, 0xEF,
  0x00, 0x0F, 0x9C, 0xF8, 0x00, 0x7B, 0xF8, 0x01, 0xEF, 0xF8, 0x03, 0x9E,
  0x70, 0x0F, 0x38, 0xF0, 0x1C, 0xF0, 0xE0, 0x79, 0xC1, 0xC1, 0xE3, 0x83,
  0x83, 0x87, 0x07, 0x0F, 0x0E, 0x0E, 0x1C, 0x1E, 0x1C, 0x78, 0x1C, 0x79,
  0xE0, 0x38, 0xE3, 0x80, 0x7F, 0xCF, 0x00, 0x7F, 0x1C, 0x00, 0x7C, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3E,
  0x1F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F,
  0x00, 0xF0, 0x78, 0x01, 0xE3, 0xE0, 0x07, 0x9F, 0x00, 0x0F, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFC, 0x0F, 0x07, 0xF8, 0x3C, 0x3D, 0xF0, 0xF1, 0xE3,
  0xE3, 0x87, 0x87, 0xCE, 0x3C, 0x0F, 0xF8, 0xF0, 0x1F, 0xE3, 0xC0, 0x7F,
  0x0F, 0x00, 0xFC, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xE0, 0x3F, 0x8F,
  0xE3, 0xFF, 0x1F, 0xFF, 0xBC, 0x3F, 0xFC, 0xF8, 0x7F, 0xE1, 0xE0, 0x7E,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x73, 0x9C, 0xE7, 0x00, 0x00,
  0x20, 0x03, 0x80, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x03, 0x80, 0x08, 0x20, 0x03, 0x80,
  0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x0F, 0x80, 0xF8,
  0x1F, 0x80, 0xF8, 0x03, 0x80, 0x08, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x70, 0x04, 0x0E, 0x04, 0xF1, 0xC7, 0xBF, 0xBB, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xDC, 0x00,
  0x7B, 0xC0, 0x1E, 0x3C, 0x07, 0xC7, 0xC1, 0xF0, 0x7C, 0x0E, 0x0E, 0x00,
  0x80, 0x80, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00,
  0x70, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03,
  0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00,
  0x07, 0x81, 0xF8, 0x7F, 0x0F, 0xE1, 0xFE, 0x1F, 0x83, 0xF0, 0x1E, 0x07,
  0xC1, 0xF0, 0xFC, 0x3F, 0x07, 0xC0, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0,
  0x3F, 0xFF, 0x81, 0xF0, 0x7C, 0x1F, 0x01, 0xF0, 0xF0, 0x07, 0x8F, 0x80,
  0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3D, 0xF0, 0x01, 0xEF,
  0x87, 0x0F, 0xFC, 0x7C, 0x7F, 0xE3, 0xE3, 0xFF, 0x1F, 0x1F, 0xF8, 0xF8,
  0xFF, 0xC7, 0xC7, 0xFE, 0x1C, 0x3F, 0xF0, 0x01, 0xE7, 0x80, 0x0F, 0x3C,
  0x00, 0x79, 0xE0, 0x03, 0xCF, 0x80, 0x3E, 0x3C, 0x01, 0xE1, 0xF0, 0x1F,
  0x07, 0xC1, 0xF0, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07,
  0xF0, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x1F,
  0xF0, 0x1F, 0xFC, 0x0F, 0xEF, 0x03, 0xE3, 0xC0, 0x60, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x01, 0xFF, 0xFF, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFC,
  0x07, 0xF8, 0x03, 0xFF, 0xC1, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0xC1, 0xF8,
  0xE0, 0x0F, 0x90, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x07, 0xF0, 0x07, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7,
  0x81, 0xF8, 0x40, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xFC, 0x01,
  0xFE, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE8, 0x00, 0xFF, 0xC0, 0x3F, 0x7F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xCF, 0x00, 0x3C,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x1E, 0x07, 0x80,
  0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x1F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0xFF, 0xE1,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0xF8, 0x0F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE8, 0x00, 0xF9, 0xC0, 0x7F, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0, 0xFF,
  0xFC, 0x03, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xF0, 0x07, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0xBF, 0xC1, 0xFF,
  0xFE, 0x3F, 0xFF, 0xE7, 0xFF, 0xFE, 0xFC, 0x0F, 0xDE, 0x00, 0x7F, 0xC0,
  0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0xC0,
  0x0F, 0x78, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x3F, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF8, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFE, 0x1F, 0xFF, 0xC7, 0xE0, 0xFC,
  0xF0, 0x07, 0xBE, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F,
  0xE0, 0x0F, 0x3E, 0x03, 0xE7, 0xE0, 0xF8, 0x7F, 0xBE, 0x07, 0xFF, 0x80,
  0x7F, 0xF8, 0x1F, 0xFF, 0x87, 0xC7, 0xF9, 0xE0, 0x1F, 0xF8, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x7F, 0xF0, 0x3F, 0xBF, 0xFF, 0xE3, 0xFF, 0xF8, 0x3F, 0xFE, 0x01,
  0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0xFF, 0xFC, 0x1F, 0xFF, 0xC7,
  0xE0, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xDF,
  0x81, 0xFB, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xFF, 0xFC, 0x1F, 0xE7, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x0F, 0xE0, 0x0F, 0xF8, 0x3F, 0xFE, 0x07, 0xFF, 0x00, 0xFF,
  0x80, 0x1F, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x39, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE,
  0x00, 0x07, 0x07, 0xF1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x83, 0xF1,
  0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x07, 0x83, 0xE3, 0xF3, 0xF8,
  0x7C, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x60, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0x40, 0x7E,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0x80, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x0F, 0xFC, 0x01, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F, 0x80, 0x78, 0xF8, 0x03, 0xE7, 0x80,
  0x0F, 0x3C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x0F, 0xFF,
  0x81, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0x8F, 0xF0, 0xF0,
  0x7F, 0x8F, 0x83, 0xFC, 0x78, 0x1F, 0xE3, 0xC0, 0xFF, 0x1E, 0x07, 0xF8,
  0xF0, 0x3F, 0xC7, 0xC1, 0xFE, 0x1E, 0x0F, 0xF8, 0xF8, 0x7B, 0xC3, 0xFF,
  0xDE, 0x1F, 0xFE, 0xF8, 0x7F, 0xF3, 0xC0, 0xFF, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x01, 0x01, 0xFF, 0xF8,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x07, 0xBC, 0x00, 0x03, 0x8E, 0x00, 0x03, 0xC7, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0xE0, 0xE0, 0x00, 0xF0, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x38, 0x0E,
  0x00, 0x3C, 0x07, 0x80, 0x1E, 0x03, 0xC0, 0x0E, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x78, 0x00, 0x7C, 0x3C,
  0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xE7,
  0x80, 0x00, 0xF3, 0xC0, 0x00, 0x79, 0xE0, 0x00, 0x3C, 0x7F, 0xF0, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x1F, 0x8F, 0x00, 0x7C,
  0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07,
  0xCF, 0x00, 0x78, 0xF0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0,
  0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x3E, 0xF0, 0x0F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xE0,
  0x7F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFC, 0x0F, 0x0F, 0xC0, 0x08, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x87,
  0xF0, 0x1C, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0,
  0x3F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x03, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00,
  0x3E, 0xF0, 0x07, 0xCF, 0x00, 0xFC, 0xF0, 0x3F, 0x8F, 0xFF, 0xF0, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF,
  0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFB, 0xFF,
  0xFD, 0xFF, 0xFE, 0xFF, 0xFF, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xFF, 0x00, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFE, 0x0F,
  0x0F, 0xC0, 0x08, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBE, 0x00, 0x3D, 0xF0, 0x01, 0xE7,
  0xC0, 0x0F, 0x3E, 0x00, 0x78, 0xF8, 0x03, 0xC7, 0xF0, 0x3E, 0x1F, 0xFF,
  0xF0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xD0, 0x03, 0xE7,
  0x01, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x1F, 0xFF, 0x00, 0xFF, 0x00, 0xF0,
  0x01, 0xF3, 0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x0F,
  0x83, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x80, 0xF0, 0x7C, 0x03,
  0xC3, 0xE0, 0x0F, 0x1F, 0x00, 0x3C, 0xFC, 0x00, 0xF3, 0xE0, 0x03, 0xDF,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF7, 0xE0, 0x03, 0xCF, 0xC0,
  0x0F, 0x1F, 0x80, 0x3C, 0x3F, 0x00, 0xF0, 0x7E, 0x03, 0xC0, 0xFC, 0x0F,
  0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x8F, 0x00,
  0x3E, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x03, 0xEF, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3C,
  0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x80, 0x7C, 0xFC, 0x07, 0xE7, 0xE0, 0x3F,
  0x3F, 0x01, 0xF9, 0xDC, 0x1D, 0xCE, 0xE0, 0xEE, 0x77, 0x07, 0x73, 0x9C,
  0x73, 0x9C, 0xE3, 0x9C, 0xE7, 0x1C, 0xE7, 0x1D, 0xC7, 0x38, 0xEE, 0x3F,
  0xC7, 0x71, 0xFE, 0x1F, 0x0F, 0xF0, 0xF8, 0x7F, 0x87, 0xC3, 0xFC, 0x1E,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0xF0, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC, 0x03, 0xFF,
  0x80, 0x7F, 0xF8, 0x0F, 0xF7, 0x81, 0xFE, 0xF0, 0x3F, 0xCF, 0x07, 0xF9,
  0xE0, 0xFF, 0x1E, 0x1F, 0xE3, 0xC3, 0xFC, 0x38, 0x7F, 0x87, 0x8F, 0xF0,
  0x71, 0xFE, 0x0F, 0x3F, 0xC0, 0xE7, 0xF8, 0x1E, 0xFF, 0x01, 0xDF, 0xE0,
  0x3F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x78, 0x00,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF8,
  0x3F, 0x07, 0xC0, 0x3F, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x3C, 0x7C, 0x00,
  0x7C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03,
  0xDF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E,
  0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF,
  0x00, 0x07, 0x9F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C,
  0x03, 0xF0, 0x7E, 0x0F, 0xC0, 0x7F, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC,
  0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x0F, 0xBC, 0x00, 0xF7, 0x80, 0x1F,
  0xF0, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0xFC, 0xFF, 0xFF, 0x9F, 0xFF, 0xE3,
  0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xF8, 0x3F, 0x07, 0xC0, 0x3F,
  0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x7C, 0xF0, 0x00, 0x79,
  0xE0, 0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xDF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7D, 0xE0,
  0x00, 0xF3, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00,
  0x1F, 0x3E, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x7E, 0x0F,
  0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x0E, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x1F,
  0x8F, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00,
  0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x07, 0xCF, 0x01, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F,
  0xFF, 0x80, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x1E, 0x0F, 0x00, 0xF0,
  0xF0, 0x0F, 0x8F, 0x00, 0x78, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03,
  0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xE7, 0xE0, 0x78, 0xF8, 0x01, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE8, 0x00, 0x7F, 0xE0, 0x3F, 0x7F, 0xFF,
  0xEF, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x7D, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0x7C, 0x01, 0xF3,
  0xE0, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x07, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xF7, 0x80, 0x03, 0xCF, 0x00, 0x07, 0x9F, 0x00, 0x0F,
  0x1E, 0x00, 0x3E, 0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF8, 0x03, 0xE0,
  0xF0, 0x07, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x07, 0xC0, 0x1E, 0x0F, 0x00, 0x3C,
  0x1E, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0xF0, 0x00, 0xF1, 0xE0, 0x01, 0xF7,
  0xC0, 0x01, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x0F, 0x07, 0xF8, 0x7C, 0x3F, 0xC3,
  0xE1, 0xFE, 0x1F, 0x0F, 0xF1, 0xDC, 0x7F, 0x8E, 0xE3, 0x9C, 0x77, 0x1C,
  0xE7, 0x1C, 0xE7, 0x38, 0xE7, 0x39, 0xC7, 0x39, 0xDC, 0x1D, 0xCE, 0xE0,
  0xEE, 0x77, 0x07, 0x73, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0xFC, 0x07, 0xE7,
  0xC0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x07, 0x80, 0x7C, 0x00, 0x3C, 0x78,
  0x00, 0xF0, 0xF8, 0x03, 0xE0, 0xF0, 0x07, 0x81, 0xF0, 0x1F, 0x01, 0xE0,
  0x3C, 0x03, 0xE0, 0xF8, 0x03, 0xE1, 0xE0, 0x03, 0xC7, 0x80, 0x07, 0xDF,
  0x00, 0x07, 0xBC, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0x78, 0x00, 0xF8, 0xF8, 0x01,
  0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x78,
  0x03, 0xE1, 0xE0, 0x03, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0xBE, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0xF3, 0xE0,
  0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x80, 0x3E, 0x0F, 0x80,
  0x78, 0x1F, 0x01, 0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1E,
  0x00, 0x7C, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3D, 0xE0, 0x01, 0xEF, 0x00, 0x1E,
  0x3C, 0x01, 0xF1, 0xF0, 0x0F, 0x07, 0x80, 0xF8, 0x3E, 0x07, 0x80, 0xF0,
  0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3C, 0x00, 0x7B, 0xE0, 0x03, 0xFE, 0x00,
  0x0F, 0x30, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x38, 0x3E, 0x0F, 0x83, 0xC0, 0xF0,
  0x3C, 0x0E, 0x02, 0x00, 0x0F, 0xF8, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE1, 0x80, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x7F, 0xBC, 0x7F, 0xFF, 0x9F, 0xFF, 0xF7, 0xE0, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xF0,
  0x07, 0xBF, 0xFF, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC1, 0xFF, 0xC0, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x3F, 0x01, 0xFF, 0xF8, 0x3F, 0xFF, 0xC7, 0xFF,
  0xFC, 0xFC, 0x1F, 0x9E, 0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xFF, 0x00,
  0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0xF8, 0x01, 0xEF, 0x00, 0x7D, 0xE0, 0x1F, 0xBC, 0x07,
  0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0xC0, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0xE1, 0xFC, 0x02,
  0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0,
  0x0C, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x1F, 0x9E, 0x0F, 0xFF, 0xC7, 0xFF, 0xF9,
  0xFF, 0xFF, 0x3F, 0x07, 0xEF, 0x80, 0x3D, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0xC0, 0x1E, 0xFC, 0x03, 0xCF,
  0xC0, 0x78, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3, 0xF0,
  0x3E, 0x3E, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1E, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x18, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF, 0xF0,
  0x3F, 0x03, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x9F, 0xFF, 0xFC, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0x00,
  0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xF0, 0x1E, 0xF8, 0x03, 0xDF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C,
  0x01, 0xEF, 0xE0, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03,
  0xF3, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0xC0,
  0x3F, 0x1F, 0xFF, 0xE7, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF7, 0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xFF, 0xFC, 0xF0,
  0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F,
  0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0,
  0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x03, 0x80, 0x00, 0x7C, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x20, 0x1F, 0xFE, 0x00, 0xFF, 0xE0,
  0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE7, 0xFF, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x01,
  0xFE, 0x07, 0xFF, 0xFF, 0xBF, 0xFE, 0x7F, 0xF8, 0x1F, 0xC0, 0x70, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F,
  0x01, 0xF0, 0xF0, 0x3E, 0x0F, 0x0F, 0xC0, 0xF1, 0xF8, 0x0F, 0x3F, 0x00,
  0xF7, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0,
  0x0F, 0x3E, 0x00, 0xF1, 0xF0, 0x0F, 0x0F, 0x80, 0xF0, 0x7C, 0x0F, 0x03,
  0xE0, 0xF0, 0x1F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0,
  0x01, 0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x20, 0x1F, 0xFE, 0x00, 0xFF,
  0xE0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x3F, 0x87, 0xC7, 0xFE, 0xFF, 0x3F,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x0F, 0x8F, 0xF8, 0x78, 0x3F, 0xC1, 0xC1,
  0xFE, 0x0F, 0x0F, 0xF0, 0x78, 0x7F, 0x83, 0xC3, 0xFC, 0x1E, 0x1F, 0xE0,
  0xF0, 0xFF, 0x07, 0x87, 0xF8, 0x3C, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x1F, 0xF0, 0x3F, 0xFF, 0x0F,
  0xFF, 0xE3, 0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x03, 0xEF, 0x00, 0x7B, 0xC0,
  0x1E, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07,
  0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7C, 0x01,
  0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E,
  0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xEF, 0x00, 0x1E, 0x7C, 0x01, 0xF3, 0xE0, 0x0F, 0x8F, 0xC1,
  0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x3F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x7F, 0xFF, 0x8F, 0x01, 0xF9,
  0xE0, 0x1F, 0xBC, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF1, 0xFF, 0xF8, 0x3C, 0xFC, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xF0, 0x1E, 0xFC, 0x03, 0xDF, 0x00, 0x7B, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7F, 0xC0, 0x0F, 0x7C, 0x01, 0xEF, 0x80, 0x3C, 0xFC, 0x1F, 0x9F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7E, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xEF, 0xC0, 0x17, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xF0, 0xFF, 0xFE,
  0x1F, 0xFF, 0xC7, 0xC0, 0x18, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x7F, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE8, 0x00, 0x7D,
  0xE0, 0x1F, 0x3F, 0xFF, 0xEF, 0xFF, 0xF8, 0xFF, 0xFE, 0x03, 0xFF, 0x00,
  0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x02, 0x03, 0xFF, 0xE0, 0x3F, 0xFE, 0x01, 0xFF,
  0xE0, 0x03, 0xF8, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xF7, 0xE0, 0x3C, 0xFF, 0xFF,
  0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0x78, 0x00, 0x3C, 0xF0, 0x00,
  0x79, 0xF0, 0x01, 0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0xC0, 0x1F,
  0x07, 0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xC0,
  0x3C, 0x07, 0x80, 0x7C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xF0, 0xF8, 0x00,
  0xF1, 0xE0, 0x01, 0xE3, 0xC0, 0x03, 0xEF, 0x00, 0x03, 0xDE, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xEE, 0x07, 0x03, 0x9C, 0x0F, 0x07, 0x3C, 0x3E,
  0x0E, 0x78, 0x7C, 0x3C, 0xF0, 0xF8, 0x79, 0xE3, 0xF8, 0xF3, 0xC7, 0x71,
  0xE3, 0x8E, 0xE3, 0x87, 0x3D, 0xE7, 0x0F, 0x71, 0xDE, 0x1F, 0xE3, 0xFC,
  0x3F, 0x87, 0xF8, 0x7F, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xC0, 0x3E, 0x03, 0x80, 0x38, 0x00, 0x7C, 0x00, 0x78,
  0x7C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF8, 0x0F, 0x00, 0xF8, 0x3E, 0x00,
  0xF8, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xF7, 0x80, 0x01, 0xFF, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0xFB, 0xE0, 0x01, 0xE3, 0xC0, 0x07, 0x83, 0xC0, 0x1F, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0xF0, 0x07, 0x83, 0xC0, 0x0F, 0x8F, 0x80, 0x0F,
  0x9E, 0x00, 0x0F, 0x00, 0x78, 0x00, 0x7B, 0xC0, 0x07, 0xDF, 0x00, 0x3C,
  0xF8, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0xF8, 0xF8, 0x07, 0x83, 0xC0,
  0x3C, 0x1E, 0x01, 0xE0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1F, 0x07, 0x80,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0, 0x03, 0xEF,
  0x00, 0x0F, 0x78, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x01, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x7F, 0xE0, 0x7C, 0x00,
  0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0xE0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0x80, 0x07, 0xC0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xC0, 0x00,
  0x0F, 0x00, 0x31, 0xFE, 0x01, 0xCF, 0xFC, 0x1E, 0xFF, 0xF0, 0xF7, 0x0F,
  0xFF, 0x78, 0x3F, 0xFB, 0x80, 0x7F, 0x8C, 0x00, 0xF0,
};

const GFXglyph UbuntuMono_Regular50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 7, 31, 25, 9, -31 },
  { 29, 13, 12, 25, 6, -34 },
  { 49, 23, 31, 25, 1, -31 },
  { 139, 19, 40, 25, 3, -35 },
  { 234, 23, 31, 25, 1, -31 },
  { 324, 22, 31, 25, 2, -31 },
  { 410, 5, 13, 25, 10, -34 },
  { 419, 13, 43, 25, 6, -35 },
  { 489, 13, 43, 25, 6, -35 },
  { 559, 19, 18, 25, 3, -31 },
  { 602, 21, 22, 25, 2, -24 },
  { 660, 11, 14, 25, 7, -7 },
  { 680, 11, 4, 25, 7, -15 },
  { 686, 7, 7, 25, 9, -7 },
  { 693, 19, 43, 25, 3, -35 },
  { 796, 21, 31, 25, 2, -31 },
  { 878, 18, 31, 25, 4, -31 },
  { 948, 19, 31, 25, 3, -31 },
  { 1022, 19, 31, 25, 3, -31 },
  { 1096, 21, 31, 25, 2, -31 },
  { 1178, 19, 31, 25, 3, -31 },
  { 1252, 19, 31, 25, 3, -31 },
  { 1326, 20, 31, 25, 3, -31 },
  { 1404, 19, 31, 25, 3, -31 },
  { 1478, 19, 31, 25, 3, -31 },
  { 1552, 7, 23, 25, 9, -23 },
  { 1573, 10, 30, 25, 6, -23 },
  { 1611, 21, 20, 25, 2, -22 },
  { 1664, 21, 14, 25, 2, -20 },
  { 1701, 21, 20, 25, 2, -22 },
  { 1754, 16, 31, 25, 5, -31 },
  { 1816, 21, 38, 25, 2, -31 },
  { 1916, 25, 31, 25, 0, -31 },
  { 2013, 20, 31, 25, 3, -31 },
  { 2091, 21, 31, 25, 2, -31 },
  { 2173, 20, 31, 25, 3, -31 },
  { 2251, 18, 31, 25, 5, -31 },
  { 2321, 17, 31, 25, 5, -31 },
  { 2387, 21, 31, 25, 2, -31 },
  { 2469, 21, 31, 25, 2, -31 },
  { 2551, 17, 31, 25, 4, -31 },
  { 2617, 18, 31, 25, 3, -31 },
  { 2687, 22, 31, 25, 3, -31 },
  { 2773, 18, 31, 25, 5, -31 },
  { 2843, 21, 31, 25, 2, -31 },
  { 2925, 19, 31, 25, 3, -31 },
  { 2999, 23, 31, 25, 1, -31 },
  { 3089, 19, 31, 25, 4, -31 },
  { 3163, 23, 39, 25, 1, -31 },
  { 3276, 20, 31, 25, 3, -31 },
  { 3354, 19, 31, 25, 3, -31 },
  { 3428, 21, 31, 25, 2, -31 },
  { 3510, 21, 31, 25, 2, -31 },
  { 3592, 23, 31, 25, 1, -31 },
  { 3682, 21, 31, 25, 2, -31 },
  { 3764, 23, 31, 25, 1, -31 },
  { 3854, 23, 31, 25, 1, -31 },
  { 3944, 20, 31, 25, 3, -31 },
  { 4022, 12, 43, 25, 7, -35 },
  { 4087, 19, 43, 25, 3, -35 },
  { 4190, 12, 43, 25, 6, -35 },
  { 4255, 21, 17, 25, 2, -31 },
  { 4300, 25, 4, 25, 0, 5 },
  { 4313, 9, 9, 25, 8, -35 },
  { 4324, 19, 23, 25, 3, -23 },
  { 4379, 19, 35, 25, 4, -35 },
  { 4463, 21, 23, 25, 2, -23 },
  { 4524, 19, 35, 25, 2, -35 },
  { 4608, 21, 23, 25, 2, -23 },
  { 4669, 21, 35, 25, 3, -35 },
  { 4761, 19, 31, 25, 2, -23 },
  { 4835, 18, 35, 25, 4, -35 },
  { 4914, 20, 33, 25, 3, -33 },
  { 4997, 15, 41, 25, 4, -33 },
  { 5074, 20, 35, 25, 4, -35 },
  { 5162, 20, 35, 25, 3, -35 },
  { 5250, 21, 23, 25, 2, -23 },
  { 5311, 18, 23, 25, 4, -23 },
  { 5363, 21, 23, 25, 2, -23 },
  { 5424, 19, 31, 25, 4, -23 },
  { 5498, 19, 31, 25, 2, -23 },
  { 5572, 17, 23, 25, 5, -23 },
  { 5621, 19, 23, 25, 3, -23 },
  { 5676, 20, 30, 25, 3, -30 },
  { 5751, 18, 23, 25, 3, -23 },
  { 5803, 23, 23, 25, 1, -23 },
  { 5870, 23, 23, 25, 1, -23 },
  { 5937, 23, 23, 25, 1, -23 },
  { 6004, 21, 31, 25, 2, -23 },
  { 6086, 17, 23, 25, 4, -23 },
  { 6135, 17, 43, 25, 4, -35 },
  { 6227, 3, 43, 25, 11, -35 },
  { 6244, 17, 43, 25, 4, -35 },
  { 6336, 21, 8, 25, 2, -17 },
};

const GFXfont UbuntuMono_Regular50pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular50pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular50pt7bGlyphs,
  0x20, 0x7E, 50
};

#endif // _UBUNTUMONO_REGULAR50PT7B_H_
