#ifndef _UBUNTUMONO_REGULAR35PT7B_H_
#define _UBUNTUMONO_REGULAR35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular35pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE3, 0x18, 0x00, 0x03,
  0xBF, 0xFF, 0xB8, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC7, 0xC3, 0xC3, 0xC2,
  0x07, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x06, 0x1C, 0x0E, 0x1C, 0x0E, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x30,
  0x1C, 0x70, 0x18, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x60,
  0x30, 0xE0, 0x30, 0xE0, 0x70, 0xE0, 0x70, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0xE0, 0xFF, 0xC7, 0xFF, 0x1E, 0x04, 0xE0, 0x03,
  0x80, 0x0F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x00, 0x3E,
  0x00, 0x38, 0x00, 0xF0, 0x03, 0xF0, 0x1E, 0xFF, 0xFB, 0xFF, 0xC3, 0xFC,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x00, 0x38, 0x06, 0x7C, 0x0E,
  0xEE, 0x0C, 0xC6, 0x1C, 0xC6, 0x38, 0xC6, 0x30, 0xC6, 0x70, 0xC6, 0x60,
  0xCE, 0xC0, 0x7D, 0xC0, 0x39, 0x80, 0x03, 0xBC, 0x03, 0x7E, 0x06, 0x66,
  0x0E, 0xE7, 0x0C, 0xC3, 0x1C, 0xC3, 0x18, 0xC3, 0x30, 0xE7, 0x70, 0x66,
  0x60, 0x7E, 0xE0, 0x3C, 0x0F, 0x80, 0x1F, 0xE0, 0x3F, 0xE0, 0x38, 0xF0,
  0x38, 0x70, 0x30, 0x70, 0x38, 0x60, 0x38, 0xE0, 0x1F, 0xC0, 0x1F, 0x80,
  0x1E, 0x0C, 0x3F, 0x0C, 0x73, 0x9C, 0x71, 0xDC, 0xE0, 0xF8, 0xE0, 0x78,
  0xE0, 0x38, 0xF0, 0x78, 0xF8, 0xFC, 0x7F, 0xFC, 0x3F, 0xCE, 0x1F, 0x0E,
  0xFF, 0xFF, 0xDB, 0x60, 0x01, 0x00, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x07,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x10, 0x40, 0x38, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xE0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0x60, 0x18, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x70,
  0x1C, 0x0E, 0x07, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x04, 0x00, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x10, 0xC6, 0xF3, 0x7B, 0xFF, 0xE3, 0xFF, 0x01, 0xE0,
  0x0F, 0xC0, 0x77, 0x83, 0xCE, 0x0E, 0x38, 0x10, 0x40, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x1C, 0x7C,
  0xF9, 0xF1, 0xE1, 0xC7, 0x1E, 0xF8, 0xC0, 0xFF, 0xFF, 0xFF, 0x77, 0xFF,
  0xF7, 0x00, 0x00, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x00, 0x0F, 0x80, 0x7F, 0x83, 0xFF, 0x1E, 0x3C, 0x70, 0x3B,
  0x80, 0xEE, 0x03, 0xB8, 0x07, 0xE3, 0x1F, 0x9E, 0x7E, 0x79, 0xF9, 0xE7,
  0xE3, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0E, 0xE0, 0x39, 0xC0, 0xE7, 0x8F,
  0x0F, 0xFC, 0x1F, 0xE0, 0x3E, 0x00, 0x03, 0x00, 0x70, 0x0F, 0x03, 0xF0,
  0x7F, 0x0F, 0x70, 0xC7, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x07, 0xFF,
  0x7F, 0xF7, 0xFF, 0x1F, 0x81, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0x40, 0x78,
  0x00, 0xE0, 0x03, 0x80, 0x0C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFF, 0x1F, 0xFC, 0xC1,
  0xE0, 0x07, 0x00, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x7F, 0x03, 0xF0,
  0x1F, 0xE0, 0x0F, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x38, 0x01, 0xD0,
  0x1F, 0xFF, 0xEF, 0xFE, 0x1F, 0xC0, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x3B, 0x80, 0xE7, 0x03, 0x8E, 0x06, 0x1C, 0x1C, 0x38, 0x70,
  0x70, 0xC0, 0xE3, 0x81, 0xC6, 0x03, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0x01, 0xFF, 0x0F, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x00, 0x38, 0x01, 0xD0, 0x3E, 0xFF, 0xEF, 0xFE, 0x1F, 0xC0,
  0x00, 0xF0, 0x0F, 0xC0, 0xFF, 0x07, 0xE0, 0x3C, 0x00, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xEF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1E, 0xE0, 0x3B, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3D, 0xC0, 0xE7, 0x87, 0x8F, 0xFC, 0x3F,
  0xE0, 0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x70, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFF, 0x1E,
  0x1E, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xBC, 0x0E, 0x78, 0x71, 0xFB, 0x83,
  0xFC, 0x07, 0xFC, 0x79, 0xF9, 0xC0, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFF, 0x07, 0x9F, 0xFE, 0x3F, 0xF0, 0x7F, 0x00, 0x0F, 0x80, 0xFF,
  0x87, 0xFF, 0x1E, 0x1C, 0xE0, 0x3B, 0x80, 0xEE, 0x03, 0xB8, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x03, 0xDF, 0xFF, 0x3F, 0xF8, 0x7F, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x03, 0x80, 0x7E, 0x1F, 0xF0, 0x7F, 0x01, 0xE0, 0x00,
  0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xEE, 0x1C, 0x7C,
  0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0xCF, 0x8F,
  0x0E, 0x18, 0xF7, 0xC6, 0x00, 0x00, 0x08, 0x01, 0xF0, 0x1F, 0x83, 0xF0,
  0x3F, 0x03, 0xE0, 0x0E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3C, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xC0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF0, 0x03, 0x00, 0x00, 0x3F, 0x1F, 0xF9,
  0xFF, 0xA0, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x00, 0xC0, 0x38, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x78, 0x0F,
  0x01, 0xE0, 0x18, 0x00, 0x03, 0xE0, 0x1F, 0xF0, 0x7F, 0xF0, 0xF0, 0xF3,
  0x80, 0xE7, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x70, 0x7E, 0xC3, 0xFD, 0x8F,
  0xFF, 0x1C, 0x3E, 0x38, 0x7C, 0xE0, 0xF9, 0xC1, 0xF1, 0xC3, 0x63, 0x86,
  0xE7, 0xFD, 0xC7, 0xFB, 0x83, 0xF3, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x80, 0x0F, 0xFC, 0x0F, 0xF8, 0x07, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00,
  0xFC, 0x00, 0x6E, 0x00, 0x77, 0x00, 0x39, 0xC0, 0x18, 0xE0, 0x1C, 0x70,
  0x0E, 0x18, 0x07, 0x0E, 0x07, 0x07, 0x03, 0x81, 0x81, 0xC0, 0xE0, 0xC0,
  0x70, 0xFF, 0xF8, 0x7F, 0xFC, 0x3F, 0xFF, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0xF7, 0x00, 0x3F, 0x00, 0x1C, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38,
  0x3C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x1C, 0xE0, 0xF3, 0xFF, 0x8F,
  0xFC, 0x3F, 0xFC, 0xE0, 0x7B, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFE, 0x07, 0xBF, 0xFE, 0xFF, 0xE3, 0xFE, 0x00, 0x03, 0xF0, 0x3F,
  0xF1, 0xFF, 0xCF, 0x02, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x8F, 0xFF, 0x1F, 0xFC, 0x1F, 0xC0,
  0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x38, 0x7C, 0xE0, 0x7B, 0x80, 0xEE, 0x03,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x3B, 0x81, 0xEE, 0x1F, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFC, 0x00, 0xFF, 0xF7, 0xFF, 0xBF, 0xFD, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF, 0x3F, 0xF9, 0xFF, 0xCE, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE, 0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0x03, 0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0x02, 0x78, 0x01, 0xC0, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0x70, 0x1D, 0xE0, 0x73, 0xC1, 0xCF, 0xFF, 0x1F,
  0xFC, 0x1F, 0xC0, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x7A, 0x03, 0xB8, 0x3D, 0xFF, 0xC7, 0xFE, 0x1F,
  0xC0, 0xE0, 0x1D, 0xC0, 0x73, 0x81, 0xE7, 0x03, 0x8E, 0x0E, 0x1C, 0x3C,
  0x38, 0xF0, 0x73, 0xC0, 0xEF, 0x01, 0xDC, 0x03, 0xF0, 0x07, 0xF0, 0x0E,
  0xF0, 0x1C, 0xF0, 0x38, 0xF0, 0x70, 0xF0, 0xE0, 0xF1, 0xC0, 0xF3, 0x80,
  0xE7, 0x01, 0xEE, 0x01, 0xDC, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x38, 0x1C, 0x70, 0x39, 0xE0,
  0xF3, 0xC1, 0xE6, 0xC3, 0xCD, 0x8F, 0x9B, 0x1B, 0xB3, 0x37, 0x66, 0x6E,
  0xCD, 0x9D, 0x9F, 0x3B, 0x1E, 0x76, 0x3C, 0xEC, 0x71, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xC0, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x7E,
  0xC1, 0xFB, 0x87, 0xE6, 0x1F, 0x9C, 0x7E, 0x31, 0xF8, 0xE7, 0xE1, 0x9F,
  0x87, 0x7E, 0x1D, 0xF8, 0x37, 0xE0, 0xFF, 0x81, 0xFE, 0x07, 0xF8, 0x0F,
  0xE0, 0x3F, 0x80, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x3C,
  0x70, 0x1C, 0x70, 0x0E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E,
  0x70, 0x0E, 0x70, 0x1C, 0x3C, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xC0,
  0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0x81, 0xEC, 0x07, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x3D, 0xFF, 0xEF, 0xFC, 0x7F, 0xC3, 0x00,
  0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x00,
  0x07, 0xC0, 0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x3C, 0x70, 0x1C, 0x70, 0x0E,
  0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x70, 0x1C,
  0x7C, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xE0, 0x03, 0x80, 0x01, 0xF0,
  0x00, 0xFE, 0x00, 0x7C, 0x00, 0x1C, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38,
  0x3C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xEE,
  0x0F, 0x3F, 0xFC, 0xFF, 0xE3, 0xFE, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0xE3,
  0x81, 0xCE, 0x07, 0x38, 0x0E, 0xE0, 0x3B, 0x80, 0x70, 0x0F, 0xE0, 0xFF,
  0xE7, 0xFF, 0x1E, 0x0C, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xE0, 0x03, 0x80,
  0x07, 0x00, 0x1C, 0x00, 0xE4, 0x07, 0xBF, 0xFE, 0xFF, 0xF0, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xEF, 0x87, 0x9F, 0xFC, 0x3F, 0xF0, 0x3F, 0x00, 0x70, 0x03, 0xB8,
  0x01, 0xDC, 0x01, 0xCE, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x38, 0xE0, 0x38,
  0x70, 0x1C, 0x1C, 0x0E, 0x0E, 0x07, 0x07, 0x07, 0x01, 0xC3, 0x80, 0xE1,
  0xC0, 0x71, 0xC0, 0x38, 0xE0, 0x0E, 0x70, 0x07, 0x70, 0x03, 0xB8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE3,
  0x8E, 0xC7, 0x1D, 0x8F, 0x3B, 0x36, 0x76, 0x6C, 0xEC, 0xCD, 0xDB, 0x9B,
  0xB6, 0x36, 0x6C, 0x7C, 0xD8, 0x79, 0xE0, 0xF3, 0xC1, 0xE7, 0x81, 0xC7,
  0x03, 0x80, 0x70, 0x0E, 0x70, 0x1C, 0x38, 0x1C, 0x38, 0x38, 0x1C, 0x38,
  0x1C, 0x70, 0x0E, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0x80,
  0x03, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1C, 0x70, 0x1C, 0x38,
  0x38, 0x38, 0x38, 0x1C, 0x70, 0x1C, 0x70, 0x0E, 0xE0, 0x0E, 0x70, 0x03,
  0xB8, 0x03, 0xDE, 0x01, 0xC7, 0x01, 0xE3, 0xC0, 0xE0, 0xE0, 0x70, 0x78,
  0x70, 0x1C, 0x38, 0x0F, 0x38, 0x03, 0xBC, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xFF, 0xFF, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80,
  0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00, 0x60, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C,
  0x00, 0xE0, 0x03, 0x80, 0x1C, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF, 0xFF,
  0xF0, 0x03, 0x80, 0x07, 0x80, 0x1F, 0x00, 0x77, 0x00, 0xE7, 0x03, 0x8E,
  0x07, 0x0E, 0x1C, 0x1C, 0x38, 0x1C, 0xE0, 0x39, 0xC0, 0x39, 0x00, 0x20,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x43, 0x8F, 0x1E, 0x38, 0x20, 0x1F, 0xC1,
  0xFF, 0x8F, 0xFC, 0x40, 0xF0, 0x03, 0x80, 0x1C, 0x3F, 0xE7, 0xFF, 0x70,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xBF, 0xFD, 0xFF, 0xE3, 0xFE,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xEF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3E, 0x1E, 0xE0, 0x3F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0E, 0xE0,
  0x7B, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7F, 0xE3, 0xFF, 0x9F,
  0x02, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x3C, 0x00, 0x7C, 0x08, 0xFF, 0xF1, 0xFF, 0xC1, 0xFC, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x07, 0xDC, 0x7F, 0xF3, 0xFF, 0xDF, 0x0F, 0x70, 0x1D, 0xC0, 0x7F, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x77, 0x01, 0xDE, 0x07, 0x3C, 0x1C, 0xFF,
  0xF1, 0xFF, 0xC1, 0xFE, 0x07, 0xE0, 0x3F, 0xF0, 0xFF, 0xF1, 0xE1, 0xE7,
  0x00, 0xEE, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x87, 0xFF, 0x87, 0xFF, 0x01, 0xF8, 0x01, 0xF8,
  0x0F, 0xFC, 0x1F, 0xF8, 0x78, 0x20, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xE0, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF,
  0xDF, 0x07, 0x70, 0x1D, 0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1D, 0xC0,
  0x77, 0x01, 0xDE, 0x0F, 0x3F, 0xFC, 0x7F, 0xF0, 0xFD, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF2, 0x07, 0x9F, 0xFE, 0x7F, 0xF0, 0x7F, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xEF,
  0xC7, 0xFF, 0x3F, 0xFD, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00,
  0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC2,
  0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0x80, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x3F, 0xE7, 0xFC, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x07, 0x00, 0xEC, 0x3D, 0xFF, 0xBF, 0xE3, 0xF0, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x3D, 0xC0, 0xF3, 0x83, 0xC7, 0x0F, 0x0E, 0x3C, 0x1C, 0xF0,
  0x3B, 0xC0, 0x7E, 0x00, 0xEF, 0x01, 0xCF, 0x03, 0x8F, 0x07, 0x0F, 0x0E,
  0x0F, 0x1C, 0x0F, 0x38, 0x0F, 0x70, 0x0E, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18,
  0x00, 0x60, 0x01, 0x80, 0x06, 0x00, 0x18, 0x00, 0x60, 0x01, 0x80, 0x06,
  0x00, 0x18, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x08, 0x1F, 0xF0, 0x3F, 0xC0,
  0x7E, 0x7E, 0x79, 0xFF, 0xFB, 0xFF, 0xFF, 0x1C, 0x7E, 0x38, 0xFC, 0x30,
  0xF8, 0x61, 0xF0, 0xC3, 0xE1, 0x87, 0xC3, 0x0F, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0x3F, 0xC7, 0xFF, 0x3F, 0xFD,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x07, 0xE0, 0x3F,
  0xE0, 0xFF, 0xE3, 0xE1, 0xE7, 0x01, 0xCE, 0x01, 0xFC, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE3, 0xC3, 0xC7, 0xFF, 0x07,
  0xFC, 0x03, 0xF0, 0x3F, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x1E, 0xE0, 0x3B,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x0F,
  0xF0, 0x7B, 0xFF, 0xCF, 0xFE, 0x3B, 0xF0, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xCF,
  0x07, 0x78, 0x1D, 0xC0, 0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x77,
  0x01, 0xDC, 0x07, 0x7C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC1, 0xF7, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x0F, 0xE1, 0xFF, 0x9F, 0xFC,
  0xE0, 0x26, 0x00, 0x38, 0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xF0, 0x0F, 0xC0,
  0x0E, 0x00, 0x76, 0x07, 0xBF, 0xFF, 0xFF, 0xC7, 0xF8, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xFF, 0xEF, 0xFF, 0xBF, 0xFE, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x3C, 0x20, 0xFF, 0xC1, 0xFF, 0x03, 0xF0, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0,
  0x3F, 0x01, 0xFC, 0x0E, 0xE0, 0x77, 0x83, 0xBF, 0xFC, 0xFF, 0xE1, 0xFE,
  0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0xE7, 0x81, 0xC7, 0x03, 0x8E,
  0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x38, 0xE0, 0x39, 0xC0, 0x77, 0x00, 0x7E,
  0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x06, 0xE1, 0x86, 0xE3, 0x86, 0xE3, 0xCE, 0x63, 0xCE, 0x67, 0xCE,
  0x66, 0xEE, 0x7E, 0x6C, 0x7C, 0x6C, 0x7C, 0x7C, 0x3C, 0x3C, 0x38, 0x3C,
  0x38, 0x18, 0x70, 0x0E, 0x78, 0x1C, 0x38, 0x38, 0x1C, 0x70, 0x0E, 0x70,
  0x0F, 0xE0, 0x07, 0xC0, 0x03, 0x80, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70,
  0x1C, 0x70, 0x38, 0x38, 0x38, 0x1C, 0x70, 0x1E, 0xE0, 0x0E, 0x70, 0x0E,
  0xE0, 0x1D, 0xE0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x03, 0x87, 0x0E, 0x0E,
  0x1C, 0x0E, 0x38, 0x1C, 0x60, 0x39, 0xC0, 0x3B, 0x80, 0x76, 0x00, 0x7C,
  0x00, 0xF8, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00, 0x1E, 0x03, 0xF8, 0x0F,
  0xE0, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01,
  0xC0, 0xF8, 0x0F, 0x80, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0xF0,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x0F, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xF0,
  0x1F, 0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0xE0, 0xFE, 0x0F, 0x80, 0x1C, 0x06,
  0x7E, 0x0D, 0xFF, 0x3B, 0x1F, 0xEE, 0x1F, 0xC8, 0x0F, 0x00,
};

const GFXglyph UbuntuMono_Regular35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 5, 22, 18, 6, -22 },
  { 15, 8, 9, 18, 5, -24 },
  { 24, 16, 22, 18, 1, -22 },
  { 68, 14, 27, 18, 2, -24 },
  { 116, 16, 22, 18, 1, -22 },
  { 160, 16, 22, 18, 1, -22 },
  { 204, 3, 9, 18, 7, -24 },
  { 208, 10, 31, 18, 4, -25 },
  { 247, 10, 31, 18, 4, -25 },
  { 286, 14, 13, 18, 2, -22 },
  { 309, 14, 14, 18, 2, -16 },
  { 334, 7, 10, 18, 5, -5 },
  { 343, 8, 3, 18, 5, -11 },
  { 346, 5, 5, 18, 6, -5 },
  { 350, 13, 30, 18, 2, -24 },
  { 399, 14, 22, 18, 2, -22 },
  { 438, 12, 22, 18, 3, -22 },
  { 471, 14, 22, 18, 2, -22 },
  { 510, 13, 22, 18, 2, -22 },
  { 546, 15, 22, 18, 1, -22 },
  { 588, 13, 22, 18, 2, -22 },
  { 624, 14, 22, 18, 2, -22 },
  { 663, 14, 22, 18, 2, -22 },
  { 702, 14, 22, 18, 2, -22 },
  { 741, 14, 22, 18, 2, -22 },
  { 780, 5, 16, 18, 6, -16 },
  { 790, 7, 21, 18, 4, -16 },
  { 809, 14, 14, 18, 2, -15 },
  { 834, 14, 8, 18, 2, -12 },
  { 848, 14, 14, 18, 2, -15 },
  { 873, 11, 22, 18, 3, -22 },
  { 904, 15, 27, 18, 1, -22 },
  { 955, 17, 22, 18, 0, -22 },
  { 1002, 14, 22, 18, 2, -22 },
  { 1041, 14, 22, 18, 2, -22 },
  { 1080, 14, 22, 18, 2, -22 },
  { 1119, 13, 22, 18, 3, -22 },
  { 1155, 12, 22, 18, 3, -22 },
  { 1188, 14, 22, 18, 2, -22 },
  { 1227, 14, 22, 18, 2, -22 },
  { 1266, 11, 22, 18, 3, -22 },
  { 1297, 13, 22, 18, 2, -22 },
  { 1333, 15, 22, 18, 2, -22 },
  { 1375, 13, 22, 18, 3, -22 },
  { 1411, 15, 22, 18, 1, -22 },
  { 1453, 14, 22, 18, 2, -22 },
  { 1492, 16, 22, 18, 1, -22 },
  { 1536, 13, 22, 18, 3, -22 },
  { 1572, 16, 27, 18, 1, -22 },
  { 1626, 14, 22, 18, 2, -22 },
  { 1665, 14, 22, 18, 2, -22 },
  { 1704, 15, 22, 18, 1, -22 },
  { 1746, 14, 22, 18, 2, -22 },
  { 1785, 17, 22, 18, 0, -22 },
  { 1832, 15, 22, 18, 1, -22 },
  { 1874, 16, 22, 18, 1, -22 },
  { 1918, 17, 22, 18, 0, -22 },
  { 1965, 14, 22, 18, 2, -22 },
  { 2004, 8, 28, 18, 5, -22 },
  { 2032, 13, 30, 18, 2, -24 },
  { 2081, 9, 28, 18, 4, -22 },
  { 2113, 15, 12, 18, 1, -22 },
  { 2136, 17, 2, 18, 0, 3 },
  { 2141, 6, 6, 18, 6, -24 },
  { 2146, 13, 16, 18, 2, -16 },
  { 2172, 14, 24, 18, 2, -24 },
  { 2214, 14, 16, 18, 2, -16 },
  { 2242, 14, 24, 18, 1, -24 },
  { 2284, 15, 16, 18, 1, -16 },
  { 2314, 15, 24, 18, 2, -24 },
  { 2359, 14, 22, 18, 1, -16 },
  { 2398, 13, 24, 18, 2, -24 },
  { 2437, 14, 23, 18, 2, -23 },
  { 2478, 11, 29, 18, 2, -23 },
  { 2518, 15, 24, 18, 2, -24 },
  { 2563, 14, 24, 18, 2, -24 },
  { 2605, 15, 16, 18, 1, -16 },
  { 2635, 13, 16, 18, 2, -16 },
  { 2661, 15, 16, 18, 1, -16 },
  { 2691, 14, 22, 18, 2, -16 },
  { 2730, 14, 22, 18, 1, -16 },
  { 2769, 11, 16, 18, 4, -16 },
  { 2791, 13, 16, 18, 2, -16 },
  { 2817, 14, 21, 18, 2, -21 },
  { 2854, 13, 16, 18, 2, -16 },
  { 2880, 15, 16, 18, 1, -16 },
  { 2910, 16, 16, 18, 1, -16 },
  { 2942, 16, 16, 18, 1, -16 },
  { 2974, 15, 22, 18, 1, -16 },
  { 3016, 12, 16, 18, 3, -16 },
  { 3040, 12, 30, 18, 3, -24 },
  { 3085, 3, 30, 18, 7, -24 },
  { 3097, 12, 30, 18, 3, -24 },
  { 3142, 15, 6, 18, 1, -13 },
};

const GFXfont UbuntuMono_Regular35pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular35pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular35pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _UBUNTUMONO_REGULAR35PT7B_H_
