#ifndef _UBUNTUMONO_REGULAR69PT7B_H_
#define _UBUNTUMONO_REGULAR69PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular69pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x3F, 0x9F,
  0xE7, 0xFF, 0xFF, 0x7F, 0xDF, 0xE3, 0xF8, 0x78, 0xF8, 0x1F, 0xFC, 0x0F,
  0xFE, 0x07, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xE0, 0x7D, 0xF0,
  0x3E, 0xF8, 0x1F, 0x7C, 0x07, 0xBE, 0x03, 0xDF, 0x01, 0xEF, 0x80, 0xF3,
  0x80, 0x79, 0xC0, 0x3C, 0xE0, 0x1E, 0x70, 0x0E, 0x00, 0x00, 0x3E, 0x01,
  0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x80, 0xFC, 0x00, 0x3F, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3F, 0x00, 0x0F, 0xC0,
  0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x7C, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0x7E, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF,
  0x83, 0xFC, 0x01, 0xF0, 0xFE, 0x00, 0x06, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x60,
  0x00, 0x1F, 0xCF, 0xC0, 0x0F, 0xFB, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0x3F, 0xF8,
  0x00, 0x3E, 0x3F, 0xFC, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x7C, 0x78, 0x3E,
  0x00, 0xF8, 0x78, 0x3E, 0x00, 0xF0, 0xF8, 0x1E, 0x01, 0xF0, 0xF8, 0x1E,
  0x03, 0xE0, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x07, 0xC0, 0xF0, 0x1E,
  0x0F, 0x80, 0xF8, 0x1E, 0x0F, 0x80, 0xF8, 0x1E, 0x1F, 0x00, 0x78, 0x3E,
  0x1F, 0x00, 0x78, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x3F, 0xFC,
  0x7C, 0x00, 0x3F, 0xF8, 0xF8, 0x00, 0x1F, 0xF0, 0xF0, 0x00, 0x07, 0xC1,
  0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F, 0x8F, 0xF8, 0x00, 0x1F,
  0x1F, 0xFC, 0x00, 0x1F, 0x1F, 0xFE, 0x00, 0x3E, 0x3E, 0x3E, 0x00, 0x3C,
  0x3C, 0x1F, 0x00, 0x7C, 0x3C, 0x1F, 0x00, 0xF8, 0x7C, 0x0F, 0x00, 0xF8,
  0x7C, 0x0F, 0x01, 0xF0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x07, 0xC0, 0x7C, 0x0F, 0x07, 0xC0, 0x7C, 0x0F, 0x0F, 0x80,
  0x3C, 0x1F, 0x1F, 0x00, 0x3C, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x3E, 0x00,
  0x1F, 0xFE, 0x3C, 0x00, 0x1F, 0xFC, 0x7C, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFC, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x3E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x1F, 0x00,
  0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0xC0, 0x7C, 0x0F, 0xFF, 0xC0, 0xF8, 0x1F,
  0x9F, 0xC1, 0xF0, 0x7E, 0x1F, 0xC3, 0xC1, 0xF8, 0x1F, 0xCF, 0x83, 0xF0,
  0x1F, 0xDF, 0x07, 0xC0, 0x1F, 0xFE, 0x1F, 0x80, 0x1F, 0xF8, 0x3F, 0x00,
  0x1F, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0xFF, 0x03, 0xF0, 0x03, 0xFF, 0x07, 0xF0, 0x0F,
  0xFE, 0x0F, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0xFE, 0x7E, 0x0F, 0xFF, 0xF8,
  0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xF7, 0xDF, 0x7D, 0xF7,
  0x9E, 0x79, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x70, 0x00, 0x3E, 0x00, 0x0F,
  0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x0E, 0x00,
  0x00, 0x80, 0x10, 0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0xE0, 0x00, 0x08, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x07, 0xC0,
  0x23, 0xC0, 0xF0, 0x3C, 0x7E, 0x1E, 0x1F, 0x8F, 0xF1, 0xCF, 0xFB, 0xFF,
  0xBF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0,
  0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0x00, 0x1C, 0x03, 0xC0, 0x01, 0x00,
  0x20, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC,
  0x3F, 0xF0, 0xFF, 0xC1, 0xFF, 0x03, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x7C,
  0x07, 0xF0, 0xFF, 0x8F, 0xFC, 0x1F, 0xE0, 0x7E, 0x01, 0xC0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xF0, 0x1F,
  0xC0, 0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xC3, 0xF0, 0x00,
  0xFC, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x70, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xFC, 0x3F,
  0xFC, 0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x1F, 0xFC, 0x3F, 0xC1, 0xFF, 0xC1,
  0xFC, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC0, 0xF0, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x0F, 0xC1,
  0xF8, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x80, 0xFF, 0x07, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xCF, 0xC0, 0x1F,
  0xC7, 0xE0, 0x0F, 0x83, 0xF0, 0x02, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0x03, 0xFE, 0x1F, 0x00, 0x1F, 0xC1, 0xC0, 0x01, 0xF8, 0x20, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x03, 0xFC, 0x0F, 0x00, 0x1F, 0xC0,
  0x80, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x10, 0x00, 0x0F, 0xE3,
  0xE0, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01,
  0xFB, 0xE0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF0,
  0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF0, 0x3E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x0F, 0x80, 0x3E, 0x00, 0x7E, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x10, 0x00, 0x3F, 0xCF, 0x80, 0x3F, 0xE3, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x87,
  0xF8, 0x03, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xE7, 0xE0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x7F, 0x07, 0xF8, 0x1F,
  0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x07,
  0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xF0, 0x7F, 0x81, 0xFE, 0x0F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0,
  0x00, 0x7C, 0x7F, 0x00, 0x1F, 0x87, 0xF0, 0x07, 0xE0, 0xFF, 0x01, 0xF8,
  0x0F, 0xFC, 0x7E, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0xC7, 0xFF, 0x07, 0xF0, 0x3F, 0xF0,
  0xFC, 0x01, 0xFE, 0x3F, 0x00, 0x0F, 0xE7, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF3, 0xFE, 0x03, 0xFC, 0x3F,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE,
  0x1F, 0xC0, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x7E, 0xFF, 0x80, 0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x1F, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFD, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xF1, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xE1, 0xF0,
  0x03, 0xE0, 0x3F, 0xC0, 0xFF, 0x87, 0xFE, 0x1F, 0xF8, 0x7F, 0xE0, 0xFF,
  0x83, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x0F, 0xF8, 0x7F, 0xE1, 0xFF, 0x87,
  0xFF, 0x0F, 0xFC, 0x3F, 0xE0, 0x7F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0xFE, 0x0F, 0xF0, 0xFF, 0x83, 0xFC, 0x0F, 0xC0, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF9, 0xF0, 0x1F, 0xE2, 0x00, 0x1F,
  0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0xFF, 0xEF, 0x80, 0x3F, 0xFF, 0x7C, 0x03, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xC1, 0xFF, 0xC1, 0xF8,
  0x0F, 0xFC, 0x1F, 0xC0, 0x7F, 0xE0, 0xFC, 0x03, 0xFF, 0x07, 0xE0, 0x1F,
  0xF8, 0x3E, 0x00, 0xFF, 0xC1, 0xF0, 0x07, 0xFE, 0x0F, 0x80, 0x3F, 0xF0,
  0x7C, 0x01, 0xFF, 0x83, 0xE0, 0x0F, 0xFE, 0x1F, 0x80, 0x7F, 0xF0, 0xFC,
  0x03, 0xFF, 0x87, 0xE0, 0x1F, 0xFC, 0x1F, 0x80, 0xFF, 0xE0, 0xFF, 0x07,
  0xDF, 0x03, 0xFF, 0xFE, 0xFC, 0x0F, 0xFF, 0xF7, 0xE0, 0x3F, 0xFF, 0xBF,
  0x00, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x1F, 0x00,
  0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x00, 0x3E, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0xF8,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0x07, 0xFE,
  0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00,
  0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9,
  0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00,
  0x7E, 0x1F, 0x00, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC7, 0xC0, 0x0F,
  0xFC, 0xF8, 0x00, 0x3F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xEF, 0x80, 0x03, 0xFD, 0xF0, 0x03, 0xFF,
  0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0x03, 0xF8, 0x1F, 0xE0, 0x03, 0x81, 0xFC, 0x00, 0x04, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x02, 0x03, 0xFF, 0x00, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F,
  0x80, 0x7F, 0xE0, 0xF8, 0x01, 0xFF, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x00,
  0x3F, 0x8F, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFC,
  0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x7E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x8F, 0x80, 0x07, 0xF0,
  0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x7F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC3, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xE0, 0x3E, 0x07, 0xF8, 0x00,
  0xE0, 0xFE, 0x00, 0x02, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7F, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xF8, 0x00, 0x1F, 0x1F,
  0xC0, 0x01, 0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xF0, 0x01, 0xF0, 0x7F, 0xE0,
  0x3F, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC4, 0x00, 0x0F, 0xE7, 0x80, 0x0F, 0xF3, 0xF0, 0x1F, 0xF3,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC,
  0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC1, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x7F, 0xC0, 0x00, 0xFC, 0xFF,
  0x80, 0x03, 0xF0, 0xFF, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0x03, 0xFC,
  0x00, 0xFC, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFF, 0x03, 0xF0, 0x01, 0xFC, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x01, 0xFC, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07,
  0xF0, 0x7F, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0x78, 0x03, 0xFC,
  0x3D, 0xE0, 0x1F, 0xF0, 0xF7, 0xC0, 0x7B, 0xC3, 0xCF, 0x01, 0xEF, 0x0F,
  0x3C, 0x0F, 0xBE, 0x3C, 0xF0, 0x3C, 0xF8, 0xF1, 0xE0, 0xF3, 0xE3, 0xC7,
  0x83, 0xCF, 0x8F, 0x1E, 0x1E, 0x3E, 0x3C, 0x7C, 0x78, 0xF8, 0xF0, 0xF1,
  0xE3, 0xE3, 0xC3, 0xCF, 0x0F, 0x9F, 0x0F, 0xBC, 0x3E, 0x7C, 0x1E, 0xF0,
  0xF9, 0xF0, 0x7F, 0xC3, 0xE7, 0xC1, 0xFE, 0x0F, 0x9F, 0x03, 0xF8, 0x3E,
  0x7C, 0x0F, 0xE0, 0xF9, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0x7C, 0x0F, 0xDF,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xEF, 0x80,
  0x0F, 0xFD, 0xF8, 0x01, 0xFF, 0x9F, 0x00, 0x3F, 0xF3, 0xF0, 0x07, 0xFE,
  0x3E, 0x00, 0xFF, 0xC3, 0xE0, 0x1F, 0xF8, 0x7C, 0x03, 0xFF, 0x07, 0xC0,
  0x7F, 0xE0, 0xF8, 0x0F, 0xFC, 0x1F, 0x81, 0xFF, 0x81, 0xF0, 0x3F, 0xF0,
  0x3F, 0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0x7E, 0x1F, 0xF8, 0x07, 0xC3,
  0xFF, 0x00, 0xF8, 0x7F, 0xE0, 0x0F, 0x8F, 0xFC, 0x01, 0xF1, 0xFF, 0x80,
  0x1F, 0x3F, 0xF0, 0x03, 0xE7, 0xFE, 0x00, 0x3C, 0xFF, 0xC0, 0x07, 0xDF,
  0xF8, 0x00, 0xFB, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x07,
  0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFB,
  0xF0, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x07, 0xE7, 0xC0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0xFE, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xCF, 0xC0, 0x03, 0xFB,
  0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x7F, 0xBF, 0x00, 0x7F,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0,
  0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x00, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x01, 0xFE, 0x07, 0xFC,
  0x01, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0E, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0,
  0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x00,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF0, 0x7F, 0xC0, 0x3E, 0x0F, 0xE0, 0x00, 0xC3, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x20, 0x00, 0x07, 0xE7,
  0x80, 0x01, 0xFC, 0xFE, 0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xF7, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xE3, 0xFE, 0x03,
  0xFC, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E,
  0x07, 0xC0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0x80, 0x01, 0xF0,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x00,
  0x3F, 0x3F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x7C,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x3F, 0x7C, 0x07, 0xC0, 0xF9, 0xF0, 0x3F, 0x03,
  0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x03, 0xF8, 0x3E, 0x7C, 0x1F, 0xE0, 0xF9,
  0xF0, 0x7F, 0x83, 0xE7, 0xC1, 0xEF, 0x0F, 0x9F, 0x0F, 0xBC, 0x3E, 0x7C,
  0x3C, 0xF0, 0xF8, 0xF0, 0xF3, 0xE3, 0xE3, 0xC7, 0xC7, 0x8F, 0x8F, 0x1E,
  0x1E, 0x3E, 0x3C, 0x78, 0x7C, 0xF8, 0xF3, 0xE0, 0xF3, 0xE3, 0xCF, 0x03,
  0xCF, 0x0F, 0x3C, 0x0F, 0xBC, 0x3C, 0xF0, 0x1E, 0xF0, 0xF7, 0x80, 0x7B,
  0xC3, 0xDE, 0x01, 0xFF, 0x0F, 0x78, 0x03, 0xFC, 0x3F, 0xE0, 0x0F, 0xF0,
  0x7F, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x01, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0xFC, 0x03, 0xF0,
  0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x07, 0xE0,
  0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x1F, 0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0xFC, 0x7E, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xF8, 0x07,
  0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x3F, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xBC,
  0x00, 0x00, 0xF0, 0x60, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x10, 0x03, 0x80, 0x7C, 0x0F, 0xE0, 0x7F, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xE0, 0x08, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFB, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFC, 0x01, 0xFF,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xF8,
  0x00, 0xFD, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x7F, 0x80, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x3F, 0x80, 0x1F, 0xC7,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xFB, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x9F, 0x80, 0x0F, 0xE3, 0xF0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xC0, 0x0C, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x7F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x87, 0xE0, 0x3F, 0xFE, 0xFC, 0x0F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0xFF, 0xCF, 0xE0, 0x07, 0xFB, 0xF8, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x07, 0xE7, 0xF8,
  0x00, 0xFC, 0x7F, 0xC0, 0x3F, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0x03, 0xFC, 0x3F, 0xC0, 0x0F, 0xE3, 0xF0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xFC, 0x00, 0x04, 0x1F, 0xF8, 0x03, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x7C,
  0x03, 0xF8, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x3F, 0xC0, 0x1F, 0xCF, 0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x7F,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80,
  0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xFC, 0x0F, 0xFC,
  0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF,
  0xEF, 0xC0, 0x1F, 0xF1, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE3, 0x00, 0x03,
  0xF8, 0x7C, 0x01, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xC7, 0xF8, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x10, 0x01, 0xFC, 0x0E, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0x7F,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF9, 0x80, 0x0F, 0xE7, 0xC0, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x1C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xFC, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x0F,
  0xC0, 0x1F, 0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0xFF, 0x00, 0xFC, 0x1F,
  0xE0, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x0F, 0xCF, 0xE0, 0x00,
  0xFD, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0xFC, 0xFF, 0x00,
  0x0F, 0xC7, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x08, 0x00, 0xFE, 0x07, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0x07, 0xFF, 0xC7, 0xFC, 0x3F,
  0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0x7C, 0x1F,
  0xE1, 0xFB, 0xE0, 0x7E, 0x07, 0xFF, 0x01, 0xF0, 0x3F, 0xF8, 0x0F, 0x80,
  0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF,
  0x80, 0xF8, 0x0F, 0xFC, 0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01,
  0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0,
  0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0x07, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xE7, 0xE0, 0x0F, 0xF3, 0xF0, 0x01, 0xFD, 0xF8, 0x00,
  0x7E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0,
  0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0x7F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xF8, 0x03, 0xFE, 0x3F, 0x00, 0x1F, 0xC7,
  0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xBF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x9F, 0xC0, 0x0F, 0xE3, 0xFE, 0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xE3, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xCF, 0xF0,
  0x01, 0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x81, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xF8, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xBF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xE3, 0xFC, 0x01, 0xF3, 0xF8, 0x00, 0x11, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x40, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x3F,
  0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x0F, 0xF0, 0x1C, 0x01, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF,
  0xF0, 0x0F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x03,
  0xE0, 0x3E, 0x7C, 0x03, 0xE0, 0x3E, 0x7E, 0x03, 0xE0, 0x3E, 0x7E, 0x07,
  0xF0, 0x3E, 0x3E, 0x07, 0xF0, 0x3E, 0x3E, 0x07, 0xF0, 0x3E, 0x3E, 0x0F,
  0xF0, 0x3E, 0x3E, 0x0F, 0xF8, 0x7C, 0x3E, 0x0F, 0xF8, 0x7C, 0x3E, 0x1F,
  0x78, 0x7C, 0x1F, 0x1E, 0x7C, 0x7C, 0x1F, 0x1E, 0x7C, 0x7C, 0x1F, 0x3E,
  0x3C, 0x78, 0x1F, 0x3C, 0x3E, 0x78, 0x1F, 0x7C, 0x1E, 0xF8, 0x1F, 0x7C,
  0x1E, 0xF8, 0x0F, 0x78, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x01, 0xF9, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xC7, 0xC0, 0x00,
  0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x3F,
  0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x0F, 0xDF, 0x80,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x01, 0x01, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC,
  0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x60, 0xFF,
  0xC0, 0x03, 0xCF, 0xFF, 0x80, 0x3E, 0x7F, 0xFF, 0x01, 0xE7, 0xFF, 0xFC,
  0x1F, 0x3E, 0x1F, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0x9E, 0x00, 0x7F, 0xF8,
  0xF0, 0x01, 0xFF, 0x81, 0x80, 0x01, 0xF0, 0x00,
};

const GFXglyph UbuntuMono_Regular69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 10, 44, 35, 12, -43 },
  { 56, 17, 17, 35, 9, -47 },
  { 93, 31, 43, 35, 2, -43 },
  { 260, 27, 55, 35, 4, -48 },
  { 446, 32, 45, 35, 1, -44 },
  { 626, 31, 43, 35, 2, -43 },
  { 793, 6, 18, 35, 14, -47 },
  { 807, 19, 60, 35, 8, -48 },
  { 950, 19, 60, 35, 8, -48 },
  { 1093, 27, 25, 35, 4, -43 },
  { 1178, 28, 31, 35, 3, -34 },
  { 1287, 14, 18, 35, 10, -8 },
  { 1319, 15, 5, 35, 10, -20 },
  { 1329, 10, 9, 35, 12, -8 },
  { 1341, 25, 59, 35, 5, -48 },
  { 1526, 28, 45, 35, 3, -44 },
  { 1684, 25, 43, 35, 5, -43 },
  { 1819, 27, 44, 35, 4, -44 },
  { 1968, 27, 45, 35, 4, -44 },
  { 2120, 30, 43, 35, 2, -43 },
  { 2282, 26, 44, 35, 5, -43 },
  { 2425, 27, 44, 35, 4, -43 },
  { 2574, 27, 43, 35, 4, -43 },
  { 2720, 27, 45, 35, 4, -44 },
  { 2872, 27, 44, 35, 4, -44 },
  { 3021, 10, 31, 35, 12, -30 },
  { 3060, 14, 40, 35, 9, -30 },
  { 3130, 29, 27, 35, 3, -31 },
  { 3228, 28, 18, 35, 3, -27 },
  { 3291, 29, 27, 35, 3, -31 },
  { 3389, 22, 45, 35, 6, -44 },
  { 3513, 29, 52, 35, 3, -43 },
  { 3702, 33, 43, 35, 1, -43 },
  { 3880, 27, 43, 35, 4, -43 },
  { 4026, 29, 43, 35, 3, -43 },
  { 4182, 28, 43, 35, 4, -43 },
  { 4333, 26, 43, 35, 6, -43 },
  { 4473, 25, 43, 35, 6, -43 },
  { 4608, 28, 43, 35, 3, -43 },
  { 4759, 28, 43, 35, 3, -43 },
  { 4910, 22, 43, 35, 6, -43 },
  { 5029, 25, 43, 35, 4, -43 },
  { 5164, 30, 43, 35, 4, -43 },
  { 5326, 26, 43, 35, 6, -43 },
  { 5466, 30, 43, 35, 2, -43 },
  { 5628, 27, 43, 35, 4, -43 },
  { 5774, 31, 43, 35, 2, -43 },
  { 5941, 26, 43, 35, 5, -43 },
  { 6081, 31, 54, 35, 2, -43 },
  { 6291, 28, 43, 35, 4, -43 },
  { 6442, 27, 43, 35, 4, -43 },
  { 6588, 29, 43, 35, 3, -43 },
  { 6744, 28, 43, 35, 3, -43 },
  { 6895, 33, 43, 35, 1, -43 },
  { 7073, 30, 43, 35, 2, -43 },
  { 7235, 31, 43, 35, 2, -43 },
  { 7402, 33, 43, 35, 1, -43 },
  { 7580, 27, 43, 35, 4, -43 },
  { 7726, 16, 59, 35, 10, -48 },
  { 7844, 25, 59, 35, 5, -48 },
  { 8029, 17, 59, 35, 8, -48 },
  { 8155, 29, 23, 35, 3, -43 },
  { 8239, 33, 5, 35, 1, 7 },
  { 8260, 12, 12, 35, 11, -48 },
  { 8278, 26, 32, 35, 4, -32 },
  { 8382, 27, 48, 35, 5, -48 },
  { 8544, 28, 32, 35, 3, -32 },
  { 8656, 27, 48, 35, 3, -48 },
  { 8818, 28, 32, 35, 3, -32 },
  { 8930, 29, 48, 35, 4, -48 },
  { 9104, 27, 43, 35, 3, -32 },
  { 9250, 25, 48, 35, 5, -48 },
  { 9400, 27, 45, 35, 4, -45 },
  { 9552, 22, 56, 35, 5, -45 },
  { 9706, 28, 48, 35, 5, -48 },
  { 9874, 27, 48, 35, 4, -48 },
  { 10036, 29, 32, 35, 3, -32 },
  { 10152, 25, 32, 35, 5, -32 },
  { 10252, 29, 32, 35, 3, -32 },
  { 10368, 27, 43, 35, 5, -32 },
  { 10514, 27, 43, 35, 3, -32 },
  { 10660, 23, 32, 35, 7, -32 },
  { 10752, 25, 32, 35, 5, -32 },
  { 10852, 27, 42, 35, 4, -42 },
  { 10994, 25, 32, 35, 5, -32 },
  { 11094, 30, 32, 35, 2, -32 },
  { 11214, 32, 32, 35, 1, -32 },
  { 11342, 31, 32, 35, 2, -32 },
  { 11466, 30, 43, 35, 2, -32 },
  { 11628, 24, 32, 35, 5, -32 },
  { 11724, 24, 59, 35, 5, -48 },
  { 11901, 5, 59, 35, 15, -48 },
  { 11938, 24, 59, 35, 5, -48 },
  { 12115, 29, 10, 35, 3, -23 },
};

const GFXfont UbuntuMono_Regular69pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular69pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular69pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _UBUNTUMONO_REGULAR69PT7B_H_
