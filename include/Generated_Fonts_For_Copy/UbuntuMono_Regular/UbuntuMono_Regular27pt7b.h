#ifndef _UBUNTUMONO_REGULAR27PT7B_H_
#define _UBUNTUMONO_REGULAR27PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 27pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular27pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x0E, 0xEE, 0x60, 0xE7, 0xCD,
  0x9A, 0x34, 0x68, 0xD1, 0x80, 0x0C, 0x60, 0xC6, 0x18, 0xC1, 0x8C, 0xFF,
  0xFF, 0xFF, 0x18, 0xC3, 0x18, 0x31, 0x83, 0x18, 0x31, 0x8F, 0xFF, 0xFF,
  0xF6, 0x30, 0x63, 0x06, 0x30, 0x63, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x0F,
  0xC3, 0xFC, 0xE0, 0x98, 0x03, 0x00, 0x70, 0x0F, 0x80, 0xFC, 0x07, 0xE0,
  0x1C, 0x01, 0xC0, 0x18, 0x03, 0x40, 0xEF, 0xF8, 0xFE, 0x03, 0x00, 0x60,
  0x0C, 0x00, 0x38, 0x1B, 0x61, 0x91, 0x19, 0x88, 0xCC, 0x4C, 0x22, 0x61,
  0xB6, 0x07, 0x60, 0x03, 0x00, 0x37, 0x81, 0x26, 0x1B, 0x31, 0x99, 0x8C,
  0xCC, 0xC6, 0x64, 0x13, 0x60, 0xF0, 0x1E, 0x03, 0xF0, 0x73, 0x86, 0x18,
  0x61, 0x86, 0x30, 0x37, 0x03, 0xE0, 0x3C, 0x66, 0xE6, 0xE7, 0x4C, 0x3C,
  0xC1, 0xCC, 0x1C, 0xE3, 0xE7, 0xF6, 0x3C, 0x70, 0xFF, 0xFC, 0x06, 0x1C,
  0x71, 0xC3, 0x0E, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x1C, 0x18, 0x30,
  0x70, 0x60, 0xE0, 0xE0, 0xE0, 0xC0, 0x41, 0xC1, 0xC1, 0xC1, 0xC1, 0x83,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x0C, 0x38, 0xE3, 0x8E,
  0x08, 0x00, 0x0C, 0x03, 0x08, 0xCB, 0xEF, 0x7F, 0x07, 0x03, 0x61, 0xCC,
  0x73, 0x88, 0x80, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x61, 0xFF, 0xFF,
  0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x39, 0xDE, 0x71, 0x9F,
  0xD8, 0xFF, 0xF0, 0xEF, 0xFE, 0x01, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01, 0x80,
  0xE0, 0x30, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x00, 0x0F, 0x07,
  0xF1, 0xC7, 0x30, 0x66, 0x0F, 0xC0, 0xF9, 0x9F, 0x73, 0xEE, 0x7C, 0xCF,
  0x81, 0xF0, 0x36, 0x0E, 0xC1, 0xDC, 0x71, 0xFC, 0x1F, 0x00, 0x06, 0x07,
  0x87, 0xE3, 0xF8, 0x4E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE1, 0xFF, 0x7F, 0xC0, 0x3E, 0x3F, 0xCC, 0x3A,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x18, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0x7E, 0x3F, 0xC4, 0x38, 0x06, 0x01,
  0x80, 0x60, 0x30, 0x78, 0x1F, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x78,
  0x3B, 0xFE, 0x7E, 0x00, 0x01, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x0D, 0xC1,
  0x9C, 0x19, 0xC3, 0x1C, 0x61, 0xC6, 0x1C, 0xC1, 0xCF, 0xFF, 0xFF, 0xF0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x7F, 0x9F, 0xE6, 0x01, 0x80, 0x60,
  0x18, 0x07, 0xC1, 0xFC, 0x07, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x78,
  0x3B, 0xFE, 0x7E, 0x00, 0x01, 0xC1, 0xF8, 0x78, 0x1C, 0x03, 0x00, 0xC0,
  0x1F, 0xE3, 0xFE, 0xE0, 0xFC, 0x1F, 0x81, 0xB0, 0x36, 0x06, 0xC1, 0xDC,
  0x71, 0xFE, 0x1F, 0x00, 0xFF, 0xFF, 0xF0, 0x1C, 0x06, 0x03, 0x80, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xE0,
  0x38, 0x00, 0x1F, 0x07, 0xF9, 0xC3, 0x30, 0x76, 0x06, 0xC1, 0xDC, 0x31,
  0xFC, 0x1F, 0x86, 0x79, 0x83, 0xF0, 0x3E, 0x07, 0xC0, 0xDC, 0x3B, 0xFE,
  0x1F, 0x80, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x7E, 0x0F, 0xC0, 0xF8, 0x1B,
  0x03, 0x70, 0xE7, 0xFC, 0x7D, 0x80, 0x60, 0x0C, 0x03, 0x01, 0xE3, 0xF0,
  0x78, 0x00, 0xEF, 0xFE, 0x00, 0x00, 0x0E, 0xFF, 0xE0, 0x38, 0xF3, 0xCE,
  0x00, 0x00, 0x00, 0x00, 0x63, 0xCF, 0x3C, 0x63, 0xBC, 0x60, 0x00, 0x20,
  0x3C, 0x1F, 0x0F, 0x8F, 0x81, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3C,
  0x00, 0x80, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8,
  0x40, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xC0, 0xF8, 0x7C, 0x3E,
  0x1E, 0x01, 0x00, 0x00, 0x3E, 0x3F, 0x90, 0xE0, 0x30, 0x18, 0x1C, 0x1C,
  0x1C, 0x0C, 0x0C, 0x06, 0x00, 0x00, 0x00, 0xC0, 0xF0, 0x78, 0x18, 0x00,
  0x0F, 0x81, 0xFC, 0x38, 0xE7, 0x06, 0x60, 0x76, 0x07, 0xE3, 0xFC, 0x7F,
  0xCE, 0x7C, 0xC7, 0xCC, 0x7C, 0xC7, 0xCC, 0x7E, 0xE7, 0x67, 0xF6, 0x3E,
  0x70, 0x03, 0x00, 0x3C, 0x01, 0xFC, 0x07, 0xC0, 0x07, 0x00, 0x3C, 0x03,
  0xE0, 0x1B, 0x00, 0xCC, 0x0E, 0x60, 0x63, 0x03, 0x1C, 0x18, 0x61, 0x83,
  0x0C, 0x1C, 0x7F, 0xE7, 0xFF, 0x30, 0x19, 0x80, 0xEC, 0x03, 0xE0, 0x18,
  0xFF, 0x1F, 0xF3, 0x87, 0x70, 0x6E, 0x0D, 0xC1, 0xB8, 0x77, 0xFC, 0xFF,
  0x9C, 0x3B, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x7F, 0xFE, 0xFF, 0x00,
  0x07, 0xC3, 0xFC, 0xE0, 0xB8, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0E, 0x08, 0xFF, 0x0F, 0xC0,
  0xFE, 0x1F, 0xF3, 0x8F, 0x70, 0x6E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x0F, 0xC1, 0xB8, 0xF7, 0xFC, 0xFE, 0x00,
  0xFF, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFE, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03,
  0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x00, 0x07, 0xC3, 0xFC, 0xE0,
  0xB8, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x0F, 0x81, 0xB0,
  0x36, 0x06, 0xE0, 0xCE, 0x18, 0xFF, 0x0F, 0xE0, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x60, 0xFF, 0xFF, 0xC3, 0x01,
  0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60,
  0x31, 0xFF, 0xFF, 0x80, 0x3F, 0xCF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x34, 0x1D, 0xFE,
  0x3F, 0x00, 0xC0, 0xD8, 0x3B, 0x0E, 0x63, 0x8C, 0xE1, 0x9C, 0x37, 0x07,
  0xC0, 0xF8, 0x1B, 0x83, 0x38, 0x63, 0x8C, 0x39, 0x83, 0x30, 0x76, 0x07,
  0xC0, 0xE0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0xFF, 0xFF, 0xC0,
  0x60, 0xE7, 0x0E, 0x70, 0xE5, 0x1E, 0x51, 0xED, 0x96, 0xDB, 0x6C, 0xB6,
  0xCE, 0x6C, 0xE6, 0xC6, 0x6C, 0x06, 0xC0, 0x6C, 0x06, 0xC0, 0x7C, 0x07,
  0xC0, 0x70, 0xE0, 0x7E, 0x0F, 0xC1, 0xFC, 0x3F, 0x87, 0xD8, 0xFB, 0x1F,
  0x33, 0xE6, 0x7C, 0x4F, 0x8D, 0xF1, 0xBE, 0x1F, 0xC3, 0xF8, 0x3F, 0x07,
  0xE0, 0x60, 0x1F, 0x03, 0xFC, 0x71, 0xC6, 0x0E, 0xE0, 0x6C, 0x06, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xE0, 0x66, 0x0E, 0x71,
  0xC3, 0xFC, 0x1F, 0x00, 0xFE, 0x3F, 0xEC, 0x1F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC1, 0xFF, 0xEF, 0xE3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x00, 0x1F, 0x03, 0xFC, 0x71, 0xC6, 0x0E, 0xE0, 0x6C, 0x06, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xE0, 0x66, 0x0E, 0x71,
  0xC3, 0xFC, 0x1F, 0x00, 0x60, 0x07, 0x80, 0x3E, 0x00, 0xE0, 0xFF, 0x0F,
  0xF8, 0xE1, 0xCE, 0x0C, 0xE0, 0xEE, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCF,
  0xF8, 0xFF, 0x0E, 0x30, 0xE1, 0x8E, 0x1C, 0xE0, 0xCE, 0x0E, 0xE0, 0x60,
  0x1F, 0x87, 0xF9, 0xC1, 0x30, 0x06, 0x00, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0x80, 0x30, 0x06, 0x00, 0xD0, 0x3B, 0xFE, 0x3F, 0x00,
  0xFF, 0xFF, 0xFC, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC1, 0xDC, 0x39, 0xFE, 0x1F, 0x00,
  0xE0, 0x1B, 0x00, 0xD8, 0x0E, 0xE0, 0x67, 0x03, 0x18, 0x38, 0xC1, 0x87,
  0x0C, 0x18, 0x60, 0xC7, 0x06, 0x30, 0x19, 0x80, 0xDC, 0x06, 0xC0, 0x3E,
  0x00, 0xF0, 0x07, 0x00, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0x6C,
  0x06, 0xC6, 0x6C, 0xE6, 0xCE, 0x6C, 0xB6, 0xDB, 0x6D, 0x96, 0x51, 0xE5,
  0x1E, 0x70, 0xE7, 0x0E, 0x60, 0xC0, 0xE0, 0x66, 0x0E, 0x70, 0xC3, 0x1C,
  0x39, 0x81, 0xB8, 0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x1F, 0x01, 0xB8,
  0x31, 0xC7, 0x0C, 0x60, 0xEE, 0x06, 0xC0, 0x70, 0x60, 0x1B, 0x01, 0xDC,
  0x0C, 0x60, 0xE3, 0x86, 0x0C, 0x70, 0x73, 0x01, 0xB8, 0x0F, 0x80, 0x3C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x00,
  0x7F, 0xEF, 0xFC, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x00, 0xC0, 0x30, 0x0E,
  0x01, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x3F, 0xFC, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18,
  0x06, 0x00, 0xC0, 0x30, 0x0C, 0x01, 0x80, 0x60, 0x18, 0xFF, 0xFC, 0x18,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06,
  0x0C, 0x1F, 0xFF, 0xE0, 0x0E, 0x01, 0xE0, 0x7C, 0x0D, 0xC3, 0x98, 0x61,
  0x98, 0x37, 0x03, 0x40, 0x60, 0xFF, 0xFF, 0xFF, 0xC0, 0x47, 0x1C, 0x71,
  0x00, 0x7E, 0x1F, 0xE0, 0x38, 0x07, 0x01, 0xCF, 0xFF, 0xFF, 0x87, 0xC1,
  0xF0, 0x7E, 0x1F, 0xFF, 0x3F, 0xC0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0D, 0xE3, 0xFE, 0xE1, 0xB0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x07, 0xC3, 0xBF, 0xE7, 0xE0, 0x0F, 0xC7, 0xFD, 0xE0, 0xB8, 0x06,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xE0, 0x9F, 0xF0, 0xFC,
  0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC7, 0xF9, 0xFF, 0x70,
  0xEC, 0x1F, 0x83, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x3B, 0x07, 0x70, 0xE7,
  0xFC, 0x7F, 0x00, 0x0F, 0x07, 0xF9, 0xC3, 0xB0, 0x3C, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xE0, 0x0C, 0x01, 0xC1, 0x1F, 0xE0, 0xFC, 0x07, 0xC3, 0xFC,
  0x70, 0x9C, 0x03, 0x80, 0x70, 0x3F, 0xF7, 0xFE, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x00,
  0x1F, 0xC7, 0xFD, 0xC3, 0xB0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0,
  0xEC, 0x1D, 0xC3, 0x9F, 0xF1, 0xFE, 0x01, 0x90, 0x73, 0xFC, 0x7F, 0x00,
  0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xE3, 0xFC, 0xC3, 0xB0,
  0x6C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1C,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x71, 0x07, 0xE0,
  0x7C, 0x07, 0x07, 0x07, 0x00, 0x00, 0x7F, 0x7F, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x87, 0xFE, 0x7C, 0xC0,
  0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x76, 0x1C, 0xC7, 0x19,
  0xC3, 0x70, 0x7C, 0x0F, 0x81, 0xB8, 0x33, 0x86, 0x38, 0xC3, 0x98, 0x3B,
  0x03, 0x80, 0xFC, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0E, 0x20, 0xFC, 0x0F, 0x80, 0x7B, 0xCF, 0xFE, 0xCE, 0x6C, 0x67, 0xC6,
  0x7C, 0x67, 0xC6, 0x7C, 0x67, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x70, 0x7E, 0x3F, 0xEC, 0x3B, 0x06, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xC0, 0x1F, 0x07, 0xF9, 0xC7, 0x30, 0x7E,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0x6C, 0x1D, 0xC7, 0x1F, 0xE1, 0xF0,
  0xFE, 0x3F, 0xEC, 0x3B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x7E, 0x1B, 0xFE, 0xDE, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x00, 0x0F, 0xC7,
  0xFD, 0xC3, 0xB0, 0x7E, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xE0, 0xEC, 0x1D,
  0xC3, 0x9F, 0xF1, 0xFE, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x7F, 0xFF,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x3F, 0x9F, 0xEE, 0x0B, 0x00, 0xE0, 0x1E, 0x03, 0xF0, 0x1E, 0x01,
  0xC0, 0x7C, 0x1F, 0xFE, 0x7F, 0x00, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0xFF,
  0xFF, 0xF3, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01,
  0x84, 0x7F, 0x0F, 0x80, 0xC1, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0x7E, 0x1D, 0xFF, 0x3F, 0x80, 0xC0, 0x7E, 0x06,
  0x60, 0x66, 0x0E, 0x70, 0xC3, 0x0C, 0x31, 0x83, 0x98, 0x1B, 0x81, 0xB0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x63, 0xC6,
  0x2C, 0xE6, 0xCF, 0x6C, 0xB6, 0x79, 0x67, 0x9E, 0x71, 0xC7, 0x0C, 0x60,
  0xC0, 0xE0, 0x67, 0x0C, 0x31, 0xC3, 0xB8, 0x1F, 0x00, 0xE0, 0x0E, 0x00,
  0xF0, 0x1B, 0x83, 0x98, 0x70, 0xC6, 0x0E, 0xC0, 0x60, 0xE0, 0x6C, 0x0D,
  0x83, 0xB8, 0x73, 0x0C, 0x61, 0x8E, 0x70, 0xCC, 0x1D, 0x81, 0xF0, 0x3C,
  0x03, 0x80, 0x60, 0x0C, 0x03, 0x07, 0xE0, 0xF0, 0x00, 0xFF, 0xBF, 0xE0,
  0x38, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0xE0, 0x30, 0x1C, 0x0E, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xC3, 0xF1, 0xC0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x03, 0x83, 0xC0, 0xF0, 0x0E, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x01, 0x80, 0x60, 0x1C, 0x03, 0xF0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xF8, 0x7E, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0x01, 0x80, 0xF0, 0x78, 0x30, 0x38, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC7, 0xE3, 0xE0, 0x38, 0x37, 0xE6, 0xC7, 0xEC, 0x3C,
};

const GFXglyph UbuntuMono_Regular27pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 7, 7, 14, 3, -18 },
  { 17, 12, 17, 14, 1, -17 },
  { 43, 11, 22, 14, 1, -19 },
  { 74, 13, 17, 14, 0, -17 },
  { 102, 12, 17, 14, 1, -17 },
  { 128, 2, 7, 14, 6, -18 },
  { 130, 7, 22, 14, 3, -17 },
  { 150, 7, 22, 14, 3, -17 },
  { 170, 10, 10, 14, 2, -17 },
  { 183, 11, 12, 14, 1, -13 },
  { 200, 5, 8, 14, 4, -4 },
  { 205, 6, 2, 14, 4, -8 },
  { 207, 4, 4, 14, 5, -4 },
  { 209, 10, 23, 14, 2, -19 },
  { 238, 11, 17, 14, 1, -17 },
  { 262, 10, 17, 14, 2, -17 },
  { 284, 10, 17, 14, 2, -17 },
  { 306, 10, 17, 14, 2, -17 },
  { 328, 12, 17, 14, 1, -17 },
  { 354, 10, 17, 14, 2, -17 },
  { 376, 11, 17, 14, 1, -17 },
  { 400, 10, 17, 14, 2, -17 },
  { 422, 11, 17, 14, 1, -17 },
  { 446, 11, 17, 14, 1, -17 },
  { 470, 4, 13, 14, 5, -13 },
  { 477, 6, 17, 14, 3, -13 },
  { 490, 11, 11, 14, 1, -12 },
  { 506, 11, 7, 14, 1, -10 },
  { 516, 11, 11, 14, 1, -12 },
  { 532, 9, 17, 14, 2, -17 },
  { 552, 12, 21, 14, 1, -17 },
  { 584, 13, 17, 14, 0, -17 },
  { 612, 11, 17, 14, 1, -17 },
  { 636, 11, 17, 14, 1, -17 },
  { 660, 11, 17, 14, 1, -17 },
  { 684, 10, 17, 14, 2, -17 },
  { 706, 10, 17, 14, 2, -17 },
  { 728, 11, 17, 14, 1, -17 },
  { 752, 11, 17, 14, 1, -17 },
  { 776, 9, 17, 14, 2, -17 },
  { 796, 10, 17, 14, 1, -17 },
  { 818, 11, 17, 14, 2, -17 },
  { 842, 10, 17, 14, 2, -17 },
  { 864, 12, 17, 14, 1, -17 },
  { 890, 11, 17, 14, 1, -17 },
  { 914, 12, 17, 14, 1, -17 },
  { 940, 10, 17, 14, 2, -17 },
  { 962, 12, 21, 14, 1, -17 },
  { 994, 12, 17, 14, 1, -17 },
  { 1020, 11, 17, 14, 1, -17 },
  { 1044, 11, 17, 14, 1, -17 },
  { 1068, 11, 17, 14, 1, -17 },
  { 1092, 13, 17, 14, 0, -17 },
  { 1120, 12, 17, 14, 1, -17 },
  { 1146, 12, 17, 14, 1, -17 },
  { 1172, 13, 17, 14, 0, -17 },
  { 1200, 11, 17, 14, 1, -17 },
  { 1224, 6, 21, 14, 4, -17 },
  { 1240, 10, 23, 14, 2, -19 },
  { 1269, 7, 21, 14, 3, -17 },
  { 1288, 11, 9, 14, 1, -17 },
  { 1301, 13, 2, 14, 0, 3 },
  { 1305, 5, 5, 14, 4, -19 },
  { 1309, 10, 13, 14, 2, -13 },
  { 1326, 10, 19, 14, 2, -19 },
  { 1350, 11, 13, 14, 1, -13 },
  { 1368, 11, 19, 14, 1, -19 },
  { 1395, 11, 13, 14, 1, -13 },
  { 1413, 11, 19, 14, 2, -19 },
  { 1440, 11, 17, 14, 1, -13 },
  { 1464, 10, 19, 14, 2, -19 },
  { 1488, 11, 18, 14, 1, -18 },
  { 1513, 8, 22, 14, 2, -18 },
  { 1535, 11, 19, 14, 2, -19 },
  { 1562, 11, 19, 14, 1, -19 },
  { 1589, 12, 13, 14, 1, -13 },
  { 1609, 10, 13, 14, 2, -13 },
  { 1626, 11, 13, 14, 1, -13 },
  { 1644, 10, 17, 14, 2, -13 },
  { 1666, 11, 17, 14, 1, -13 },
  { 1690, 9, 13, 14, 3, -13 },
  { 1705, 10, 13, 14, 2, -13 },
  { 1722, 10, 17, 14, 2, -17 },
  { 1744, 10, 13, 14, 2, -13 },
  { 1761, 12, 13, 14, 1, -13 },
  { 1781, 12, 13, 14, 1, -13 },
  { 1801, 12, 13, 14, 1, -13 },
  { 1821, 11, 17, 14, 1, -13 },
  { 1845, 10, 13, 14, 2, -13 },
  { 1862, 10, 23, 14, 2, -19 },
  { 1891, 2, 23, 14, 6, -19 },
  { 1897, 9, 23, 14, 2, -19 },
  { 1923, 12, 4, 14, 1, -9 },
};

const GFXfont UbuntuMono_Regular27pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular27pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular27pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _UBUNTUMONO_REGULAR27PT7B_H_
