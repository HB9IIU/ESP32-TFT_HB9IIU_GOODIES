#ifndef _UBUNTUMONO_REGULAR61PT7B_H_
#define _UBUNTUMONO_REGULAR61PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular61pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7E, 0x3C, 0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83,
  0xFE, 0x07, 0xFC, 0x0F, 0x78, 0x1E, 0xF0, 0x3D, 0xE0, 0x7B, 0xC0, 0xF7,
  0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07, 0x00, 0x00, 0x78, 0x0F, 0x80,
  0x0F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00, 0x7C, 0x07, 0x80, 0x0F, 0x81,
  0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x3E, 0x07, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x1F, 0x00, 0x1F,
  0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0x78, 0x0F, 0x80, 0x1F, 0x01, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xE0,
  0x3E, 0x00, 0x7C, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xF0, 0x1E, 0x00, 0x3E, 0x03,
  0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x03, 0xE0, 0x07,
  0xC0, 0x78, 0x00, 0xF8, 0x0F, 0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x3F,
  0xC0, 0x7C, 0x3F, 0x00, 0x08, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x60, 0x00, 0x7E, 0x7C, 0x01, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF1, 0xFE, 0x00, 0x1E,
  0x3F, 0xF0, 0x03, 0xC7, 0x8F, 0x00, 0x7C, 0x78, 0x78, 0x07, 0x8F, 0x07,
  0x80, 0xF8, 0xF0, 0x78, 0x0F, 0x0F, 0x07, 0x81, 0xE0, 0xF0, 0x38, 0x3E,
  0x0F, 0x03, 0x83, 0xC0, 0xF0, 0x38, 0x7C, 0x0F, 0x07, 0x87, 0x80, 0xF0,
  0x78, 0xF0, 0x07, 0x07, 0x9F, 0x00, 0x78, 0x79, 0xE0, 0x07, 0x8F, 0x3E,
  0x00, 0x3F, 0xF3, 0xC0, 0x01, 0xFE, 0x78, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x00, 0xF1, 0xF0, 0x00, 0x1E, 0x3F, 0xC0, 0x01, 0xE7, 0xFE, 0x00, 0x3C,
  0xF9, 0xE0, 0x07, 0xCF, 0x0F, 0x00, 0x78, 0xE0, 0xF0, 0x0F, 0x1E, 0x0F,
  0x00, 0xF1, 0xE0, 0x70, 0x1E, 0x1E, 0x07, 0x03, 0xE1, 0xE0, 0x70, 0x3C,
  0x1E, 0x07, 0x07, 0x81, 0xE0, 0x70, 0xF8, 0x1E, 0x0F, 0x0F, 0x00, 0xE0,
  0xF1, 0xF0, 0x0F, 0x0F, 0x1E, 0x00, 0xF1, 0xE3, 0xC0, 0x07, 0xFE, 0x7C,
  0x00, 0x3F, 0xC7, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xC0, 0x7C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0,
  0x03, 0xC0, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0xFC, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x3E, 0x07, 0xFC,
  0x07, 0xC1, 0xFF, 0xC0, 0xF0, 0x7E, 0xFC, 0x1E, 0x0F, 0x8F, 0xC3, 0xC3,
  0xE0, 0xFC, 0x78, 0x7C, 0x0F, 0xDF, 0x1F, 0x00, 0xFF, 0xC3, 0xE0, 0x0F,
  0xF8, 0x7C, 0x00, 0xFF, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x87, 0xE0, 0x0F, 0xF0, 0x7E, 0x03, 0xFF, 0x0F, 0xF1, 0xFF,
  0xF0, 0xFF, 0xFF, 0x3E, 0x0F, 0xFF, 0xC7, 0xE0, 0xFF, 0xF0, 0x7C, 0x07,
  0xF0, 0x0F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xEF, 0x7B,
  0xCE, 0x00, 0x04, 0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x01, 0xC0, 0x00, 0x40, 0x20, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x1F, 0x00, 0x07, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x20, 0x3C, 0x06, 0x3C, 0x3C, 0x1E, 0x7F, 0x1C, 0x7E, 0x7F,
  0xDD, 0xFF, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xF7, 0x80, 0x03, 0xE7, 0xC0, 0x07,
  0xE3, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0x81, 0xF0, 0x07,
  0x80, 0xE0, 0x01, 0x00, 0xC0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x03, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x01, 0xF0, 0x3E, 0x07, 0xE3, 0xFC, 0xFF, 0x8F, 0xF0,
  0x7C, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3E, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01,
  0xFC, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00, 0xFC,
  0x7E, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xDF, 0x80, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xF0, 0x38,
  0x3F, 0xF8, 0x3E, 0x1F, 0xFC, 0x3F, 0x87, 0xFE, 0x1F, 0xC3, 0xFF, 0x0F,
  0xE1, 0xFF, 0x87, 0xF0, 0xFF, 0xC1, 0xF0, 0xFF, 0xE0, 0x70, 0x7F, 0xF0,
  0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7E, 0x00, 0xF8, 0x1F, 0x00, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00,
  0x1F, 0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xEF, 0x80, 0xFF, 0x3E, 0x03, 0xF0,
  0xF8, 0x07, 0x83, 0xE0, 0x10, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0xFF, 0x03, 0xF8, 0x7C, 0x00,
  0xFC, 0x38, 0x00, 0xFC, 0x10, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF,
  0xFF, 0x03, 0xFC, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x07, 0xC0, 0x7F, 0x04, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0xC0, 0x01, 0xFD,
  0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x3C, 0x07, 0xC0, 0x1F, 0x01, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x78, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x0F,
  0x00, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xE0, 0x01, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7E, 0x40, 0x01, 0xFC, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0x80,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x7F, 0x80, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFF, 0x01, 0xFE, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x7E,
  0x1F, 0xC1, 0xFC, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x1F, 0x81, 0xFC,
  0x3F, 0x00, 0x7E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0x7E, 0x00, 0x3E,
  0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0xE1, 0xF8,
  0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x0F, 0xDF, 0xF8,
  0x1F, 0x03, 0xFC, 0x3E, 0x00, 0xFE, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x7E,
  0x3F, 0x80, 0xFE, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF8, 0x3F, 0x81, 0xF8, 0x3F, 0x00, 0xFC, 0x7E, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3F, 0x80, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x3F, 0xBF,
  0xDF, 0xFF, 0xFF, 0xF9, 0xFC, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3, 0xFB, 0xFD, 0xFF,
  0xFF, 0xFF, 0x9F, 0xC7, 0xC0, 0x07, 0xC0, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F,
  0xF1, 0xFE, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7F, 0x03,
  0xE0, 0x3E, 0x0F, 0xC3, 0xF8, 0xFF, 0x8F, 0xE0, 0xFC, 0x0E, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x07, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x0F, 0xFF, 0xC3, 0xFF, 0xFE, 0x7F, 0xFF, 0xCF, 0x01, 0xFC,
  0x80, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x03, 0xF0,
  0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x1F, 0x00, 0x01, 0xE3,
  0xC0, 0x0F, 0xFE, 0xF8, 0x07, 0xFF, 0xDF, 0x01, 0xFF, 0xFB, 0xE0, 0x7F,
  0xFF, 0x7C, 0x1F, 0x83, 0xEF, 0x87, 0xE0, 0x7D, 0xF0, 0xF8, 0x0F, 0xBC,
  0x1F, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0xF8, 0x07, 0xFE, 0x1F, 0x00,
  0xFF, 0xC3, 0xE0, 0x1F, 0xF8, 0x7C, 0x03, 0xEF, 0x0F, 0x80, 0x7D, 0xF0,
  0xF0, 0x0F, 0xBE, 0x1F, 0x01, 0xF7, 0xC3, 0xE0, 0x3E, 0xF8, 0x7E, 0x07,
  0xDF, 0x07, 0xE0, 0xFB, 0xE0, 0x7F, 0xFF, 0x3E, 0x0F, 0xFF, 0xE7, 0xC0,
  0x7F, 0xFC, 0xFC, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x40, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00,
  0x00, 0xF8, 0xF0, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE0, 0xF0, 0x00, 0x1E, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x80,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x07, 0x80, 0x3C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF,
  0x83, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7C, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xFF, 0x0F, 0x80, 0x7F, 0x87, 0xC0, 0x0F, 0xE3, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xE1,
  0xF0, 0x0F, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xC7, 0xC0, 0x03, 0xF3, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xE0,
  0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0x7C, 0x01, 0xFF, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x7F, 0x81, 0xF0, 0x7E, 0x00, 0x18, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x01, 0x07, 0xFC, 0x07, 0x81, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F,
  0x80, 0xFF, 0x07, 0xC0, 0x1F, 0xC3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xFC,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF9,
  0xF0, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0x7C, 0x07, 0xF8, 0x3F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x7F, 0x81, 0xF0, 0x7F, 0x00, 0x10, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF,
  0x80, 0x01, 0xF7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x0F, 0x87, 0xF8, 0x0F, 0xC1, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x10, 0x00, 0x7E, 0x38, 0x01, 0xF8, 0xFC, 0x0F, 0xF1, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0xF8,
  0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x03, 0xE0, 0xFC,
  0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xEF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0xFB, 0xFC, 0x00, 0x3E, 0x7F, 0x80, 0x0F, 0x87, 0xF0,
  0x03, 0xE0, 0xFE, 0x00, 0xF8, 0x1F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80,
  0x7E, 0x03, 0xE0, 0x1F, 0xC0, 0xF8, 0x03, 0xF8, 0x3E, 0x00, 0x7E, 0x0F,
  0x80, 0x0F, 0xC3, 0xE0, 0x03, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0xBE, 0x00,
  0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F,
  0x83, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0xFF, 0x0E, 0xE0, 0x1F, 0xE1, 0xDE,
  0x03, 0xFC, 0x3B, 0xC0, 0x77, 0x87, 0x38, 0x1E, 0xF0, 0xE7, 0x83, 0xDE,
  0x3C, 0xF0, 0x73, 0xC7, 0x9E, 0x1E, 0x78, 0xF1, 0xE3, 0xCF, 0x1E, 0x3C,
  0x71, 0xE3, 0xC7, 0x9E, 0x3C, 0x78, 0x73, 0xC7, 0x8F, 0x0F, 0x78, 0xF9,
  0xE1, 0xEE, 0x1F, 0x3C, 0x1F, 0xC3, 0xE7, 0x83, 0xF8, 0x7C, 0xF0, 0x7E,
  0x0F, 0x9E, 0x07, 0xC1, 0xF3, 0xC0, 0xF8, 0x3E, 0x78, 0x00, 0x07, 0xCF,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x1E, 0xF8,
  0x00, 0x03, 0xDF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x0F, 0xFB,
  0xE0, 0x0F, 0xFB, 0xE0, 0x0F, 0xF9, 0xF0, 0x0F, 0xF9, 0xF0, 0x0F, 0xF8,
  0xF8, 0x0F, 0xF8, 0xF8, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8, 0x7C, 0x0F, 0xF8,
  0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x1E, 0x0F, 0xF8, 0x1F, 0x0F, 0xF8,
  0x0F, 0x0F, 0xF8, 0x0F, 0x8F, 0xF8, 0x07, 0x8F, 0xF8, 0x07, 0xCF, 0xF8,
  0x03, 0xCF, 0xF8, 0x03, 0xCF, 0xF8, 0x01, 0xEF, 0xF8, 0x01, 0xEF, 0xF8,
  0x01, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1,
  0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7D, 0xF0, 0x00,
  0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0xF8,
  0x03, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x03, 0xF8, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFC, 0x0F, 0xE0, 0x3F, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xC1, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0x8F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x3F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x1F, 0xC0,
  0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xC0, 0x3F, 0xFE, 0x00, 0x7F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0x80, 0x3F, 0x87,
  0xC0, 0x07, 0xE3, 0xE0, 0x01, 0xF1, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3E,
  0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00,
  0x7C, 0x7C, 0x00, 0x7E, 0x3E, 0x01, 0xFE, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0x80, 0xF8,
  0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF1, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xDF, 0x00, 0x03,
  0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xC0, 0x7C, 0x3F, 0x00,
  0x08, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x20, 0x00, 0x7E, 0x7C, 0x01,
  0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7C, 0x7F, 0x00, 0x7E,
  0x1F, 0xC0, 0xFE, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xBF,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x81,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xF0,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07,
  0xC0, 0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x8F,
  0x80, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F, 0xBE, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x7C, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0x3D, 0xF0, 0x00, 0x07, 0xBE, 0x00, 0x00, 0xF7, 0xC0, 0x00,
  0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x7C, 0xF0, 0x00, 0x0F, 0x9E, 0x07, 0xC1,
  0xF3, 0xC0, 0xF8, 0x3E, 0x78, 0x3F, 0x07, 0xCF, 0x07, 0xF0, 0xF9, 0xE0,
  0xFE, 0x1F, 0x3C, 0x3F, 0xC3, 0xC7, 0x87, 0xB8, 0x78, 0xF0, 0xE7, 0x8F,
  0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x8E, 0x3C, 0x78, 0xE1, 0xE7, 0x8F, 0x3C,
  0x3C, 0xF1, 0xE7, 0x83, 0x9E, 0x3C, 0xF0, 0x7B, 0xC3, 0x9C, 0x0F, 0x78,
  0x77, 0x80, 0xEF, 0x0E, 0xF0, 0x1F, 0xE1, 0xDC, 0x03, 0xF8, 0x3F, 0x80,
  0x7F, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83,
  0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07, 0xCF, 0xC0,
  0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0,
  0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xE0, 0x07, 0xC0,
  0xFC, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xF3, 0xF0, 0x00, 0x7E, 0x3E, 0x00, 0x0F,
  0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0,
  0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F,
  0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07,
  0xCF, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x7C, 0xE0, 0x00, 0x1E, 0x18, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x10, 0x0C, 0x07, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xC0,
  0xE0, 0x10, 0x07, 0xFF, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0x07, 0xFF,
  0xFE, 0x18, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xC0, 0x1F, 0xFC, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0x7F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xF0, 0x38, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0xFF, 0x00, 0xFB, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0xFF, 0x03, 0xF8, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xFC, 0xFC, 0x07,
  0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xC1, 0xFF, 0x00, 0x60, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x06, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x7F, 0x1F, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F,
  0xC0, 0xFF, 0x1F, 0x80, 0x3F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3E,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0xE0, 0x1F, 0x0F,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x0F, 0xE0, 0xFE, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x3E, 0x7E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x79, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x18, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x1F, 0xC0, 0x78, 0x0F, 0xC0,
  0x04, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x03, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0x3F, 0x1F, 0x80, 0x1F,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x00, 0x1F,
  0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x10, 0x00, 0x7E, 0x1E, 0x01, 0xFC,
  0x3F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x38, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x9F, 0xE0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xCF, 0xE0, 0x3F, 0xBE, 0x00, 0x7E, 0xF8, 0x00, 0xFF, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x03, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0x80, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF1, 0xFF, 0xFE,
  0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xF7, 0x81, 0xFC, 0xFF, 0xFF, 0x1F, 0xFF, 0xE3, 0xFF, 0xF0, 0x07,
  0xF8, 0x00, 0x38, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0xFD, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x3E, 0x00,
  0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x81, 0xFC, 0x07, 0xC1, 0xFC, 0x03, 0xE1,
  0xFC, 0x01, 0xF1, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0x7D, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xCF, 0xE0, 0x03,
  0xE3, 0xF8, 0x01, 0xF0, 0xFE, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x07, 0xE0,
  0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x87, 0xC0, 0x07,
  0xE3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0xC0, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0xFC, 0x3F,
  0xFE, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0xF8, 0x3F, 0x8F,
  0xFE, 0x07, 0x81, 0xFF, 0x81, 0xF0, 0x7F, 0xE0, 0x7C, 0x0F, 0xF8, 0x1F,
  0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F, 0xF8,
  0x1F, 0x03, 0xFE, 0x07, 0xC0, 0xFF, 0x81, 0xF0, 0x3F, 0xE0, 0x7C, 0x0F,
  0xF8, 0x1F, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFC, 0xFC, 0x03, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xE0, 0xFE,
  0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0x7C, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x7F,
  0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFC, 0x07, 0xF8, 0xF8, 0x01, 0xFC, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0xFC,
  0xFF, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFB, 0xFF, 0xC0,
  0xF8, 0xFF, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F,
  0x1F, 0x80, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x3F, 0x1F, 0xC0, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x03, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0xFE, 0x00, 0x6F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xE1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE,
  0x7F, 0x00, 0x31, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF4, 0x00, 0x07, 0xDF, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x06, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x03,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F,
  0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xCF, 0xE0, 0x1F, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x7F, 0xF0, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0x78,
  0x00, 0x01, 0xF7, 0x80, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0xF0,
  0x1E, 0x7C, 0x0F, 0x81, 0xE7, 0xC0, 0xF8, 0x1E, 0x7C, 0x1F, 0x81, 0xE3,
  0xC1, 0xFC, 0x1E, 0x3C, 0x1F, 0xC3, 0xE3, 0xC3, 0xFC, 0x3E, 0x3E, 0x3F,
  0xE3, 0xC3, 0xE3, 0xDE, 0x3C, 0x3E, 0x79, 0xE3, 0xC1, 0xE7, 0x8F, 0x3C,
  0x1E, 0xF8, 0xF7, 0xC1, 0xEF, 0x0F, 0x78, 0x1E, 0xF0, 0x7F, 0x81, 0xFE,
  0x07, 0xF8, 0x1F, 0xE0, 0x3F, 0x80, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x78, 0x00, 0xF0, 0x7C,
  0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7C, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x1F,
  0x0F, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0xC7, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x1F, 0x00,
  0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE0, 0x7E, 0x00,
  0x07, 0xDF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3E, 0x3F,
  0x00, 0x0F, 0x87, 0xC0, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x8F, 0x80,
  0x03, 0xE7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x10, 0x3F, 0x00,
  0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xF8, 0x01, 0xFF,
  0xC0, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0,
  0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0x83, 0xFC, 0x00, 0xF1, 0xFF, 0xC0,
  0x3C, 0xFF, 0xF8, 0x1F, 0x7C, 0x3F, 0x87, 0x9E, 0x07, 0xFF, 0xE7, 0x80,
  0x7F, 0xF3, 0xC0, 0x0F, 0xF8, 0x30, 0x00, 0xF8, 0x00,
};

const GFXglyph UbuntuMono_Regular61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 8, 38, 31, 11, -38 },
  { 39, 15, 15, 31, 8, -41 },
  { 68, 27, 38, 31, 2, -38 },
  { 197, 24, 48, 31, 3, -42 },
  { 341, 28, 38, 31, 1, -38 },
  { 474, 27, 38, 31, 2, -38 },
  { 603, 5, 16, 31, 13, -41 },
  { 613, 17, 53, 31, 7, -43 },
  { 726, 17, 53, 31, 7, -43 },
  { 839, 24, 22, 31, 3, -38 },
  { 905, 25, 26, 31, 3, -29 },
  { 987, 12, 16, 31, 9, -8 },
  { 1011, 13, 5, 31, 9, -18 },
  { 1020, 9, 8, 31, 11, -8 },
  { 1029, 22, 53, 31, 4, -43 },
  { 1175, 25, 38, 31, 3, -38 },
  { 1294, 22, 38, 31, 5, -38 },
  { 1399, 24, 38, 31, 3, -38 },
  { 1513, 23, 38, 31, 4, -38 },
  { 1623, 26, 38, 31, 2, -38 },
  { 1747, 23, 38, 31, 4, -38 },
  { 1857, 24, 38, 31, 3, -38 },
  { 1971, 24, 38, 31, 4, -38 },
  { 2085, 24, 38, 31, 3, -38 },
  { 2199, 24, 38, 31, 3, -38 },
  { 2313, 9, 28, 31, 11, -28 },
  { 2345, 12, 36, 31, 8, -28 },
  { 2399, 25, 25, 31, 3, -28 },
  { 2478, 25, 15, 31, 3, -23 },
  { 2525, 25, 25, 31, 3, -28 },
  { 2604, 19, 38, 31, 6, -38 },
  { 2695, 27, 46, 31, 2, -38 },
  { 2851, 29, 38, 31, 1, -38 },
  { 2989, 25, 38, 31, 3, -38 },
  { 3108, 25, 38, 31, 3, -38 },
  { 3227, 25, 38, 31, 3, -38 },
  { 3346, 22, 38, 31, 6, -38 },
  { 3451, 21, 38, 31, 6, -38 },
  { 3551, 25, 38, 31, 3, -38 },
  { 3670, 25, 38, 31, 3, -38 },
  { 3789, 20, 38, 31, 5, -38 },
  { 3884, 23, 38, 31, 3, -38 },
  { 3994, 26, 38, 31, 4, -38 },
  { 4118, 22, 38, 31, 6, -38 },
  { 4223, 27, 38, 31, 2, -38 },
  { 4352, 24, 38, 31, 3, -38 },
  { 4466, 27, 38, 31, 2, -38 },
  { 4595, 24, 38, 31, 4, -38 },
  { 4709, 27, 47, 31, 2, -38 },
  { 4868, 25, 38, 31, 3, -38 },
  { 4987, 24, 38, 31, 3, -38 },
  { 5101, 26, 38, 31, 2, -38 },
  { 5225, 25, 38, 31, 3, -38 },
  { 5344, 29, 38, 31, 1, -38 },
  { 5482, 27, 38, 31, 2, -38 },
  { 5611, 27, 38, 31, 2, -38 },
  { 5740, 29, 38, 31, 1, -38 },
  { 5878, 25, 38, 31, 3, -38 },
  { 5997, 14, 53, 31, 9, -43 },
  { 6090, 22, 53, 31, 4, -43 },
  { 6236, 15, 53, 31, 7, -43 },
  { 6336, 26, 21, 31, 2, -38 },
  { 6405, 30, 4, 31, 0, 6 },
  { 6420, 10, 11, 31, 10, -43 },
  { 6434, 22, 28, 31, 4, -28 },
  { 6511, 24, 42, 31, 4, -42 },
  { 6637, 25, 28, 31, 3, -28 },
  { 6725, 24, 42, 31, 2, -42 },
  { 6851, 26, 28, 31, 2, -28 },
  { 6942, 25, 42, 31, 4, -42 },
  { 7074, 24, 38, 31, 2, -28 },
  { 7188, 22, 42, 31, 4, -42 },
  { 7304, 24, 39, 31, 3, -39 },
  { 7421, 19, 49, 31, 4, -39 },
  { 7538, 25, 42, 31, 4, -42 },
  { 7670, 24, 42, 31, 3, -42 },
  { 7796, 26, 28, 31, 2, -28 },
  { 7887, 22, 28, 31, 4, -28 },
  { 7964, 26, 28, 31, 2, -28 },
  { 8055, 24, 38, 31, 4, -28 },
  { 8169, 24, 38, 31, 2, -28 },
  { 8283, 20, 28, 31, 7, -28 },
  { 8353, 22, 28, 31, 4, -28 },
  { 8430, 23, 37, 31, 4, -37 },
  { 8537, 22, 28, 31, 4, -28 },
  { 8614, 27, 28, 31, 2, -28 },
  { 8709, 28, 28, 31, 1, -28 },
  { 8807, 27, 28, 31, 2, -28 },
  { 8902, 26, 38, 31, 2, -28 },
  { 9026, 22, 28, 31, 4, -28 },
  { 9103, 21, 53, 31, 5, -43 },
  { 9243, 5, 53, 31, 13, -43 },
  { 9277, 22, 53, 31, 4, -43 },
  { 9423, 26, 9, 31, 2, -21 },
};

const GFXfont UbuntuMono_Regular61pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular61pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular61pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _UBUNTUMONO_REGULAR61PT7B_H_
