#ifndef _UBUNTUMONO_REGULAR34PT7B_H_
#define _UBUNTUMONO_REGULAR34PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 34pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular34pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE6, 0x00, 0x00, 0x77,
  0xFF, 0xF7, 0x00, 0xE3, 0xF1, 0xF8, 0xFC, 0x76, 0x33, 0x19, 0x8C, 0x82,
  0x07, 0x1C, 0x0C, 0x38, 0x18, 0x70, 0x70, 0xC0, 0xE1, 0x81, 0xC7, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0x60, 0x71, 0xC0, 0xE3, 0x81, 0x87,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0xE0, 0x61, 0xC0, 0xC3, 0x03,
  0x86, 0x07, 0x1C, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x1F, 0xC3, 0xFF,
  0x3F, 0xF9, 0xC0, 0xDC, 0x00, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xFE, 0x03,
  0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0F, 0x80,
  0xFF, 0xFF, 0x7F, 0xF0, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x38, 0x0E, 0xF8, 0x1B, 0x38, 0x76, 0x30, 0xCC, 0x63, 0x18, 0xCE, 0x31,
  0x98, 0x63, 0x70, 0xCE, 0xC0, 0xFB, 0x01, 0xEE, 0xE0, 0x1B, 0xE0, 0x6E,
  0x61, 0xD8, 0xC3, 0x31, 0x8E, 0x63, 0x18, 0xC6, 0x61, 0x8D, 0xC3, 0x9B,
  0x03, 0xEE, 0x03, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x81, 0xC7, 0x03,
  0x06, 0x06, 0x0C, 0x0E, 0x30, 0x1F, 0xE0, 0x1F, 0x00, 0x3C, 0x38, 0xFC,
  0x73, 0x9C, 0xE6, 0x1D, 0x9C, 0x1F, 0x38, 0x3E, 0x70, 0x38, 0xE0, 0x79,
  0xE3, 0xF1, 0xFF, 0x71, 0xFC, 0x61, 0xF0, 0xE0, 0xFF, 0xFF, 0xFF, 0x40,
  0x01, 0x01, 0xC1, 0xC1, 0xC1, 0xC1, 0xE0, 0xE0, 0xE0, 0x70, 0x30, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x07, 0x03,
  0x81, 0xC0, 0x70, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x38, 0x08, 0x40, 0x70,
  0x3C, 0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x0E, 0x07, 0x03, 0x80, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x1C,
  0x1C, 0x1C, 0x1E, 0x0E, 0x1E, 0x0E, 0x02, 0x00, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x8E, 0x2F, 0x27, 0xFF, 0xFC, 0xFF, 0x80, 0xE0, 0x0D, 0x80, 0xEE,
  0x0E, 0x38, 0x71, 0xC1, 0x04, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x83, 0xFF, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x7C, 0xF9, 0xF1, 0xE1, 0x87, 0x1C,
  0xF1, 0x80, 0xFF, 0xFF, 0xF8, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x06,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x00, 0x0F, 0x81,
  0xFF, 0x0F, 0xF8, 0xF1, 0xEF, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE7,
  0x3E, 0x38, 0xF1, 0xC7, 0x8E, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xF0, 0x7B, 0xC7, 0x8F, 0xF8, 0x7F, 0xC0, 0xF8, 0x00, 0x07, 0x00, 0xF0,
  0x1F, 0x07, 0xF0, 0xF7, 0x0C, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1F, 0x83, 0xFF, 0x3F, 0xFD, 0xE1, 0xE4,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x83, 0xFF, 0x1F, 0xF8, 0xC1, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x1C, 0x0F, 0xC0, 0x7E, 0x03, 0xF8, 0x01, 0xE0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3E, 0x07, 0xBF, 0xFD, 0xFF,
  0xC3, 0xF8, 0x00, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xC0, 0x1D, 0x80, 0x3B,
  0x00, 0xE6, 0x03, 0x8C, 0x06, 0x18, 0x1C, 0x30, 0x70, 0x60, 0xC0, 0xC3,
  0x81, 0x86, 0x03, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x30, 0x00,
  0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x3F, 0x01, 0xFE, 0x0F,
  0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3A, 0x07,
  0xBF, 0xFD, 0xFF, 0xC3, 0xF8, 0x00, 0x00, 0xF0, 0x3F, 0x83, 0xFC, 0x3E,
  0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x0C, 0x00, 0xEF, 0xC7, 0xFF, 0x3F, 0xFD,
  0xE0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3B, 0xC3, 0xDF,
  0xFC, 0x7F, 0xC0, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00,
  0x38, 0x01, 0xC0, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFC, 0xE0, 0xFE, 0x03,
  0xF0, 0x1F, 0x80, 0xFE, 0x0E, 0x78, 0xE1, 0xFE, 0x07, 0xF8, 0x7F, 0xE7,
  0x0F, 0xF0, 0x1F, 0x80, 0xF8, 0x03, 0xE0, 0x3F, 0x83, 0xDF, 0xFC, 0xFF,
  0xC1, 0xFC, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD, 0xE1, 0xEE, 0x07, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x81, 0xDF, 0xFE, 0x7F, 0xF1, 0xFB,
  0x80, 0x1C, 0x01, 0xC0, 0x1E, 0x01, 0xE0, 0x3F, 0x1F, 0xE0, 0xFE, 0x07,
  0x80, 0x00, 0x77, 0xFF, 0xF7, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFF, 0xEE,
  0x1C, 0x7C, 0xF9, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xE7,
  0xCF, 0x8F, 0x0E, 0x38, 0xF7, 0x86, 0x00, 0x00, 0x08, 0x01, 0xE0, 0x1F,
  0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x0E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xC0, 0x3F, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0x3C, 0x00, 0xC0, 0x00, 0x3F, 0x1F, 0xFB, 0xFF, 0x20, 0xF0,
  0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x01, 0xC0,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0x03, 0xC0, 0xF8, 0x0F, 0x01, 0xC0, 0x03,
  0xE0, 0x1F, 0xF0, 0x7F, 0xF1, 0xE1, 0xE3, 0x81, 0xEF, 0x01, 0xDC, 0x03,
  0xB8, 0x07, 0x70, 0xFE, 0xC3, 0xFF, 0x8F, 0xFF, 0x1C, 0x7E, 0x70, 0xFC,
  0xE1, 0xF9, 0xC3, 0xF1, 0xC7, 0x63, 0xFE, 0xE3, 0xFD, 0xC3, 0xF3, 0xC0,
  0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xF0,
  0x01, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xEE, 0x00, 0x77, 0x00, 0x31,
  0x80, 0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x18, 0x06, 0x0C, 0x07, 0x07, 0x03,
  0x03, 0x81, 0x80, 0xC1, 0xFF, 0xF0, 0xFF, 0xF8, 0x7F, 0xFC, 0x70, 0x06,
  0x38, 0x03, 0x9C, 0x01, 0xCE, 0x00, 0xEE, 0x00, 0x38, 0xFF, 0x87, 0xFF,
  0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0x70, 0x1B, 0x80, 0xDC, 0x0E, 0xE0, 0xE7,
  0xFE, 0x3F, 0xF1, 0xFF, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0,
  0x3F, 0x03, 0xFF, 0xFD, 0xFF, 0xCF, 0xF8, 0x00, 0x07, 0xE0, 0x7F, 0xE3,
  0xFF, 0x8F, 0x06, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x70, 0x01, 0xF0, 0x23, 0xFF, 0x87, 0xFF, 0x07, 0xF0, 0xFF, 0x03, 0xFF,
  0x0F, 0xFE, 0x38, 0x7C, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xB8, 0x0E, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0xEE, 0x03, 0xB8,
  0x0E, 0xE0, 0x73, 0x87, 0xCF, 0xFE, 0x3F, 0xF0, 0xFF, 0x00, 0xFF, 0xF7,
  0xFF, 0xBF, 0xFD, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0xFF, 0x3F, 0xF9, 0xFF, 0xCE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFE,
  0xFF, 0xEF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0xFF, 0xCF, 0xFE, 0xF8, 0x37,
  0x80, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x06, 0x00, 0x30, 0x01, 0x80,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0x70, 0x1B, 0xE0, 0xCF, 0xFE,
  0x3F, 0xF0, 0x7F, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xF3, 0xFF, 0x3F,
  0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x40, 0x7E, 0x0F, 0xFF,
  0xE7, 0xFC, 0x3F, 0x80, 0xE0, 0x3D, 0xC0, 0x73, 0x81, 0xC7, 0x07, 0x0E,
  0x1E, 0x1C, 0x78, 0x39, 0xE0, 0x77, 0x80, 0xFE, 0x01, 0xF8, 0x03, 0xF8,
  0x07, 0x78, 0x0E, 0x78, 0x1C, 0x78, 0x38, 0x78, 0x70, 0x78, 0xE0, 0x71,
  0xC0, 0xF3, 0x80, 0xE7, 0x00, 0xEE, 0x01, 0xC0, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x30, 0x18, 0xF0, 0x79, 0xE0,
  0xF3, 0xC1, 0xE6, 0xC6, 0xCD, 0x8D, 0x9B, 0x1B, 0x33, 0x76, 0x66, 0xCC,
  0xCD, 0x99, 0x8F, 0x33, 0x1C, 0x6E, 0x38, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0, 0xE0,
  0x1F, 0x80, 0xFC, 0x07, 0xF0, 0x3D, 0x81, 0xEE, 0x0F, 0x30, 0x79, 0xC3,
  0xC6, 0x1E, 0x38, 0xF0, 0xC7, 0x87, 0x3C, 0x19, 0xE0, 0xCF, 0x07, 0x78,
  0x1B, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0x80, 0x07, 0xC0,
  0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xF0, 0x78, 0xFF, 0xE0, 0xFF, 0x80,
  0x7C, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC0, 0xFE, 0x03, 0xF0, 0x1F,
  0x80, 0x7C, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xFF, 0xEF, 0xFE, 0x7F,
  0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1, 0xE7, 0x01, 0xCE, 0x03,
  0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xB8, 0x0E, 0x70, 0x1C, 0xF0, 0x78, 0xFF,
  0xE0, 0xFF, 0x80, 0xFE, 0x00, 0x70, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7C,
  0x00, 0x38, 0xFF, 0x03, 0xFF, 0x0F, 0xFE, 0x38, 0x3C, 0xE0, 0x73, 0x80,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0x3B, 0x81, 0xCE, 0x0F, 0x3F, 0xF8, 0xFF,
  0xC3, 0xFE, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0xE3, 0x81, 0xCE, 0x07, 0x38,
  0x0E, 0xE0, 0x38, 0x0F, 0xC1, 0xFF, 0x9F, 0xFC, 0xF0, 0x6E, 0x00, 0x70,
  0x03, 0x80, 0x0E, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x0F,
  0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3A, 0x03, 0xFF, 0xFD, 0xFF, 0xC3,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xDF,
  0xFC, 0x7F, 0xC1, 0xFC, 0x00, 0x70, 0x03, 0x38, 0x03, 0x9C, 0x01, 0xCE,
  0x00, 0xE3, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38, 0x70, 0x1C, 0x1C, 0x1C,
  0x0E, 0x0E, 0x07, 0x07, 0x01, 0x83, 0x00, 0xE3, 0x80, 0x71, 0xC0, 0x18,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x01, 0xB0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE3, 0x8C, 0xC7, 0x19, 0x9E, 0x33, 0x36,
  0x66, 0x6C, 0xCD, 0xD9, 0x9B, 0x1B, 0x36, 0x36, 0x6C, 0x6C, 0xF0, 0x79,
  0xE0, 0xF3, 0xC1, 0xE3, 0x01, 0x80, 0xF0, 0x0E, 0xE0, 0x38, 0xE0, 0xE1,
  0xC1, 0xC1, 0xC7, 0x03, 0x8E, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xC0, 0x07,
  0x00, 0x0E, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0x1C, 0x0E, 0x38,
  0x38, 0x38, 0x70, 0x71, 0xC0, 0x73, 0x80, 0xEE, 0x00, 0xE0, 0x70, 0x07,
  0x38, 0x03, 0x9E, 0x03, 0xC7, 0x01, 0xC3, 0x80, 0xE0, 0xE0, 0xE0, 0x70,
  0x70, 0x1C, 0x70, 0x0F, 0x38, 0x03, 0xB8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF,
  0x60, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x03, 0x00, 0x1C,
  0x00, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x18, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x03, 0x80, 0x0F, 0x80, 0x1F,
  0x00, 0x77, 0x00, 0xEE, 0x03, 0x8E, 0x0E, 0x0E, 0x1C, 0x1C, 0x70, 0x1C,
  0xE0, 0x38, 0x80, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x47, 0x38, 0xE3,
  0x88, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x40, 0xE0, 0x03, 0x80, 0x1C, 0x7F,
  0xE7, 0xFF, 0x70, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7F, 0x03, 0xBF, 0xFD,
  0xFF, 0xE3, 0xFE, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xEF, 0xC3, 0xFF, 0x8F, 0xFF, 0x3C, 0x1E,
  0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03,
  0xB8, 0x0E, 0xE0, 0xFB, 0xFF, 0xCF, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0xFF,
  0xCF, 0xFE, 0xF8, 0x3F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0xC0, 0x9F, 0xFC, 0x7F, 0xE0, 0xFE, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x07, 0xDC, 0x7F, 0xF3, 0xFF, 0xDE, 0x0F, 0x70, 0x1D, 0xC0, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDC, 0x07, 0x7C, 0x1C,
  0xFF, 0xF1, 0xFF, 0xC1, 0xFC, 0x07, 0xE0, 0x7F, 0xC3, 0xFF, 0x9E, 0x0F,
  0x70, 0x1D, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1E, 0x00, 0x7C, 0x08, 0xFF, 0xE1, 0xFF, 0x81, 0xFC, 0x01, 0xF8, 0x1F,
  0xF0, 0xFF, 0xC3, 0xC1, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xFF,
  0xFB, 0xFF, 0xEF, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xDE, 0x07, 0x70, 0x1D,
  0xC0, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x77, 0x01, 0xDE, 0x0F,
  0x3F, 0xFC, 0x7F, 0xF0, 0xFD, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xE2, 0x07,
  0x9F, 0xFE, 0x7F, 0xF0, 0xFF, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xEF, 0x87, 0xFF, 0x3F, 0xFD,
  0xC1, 0xEE, 0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8,
  0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x0E, 0x00, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x01, 0xC2, 0x0F, 0xF0, 0x7F, 0x80, 0xF8, 0x01, 0xC0, 0x7C,
  0x0F, 0x80, 0xE0, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x41, 0xEF, 0xFB, 0xFF, 0x1F, 0x80,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x3B, 0x81, 0xCE, 0x0F, 0x38, 0x78, 0xE3, 0x83, 0x9C,
  0x0F, 0xE0, 0x3F, 0x00, 0xFE, 0x03, 0x9C, 0x0E, 0x38, 0x38, 0x78, 0xE0,
  0xE3, 0x81, 0xCE, 0x03, 0xB8, 0x07, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x83, 0xFC, 0x0F, 0xE0, 0x3E, 0x7E, 0x79, 0xFF,
  0xFB, 0xFF, 0xF7, 0x1C, 0x7E, 0x38, 0xFC, 0x71, 0xF8, 0xE3, 0xF1, 0xC7,
  0xE3, 0x8F, 0xC7, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0x3F, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0x70,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC1,
  0xE7, 0x01, 0xCE, 0x03, 0xB8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1D,
  0xC0, 0x73, 0x80, 0xE7, 0x83, 0xC7, 0xFF, 0x07, 0xFC, 0x03, 0xE0, 0x3F,
  0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0xE0, 0x3B, 0x80, 0xEE, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xB8, 0x0E, 0xF0, 0x7B, 0xFF, 0xCF,
  0xFE, 0x3B, 0xE0, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x00, 0x07, 0xF0, 0x7F, 0xF3, 0xFF, 0xDF, 0x07, 0x70, 0x1D, 0xC0,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x01, 0xDC, 0x07, 0x78,
  0x3C, 0xFF, 0xF1, 0xFF, 0xC3, 0xF7, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x70, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x06, 0x00, 0x0F, 0xE1, 0xFF, 0x9F, 0xFC, 0xE0, 0x66, 0x00, 0x38,
  0x01, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x74, 0x07,
  0xFF, 0xFB, 0xFF, 0x87, 0xF8, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x43, 0xFE,
  0x0F, 0xF0, 0x3F, 0x00, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xE0, 0x77,
  0x83, 0xBF, 0xFC, 0xFF, 0xE1, 0xFC, 0xE0, 0x0F, 0xE0, 0x1D, 0xC0, 0x73,
  0x80, 0xE7, 0x01, 0xC7, 0x07, 0x0E, 0x0E, 0x1C, 0x18, 0x1C, 0x70, 0x38,
  0xE0, 0x3B, 0x80, 0x77, 0x00, 0x6C, 0x00, 0xF8, 0x01, 0xE0, 0x01, 0xC0,
  0xC0, 0x07, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x7E, 0x38, 0xFC, 0x71, 0xF8,
  0xE3, 0xB3, 0xE6, 0x66, 0xCC, 0xCD, 0x99, 0xBB, 0xB3, 0xE3, 0xE7, 0xC7,
  0x87, 0x07, 0x0E, 0x0E, 0x18, 0x1C, 0x70, 0x1C, 0xE0, 0x70, 0xE0, 0xE0,
  0xE3, 0x81, 0xEE, 0x01, 0xDC, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x3B, 0x80, 0xE3, 0x83, 0x83, 0x87, 0x07, 0x1C, 0x07, 0x70, 0x07,
  0x70, 0x0E, 0xE0, 0x39, 0xC0, 0x71, 0xC0, 0xE3, 0x81, 0xC7, 0x07, 0x07,
  0x0E, 0x0E, 0x1C, 0x1C, 0x30, 0x1C, 0xE0, 0x39, 0xC0, 0x33, 0x00, 0x7E,
  0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x03,
  0xF8, 0x0F, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0xF3, 0xFF, 0x9F, 0xFC, 0x01,
  0xE0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00,
  0x70, 0x07, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF0, 0xFF, 0x0E,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x03, 0x80, 0xF8, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x1C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x0F, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFC, 0x0F, 0xF0, 0x07, 0x00, 0x30, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xF0, 0x1F, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0xFF,
  0x0F, 0xC0, 0x1C, 0x04, 0x7E, 0x1D, 0xFE, 0x33, 0x1F, 0xEE, 0x1F, 0x88,
  0x0E, 0x00,
};

const GFXglyph UbuntuMono_Regular34pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 5, 21, 17, 6, -21 },
  { 15, 9, 8, 17, 4, -23 },
  { 24, 15, 21, 17, 1, -21 },
  { 64, 13, 27, 17, 2, -24 },
  { 108, 15, 21, 17, 1, -21 },
  { 148, 15, 21, 17, 1, -21 },
  { 188, 3, 9, 17, 7, -23 },
  { 192, 9, 30, 17, 4, -24 },
  { 226, 9, 30, 17, 4, -24 },
  { 260, 13, 13, 17, 2, -21 },
  { 282, 13, 14, 17, 2, -16 },
  { 305, 7, 10, 17, 5, -5 },
  { 314, 7, 3, 17, 5, -10 },
  { 317, 5, 5, 17, 6, -5 },
  { 321, 13, 30, 17, 2, -24 },
  { 370, 13, 21, 17, 2, -21 },
  { 405, 12, 21, 17, 3, -21 },
  { 437, 13, 21, 17, 2, -21 },
  { 472, 13, 21, 17, 2, -21 },
  { 507, 15, 21, 17, 1, -21 },
  { 547, 13, 21, 17, 2, -21 },
  { 582, 13, 21, 17, 2, -21 },
  { 617, 13, 21, 17, 2, -21 },
  { 652, 13, 21, 17, 2, -21 },
  { 687, 13, 21, 17, 2, -21 },
  { 722, 5, 16, 17, 6, -16 },
  { 732, 7, 21, 17, 4, -16 },
  { 751, 14, 13, 17, 2, -15 },
  { 774, 13, 8, 17, 2, -13 },
  { 787, 14, 13, 17, 2, -15 },
  { 810, 11, 21, 17, 3, -21 },
  { 839, 15, 26, 17, 1, -21 },
  { 888, 17, 21, 17, 0, -21 },
  { 933, 13, 21, 17, 2, -21 },
  { 968, 14, 21, 17, 2, -21 },
  { 1005, 14, 21, 17, 2, -21 },
  { 1042, 13, 21, 17, 3, -21 },
  { 1077, 12, 21, 17, 3, -21 },
  { 1109, 13, 21, 17, 2, -21 },
  { 1144, 13, 21, 17, 2, -21 },
  { 1179, 11, 21, 17, 3, -21 },
  { 1208, 12, 21, 17, 2, -21 },
  { 1240, 15, 21, 17, 2, -21 },
  { 1280, 13, 21, 17, 3, -21 },
  { 1315, 15, 21, 17, 1, -21 },
  { 1355, 13, 21, 17, 2, -21 },
  { 1390, 15, 21, 17, 1, -21 },
  { 1430, 13, 21, 17, 2, -21 },
  { 1465, 15, 26, 17, 1, -21 },
  { 1514, 14, 21, 17, 2, -21 },
  { 1551, 13, 21, 17, 2, -21 },
  { 1586, 15, 21, 17, 1, -21 },
  { 1626, 13, 21, 17, 2, -21 },
  { 1661, 17, 21, 17, 0, -21 },
  { 1706, 15, 21, 17, 1, -21 },
  { 1746, 15, 21, 17, 1, -21 },
  { 1786, 17, 21, 17, 0, -21 },
  { 1831, 13, 21, 17, 2, -21 },
  { 1866, 8, 30, 17, 5, -24 },
  { 1896, 13, 30, 17, 2, -24 },
  { 1945, 8, 30, 17, 4, -24 },
  { 1975, 15, 11, 17, 1, -21 },
  { 1996, 17, 2, 17, 0, 3 },
  { 2001, 5, 6, 17, 6, -24 },
  { 2005, 13, 16, 17, 2, -16 },
  { 2031, 14, 24, 17, 2, -24 },
  { 2073, 13, 16, 17, 2, -16 },
  { 2099, 14, 24, 17, 1, -24 },
  { 2141, 14, 16, 17, 1, -16 },
  { 2169, 14, 24, 17, 2, -24 },
  { 2211, 14, 22, 17, 1, -16 },
  { 2250, 13, 24, 17, 2, -24 },
  { 2289, 13, 22, 17, 2, -22 },
  { 2325, 11, 28, 17, 2, -22 },
  { 2364, 14, 24, 17, 2, -24 },
  { 2406, 13, 24, 17, 2, -24 },
  { 2445, 15, 16, 17, 1, -16 },
  { 2475, 13, 16, 17, 2, -16 },
  { 2501, 15, 16, 17, 1, -16 },
  { 2531, 14, 22, 17, 2, -16 },
  { 2570, 14, 22, 17, 1, -16 },
  { 2609, 11, 16, 17, 4, -16 },
  { 2631, 13, 16, 17, 2, -16 },
  { 2657, 13, 21, 17, 2, -21 },
  { 2692, 13, 16, 17, 2, -16 },
  { 2718, 15, 16, 17, 1, -16 },
  { 2748, 15, 16, 17, 1, -16 },
  { 2778, 15, 16, 17, 1, -16 },
  { 2808, 15, 22, 17, 1, -16 },
  { 2850, 13, 16, 17, 2, -16 },
  { 2876, 12, 30, 17, 3, -24 },
  { 2921, 3, 30, 17, 7, -24 },
  { 2933, 12, 30, 17, 2, -24 },
  { 2978, 15, 6, 17, 1, -12 },
};

const GFXfont UbuntuMono_Regular34pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular34pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular34pt7bGlyphs,
  0x20, 0x7E, 34
};

#endif // _UBUNTUMONO_REGULAR34PT7B_H_
