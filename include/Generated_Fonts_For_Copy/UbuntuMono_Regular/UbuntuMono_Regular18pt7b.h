#ifndef _UBUNTUMONO_REGULAR18PT7B_H_
#define _UBUNTUMONO_REGULAR18PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 18pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular18pt7bBitmaps[] PROGMEM = {
  0x00, 0x49, 0x24, 0x92, 0x03, 0x80, 0xDE, 0xF6, 0xA0, 0x13, 0x09, 0x84,
  0x9F, 0xF3, 0x21, 0xB0, 0x99, 0xFF, 0x24, 0x32, 0x19, 0x00, 0x10, 0x21,
  0xF6, 0x0C, 0x18, 0x1C, 0x0E, 0x06, 0x0E, 0x1F, 0xE1, 0x02, 0x00, 0x71,
  0x29, 0xA4, 0x92, 0x85, 0xC3, 0xF8, 0x54, 0x29, 0x24, 0xB2, 0x91, 0xC0,
  0x78, 0x48, 0xCC, 0x48, 0x70, 0x72, 0xD6, 0x8C, 0x8C, 0xCE, 0x72, 0xF8,
  0x19, 0x98, 0x8C, 0x62, 0x10, 0xC6, 0x18, 0xC3, 0x0C, 0xC3, 0x0C, 0x61,
  0x8C, 0x21, 0x18, 0xC4, 0x46, 0x60, 0x10, 0x23, 0x59, 0xC2, 0x8D, 0x91,
  0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00, 0x6F, 0x00, 0xE0, 0xE0,
  0x06, 0x08, 0x30, 0x60, 0x81, 0x06, 0x08, 0x10, 0x60, 0x81, 0x06, 0x0C,
  0x10, 0x60, 0x38, 0x8B, 0x1C, 0x19, 0x32, 0x60, 0xC1, 0xC6, 0x88, 0xE0,
  0x18, 0x71, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x31, 0xF8, 0x79, 0x08,
  0x18, 0x30, 0xC3, 0x8E, 0x18, 0x61, 0x83, 0xF8, 0x78, 0x98, 0x10, 0x20,
  0xC7, 0x01, 0x83, 0x07, 0x0F, 0xE0, 0x0C, 0x38, 0xD1, 0x26, 0x48, 0xA1,
  0x7F, 0x04, 0x08, 0x10, 0x7E, 0xC1, 0x02, 0x07, 0x81, 0x81, 0x83, 0x07,
  0x0B, 0xE0, 0x0C, 0x61, 0x86, 0x0F, 0xD0, 0xE1, 0xE1, 0xC6, 0x88, 0xF0,
  0xFE, 0x0C, 0x10, 0x60, 0x83, 0x04, 0x18, 0x30, 0x40, 0x80, 0x3C, 0x8B,
  0x1E, 0x36, 0x4F, 0x31, 0xC1, 0x83, 0x8D, 0xF0, 0x38, 0x8B, 0x1C, 0x3C,
  0x38, 0x5F, 0x83, 0x04, 0x31, 0xC0, 0xE0, 0x00, 0x38, 0x70, 0x00, 0x00,
  0x73, 0xE0, 0x02, 0x39, 0xC6, 0x07, 0x03, 0x80, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0xC0, 0xE0, 0x70, 0x11, 0xCE, 0x30, 0x00, 0xF4, 0xC2, 0x11, 0x98,
  0x8C, 0x00, 0x18, 0x3C, 0xCF, 0x0C, 0x79, 0x36, 0x6C, 0xD9, 0x93, 0x9D,
  0x03, 0x01, 0xE0, 0x1C, 0x0A, 0x05, 0x06, 0xC2, 0x21, 0x11, 0x8C, 0xFE,
  0x41, 0x20, 0xB0, 0x60, 0xF9, 0x1A, 0x1C, 0x38, 0xDF, 0x21, 0xC1, 0x83,
  0x0F, 0xF0, 0x3E, 0xC7, 0x06, 0x08, 0x10, 0x20, 0x60, 0xC0, 0xC4, 0xF8,
  0xF9, 0x1A, 0x1C, 0x18, 0x30, 0x60, 0xC1, 0x87, 0x1B, 0xE0, 0xFE, 0x08,
  0x20, 0x83, 0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8,
  0x20, 0x82, 0x08, 0x00, 0x3E, 0xC7, 0x06, 0x08, 0x10, 0x20, 0xE1, 0xC2,
  0xC4, 0xF8, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xE0, 0xC1, 0x83, 0x06, 0x08,
  0xF9, 0x08, 0x42, 0x10, 0x84, 0x21, 0x3E, 0x7E, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x05, 0x19, 0xE0, 0xC6, 0xC6, 0xCC, 0xD8, 0xF0, 0xF0, 0xF0,
  0xD8, 0xCC, 0xC6, 0xC3, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F,
  0xC0, 0xC7, 0x8F, 0xBD, 0x5A, 0xB5, 0x64, 0xC1, 0x83, 0x06, 0x08, 0xC3,
  0x87, 0x8D, 0x19, 0x32, 0x62, 0xC5, 0x8F, 0x0E, 0x18, 0x38, 0x44, 0x82,
  0x82, 0x82, 0x83, 0x82, 0x82, 0x82, 0xC6, 0x38, 0xFD, 0x8F, 0x0E, 0x1C,
  0x38, 0xFF, 0x60, 0xC1, 0x83, 0x00, 0x38, 0x44, 0x82, 0x82, 0x82, 0x82,
  0x82, 0x82, 0x82, 0xC6, 0x7C, 0x10, 0x18, 0x06, 0xF9, 0x0A, 0x1C, 0x38,
  0x70, 0xBE, 0x44, 0x8D, 0x0E, 0x08, 0x3C, 0x8B, 0x06, 0x06, 0x07, 0x01,
  0x83, 0x03, 0x0D, 0xF0, 0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xC7, 0x8D, 0xF0,
  0xC1, 0xA0, 0x90, 0x4C, 0x66, 0x31, 0x10, 0xD8, 0x6C, 0x14, 0x0E, 0x07,
  0x00, 0x83, 0x06, 0x0C, 0x19, 0x35, 0x6A, 0xD5, 0xEF, 0x8F, 0x18, 0x63,
  0x31, 0x8D, 0x82, 0x81, 0xC0, 0x40, 0x70, 0x6C, 0x22, 0x31, 0x90, 0x40,
  0xC1, 0xA0, 0x98, 0xC6, 0x43, 0x60, 0xE0, 0x20, 0x10, 0x08, 0x04, 0x02,
  0x00, 0xFE, 0x0C, 0x30, 0x41, 0x82, 0x0C, 0x30, 0x41, 0x83, 0xF8, 0xF8,
  0x88, 0x88, 0x88, 0x88, 0x88, 0x8F, 0xC0, 0x81, 0x83, 0x02, 0x04, 0x0C,
  0x08, 0x10, 0x30, 0x20, 0x40, 0xC1, 0x81, 0x03, 0xF1, 0x11, 0x11, 0x11,
  0x11, 0x11, 0x1F, 0x10, 0x71, 0xB2, 0x2C, 0x70, 0x40, 0xFF, 0x80, 0x88,
  0x80, 0x7C, 0x0C, 0x1B, 0xFC, 0x78, 0xF1, 0xBF, 0xC1, 0x83, 0x06, 0x0F,
  0xD8, 0xF0, 0xE1, 0xC3, 0x87, 0x1F, 0xC0, 0x3E, 0xC3, 0x04, 0x08, 0x18,
  0x18, 0x1F, 0x06, 0x0C, 0x18, 0x37, 0xF8, 0xE1, 0xC3, 0x87, 0x8F, 0x19,
  0xF0, 0x3D, 0x8E, 0x0F, 0xF8, 0x18, 0x30, 0x1F, 0x1F, 0x30, 0x20, 0x20,
  0xFE, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x20, 0x3F, 0x8F, 0x1C, 0x38,
  0x70, 0xF1, 0xBF, 0x06, 0x0B, 0xE0, 0xC1, 0x83, 0x06, 0x0F, 0xD8, 0xB1,
  0xE3, 0xC7, 0x8F, 0x1E, 0x30, 0x30, 0x03, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x10, 0x3C, 0x1C, 0x07, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xF8,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC6, 0xCC, 0xD8, 0xE0, 0xF0, 0xC8, 0xC4, 0xC6,
  0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x40, 0xF0, 0xEF,
  0x26, 0x4C, 0x99, 0x30, 0x60, 0xC1, 0xFD, 0x8B, 0x1E, 0x3C, 0x78, 0xF1,
  0xE3, 0x39, 0x8E, 0x0C, 0x18, 0x30, 0x71, 0x9C, 0xF9, 0x8F, 0x1E, 0x1C,
  0x38, 0x71, 0xFE, 0xC1, 0x83, 0x00, 0x3F, 0x8F, 0x1C, 0x38, 0x70, 0xF1,
  0xBF, 0x06, 0x0C, 0x18, 0xFE, 0x08, 0x20, 0x82, 0x08, 0x20, 0x7D, 0x83,
  0x03, 0x81, 0xC0, 0xE1, 0xFE, 0x20, 0x40, 0x87, 0xF2, 0x04, 0x08, 0x10,
  0x20, 0x60, 0x78, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xD1, 0xBF, 0x83, 0x8F,
  0x1A, 0x26, 0xC5, 0x0E, 0x08, 0xC1, 0xA0, 0x92, 0x4B, 0xA5, 0x52, 0xA9,
  0x9C, 0x44, 0xC6, 0x4C, 0x28, 0x38, 0x38, 0x6C, 0x44, 0x82, 0xC3, 0x8D,
  0x1B, 0x26, 0x45, 0x8E, 0x0C, 0x10, 0x63, 0x80, 0x7E, 0x18, 0x60, 0x83,
  0x0C, 0x10, 0x7F, 0x1E, 0x20, 0xC1, 0x83, 0x06, 0x0C, 0x10, 0xE0, 0x60,
  0xC1, 0x83, 0x06, 0x04, 0x0F, 0xFF, 0xFF, 0xF0, 0x20, 0x60, 0xC1, 0x83,
  0x06, 0x04, 0x0E, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x78, 0xF3, 0x3C,
};

const GFXglyph UbuntuMono_Regular18pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 3, 11, 9, 3, -11 },
  { 6, 5, 4, 9, 2, -12 },
  { 9, 9, 11, 9, 0, -11 },
  { 22, 7, 14, 9, 1, -12 },
  { 35, 9, 11, 9, 0, -11 },
  { 48, 8, 11, 9, 1, -11 },
  { 59, 1, 5, 9, 4, -12 },
  { 60, 5, 14, 9, 2, -11 },
  { 69, 5, 14, 9, 2, -11 },
  { 78, 7, 7, 9, 1, -11 },
  { 85, 7, 7, 9, 1, -8 },
  { 92, 3, 3, 9, 3, -1 },
  { 94, 3, 1, 9, 3, -5 },
  { 95, 3, 1, 9, 3, -1 },
  { 96, 7, 16, 9, 1, -13 },
  { 110, 7, 11, 9, 1, -11 },
  { 120, 7, 11, 9, 1, -11 },
  { 130, 7, 11, 9, 1, -11 },
  { 140, 7, 11, 9, 1, -11 },
  { 150, 7, 11, 9, 1, -11 },
  { 160, 7, 11, 9, 1, -11 },
  { 170, 7, 11, 9, 1, -11 },
  { 180, 7, 11, 9, 1, -11 },
  { 190, 7, 11, 9, 1, -11 },
  { 200, 7, 11, 9, 1, -11 },
  { 210, 3, 7, 9, 3, -7 },
  { 213, 4, 9, 9, 2, -7 },
  { 218, 7, 7, 9, 1, -8 },
  { 225, 7, 4, 9, 1, -7 },
  { 229, 7, 7, 9, 1, -8 },
  { 236, 5, 11, 9, 2, -11 },
  { 243, 7, 13, 9, 1, -11 },
  { 255, 9, 11, 9, 0, -11 },
  { 268, 7, 11, 9, 1, -11 },
  { 278, 7, 11, 9, 1, -11 },
  { 288, 7, 11, 9, 1, -11 },
  { 298, 6, 11, 9, 2, -11 },
  { 307, 6, 11, 9, 2, -11 },
  { 316, 7, 11, 9, 1, -11 },
  { 326, 7, 11, 9, 1, -11 },
  { 336, 5, 11, 9, 2, -11 },
  { 343, 7, 11, 9, 1, -11 },
  { 353, 8, 11, 9, 1, -11 },
  { 364, 6, 11, 9, 2, -11 },
  { 373, 7, 11, 9, 1, -11 },
  { 383, 7, 11, 9, 1, -11 },
  { 393, 8, 11, 9, 1, -11 },
  { 404, 7, 11, 9, 1, -11 },
  { 414, 8, 14, 9, 1, -11 },
  { 428, 7, 11, 9, 1, -11 },
  { 438, 7, 11, 9, 1, -11 },
  { 448, 7, 11, 9, 1, -11 },
  { 458, 7, 11, 9, 1, -11 },
  { 468, 9, 11, 9, 0, -11 },
  { 481, 7, 11, 9, 1, -11 },
  { 491, 9, 11, 9, 0, -11 },
  { 504, 9, 11, 9, 0, -11 },
  { 517, 7, 11, 9, 1, -11 },
  { 527, 4, 14, 9, 3, -11 },
  { 534, 7, 16, 9, 1, -13 },
  { 548, 4, 14, 9, 2, -11 },
  { 555, 7, 6, 9, 1, -11 },
  { 561, 9, 1, 9, 0, 2 },
  { 563, 3, 3, 9, 3, -12 },
  { 565, 7, 8, 9, 1, -8 },
  { 572, 7, 12, 9, 1, -12 },
  { 583, 7, 8, 9, 1, -8 },
  { 590, 7, 12, 9, 1, -12 },
  { 601, 7, 8, 9, 1, -8 },
  { 608, 8, 12, 9, 1, -12 },
  { 620, 7, 11, 9, 1, -8 },
  { 630, 7, 12, 9, 1, -12 },
  { 641, 7, 10, 9, 1, -10 },
  { 650, 6, 13, 9, 1, -10 },
  { 660, 8, 12, 9, 1, -12 },
  { 672, 7, 12, 9, 1, -12 },
  { 683, 7, 8, 9, 1, -8 },
  { 690, 7, 8, 9, 1, -8 },
  { 697, 7, 8, 9, 1, -8 },
  { 704, 7, 11, 9, 1, -8 },
  { 714, 7, 11, 9, 1, -8 },
  { 724, 6, 8, 9, 2, -8 },
  { 730, 7, 8, 9, 1, -8 },
  { 737, 7, 11, 9, 1, -11 },
  { 747, 7, 8, 9, 1, -8 },
  { 754, 7, 8, 9, 1, -8 },
  { 761, 9, 8, 9, 0, -8 },
  { 770, 8, 8, 9, 1, -8 },
  { 778, 7, 11, 9, 1, -8 },
  { 788, 7, 8, 9, 1, -8 },
  { 795, 7, 16, 9, 1, -13 },
  { 809, 1, 16, 9, 4, -13 },
  { 811, 7, 16, 9, 1, -13 },
  { 825, 7, 2, 9, 1, -5 },
};

const GFXfont UbuntuMono_Regular18pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular18pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular18pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _UBUNTUMONO_REGULAR18PT7B_H_
