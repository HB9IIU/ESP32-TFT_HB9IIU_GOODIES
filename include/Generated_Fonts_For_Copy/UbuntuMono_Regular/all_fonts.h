#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated_Fonts_For_Copy/UbuntuMono_Regular
// Headers: 67

#include "UbuntuMono_Regular6pt7b.h"
#include "UbuntuMono_Regular7pt7b.h"
#include "UbuntuMono_Regular8pt7b.h"
#include "UbuntuMono_Regular9pt7b.h"
#include "UbuntuMono_Regular10pt7b.h"
#include "UbuntuMono_Regular11pt7b.h"
#include "UbuntuMono_Regular12pt7b.h"
#include "UbuntuMono_Regular13pt7b.h"
#include "UbuntuMono_Regular14pt7b.h"
#include "UbuntuMono_Regular15pt7b.h"
#include "UbuntuMono_Regular16pt7b.h"
#include "UbuntuMono_Regular17pt7b.h"
#include "UbuntuMono_Regular18pt7b.h"
#include "UbuntuMono_Regular19pt7b.h"
#include "UbuntuMono_Regular20pt7b.h"
#include "UbuntuMono_Regular21pt7b.h"
#include "UbuntuMono_Regular22pt7b.h"
#include "UbuntuMono_Regular23pt7b.h"
#include "UbuntuMono_Regular24pt7b.h"
#include "UbuntuMono_Regular25pt7b.h"
#include "UbuntuMono_Regular26pt7b.h"
#include "UbuntuMono_Regular27pt7b.h"
#include "UbuntuMono_Regular28pt7b.h"
#include "UbuntuMono_Regular29pt7b.h"
#include "UbuntuMono_Regular30pt7b.h"
#include "UbuntuMono_Regular31pt7b.h"
#include "UbuntuMono_Regular32pt7b.h"
#include "UbuntuMono_Regular33pt7b.h"
#include "UbuntuMono_Regular34pt7b.h"
#include "UbuntuMono_Regular35pt7b.h"
#include "UbuntuMono_Regular36pt7b.h"
#include "UbuntuMono_Regular37pt7b.h"
#include "UbuntuMono_Regular38pt7b.h"
#include "UbuntuMono_Regular39pt7b.h"
#include "UbuntuMono_Regular40pt7b.h"
#include "UbuntuMono_Regular41pt7b.h"
#include "UbuntuMono_Regular42pt7b.h"
#include "UbuntuMono_Regular43pt7b.h"
#include "UbuntuMono_Regular44pt7b.h"
#include "UbuntuMono_Regular45pt7b.h"
#include "UbuntuMono_Regular46pt7b.h"
#include "UbuntuMono_Regular47pt7b.h"
#include "UbuntuMono_Regular48pt7b.h"
#include "UbuntuMono_Regular49pt7b.h"
#include "UbuntuMono_Regular50pt7b.h"
#include "UbuntuMono_Regular51pt7b.h"
#include "UbuntuMono_Regular52pt7b.h"
#include "UbuntuMono_Regular53pt7b.h"
#include "UbuntuMono_Regular54pt7b.h"
#include "UbuntuMono_Regular55pt7b.h"
#include "UbuntuMono_Regular56pt7b.h"
#include "UbuntuMono_Regular57pt7b.h"
#include "UbuntuMono_Regular58pt7b.h"
#include "UbuntuMono_Regular59pt7b.h"
#include "UbuntuMono_Regular60pt7b.h"
#include "UbuntuMono_Regular61pt7b.h"
#include "UbuntuMono_Regular62pt7b.h"
#include "UbuntuMono_Regular63pt7b.h"
#include "UbuntuMono_Regular64pt7b.h"
#include "UbuntuMono_Regular65pt7b.h"
#include "UbuntuMono_Regular66pt7b.h"
#include "UbuntuMono_Regular67pt7b.h"
#include "UbuntuMono_Regular68pt7b.h"
#include "UbuntuMono_Regular69pt7b.h"
#include "UbuntuMono_Regular70pt7b.h"
#include "UbuntuMono_Regular71pt7b.h"
#include "UbuntuMono_Regular72pt7b.h"
