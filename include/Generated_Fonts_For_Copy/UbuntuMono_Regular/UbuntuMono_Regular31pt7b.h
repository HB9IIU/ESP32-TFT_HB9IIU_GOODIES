#ifndef _UBUNTUMONO_REGULAR31PT7B_H_
#define _UBUNTUMONO_REGULAR31PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 31pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular31pt7bBitmaps[] PROGMEM = {
  0x00, 0xEE, 0xEE, 0xEE, 0xEE, 0xE6, 0x66, 0x00, 0x0E, 0xFF, 0xE0, 0xC7,
  0xC7, 0xC6, 0xC6, 0xC6, 0xC6, 0xC6, 0xC2, 0x0E, 0x38, 0x38, 0xC0, 0xC3,
  0x03, 0x0C, 0x0C, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x18, 0x60, 0x61,
  0x81, 0x8E, 0x0E, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCC, 0x70, 0x71,
  0xC1, 0xC6, 0x06, 0x18, 0x00, 0x06, 0x00, 0x60, 0x06, 0x01, 0xF8, 0x7F,
  0xE7, 0xFE, 0xF0, 0x4E, 0x00, 0xE0, 0x0F, 0x00, 0x7E, 0x03, 0xF8, 0x1F,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x0F, 0xFF, 0xEF, 0xFC, 0x3F,
  0x80, 0x60, 0x06, 0x00, 0x60, 0x78, 0x1B, 0xF0, 0x6C, 0xC3, 0x33, 0x1C,
  0x8C, 0x62, 0x33, 0x0C, 0xDC, 0x33, 0x60, 0xFF, 0x01, 0xED, 0xC0, 0x6F,
  0x83, 0xB7, 0x0D, 0x8C, 0x66, 0x31, 0x98, 0xCC, 0x63, 0x60, 0xDD, 0x83,
  0xEC, 0x07, 0x00, 0x0F, 0x00, 0xFF, 0x03, 0xFC, 0x1C, 0x70, 0x70, 0xC0,
  0xC7, 0x03, 0xB8, 0x07, 0xC0, 0x3E, 0x38, 0xFC, 0xC6, 0x7B, 0x38, 0xFC,
  0xE1, 0xF3, 0x83, 0x8E, 0x0F, 0x3C, 0x7C, 0x7F, 0xB9, 0xFC, 0xE1, 0xE1,
  0x80, 0xFF, 0xF6, 0xDB, 0x01, 0x01, 0xC1, 0xC1, 0xC1, 0xC0, 0xC0, 0xE0,
  0x60, 0x70, 0x38, 0x18, 0x0C, 0x06, 0x07, 0x01, 0x80, 0xC0, 0x60, 0x38,
  0x1C, 0x06, 0x03, 0x80, 0xE0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x40, 0x60,
  0x38, 0x1E, 0x07, 0x81, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xE0,
  0x70, 0x38, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x60, 0x70,
  0x70, 0x78, 0x78, 0x38, 0x08, 0x00, 0x0E, 0x00, 0xE0, 0x06, 0x0C, 0x62,
  0xF6, 0xEF, 0xFF, 0x3F, 0x80, 0xF0, 0x3B, 0x87, 0x9C, 0x10, 0x80, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x83, 0xFF, 0xFF, 0xFF,
  0x03, 0x00, 0x18, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x39, 0xF7,
  0xCF, 0x18, 0xEF, 0x30, 0xFF, 0xFC, 0x73, 0xDE, 0xE0, 0x00, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C,
  0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x70, 0x0C, 0x03, 0x80, 0x00, 0x0F,
  0x80, 0xFF, 0x0F, 0xF8, 0xF1, 0xE7, 0x07, 0x38, 0x1D, 0x80, 0xFC, 0x67,
  0xE7, 0x3F, 0x3D, 0xF8, 0xCF, 0xC0, 0x76, 0x03, 0xB8, 0x1D, 0xC1, 0xCF,
  0x1E, 0x3F, 0xE0, 0xFF, 0x03, 0xE0, 0x03, 0x00, 0x70, 0x1F, 0x07, 0xF0,
  0x77, 0x04, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0, 0x1F,
  0x07, 0xFC, 0xFF, 0xEE, 0x1E, 0x40, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0x07, 0xFC, 0x7F, 0xC4, 0x1E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x1C, 0x1F, 0x81, 0xF8, 0x1F, 0xC0, 0x1E, 0x00, 0x70,
  0x07, 0x00, 0x7C, 0x0E, 0xFF, 0xEF, 0xFC, 0x3F, 0x00, 0x00, 0xE0, 0x0F,
  0x00, 0xF8, 0x0E, 0xC0, 0x66, 0x06, 0x30, 0x71, 0x87, 0x0C, 0x30, 0x63,
  0x03, 0x18, 0x19, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0x80, 0x0C, 0x00,
  0x60, 0x03, 0x00, 0x18, 0x3F, 0xE3, 0xFE, 0x3F, 0xE3, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x07, 0xE0, 0x7F, 0x87, 0xFC, 0x03, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x7C, 0x0E, 0xFF, 0xEF, 0xFC, 0x3F, 0x00, 0x01, 0xE0, 0xFE,
  0x1F, 0xE3, 0xE0, 0x78, 0x07, 0x00, 0xE0, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE,
  0xE0, 0xFC, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7F, 0x0E, 0x7F, 0xE3, 0xFC,
  0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x00, 0xE0, 0x1C, 0x01,
  0xC0, 0x38, 0x03, 0x80, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x00, 0x1F, 0x83, 0xFC, 0x7F, 0xEF,
  0x0E, 0xE0, 0x6E, 0x06, 0xE0, 0x6F, 0x1C, 0x7F, 0x83, 0xFC, 0x3F, 0xE6,
  0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x0F, 0xFF, 0xE7, 0xFC, 0x1F, 0x80,
  0x1F, 0x07, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0, 0x6C, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0x7F, 0xFF, 0x7F, 0xF1, 0xF6, 0x00, 0xE0, 0x0E, 0x01, 0xC0, 0x7C,
  0x7F, 0x87, 0xE0, 0x78, 0x00, 0x73, 0xDE, 0xE0, 0x00, 0x00, 0x00, 0x1C,
  0xF7, 0xB8, 0x38, 0xF3, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x8F, 0x3C,
  0xF1, 0xCE, 0xF3, 0x00, 0x00, 0x30, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F,
  0x80, 0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x30,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x70,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x0F, 0x00, 0x80, 0x00, 0x3E, 0x3F, 0xEF,
  0xFB, 0x0F, 0x01, 0xC0, 0x60, 0x18, 0x0C, 0x0E, 0x07, 0x01, 0x80, 0x60,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x3C, 0x0F, 0x01, 0x80, 0x07, 0xC0, 0x3F,
  0xC1, 0xFF, 0x8F, 0x0E, 0x70, 0x39, 0xC0, 0x66, 0x01, 0xD8, 0x7F, 0xE3,
  0xFF, 0x9F, 0xFE, 0x71, 0xF9, 0x87, 0xE6, 0x1F, 0x9C, 0x7E, 0x7F, 0xD8,
  0xFF, 0x71, 0xF9, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0xF0, 0x3F, 0xC0,
  0x3F, 0x00, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x37, 0x00, 0x66, 0x01,
  0xCC, 0x03, 0x1C, 0x06, 0x38, 0x1C, 0x30, 0x30, 0x70, 0x60, 0xE1, 0xC0,
  0xC3, 0xFF, 0x87, 0xFF, 0x9F, 0xFF, 0x38, 0x06, 0x70, 0x0E, 0xC0, 0x1F,
  0x80, 0x38, 0xFF, 0x0F, 0xFC, 0xFF, 0xCC, 0x1E, 0xC0, 0xEC, 0x06, 0xC0,
  0xEC, 0x1C, 0xFF, 0x8F, 0xF8, 0xFF, 0xEC, 0x0E, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x0F, 0xFF, 0xEF, 0xFC, 0xFF, 0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFE,
  0x78, 0x37, 0x80, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x00, 0xC0, 0x06, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x83, 0x3F, 0xF8, 0x7F,
  0xC1, 0xF8, 0xFE, 0x0F, 0xF8, 0xFF, 0xCC, 0x3E, 0xC0, 0xEC, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0xEC, 0x1E, 0xFF, 0xCF, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF, 0xFB, 0xFF, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF, 0xDF, 0xFB,
  0xFF, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x00, 0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x78, 0x27, 0x80, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x06, 0xC0, 0x36, 0x01, 0xB8, 0x0D,
  0xE0, 0x67, 0x83, 0x1F, 0xF8, 0x7F, 0xC1, 0xFC, 0xE0, 0x1F, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F,
  0x00, 0xF8, 0x06, 0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x3E,
  0x0F, 0xFF, 0xDF, 0xF0, 0xFC, 0x00, 0xE0, 0x77, 0x07, 0x38, 0x39, 0xC3,
  0x8E, 0x38, 0x73, 0x83, 0xB8, 0x1F, 0x80, 0xF8, 0x07, 0xE0, 0x3B, 0x81,
  0xCE, 0x0E, 0x38, 0x70, 0xE3, 0x83, 0x9C, 0x1C, 0xE0, 0x77, 0x03, 0xF8,
  0x0E, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x31, 0xC1, 0xC7, 0x87, 0x1E, 0x1E, 0x78,
  0xD9, 0xA3, 0x66, 0xCD, 0x9B, 0x66, 0x65, 0x9B, 0x9E, 0x6E, 0x71, 0xB8,
  0xC6, 0xE0, 0x1B, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0xE0, 0x1B, 0x80, 0x6C,
  0x01, 0x80, 0xE0, 0x7E, 0x07, 0xF0, 0x7F, 0x07, 0xF8, 0x7D, 0x87, 0xDC,
  0x7C, 0xC7, 0xCE, 0x7C, 0x67, 0xC7, 0x7C, 0x37, 0xC3, 0xFC, 0x1F, 0xC1,
  0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xC0, 0x70, 0x0F, 0x80, 0x7F, 0x83, 0xFF,
  0x1E, 0x1C, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0xB8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xE7, 0x03, 0x9E, 0x1C, 0x3F,
  0xF0, 0xFF, 0x80, 0xF8, 0x00, 0xFF, 0x0F, 0xFC, 0xFF, 0xEE, 0x0F, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF, 0xFC, 0xFF,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0x80,
  0x7F, 0x83, 0xFF, 0x1E, 0x1C, 0x70, 0x3B, 0x80, 0xEE, 0x01, 0xB8, 0x06,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1B, 0x80, 0xE7, 0x03,
  0x9E, 0x1C, 0x3F, 0xF0, 0xFF, 0x80, 0xFC, 0x01, 0xC0, 0x03, 0xC0, 0x07,
  0xE0, 0x0F, 0x80, 0x0C, 0xFF, 0x0F, 0xF8, 0xFF, 0xCC, 0x1E, 0xC0, 0xEC,
  0x06, 0xC0, 0x6C, 0x06, 0xC0, 0xEC, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0x0C,
  0x38, 0xC1, 0x8C, 0x0C, 0xC0, 0xEC, 0x06, 0xC0, 0x70, 0x1F, 0x83, 0xFE,
  0x7F, 0xEF, 0x04, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x7F, 0x01, 0xFC,
  0x07, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x7C, 0x0F, 0xFF, 0xEF, 0xFC,
  0x3F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xB0, 0x1D, 0xC0, 0xEF, 0x0F, 0x7F,
  0xF1, 0xFF, 0x03, 0xF0, 0x60, 0x0E, 0xC0, 0x1D, 0xC0, 0x3B, 0x80, 0x63,
  0x01, 0xC6, 0x03, 0x8E, 0x06, 0x1C, 0x0C, 0x18, 0x38, 0x38, 0x70, 0x70,
  0xC0, 0x63, 0x80, 0xE7, 0x01, 0xCC, 0x01, 0xB8, 0x03, 0xF0, 0x07, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0xC0, 0x1F, 0x80, 0x6E, 0x01, 0xB8, 0x06, 0xE0,
  0x1B, 0x80, 0x6E, 0x01, 0xB9, 0xC6, 0xE7, 0x1B, 0x9E, 0x66, 0xD9, 0x9B,
  0x66, 0x6C, 0xD9, 0xA3, 0x67, 0x8D, 0x9E, 0x1C, 0x78, 0x71, 0xC1, 0xC7,
  0x03, 0x00, 0xE0, 0x39, 0xC0, 0xE7, 0x07, 0x0E, 0x18, 0x18, 0xE0, 0x73,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x78, 0x03, 0xF0, 0x1D,
  0xC0, 0x73, 0x83, 0x86, 0x0C, 0x1C, 0x70, 0x31, 0x80, 0xEE, 0x01, 0x80,
  0x60, 0x0E, 0xE0, 0x1D, 0xC0, 0x71, 0xC0, 0xE3, 0x83, 0x83, 0x87, 0x07,
  0x1C, 0x07, 0x38, 0x0E, 0xE0, 0x0F, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x18,
  0x00, 0x30, 0x00, 0x60, 0x00, 0xC0, 0x01, 0x80, 0x03, 0x00, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x70, 0x0E, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0,
  0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE0, 0xFF, 0xFF, 0xE0, 0x0C, 0x01, 0xC0,
  0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x18, 0x03, 0x80, 0x70, 0x06, 0x00, 0xE0, 0x1C, 0x01, 0x80, 0xFF, 0xFC,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0xFF, 0xF8, 0x07, 0x00,
  0x3C, 0x03, 0xE0, 0x1B, 0x81, 0xCE, 0x1C, 0x70, 0xC1, 0xCE, 0x06, 0x60,
  0x3B, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFC, 0x47, 0x1C, 0x71, 0x80, 0x3F,
  0x8F, 0xF9, 0xFF, 0x90, 0x70, 0x06, 0x3F, 0xDF, 0xFF, 0x03, 0xC0, 0x78,
  0x0F, 0x81, 0xFF, 0xF7, 0xFE, 0x3F, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0xF8, 0xFF, 0xCF, 0xFE, 0xF0, 0xFE,
  0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x0F, 0xFF, 0xEF,
  0xFC, 0x7F, 0x00, 0x0F, 0xE3, 0xFF, 0x7F, 0xEF, 0x82, 0xE0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xF8, 0x17, 0xFF, 0x3F, 0xF0, 0xFE,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0xFB,
  0x3F, 0xF7, 0xFF, 0x78, 0x77, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0x70, 0x37, 0x83, 0x3F, 0xF1, 0xFF, 0x0F, 0xE0, 0x0F, 0xC0, 0xFF, 0x0F,
  0xFC, 0xE0, 0xF6, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x04, 0x7F, 0xE1, 0xFF, 0x07, 0xF0, 0x03, 0xE0, 0x7F, 0xC3, 0xFE,
  0x3C, 0x31, 0xC0, 0x0E, 0x00, 0x70, 0x1F, 0xFC, 0xFF, 0xE7, 0xFF, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0x83,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x37, 0x07, 0x7F, 0xF3, 0xFF,
  0x0F, 0xB0, 0x03, 0x00, 0x76, 0x0F, 0x7F, 0xE7, 0xFE, 0x3F, 0x80, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0xFC, 0xFF, 0xDF,
  0xFF, 0x83, 0xF0, 0x7E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3E, 0x06, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x10, 0xFF, 0x07, 0xF0, 0x3E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x3F, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xD0, 0xF7, 0xFB, 0xFE, 0x3E, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x0E, 0xE0, 0xE7, 0x0E, 0x38, 0xE1,
  0xDE, 0x0F, 0xE0, 0x7C, 0x03, 0xF8, 0x1D, 0xE0, 0xE3, 0x87, 0x0E, 0x38,
  0x39, 0xC0, 0xEE, 0x07, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE1, 0x0F, 0xF0, 0x7F, 0x03,
  0xE0, 0x7C, 0xF7, 0xFF, 0xFF, 0xFF, 0xCE, 0x3E, 0x31, 0xF1, 0x8F, 0x8C,
  0x7C, 0x63, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0C,
  0x7F, 0x1F, 0xFB, 0xFF, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xC0, 0x0F, 0x80, 0xFF, 0x0F,
  0xFC, 0xF0, 0xF7, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x3B, 0x81,
  0xDE, 0x1C, 0x7F, 0xE3, 0xFE, 0x07, 0xC0, 0x7F, 0x0F, 0xFC, 0xFF, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xE0, 0xFF,
  0xFE, 0xFF, 0xCF, 0xF8, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0xE1, 0xFF, 0x3F, 0xF7, 0x83, 0x70, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xE0, 0x37, 0x03, 0x78, 0x77, 0xFF, 0x3F, 0xF0, 0xFB, 0x00, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x3F, 0xFF, 0xFB, 0xFF, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x00, 0x1F, 0xCF, 0xFD, 0xFF, 0xF0, 0x2E, 0x00, 0xF8, 0x1F, 0xE0, 0xFE,
  0x03, 0xE0, 0x0F, 0x03, 0xFF, 0xFF, 0xFC, 0x7F, 0x00, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xC0, 0x1C, 0x01, 0xC0,
  0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x11, 0xFF, 0x0F, 0xF0, 0x7E,
  0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xBF, 0xF3, 0xFE, 0x3F, 0x80, 0xE0, 0x1B, 0x80, 0xE6,
  0x03, 0x9C, 0x0C, 0x70, 0x70, 0xE1, 0xC3, 0x86, 0x06, 0x38, 0x1C, 0xC0,
  0x77, 0x00, 0xDC, 0x03, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0xC0, 0x0F, 0x00,
  0x7C, 0x01, 0xF0, 0xC7, 0xC7, 0x1B, 0x9E, 0x6E, 0x79, 0x99, 0x66, 0x6C,
  0xF9, 0xB3, 0xE7, 0x8F, 0x1E, 0x1C, 0x30, 0x70, 0xC1, 0xC0, 0xE0, 0x39,
  0xC1, 0xC3, 0x86, 0x07, 0x38, 0x0D, 0xC0, 0x3E, 0x00, 0x70, 0x01, 0xE0,
  0x0F, 0xC0, 0x73, 0x03, 0x86, 0x0C, 0x1C, 0x70, 0x3B, 0x80, 0xE0, 0x60,
  0x3B, 0x81, 0xDC, 0x0E, 0x60, 0x63, 0x87, 0x1C, 0x38, 0x61, 0x83, 0x8C,
  0x1C, 0xE0, 0x76, 0x03, 0xB0, 0x0F, 0x80, 0x78, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0xFE, 0x07, 0xE0, 0x3E, 0x00, 0x7F, 0xEF, 0xFD, 0xFF, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01, 0xC0, 0x7F, 0xFF, 0xFF,
  0xFF, 0xC0, 0x03, 0xE0, 0xFC, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC1, 0xF0, 0x3E, 0x00, 0xE0,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0E,
  0x00, 0xFC, 0x0F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8,
  0x1F, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x38, 0x03, 0xC0, 0x78, 0x1C, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x06, 0x1F, 0xC3, 0xF0,
  0x00, 0x3C, 0x1B, 0xF8, 0xDF, 0xFF, 0xCF, 0xEC, 0x1E, 0x00,
};

const GFXglyph UbuntuMono_Regular31pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 19, 16, 6, -19 },
  { 11, 8, 8, 16, 4, -21 },
  { 19, 14, 19, 16, 1, -19 },
  { 53, 12, 24, 16, 2, -21 },
  { 89, 14, 19, 16, 1, -19 },
  { 123, 14, 19, 16, 1, -19 },
  { 157, 3, 8, 16, 6, -21 },
  { 160, 9, 27, 16, 3, -22 },
  { 191, 9, 27, 16, 3, -22 },
  { 222, 12, 11, 16, 2, -19 },
  { 239, 13, 14, 16, 1, -15 },
  { 262, 6, 8, 16, 5, -4 },
  { 268, 7, 2, 16, 4, -9 },
  { 270, 5, 4, 16, 5, -4 },
  { 273, 11, 27, 16, 2, -22 },
  { 311, 13, 19, 16, 1, -19 },
  { 342, 12, 19, 16, 2, -19 },
  { 371, 12, 19, 16, 2, -19 },
  { 400, 12, 19, 16, 2, -19 },
  { 429, 13, 19, 16, 1, -19 },
  { 460, 12, 19, 16, 2, -19 },
  { 489, 12, 19, 16, 2, -19 },
  { 518, 12, 19, 16, 2, -19 },
  { 547, 12, 19, 16, 2, -19 },
  { 576, 12, 19, 16, 2, -19 },
  { 605, 5, 14, 16, 5, -14 },
  { 614, 6, 18, 16, 4, -14 },
  { 628, 12, 13, 16, 2, -14 },
  { 648, 13, 8, 16, 1, -12 },
  { 661, 12, 13, 16, 2, -14 },
  { 681, 10, 19, 16, 3, -19 },
  { 705, 14, 23, 16, 1, -19 },
  { 746, 15, 19, 16, 0, -19 },
  { 782, 12, 19, 16, 2, -19 },
  { 811, 13, 19, 16, 1, -19 },
  { 842, 12, 19, 16, 2, -19 },
  { 871, 11, 19, 16, 3, -19 },
  { 898, 11, 19, 16, 3, -19 },
  { 925, 13, 19, 16, 1, -19 },
  { 956, 13, 19, 16, 1, -19 },
  { 987, 10, 19, 16, 3, -19 },
  { 1011, 11, 19, 16, 2, -19 },
  { 1038, 13, 19, 16, 2, -19 },
  { 1069, 11, 19, 16, 3, -19 },
  { 1096, 14, 19, 16, 1, -19 },
  { 1130, 12, 19, 16, 2, -19 },
  { 1159, 14, 19, 16, 1, -19 },
  { 1193, 12, 19, 16, 2, -19 },
  { 1222, 14, 24, 16, 1, -19 },
  { 1264, 12, 19, 16, 2, -19 },
  { 1293, 12, 19, 16, 2, -19 },
  { 1322, 13, 19, 16, 1, -19 },
  { 1353, 13, 19, 16, 1, -19 },
  { 1384, 15, 19, 16, 0, -19 },
  { 1420, 14, 19, 16, 1, -19 },
  { 1454, 14, 19, 16, 1, -19 },
  { 1488, 15, 19, 16, 0, -19 },
  { 1524, 12, 19, 16, 2, -19 },
  { 1553, 8, 27, 16, 4, -22 },
  { 1580, 11, 27, 16, 2, -22 },
  { 1618, 7, 27, 16, 4, -22 },
  { 1642, 13, 10, 16, 1, -19 },
  { 1659, 15, 2, 16, 0, 3 },
  { 1663, 5, 5, 16, 5, -21 },
  { 1667, 11, 14, 16, 2, -14 },
  { 1687, 12, 21, 16, 2, -21 },
  { 1719, 12, 14, 16, 2, -14 },
  { 1740, 12, 21, 16, 1, -21 },
  { 1772, 13, 14, 16, 1, -14 },
  { 1795, 13, 21, 16, 2, -21 },
  { 1830, 12, 19, 16, 1, -14 },
  { 1859, 11, 21, 16, 2, -21 },
  { 1888, 12, 20, 16, 2, -20 },
  { 1918, 10, 25, 16, 2, -20 },
  { 1950, 13, 21, 16, 2, -21 },
  { 1985, 12, 21, 16, 2, -21 },
  { 2017, 13, 14, 16, 1, -14 },
  { 2040, 11, 14, 16, 2, -14 },
  { 2060, 13, 14, 16, 1, -14 },
  { 2083, 12, 19, 16, 2, -14 },
  { 2112, 12, 19, 16, 1, -14 },
  { 2141, 11, 14, 16, 3, -14 },
  { 2161, 11, 14, 16, 2, -14 },
  { 2181, 12, 18, 16, 2, -18 },
  { 2208, 11, 14, 16, 2, -14 },
  { 2228, 14, 14, 16, 1, -14 },
  { 2253, 14, 14, 16, 1, -14 },
  { 2278, 14, 14, 16, 1, -14 },
  { 2303, 13, 19, 16, 1, -14 },
  { 2334, 11, 14, 16, 2, -14 },
  { 2354, 11, 27, 16, 2, -22 },
  { 2392, 2, 27, 16, 7, -22 },
  { 2399, 11, 27, 16, 2, -22 },
  { 2437, 13, 5, 16, 1, -11 },
};

const GFXfont UbuntuMono_Regular31pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular31pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular31pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _UBUNTUMONO_REGULAR31PT7B_H_
