#ifndef _UBUNTUMONO_REGULAR72PT7B_H_
#define _UBUNTUMONO_REGULAR72PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 72pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular72pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3F, 0x0F, 0xC3,
  0xF0, 0xFC, 0x3F, 0x0F, 0xC3, 0xF0, 0xFC, 0x3E, 0x0F, 0x83, 0xE0, 0x78,
  0x1E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F,
  0xC7, 0xFB, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0x7F, 0x07, 0x80, 0xFC,
  0x0F, 0xFF, 0x03, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xFF, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x0F, 0xDF, 0x03, 0xE7, 0x80, 0x79,
  0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78,
  0x07, 0x9E, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF8,
  0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7E, 0x01, 0xF0,
  0x00, 0x7E, 0x01, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0x7C, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0, 0x01, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xF0, 0x0F, 0x80, 0x03, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x80,
  0x03, 0xE0, 0x1F, 0x80, 0x03, 0xE0, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0x3E, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x1F, 0x80, 0x7C, 0x00,
  0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F, 0xE0,
  0x0F, 0x83, 0xF8, 0x00, 0x18, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xF4, 0x00, 0x00, 0x7F, 0x78, 0x00, 0x0F, 0xE7, 0xF0,
  0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xE1, 0xFF, 0xC0, 0x01,
  0xF0, 0xFF, 0xF0, 0x00, 0x7C, 0x7E, 0x3E, 0x00, 0x3E, 0x1F, 0x0F, 0x80,
  0x1F, 0x07, 0x81, 0xF0, 0x07, 0xC1, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x1F,
  0x00, 0xF8, 0x3E, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF0, 0x3E, 0x03, 0xE0,
  0x3C, 0x0F, 0x80, 0xF8, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xC3, 0xF0, 0x07,
  0x81, 0xF0, 0xF8, 0x01, 0xE0, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x1F, 0x00,
  0x1F, 0x8F, 0x8F, 0x80, 0x03, 0xFF, 0xC7, 0xE0, 0x00, 0x7F, 0xF1, 0xF0,
  0x00, 0x0F, 0xF8, 0xF8, 0x00, 0x01, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x00, 0x7C, 0x7F, 0xC0, 0x00, 0x3E, 0x3F, 0xF8, 0x00,
  0x1F, 0x0F, 0xFF, 0x00, 0x07, 0xC7, 0xC7, 0xE0, 0x03, 0xE1, 0xF0, 0xF8,
  0x00, 0xF8, 0x78, 0x1E, 0x00, 0x7C, 0x3E, 0x07, 0x80, 0x3E, 0x0F, 0x81,
  0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC0, 0xF0, 0x1F, 0x01, 0xF0, 0x3C,
  0x07, 0xC0, 0xF8, 0x0F, 0x81, 0xF0, 0x7C, 0x03, 0xE0, 0x7C, 0x1F, 0x00,
  0xF8, 0x1E, 0x0F, 0x80, 0x1E, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xE1, 0xF0,
  0x01, 0xF1, 0xF8, 0xF8, 0x00, 0x3F, 0xFC, 0x3E, 0x00, 0x0F, 0xFE, 0x1F,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x00,
  0x0F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0xF8,
  0x03, 0xFF, 0x00, 0xF8, 0x07, 0xFF, 0x80, 0xF8, 0x0F, 0xFF, 0xC0, 0xF8,
  0x1F, 0x9F, 0xE0, 0xF8, 0x3F, 0x0F, 0xF0, 0xF8, 0x3F, 0x07, 0xF9, 0xF0,
  0x7E, 0x03, 0xFD, 0xF0, 0x7E, 0x01, 0xFD, 0xF0, 0x7E, 0x00, 0xFF, 0xF0,
  0xFC, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0xFC, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0xF0,
  0x7F, 0x00, 0x3F, 0xF0, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xE3, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0xFC, 0x1F, 0xFF, 0xF8, 0xFC, 0x0F, 0xFF, 0xF0, 0x7E,
  0x03, 0xFF, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE7, 0x9E, 0x79, 0xE7, 0x80, 0x00,
  0x00, 0x80, 0x00, 0x1C, 0x00, 0x07, 0xC0, 0x00, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0,
  0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x01, 0xC0, 0x00, 0x08, 0x10, 0x00,
  0x03, 0x80, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x0F, 0xF8, 0x00, 0x7F,
  0x00, 0x03, 0xE0, 0x00, 0x38, 0x00, 0x01, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x00, 0xF8,
  0x04, 0x3C, 0x0F, 0x01, 0xC7, 0xF0, 0xF0, 0xFE, 0x7F, 0xCF, 0x3F, 0xE7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xE0, 0x0F, 0xE0, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x07, 0xC0, 0x3E,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x80, 0x10, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xE0, 0xFF, 0x83, 0xFF,
  0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x0F,
  0xC0, 0x7E, 0x03, 0xF8, 0x1F, 0xC3, 0xFE, 0x3F, 0xF0, 0xFF, 0x83, 0xFC,
  0x0F, 0xC0, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1E, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xDF, 0xE1, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xC0, 0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00,
  0xFC, 0x7F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7,
  0xE0, 0x78, 0x1F, 0xBF, 0x03, 0xF0, 0x7F, 0xFC, 0x1F, 0xE0, 0xFF, 0xF0,
  0x7F, 0x83, 0xFF, 0xC1, 0xFE, 0x0F, 0xFF, 0x07, 0xF8, 0x3F, 0xFC, 0x1F,
  0xE0, 0xFF, 0xF0, 0x3F, 0x03, 0xFF, 0xC0, 0x78, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0xC0, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFD, 0xF8, 0x01, 0xFE,
  0x3F, 0x00, 0x3F, 0x87, 0xE0, 0x03, 0xC0, 0xFC, 0x00, 0x60, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xF8, 0x0F, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0x80, 0x01,
  0xF8, 0x10, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0x1C,
  0x00, 0x7F, 0x81, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x60, 0x00,
  0x3F, 0xC7, 0xC0, 0x0F, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F,
  0x1F, 0x00, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x07, 0xE0,
  0xF8, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x07, 0xC0, 0x3F, 0x00, 0x0F, 0x80,
  0x7C, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x0F,
  0xC0, 0x00, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF2, 0x00, 0x03, 0xFC, 0x78, 0x01, 0xFF,
  0x1F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0,
  0x0F, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFC, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xEF, 0xC0, 0x00,
  0xFE, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE1, 0xFC,
  0x01, 0xFC, 0x1F, 0xF0, 0x7F, 0xC0, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E,
  0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0xFC, 0x3F, 0xC0, 0x1F, 0x81, 0xFE, 0x03, 0xF8, 0x1F,
  0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFE, 0x7F, 0xF8, 0x1F, 0x80, 0xFF, 0xC3,
  0xF0, 0x03, 0xFC, 0x7E, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x0F,
  0xE3, 0xFE, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xF0,
  0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7,
  0xF8, 0x00, 0x3F, 0x3F, 0xE0, 0x1F, 0xF3, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xDF, 0xE1, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x7F, 0x9F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0x7F, 0x87, 0x80, 0x01, 0xE0,
  0x0F, 0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07,
  0xFE, 0x07, 0xFC, 0x0F, 0xF0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x0F, 0xF0, 0x3F,
  0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x87, 0xFE, 0x07, 0xFC,
  0x07, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFE, 0x0F, 0xFC, 0x7F,
  0xF0, 0xFF, 0x81, 0xFE, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0xFF, 0x03, 0xFF,
  0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x8F, 0x00, 0xFF, 0x10, 0x00,
  0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0x81, 0xFE, 0x01, 0xFC, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0x7E,
  0x00, 0xFF, 0xFE, 0xF8, 0x03, 0xFF, 0xFD, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0xC0, 0xFF, 0x07, 0xFF, 0x81, 0xF8, 0x0F, 0xFF, 0x07,
  0xF0, 0x1F, 0xFE, 0x0F, 0xC0, 0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0xF8, 0x7E,
  0x00, 0xFF, 0xF0, 0xFC, 0x01, 0xFF, 0xE1, 0xF8, 0x03, 0xFF, 0xC3, 0xF0,
  0x07, 0xFF, 0x87, 0xE0, 0x0F, 0xFF, 0x0F, 0xC0, 0x1F, 0xFE, 0x0F, 0x80,
  0x3F, 0xFC, 0x1F, 0x80, 0x7F, 0xF8, 0x3F, 0x00, 0xFF, 0xF0, 0x7E, 0x01,
  0xFB, 0xF0, 0x7E, 0x03, 0xF7, 0xE0, 0xFF, 0x07, 0xEF, 0xC0, 0xFF, 0xFF,
  0xDF, 0x80, 0xFF, 0xFF, 0x9F, 0x80, 0xFF, 0xFF, 0x3F, 0x00, 0xFF, 0xFE,
  0x7E, 0x00, 0x7F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00, 0xC0, 0x03,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x00, 0x7C, 0xFC, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x0F, 0x8F,
  0xC0, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7C,
  0x0F, 0x80, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F,
  0xFF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x9F, 0x00, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xC0, 0x1F, 0xF8, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF0, 0xFC, 0x01,
  0xFF, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0xFF, 0xCF, 0xC0,
  0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xEF,
  0xC0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x7F, 0x80, 0x07, 0x83,
  0xFC, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0x80,
  0xFF, 0xC0, 0x3E, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7E, 0x03, 0xFF, 0x83, 0xF0, 0x03, 0xFE, 0x1F,
  0x80, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7F, 0x7E, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC,
  0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x03, 0xFE, 0x1F, 0x80, 0x7F, 0xE0, 0xFF,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFC,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0x7F, 0x80, 0x07, 0x03, 0xFC, 0x00, 0x04,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0xFC, 0xFE, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0xE0, 0x00,
  0xFC, 0x3F, 0xC0, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xC0, 0xFF, 0x80, 0x7F,
  0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x88,
  0x00, 0x0F, 0xE7, 0x80, 0x07, 0xF9, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00,
  0xFE, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x03,
  0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFE, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F,
  0xE0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x0F, 0xDF, 0xE0,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x03,
  0xF3, 0xFC, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0xFC,
  0x1F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x00,
  0xFF, 0x00, 0xFC, 0x01, 0xFE, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0xC0, 0x07,
  0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x07, 0xF3,
  0xF0, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x01, 0xFC, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x1F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xF0, 0x0F, 0xFC, 0x1E, 0xF0, 0x0F, 0x7C, 0x3E, 0xF0,
  0x0F, 0x7C, 0x3E, 0xF8, 0x1F, 0x7C, 0x3E, 0x78, 0x1F, 0x7C, 0x3E, 0x78,
  0x1E, 0x7C, 0x3E, 0x7C, 0x1E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x3C,
  0x3C, 0x7C, 0x3E, 0x3E, 0x3C, 0x7C, 0x3E, 0x3E, 0x7C, 0x7C, 0x3E, 0x1E,
  0x78, 0x7C, 0x3E, 0x1E, 0x78, 0x7C, 0x3E, 0x1F, 0xF8, 0x7E, 0x7E, 0x0F,
  0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x3E, 0x7E, 0x0F, 0xF0, 0x3E, 0x7C, 0x07,
  0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xBE, 0x00, 0x1F, 0xFB, 0xF0, 0x01, 0xFF, 0x9F, 0x00, 0x1F,
  0xF9, 0xF8, 0x01, 0xFF, 0x8F, 0x80, 0x1F, 0xF8, 0xFC, 0x01, 0xFF, 0x87,
  0xC0, 0x1F, 0xF8, 0x7E, 0x01, 0xFF, 0x83, 0xE0, 0x1F, 0xF8, 0x3F, 0x01,
  0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x81, 0xFF, 0x80, 0xF8, 0x1F, 0xF8,
  0x0F, 0xC1, 0xFF, 0x80, 0x7C, 0x1F, 0xF8, 0x07, 0xC1, 0xFF, 0x80, 0x3E,
  0x1F, 0xF8, 0x03, 0xE1, 0xFF, 0x80, 0x3F, 0x1F, 0xF8, 0x01, 0xF1, 0xFF,
  0x80, 0x1F, 0x1F, 0xF8, 0x00, 0xF9, 0xFF, 0x80, 0x0F, 0x9F, 0xF8, 0x00,
  0x7D, 0xFF, 0x80, 0x07, 0xDF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x8F, 0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x03,
  0xFC, 0xFC, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xE0,
  0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xF8,
  0x1F, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x38, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0,
  0x7E, 0x00, 0xFF, 0xC3, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xFC, 0x7E, 0x00,
  0x3F, 0xC3, 0xF0, 0x07, 0xFC, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xC1, 0xFF, 0x01, 0xF8, 0x3F,
  0x80, 0x03, 0x83, 0xF0, 0x00, 0x08, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF2,
  0x00, 0x00, 0x7E, 0x78, 0x00, 0x0F, 0xE7, 0xF0, 0x07, 0xFC, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF0,
  0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xFC, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF8,
  0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xC0,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7C, 0x07,
  0xE0, 0x3E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F, 0xF0, 0x7E, 0x7E, 0x0F,
  0xF0, 0x7E, 0x7E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1E, 0x78, 0x7C, 0x3E, 0x1E,
  0x78, 0x7C, 0x3E, 0x3E, 0x7C, 0x7C, 0x3E, 0x3C, 0x7C, 0x7C, 0x3E, 0x3C,
  0x3C, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3E, 0x7C, 0x3E, 0x78,
  0x1E, 0x7C, 0x3E, 0xF8, 0x1E, 0x7C, 0x3E, 0xF8, 0x1F, 0x7C, 0x3E, 0xF0,
  0x0F, 0x7C, 0x3E, 0xF0, 0x0F, 0x78, 0x3F, 0xF0, 0x0F, 0xF8, 0x1F, 0xE0,
  0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00,
  0x00, 0xFE, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0,
  0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFE,
  0x3F, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x03, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00,
  0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xC0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFC,
  0x07, 0xF0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x03, 0xF3, 0xC0, 0x00, 0x0F, 0x02, 0x00, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x10, 0x03, 0x80, 0x7C,
  0x0F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xF0, 0x1C, 0x00, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1C, 0x00, 0xFF,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0xFF, 0xEF, 0xC0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFD, 0xFF, 0x80, 0x3F, 0xBF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xBF,
  0x80, 0x03, 0xF7, 0xFC, 0x00, 0x7E, 0x7F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x1C,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x0F, 0xDF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFC, 0x0F, 0xF8, 0xFF, 0x00, 0x3F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xF8, 0xFE, 0x01, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xE1,
  0xFF, 0xC0, 0x0E, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x70,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x3F, 0xC3, 0xF0, 0x0F, 0xFF, 0xBF, 0x03, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x03, 0xFF, 0x3F, 0xC0,
  0x0F, 0xF3, 0xF8, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x3F, 0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF1,
  0xFE, 0x00, 0x3F, 0x1F, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x7F, 0x81, 0xFE,
  0x00, 0xFF, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x08, 0x0F, 0xFC, 0x01,
  0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xE0, 0x0F, 0xE0, 0x01, 0x80, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x00,
  0x7F, 0x1F, 0xC0, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7,
  0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F,
  0xC0, 0x07, 0xF1, 0xFF, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xBF, 0x00, 0x3F, 0xC3, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE1, 0x00, 0x01, 0xFC,
  0x3E, 0x00, 0x7F, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x7F, 0x80, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x3F, 0xCF, 0xC0, 0x07, 0xFB,
  0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x10, 0x01, 0xFC, 0x0F, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE2, 0x00, 0x1F, 0xCF, 0x80, 0xFF,
  0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0x1C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x03, 0xF9,
  0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0,
  0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x07, 0xF8, 0x07, 0xE0, 0x7F,
  0x80, 0x3F, 0x07, 0xF8, 0x01, 0xF8, 0x7F, 0x80, 0x0F, 0xC7, 0xF8, 0x00,
  0x7E, 0x7F, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0x7F, 0x80, 0x01, 0xF9, 0xFE,
  0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x80,
  0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3F,
  0x00, 0x3F, 0x81, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00,
  0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFE, 0xFC, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x1F, 0xC0, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x01, 0x00, 0x1F, 0xC0, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0x83, 0xFF, 0xF1, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFB, 0xF0, 0x7F, 0x87, 0xFF, 0x80,
  0xFC, 0x0F, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F,
  0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0,
  0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE, 0x03, 0xF0, 0x1F,
  0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x3F, 0x01, 0xFF, 0x80, 0xFC, 0x07, 0xFE,
  0x03, 0xF0, 0x1F, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x1F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0x3F, 0x80, 0x3F, 0xCF, 0xC0, 0x07, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xC0, 0xFF, 0x81, 0xFC, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x0F,
  0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0x0F, 0xE0, 0x1F, 0xF8, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xF0, 0x03, 0xFC, 0xFF, 0xC0, 0xFF,
  0x8F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFD,
  0xFF, 0xF0, 0x0F, 0xC7, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xFF, 0x80, 0x7F, 0x1F, 0xE0, 0x03,
  0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F,
  0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF3, 0xFC,
  0x00, 0x7F, 0x1F, 0xF0, 0x3F, 0xF0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFB, 0xF0, 0x03, 0xFC, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x0E, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x1F, 0xF0, 0x07, 0xC7, 0xE0, 0x00, 0x31, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF4,
  0x00, 0x00, 0xFD, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xBF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x01, 0xFE, 0x03, 0xC0, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x0F, 0xDF, 0xC0, 0x03, 0xF7, 0xF8, 0x00, 0xFC, 0xFF, 0x80, 0x7F, 0x3F,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x00, 0x7E, 0x7E, 0x01, 0xF0, 0x1F, 0x9F, 0x80, 0xFC, 0x07, 0xE3, 0xE0,
  0x3F, 0x01, 0xF0, 0xF8, 0x0F, 0xC0, 0x7C, 0x3E, 0x03, 0xF8, 0x1F, 0x0F,
  0x81, 0xFE, 0x07, 0xC3, 0xE0, 0x7F, 0x81, 0xF0, 0xFC, 0x1F, 0xF0, 0x7C,
  0x3F, 0x0F, 0xFC, 0x3E, 0x07, 0xC3, 0xCF, 0x0F, 0x81, 0xF1, 0xF3, 0xE3,
  0xE0, 0x7C, 0x7C, 0xF8, 0xF8, 0x1F, 0x1E, 0x1E, 0x3E, 0x07, 0xCF, 0x87,
  0xCF, 0x81, 0xFB, 0xE1, 0xF7, 0xC0, 0x3E, 0xF0, 0x3D, 0xF0, 0x0F, 0xFC,
  0x0F, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F,
  0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xC0, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x7E,
  0x00, 0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x1F,
  0xDF, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7F,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xE0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xE3, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0xFD, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF,
  0xF8, 0x00, 0x1F, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x30, 0x3F, 0xF0, 0x00,
  0xF3, 0xFF, 0xF0, 0x07, 0xCF, 0xFF, 0xE0, 0x1F, 0x7F, 0xFF, 0xE0, 0xFB,
  0xF0, 0x7F, 0xFF, 0xEF, 0x80, 0x7F, 0xFF, 0x3C, 0x00, 0xFF, 0xF8, 0x30,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00,
};

const GFXglyph UbuntuMono_Regular72pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 36, 0, -1 },
  { 1, 10, 46, 36, 13, -45 },
  { 59, 18, 18, 36, 9, -49 },
  { 100, 32, 45, 36, 2, -45 },
  { 280, 28, 57, 36, 4, -50 },
  { 480, 34, 47, 36, 1, -46 },
  { 680, 32, 45, 36, 2, -45 },
  { 860, 6, 19, 36, 15, -49 },
  { 875, 20, 62, 36, 8, -50 },
  { 1030, 20, 62, 36, 8, -50 },
  { 1185, 28, 27, 36, 4, -45 },
  { 1280, 30, 31, 36, 3, -34 },
  { 1397, 14, 20, 36, 11, -9 },
  { 1432, 16, 6, 36, 10, -21 },
  { 1444, 10, 11, 36, 13, -10 },
  { 1458, 26, 62, 36, 5, -50 },
  { 1660, 30, 47, 36, 3, -46 },
  { 1837, 27, 45, 36, 5, -45 },
  { 1989, 28, 46, 36, 4, -46 },
  { 2150, 28, 47, 36, 4, -46 },
  { 2315, 31, 45, 36, 3, -45 },
  { 2490, 27, 46, 36, 5, -45 },
  { 2646, 28, 46, 36, 4, -45 },
  { 2807, 28, 45, 36, 5, -45 },
  { 2965, 28, 47, 36, 4, -46 },
  { 3130, 28, 46, 36, 4, -46 },
  { 3291, 10, 34, 36, 13, -33 },
  { 3334, 15, 44, 36, 9, -33 },
  { 3417, 29, 29, 36, 4, -33 },
  { 3523, 30, 19, 36, 3, -29 },
  { 3595, 29, 29, 36, 4, -33 },
  { 3701, 23, 47, 36, 7, -46 },
  { 3837, 31, 55, 36, 3, -45 },
  { 4051, 34, 45, 36, 1, -45 },
  { 4243, 28, 45, 36, 4, -45 },
  { 4401, 30, 45, 36, 3, -45 },
  { 4570, 29, 45, 36, 4, -45 },
  { 4734, 26, 45, 36, 7, -45 },
  { 4881, 25, 45, 36, 7, -45 },
  { 5022, 30, 45, 36, 3, -45 },
  { 5191, 30, 45, 36, 3, -45 },
  { 5360, 24, 45, 36, 6, -45 },
  { 5495, 26, 45, 36, 4, -45 },
  { 5642, 30, 45, 36, 5, -45 },
  { 5811, 26, 45, 36, 7, -45 },
  { 5958, 32, 45, 36, 2, -45 },
  { 6138, 28, 45, 36, 4, -45 },
  { 6296, 32, 45, 36, 2, -45 },
  { 6476, 28, 45, 36, 5, -45 },
  { 6634, 32, 56, 36, 2, -45 },
  { 6858, 29, 45, 36, 4, -45 },
  { 7022, 28, 45, 36, 4, -45 },
  { 7180, 30, 45, 36, 3, -45 },
  { 7349, 30, 45, 36, 3, -45 },
  { 7518, 34, 45, 36, 1, -45 },
  { 7710, 32, 45, 36, 2, -45 },
  { 7890, 32, 45, 36, 2, -45 },
  { 8070, 34, 45, 36, 1, -45 },
  { 8262, 29, 45, 36, 4, -45 },
  { 8426, 18, 62, 36, 10, -50 },
  { 8566, 26, 62, 36, 5, -50 },
  { 8768, 18, 62, 36, 8, -50 },
  { 8908, 30, 24, 36, 3, -45 },
  { 8998, 34, 5, 36, 1, 7 },
  { 9020, 12, 13, 36, 12, -50 },
  { 9040, 27, 34, 36, 4, -34 },
  { 9155, 28, 50, 36, 5, -50 },
  { 9330, 28, 34, 36, 4, -34 },
  { 9449, 28, 50, 36, 3, -50 },
  { 9624, 30, 34, 36, 3, -34 },
  { 9752, 30, 50, 36, 5, -50 },
  { 9940, 28, 46, 36, 3, -34 },
  { 10101, 26, 50, 36, 5, -50 },
  { 10264, 28, 47, 36, 4, -47 },
  { 10429, 23, 59, 36, 5, -47 },
  { 10599, 29, 50, 36, 5, -50 },
  { 10781, 28, 50, 36, 4, -50 },
  { 10956, 30, 34, 36, 3, -34 },
  { 11084, 26, 34, 36, 5, -34 },
  { 11195, 30, 34, 36, 3, -34 },
  { 11323, 28, 46, 36, 5, -34 },
  { 11484, 28, 46, 36, 3, -34 },
  { 11645, 24, 34, 36, 8, -34 },
  { 11747, 26, 34, 36, 5, -34 },
  { 11858, 27, 43, 36, 5, -43 },
  { 12004, 26, 33, 36, 5, -33 },
  { 12112, 32, 33, 36, 2, -33 },
  { 12244, 34, 33, 36, 1, -33 },
  { 12385, 32, 33, 36, 2, -33 },
  { 12517, 30, 45, 36, 3, -33 },
  { 12686, 26, 33, 36, 5, -33 },
  { 12794, 25, 62, 36, 6, -50 },
  { 12988, 6, 62, 36, 15, -50 },
  { 13035, 25, 62, 36, 5, -50 },
  { 13229, 30, 10, 36, 3, -24 },
};

const GFXfont UbuntuMono_Regular72pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular72pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular72pt7bGlyphs,
  0x20, 0x7E, 72
};

#endif // _UBUNTUMONO_REGULAR72PT7B_H_
