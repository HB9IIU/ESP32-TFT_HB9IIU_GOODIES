#ifndef _UBUNTUMONO_REGULAR63PT7B_H_
#define _UBUNTUMONO_REGULAR63PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular63pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0x78, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78,
  0xFE, 0x7F, 0x7F, 0xFF, 0xFF, 0xF7, 0xF3, 0xF8, 0x78, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFE, 0x07, 0xFC, 0x0F,
  0xF8, 0x1F, 0xF0, 0x3D, 0xE0, 0x7B, 0x80, 0xF7, 0x01, 0xEE, 0x03, 0xDC,
  0x07, 0xB8, 0x06, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00, 0x7C,
  0x0F, 0x80, 0x07, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x00, 0xF8, 0x0F, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03,
  0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x78, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0x80, 0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0,
  0x1E, 0x00, 0x1E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x87, 0xF8, 0x07, 0x83, 0xF0, 0x00,
  0x43, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF2, 0x00, 0x03, 0xFB, 0xF0, 0x07, 0xF9, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0xFF, 0x00, 0x07, 0x8F, 0xFC, 0x00, 0x78, 0xF9, 0xF0, 0x07, 0xC7,
  0x87, 0x80, 0x3C, 0x3C, 0x3C, 0x03, 0xE3, 0xC0, 0xF0, 0x3E, 0x1E, 0x07,
  0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x0F,
  0x01, 0xE0, 0x78, 0xF8, 0x0F, 0x03, 0xC7, 0x80, 0x78, 0x1E, 0x7C, 0x01,
  0xE1, 0xE3, 0xC0, 0x0F, 0x0F, 0x3C, 0x00, 0x7C, 0xFB, 0xE0, 0x01, 0xFF,
  0x9E, 0x00, 0x07, 0xF9, 0xF0, 0x00, 0x0F, 0x0F, 0x1F, 0x00, 0x00, 0xF3,
  0xFE, 0x00, 0x0F, 0x9F, 0xF8, 0x00, 0x79, 0xE3, 0xC0, 0x07, 0x9E, 0x1F,
  0x00, 0x7C, 0xF0, 0x78, 0x03, 0xC7, 0x83, 0xC0, 0x3E, 0x3C, 0x1E, 0x01,
  0xE1, 0xE0, 0xF0, 0x1E, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x3C, 0x0F, 0x03,
  0xC1, 0xE0, 0xF8, 0x1E, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x78, 0x07, 0x83,
  0xC7, 0xC0, 0x3E, 0x3E, 0x3C, 0x00, 0xF1, 0xE3, 0xE0, 0x03, 0xFF, 0x3E,
  0x00, 0x1F, 0xF1, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x01, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7D, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x07, 0xC0, 0xFF, 0xC0, 0x78, 0x1F, 0xFE, 0x07, 0x81, 0xF7, 0xF0, 0x78,
  0x3E, 0x3F, 0x8F, 0x87, 0xE1, 0xFC, 0xF8, 0x7C, 0x0F, 0xEF, 0x07, 0xC0,
  0x7F, 0xF0, 0xF8, 0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xE0, 0xF8, 0x00, 0xFE,
  0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xF0, 0xFE,
  0x01, 0xFF, 0x87, 0xF8, 0xFF, 0xF8, 0x7F, 0xFF, 0xEF, 0xC3, 0xFF, 0xFC,
  0x7C, 0x1F, 0xFF, 0x87, 0xE0, 0xFF, 0xF0, 0x3E, 0x01, 0xF8, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xBD, 0xEF, 0x70, 0x00,
  0x02, 0x00, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xF8,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF0, 0x00, 0x38, 0x00, 0x08, 0x10, 0x00, 0x1C, 0x00,
  0x1F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xC0,
  0x01, 0xC0, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x40,
  0x3C, 0x04, 0x78, 0x3C, 0x1E, 0xFE, 0x3C, 0x7E, 0xFF, 0xB9, 0xFE, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x00, 0x01, 0xEF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xC7, 0xE0, 0x0F,
  0xC3, 0xF0, 0x1F, 0x83, 0xF8, 0x1F, 0x81, 0xF0, 0x07, 0x01, 0xE0, 0x02,
  0x00, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x3F,
  0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F, 0xE0, 0xFF, 0x03, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x7E, 0x1F, 0xE3, 0xFE, 0x0F, 0xE0, 0x7C,
  0x03, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3E, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x07, 0xE0, 0xFC, 0x00,
  0xFC, 0x3E, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF9, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB,
  0xE0, 0x78, 0x3E, 0xF8, 0x3F, 0x0F, 0xFE, 0x1F, 0xC3, 0xFF, 0x87, 0xF0,
  0xFF, 0xE1, 0xFC, 0x3F, 0xF8, 0x7F, 0x0F, 0xFE, 0x0F, 0xC3, 0xFF, 0x81,
  0xE0, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x07,
  0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x07, 0xF0,
  0x7F, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0x3E, 0x01, 0xFC, 0x7C, 0x01, 0xE0,
  0xF8, 0x03, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x01, 0xFF,
  0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF8, 0xFE, 0x07, 0xF8, 0x78, 0x01, 0xFC, 0x70, 0x00, 0xFC, 0x20,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3C,
  0x07, 0xF8, 0x30, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x40, 0x00, 0xFE, 0xF8,
  0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0x83,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x1F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x40, 0x00, 0xFE, 0x78, 0x03, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xF8, 0x0F, 0xF7, 0xE0, 0x01, 0xFB, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7D,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x3E, 0x3F, 0x80, 0x3F, 0x0F, 0xE0, 0x7F,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE1, 0xFE, 0x07,
  0xF0, 0xFC, 0x01, 0xFC, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x01, 0xF3, 0xF0,
  0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7F, 0x80, 0xF8, 0x1F, 0xF1, 0xF8, 0x07,
  0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0xC0,
  0x7E, 0x7F, 0xF0, 0x7C, 0x07, 0xFC, 0x7C, 0x00, 0xFE, 0x7C, 0x00, 0x1F,
  0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0xBF, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC1,
  0xFE, 0x0F, 0xF0, 0xFC, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBF, 0x80, 0x07, 0xCF, 0xE0, 0x1F, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x01, 0xFE, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x1E, 0x3F,
  0x9F, 0xFF, 0xFF, 0xFF, 0xFD, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE3, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xDF, 0xEF, 0xE3, 0xE0, 0x03, 0xC0, 0x7F, 0x03, 0xFC,
  0x3F, 0xE1, 0xFF, 0x0F, 0xF8, 0x3F, 0xC1, 0xFC, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x07, 0xF0, 0x3F, 0xC3, 0xFE, 0x1F, 0xF0,
  0xFF, 0xC3, 0xFE, 0x1F, 0xE0, 0x7F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x0F,
  0xC1, 0xFE, 0x3F, 0xE1, 0xFC, 0x0F, 0xC0, 0x30, 0x00, 0x00, 0x00, 0x01,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x03,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE7, 0x81, 0xFE,
  0x40, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xE1, 0xFC, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xE0, 0xFE, 0x1F, 0xF8, 0x7E, 0x07, 0xFE, 0x1F, 0x81, 0xFF, 0x87,
  0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F, 0x01, 0xFF,
  0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F, 0x81,
  0xFF, 0x83, 0xF8, 0x7F, 0xF0, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xDF, 0x03,
  0xFF, 0xF7, 0xC0, 0x7F, 0xFD, 0xF8, 0x03, 0xFC, 0x3E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x20, 0x0F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x07, 0xDF,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE3, 0xE0,
  0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF0, 0x7C, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0x80, 0x03,
  0xE0, 0x1F, 0x00, 0x0F, 0x00, 0x7C, 0x00, 0x7C, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x00, 0xF8, 0x00,
  0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0,
  0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x7C, 0x7C,
  0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x0F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xF3, 0xF0, 0x03, 0xF9,
  0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xDF, 0x80, 0x07, 0xCF, 0xC0, 0x03, 0xE7, 0xE0, 0x03, 0xF3, 0xF0, 0x03,
  0xF1, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x8F, 0xC0, 0x1F, 0xE7, 0xE0, 0x03, 0xFB, 0xF0,
  0x00, 0x7D, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0x7E, 0x00, 0xFF,
  0xBF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xE1,
  0xFE, 0x00, 0x10, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x83, 0xFE, 0x01, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x1F,
  0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3F, 0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xE3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x0F,
  0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xFE, 0x3F, 0x01,
  0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x07, 0xE1, 0xFE, 0x00, 0x30, 0x7F, 0x00,
  0x04, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7,
  0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03,
  0xF3, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0xE0, 0x0F, 0xC3, 0xFE,
  0x03, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x90, 0x00, 0x3F, 0x38,
  0x00, 0xFC, 0xFC, 0x07, 0xF9, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x9F,
  0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x0F,
  0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x80, 0xF8,
  0x07, 0xE0, 0x1F, 0x01, 0xFC, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xCF,
  0xE0, 0x00, 0xFB, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xF7, 0xF8, 0x00, 0x3E, 0x3F,
  0x80, 0x07, 0xC3, 0xF8, 0x00, 0xF8, 0x3F, 0x80, 0x1F, 0x03, 0xF8, 0x03,
  0xE0, 0x3F, 0x80, 0x7C, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xF0, 0xF8, 0x00, 0x7E, 0x1F,
  0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFE, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x1F,
  0xC0, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x0F, 0xF0, 0x0F,
  0xE1, 0xFE, 0x03, 0xDE, 0x3F, 0xC0, 0x7B, 0xC7, 0xBC, 0x0F, 0x78, 0xF7,
  0x81, 0xCF, 0x1E, 0xF0, 0x79, 0xE3, 0xCF, 0x0F, 0x3C, 0xF9, 0xE1, 0xC7,
  0x9F, 0x3C, 0x78, 0xF3, 0xE3, 0xCF, 0x1E, 0x7C, 0x79, 0xE3, 0xCF, 0x8F,
  0x78, 0x79, 0xF0, 0xFF, 0x0F, 0x3C, 0x1F, 0xE1, 0xF7, 0x83, 0xF8, 0x3E,
  0xF0, 0x3F, 0x07, 0xDE, 0x07, 0xE0, 0xFB, 0xC0, 0xF8, 0x1F, 0x78, 0x00,
  0x03, 0xEF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x1F, 0xFB, 0xC0, 0x0F, 0xFD, 0xF0, 0x07, 0xFE, 0x78, 0x03, 0xFF,
  0x3E, 0x01, 0xFF, 0x8F, 0x00, 0xFF, 0xC7, 0xC0, 0x7F, 0xE1, 0xE0, 0x3F,
  0xF0, 0xF8, 0x1F, 0xF8, 0x3C, 0x0F, 0xFC, 0x1F, 0x07, 0xFE, 0x07, 0x83,
  0xFF, 0x03, 0xE1, 0xFF, 0x80, 0xF0, 0xFF, 0xC0, 0x7C, 0x7F, 0xE0, 0x1E,
  0x3F, 0xF0, 0x0F, 0x9F, 0xF8, 0x07, 0xCF, 0xFC, 0x01, 0xE7, 0xFE, 0x00,
  0xFB, 0xFF, 0x00, 0x3D, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0x3E, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x0F, 0xF0,
  0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x81, 0xFE,
  0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8,
  0x03, 0xFC, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x07, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE,
  0x0F, 0xF0, 0x1F, 0x80, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x7E, 0xFC,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x3F,
  0x81, 0xFE, 0x07, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x1F, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFC, 0x3F, 0x00, 0xFF, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C,
  0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0,
  0x0F, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3E,
  0x03, 0xF0, 0x07, 0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x8F,
  0xC0, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFE, 0x01, 0xF0, 0xFC,
  0x00, 0x10, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x40, 0x00, 0x3F, 0x38, 0x00, 0x3F, 0x3F,
  0x80, 0x7F, 0x9F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x7F, 0x00,
  0x3F, 0x1F, 0xE0, 0x7F, 0x8F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0x80,
  0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x3E, 0x07, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F,
  0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC,
  0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3E, 0xF0, 0x00, 0x07, 0xDE, 0x00,
  0x00, 0xFB, 0xC0, 0xF8, 0x1F, 0x78, 0x1F, 0x03, 0xEF, 0x03, 0xF0, 0x7D,
  0xE0, 0xFE, 0x0F, 0xBC, 0x1F, 0xC1, 0xE7, 0xC3, 0xBC, 0x3C, 0xF8, 0xF7,
  0x87, 0x9F, 0x1E, 0x70, 0xF3, 0xE3, 0xCF, 0x1E, 0x7C, 0xF1, 0xE3, 0xCF,
  0x9E, 0x1C, 0x79, 0xF3, 0xC3, 0xCF, 0x1E, 0xF0, 0x79, 0xE3, 0xDE, 0x0F,
  0x3C, 0x7B, 0xC0, 0xF7, 0x8F, 0xF0, 0x1E, 0xF1, 0xFE, 0x03, 0xDC, 0x3F,
  0xC0, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0xC0, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xE0, 0xFC,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x03, 0xF0,
  0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3E, 0x0F,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x01,
  0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xE7,
  0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x07,
  0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0x7E, 0x1F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x9F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0x7E,
  0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xC0, 0x1F, 0x83,
  0xE0, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0xBF, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFD, 0xE0, 0x00, 0x1E, 0x10, 0x00, 0x02, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x3E, 0x03, 0xE0, 0x38, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0x80, 0x3F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x0F, 0xFD, 0xF0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xBF, 0xC0, 0x3F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0,
  0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00,
  0x0F, 0xFF, 0x80, 0x1F, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xF8, 0x1F,
  0xE7, 0xF0, 0x03, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0x7E, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF, 0x80, 0x07, 0xEF,
  0xC0, 0x07, 0xF7, 0xE0, 0x07, 0xF3, 0xF0, 0x0F, 0xF1, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x18, 0xFF, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x03, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xFF, 0x1F, 0x03, 0xFF, 0xDF, 0x0F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xC0, 0xFF, 0x7F,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7F,
  0x00, 0x1F, 0x3F, 0xC0, 0x1F, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE,
  0x0F, 0xF0, 0x3F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x7C, 0x00,
  0x0F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x18, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0x7F, 0x80, 0xF0, 0x1F, 0x80, 0x0C, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xC0, 0x3F,
  0x7F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7F, 0x00, 0x3F,
  0x7F, 0x80, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x20, 0x00, 0x7E, 0x3C, 0x01, 0xFE,
  0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x7F,
  0x80, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xCF, 0xE0, 0x3F, 0xDF, 0x80, 0x1F, 0xBF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xF0, 0x00, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x18, 0x01, 0xFF, 0xFC, 0x00, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0x80, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1,
  0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xF2, 0x00, 0x3F, 0x3C, 0x0F, 0xE7, 0xFF, 0xFE, 0x7F, 0xFF,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0xC0, 0x1C, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0xFE,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x0F,
  0xE0, 0xFC, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x0F, 0xC1, 0xFC, 0x03, 0xF0,
  0xFE, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x80,
  0x03, 0xF3, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xC1,
  0xFC, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x0F,
  0xCF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x06, 0x00, 0x7F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0xF8, 0x3F, 0xFC, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBC, 0x1F, 0xC3, 0xFF, 0x03, 0xE0, 0x7F,
  0xC0, 0xF8, 0x1F, 0xF0, 0x1E, 0x07, 0xFC, 0x07, 0x81, 0xFF, 0x01, 0xE0,
  0x7F, 0xC0, 0x78, 0x1F, 0xF0, 0x1E, 0x07, 0xFC, 0x07, 0x81, 0xFF, 0x01,
  0xE0, 0x7F, 0xC0, 0x78, 0x1F, 0xF0, 0x1E, 0x07, 0xFC, 0x07, 0x81, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0,
  0x07, 0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x9F, 0x80, 0x7F, 0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xE0,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x7F, 0x87, 0xF0, 0x07, 0xF1, 0xF8,
  0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x9F, 0x80, 0x0F, 0xE7,
  0xF0, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xE3, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0xFE,
  0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x01, 0xF9, 0xFF,
  0x03, 0xFC, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xFC, 0x0F, 0xC7, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0x7F, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00,
  0x1F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7F, 0x00, 0x3F, 0x3F, 0xC0,
  0xFF, 0x1F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF,
  0xDF, 0x00, 0xFF, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xFF,
  0xE1, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x7F,
  0x00, 0x1B, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xE0, 0x0F, 0x1F, 0x00, 0x02, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xD8, 0x00, 0x0F, 0xBE, 0x00, 0x7F,
  0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF8, 0xF8, 0x00, 0x3F,
  0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x07,
  0xDF, 0xC0, 0x0F, 0x9F, 0xC0, 0x1F, 0x3F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0xF8, 0x1F, 0x00, 0x1F, 0x81, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x00,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0,
  0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x0F,
  0xBF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3E, 0xF0, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x03, 0xEF, 0x80, 0xF0, 0x1E, 0x7C, 0x0F, 0x80, 0xF3,
  0xE0, 0x7E, 0x07, 0x9F, 0x03, 0xF0, 0x3C, 0x78, 0x1F, 0x83, 0xE3, 0xC1,
  0xFC, 0x1F, 0x1F, 0x0F, 0xF0, 0xF8, 0xF8, 0x7F, 0x87, 0x87, 0xC7, 0xBC,
  0x3C, 0x3E, 0x3C, 0xF1, 0xE0, 0xF3, 0xC7, 0x8F, 0x07, 0x9E, 0x3C, 0xF8,
  0x3C, 0xF0, 0xF7, 0xC1, 0xEF, 0x07, 0xBC, 0x0F, 0xF8, 0x3F, 0xE0, 0x7F,
  0xC0, 0xFF, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x81,
  0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xE0, 0x7E, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x0F, 0x80,
  0x1F, 0x81, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x7E, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x83,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xE0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x08, 0x1F,
  0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x0F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0x81, 0xFF, 0x00, 0x3C, 0x7F, 0xF0, 0x07, 0x9F, 0xFF, 0x81,
  0xF3, 0xFF, 0xFC, 0x7C, 0xF8, 0x7F, 0xFF, 0x9E, 0x03, 0xFF, 0xE3, 0xC0,
  0x3F, 0xFC, 0xF0, 0x01, 0xFF, 0x06, 0x00, 0x0F, 0x80,
};

const GFXglyph UbuntuMono_Regular63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 9, 39, 32, 11, -39 },
  { 45, 15, 16, 32, 8, -43 },
  { 75, 28, 39, 32, 2, -39 },
  { 212, 25, 50, 32, 3, -44 },
  { 369, 29, 39, 32, 1, -39 },
  { 511, 28, 39, 32, 2, -39 },
  { 648, 5, 17, 32, 13, -43 },
  { 659, 17, 55, 32, 7, -44 },
  { 776, 17, 55, 32, 7, -44 },
  { 893, 24, 23, 32, 4, -39 },
  { 962, 26, 28, 32, 3, -30 },
  { 1053, 13, 18, 32, 9, -9 },
  { 1083, 14, 5, 32, 9, -19 },
  { 1092, 9, 9, 32, 11, -9 },
  { 1103, 23, 54, 32, 4, -44 },
  { 1259, 26, 39, 32, 3, -39 },
  { 1386, 23, 39, 32, 5, -39 },
  { 1499, 24, 39, 32, 4, -39 },
  { 1616, 24, 39, 32, 4, -39 },
  { 1733, 27, 39, 32, 2, -39 },
  { 1865, 24, 39, 32, 4, -39 },
  { 1982, 25, 39, 32, 3, -39 },
  { 2104, 25, 39, 32, 4, -39 },
  { 2226, 25, 39, 32, 3, -39 },
  { 2348, 25, 39, 32, 3, -39 },
  { 2470, 9, 29, 32, 11, -29 },
  { 2503, 13, 38, 32, 8, -29 },
  { 2565, 26, 25, 32, 3, -29 },
  { 2647, 26, 16, 32, 3, -25 },
  { 2699, 26, 25, 32, 3, -29 },
  { 2781, 20, 39, 32, 6, -39 },
  { 2879, 26, 48, 32, 3, -39 },
  { 3035, 30, 39, 32, 1, -39 },
  { 3182, 25, 39, 32, 3, -39 },
  { 3304, 26, 39, 32, 3, -39 },
  { 3431, 26, 39, 32, 3, -39 },
  { 3558, 23, 39, 32, 6, -39 },
  { 3671, 22, 39, 32, 6, -39 },
  { 3779, 26, 39, 32, 3, -39 },
  { 3906, 26, 39, 32, 3, -39 },
  { 4033, 20, 39, 32, 6, -39 },
  { 4131, 23, 39, 32, 3, -39 },
  { 4244, 27, 39, 32, 4, -39 },
  { 4376, 23, 39, 32, 6, -39 },
  { 4489, 27, 39, 32, 2, -39 },
  { 4621, 25, 39, 32, 3, -39 },
  { 4743, 28, 39, 32, 2, -39 },
  { 4880, 24, 39, 32, 5, -39 },
  { 4997, 28, 49, 32, 2, -39 },
  { 5169, 26, 39, 32, 3, -39 },
  { 5296, 25, 39, 32, 3, -39 },
  { 5418, 27, 39, 32, 2, -39 },
  { 5550, 25, 39, 32, 3, -39 },
  { 5672, 30, 39, 32, 1, -39 },
  { 5819, 27, 39, 32, 2, -39 },
  { 5951, 28, 39, 32, 2, -39 },
  { 6088, 30, 39, 32, 1, -39 },
  { 6235, 26, 39, 32, 3, -39 },
  { 6362, 15, 54, 32, 9, -44 },
  { 6464, 23, 54, 32, 4, -44 },
  { 6620, 15, 54, 32, 7, -44 },
  { 6722, 26, 21, 32, 3, -39 },
  { 6791, 31, 4, 32, 0, 6 },
  { 6807, 11, 11, 32, 10, -44 },
  { 6823, 23, 29, 32, 4, -29 },
  { 6907, 25, 44, 32, 4, -44 },
  { 7045, 25, 29, 32, 3, -29 },
  { 7136, 24, 44, 32, 3, -44 },
  { 7268, 26, 29, 32, 3, -29 },
  { 7363, 26, 44, 32, 4, -44 },
  { 7506, 24, 39, 32, 3, -29 },
  { 7623, 23, 44, 32, 4, -44 },
  { 7750, 25, 42, 32, 3, -42 },
  { 7882, 20, 52, 32, 4, -42 },
  { 8012, 26, 44, 32, 4, -44 },
  { 8155, 25, 44, 32, 3, -44 },
  { 8293, 26, 29, 32, 3, -29 },
  { 8388, 23, 29, 32, 4, -29 },
  { 8472, 26, 29, 32, 3, -29 },
  { 8567, 25, 39, 32, 4, -29 },
  { 8689, 24, 39, 32, 3, -29 },
  { 8806, 21, 29, 32, 7, -29 },
  { 8883, 23, 29, 32, 4, -29 },
  { 8967, 24, 38, 32, 4, -38 },
  { 9081, 23, 29, 32, 4, -29 },
  { 9165, 28, 29, 32, 2, -29 },
  { 9267, 29, 29, 32, 1, -29 },
  { 9373, 28, 29, 32, 2, -29 },
  { 9475, 27, 39, 32, 2, -29 },
  { 9607, 22, 29, 32, 5, -29 },
  { 9687, 22, 54, 32, 5, -44 },
  { 9836, 5, 54, 32, 13, -44 },
  { 9870, 22, 54, 32, 5, -44 },
  { 10019, 27, 10, 32, 2, -22 },
};

const GFXfont UbuntuMono_Regular63pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular63pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular63pt7bGlyphs,
  0x20, 0x7E, 63
};

#endif // _UBUNTUMONO_REGULAR63PT7B_H_
