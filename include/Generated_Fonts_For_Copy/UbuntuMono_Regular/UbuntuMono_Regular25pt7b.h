#ifndef _UBUNTUMONO_REGULAR25PT7B_H_
#define _UBUNTUMONO_REGULAR25PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 25pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular25pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6D, 0xB6, 0xD8, 0x0D, 0xF0, 0xCF, 0x3C, 0xF3, 0xC5, 0x10,
  0x18, 0xC3, 0x18, 0x63, 0x0C, 0xCF, 0xFF, 0xFF, 0xCC, 0x61, 0x8C, 0x33,
  0x1F, 0xFF, 0xFF, 0xB1, 0x86, 0x30, 0xCC, 0x11, 0x80, 0x0C, 0x03, 0x00,
  0xC0, 0x7E, 0x7F, 0x98, 0x26, 0x01, 0x80, 0x7C, 0x0F, 0xC0, 0x7C, 0x07,
  0x00, 0xD0, 0x7F, 0xF9, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x34, 0x86,
  0x4C, 0xCC, 0xCC, 0xCD, 0x84, 0xD0, 0x4B, 0x03, 0xEE, 0x05, 0xB0, 0xD3,
  0x19, 0x11, 0x93, 0x31, 0x32, 0x1B, 0x60, 0xE0, 0x1E, 0x0F, 0xE1, 0x8C,
  0x31, 0x86, 0x30, 0xCC, 0x0F, 0x01, 0xC6, 0x6C, 0xD8, 0xD3, 0x0E, 0x60,
  0xCE, 0x7C, 0xFD, 0x8F, 0x38, 0xFF, 0xF4, 0x04, 0x1C, 0x61, 0x86, 0x0C,
  0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x1C, 0x10,
  0x41, 0xC1, 0xC1, 0xC1, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18, 0x60, 0xC1,
  0x86, 0x1C, 0x71, 0xC1, 0x00, 0x0C, 0x03, 0x04, 0xCD, 0xDF, 0x3F, 0x03,
  0x81, 0xB0, 0xCE, 0x11, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x3F,
  0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x33, 0xDE, 0x6F, 0x60,
  0xFF, 0xF0, 0x7F, 0x70, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30, 0x18,
  0x18, 0x0C, 0x06, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x60, 0x30,
  0x18, 0x18, 0x0C, 0x00, 0x1E, 0x0F, 0xE7, 0x19, 0x83, 0xE0, 0xF0, 0x3C,
  0xCF, 0x3B, 0xCC, 0xF0, 0x3E, 0x0D, 0x83, 0x71, 0x8F, 0xE1, 0xE0, 0x0C,
  0x0E, 0x1F, 0x1D, 0x8C, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC3, 0xFD, 0xFE, 0x3E, 0x1F, 0xE4, 0x38, 0x06, 0x01, 0x80, 0x60,
  0x38, 0x0C, 0x0E, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x1F, 0xF7, 0xFC, 0x3E,
  0x1F, 0xE4, 0x18, 0x06, 0x01, 0x80, 0xE1, 0xF0, 0x7C, 0x01, 0x80, 0x30,
  0x0C, 0x03, 0x41, 0xDF, 0xE3, 0xE0, 0x03, 0x80, 0xF0, 0x3E, 0x06, 0xC1,
  0x98, 0x63, 0x18, 0x63, 0x0C, 0xC1, 0x9F, 0xFF, 0xFF, 0x80, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x03, 0x01, 0xF0, 0xFE,
  0x07, 0x00, 0xC0, 0x60, 0x38, 0x3F, 0xF9, 0xF0, 0x03, 0x83, 0xE1, 0xC0,
  0xC0, 0x70, 0x18, 0x07, 0xF3, 0xFE, 0xE1, 0xF0, 0x3E, 0x0D, 0x83, 0x71,
  0xCF, 0xE1, 0xF0, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x70, 0x30, 0x30, 0x18,
  0x1C, 0x0C, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x1F, 0x0F, 0xE7, 0x1D,
  0x83, 0x60, 0xD8, 0x67, 0xF0, 0x7C, 0x73, 0x98, 0x3C, 0x0F, 0x03, 0x61,
  0xDF, 0xE1, 0xF0, 0x1E, 0x1F, 0xE6, 0x1B, 0x83, 0xC0, 0xF8, 0x36, 0x0D,
  0xFF, 0x3F, 0xC0, 0x70, 0x18, 0x0E, 0x0F, 0x1F, 0x87, 0x80, 0x7F, 0x70,
  0x00, 0x00, 0x7F, 0x70, 0x3B, 0xCE, 0x00, 0x00, 0x00, 0x3B, 0xCE, 0x7F,
  0x60, 0x00, 0x40, 0xF1, 0xF9, 0xF0, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01,
  0xC0, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x40,
  0x3E, 0x03, 0xE0, 0x1F, 0x00, 0xC0, 0xF0, 0xF1, 0xF0, 0xF0, 0x10, 0x00,
  0x7C, 0xFF, 0x47, 0x03, 0x03, 0x06, 0x0E, 0x1C, 0x18, 0x10, 0x00, 0x00,
  0x38, 0x38, 0x38, 0x0F, 0x07, 0xF9, 0xC3, 0x30, 0x76, 0x07, 0x87, 0xF3,
  0xFE, 0x63, 0xCC, 0x79, 0x8F, 0x31, 0xE7, 0xFE, 0x7E, 0xC0, 0x1C, 0x01,
  0xC0, 0x1F, 0x81, 0xF8, 0x07, 0x00, 0xF0, 0x0F, 0x80, 0xD8, 0x19, 0x81,
  0x8C, 0x10, 0xC3, 0x0C, 0x30, 0x43, 0xFE, 0x7F, 0xE6, 0x06, 0x60, 0x36,
  0x03, 0xC0, 0x30, 0xFE, 0x3F, 0xEC, 0x1B, 0x07, 0xC1, 0xB0, 0x6F, 0xF3,
  0xFE, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xFF, 0xEF, 0xE0, 0x0F, 0x87,
  0xF8, 0xE1, 0x30, 0x06, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x01,
  0x80, 0x30, 0x07, 0x84, 0x7F, 0x83, 0xE0, 0xFE, 0x1F, 0xE3, 0x0E, 0x60,
  0xEC, 0x0D, 0x81, 0xB0, 0x36, 0x07, 0xC0, 0xD8, 0x1B, 0x03, 0x60, 0xEC,
  0x39, 0xFE, 0x3F, 0x80, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0F,
  0xF3, 0xFC, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x0F, 0x8F, 0xF3, 0x85, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xF8, 0x36, 0x0D, 0x83, 0x78, 0xCF, 0xF0, 0xFC, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3F, 0xCF, 0xF0,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x43, 0xBF, 0xC3, 0xE0, 0xC1, 0xB0, 0xEC, 0x73, 0x38, 0xDC, 0x3E, 0x0F,
  0x03, 0xE0, 0xDC, 0x33, 0x8C, 0x63, 0x0C, 0xC3, 0xB0, 0x7C, 0x0C, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x3F, 0xFF, 0xFC, 0x61, 0xCC, 0x39, 0xC7, 0x39, 0xED,
  0xBD, 0xB5, 0xB7, 0x96, 0x72, 0xCC, 0x58, 0x0B, 0x01, 0x60, 0x3C, 0x07,
  0x80, 0xF0, 0x18, 0xE0, 0xF8, 0x3F, 0x0F, 0xC3, 0xD8, 0xF3, 0x3C, 0xCF,
  0x1B, 0xC6, 0xF0, 0xBC, 0x3F, 0x0F, 0xC1, 0xF0, 0x7C, 0x0C, 0x1F, 0x07,
  0xF1, 0xC7, 0x70, 0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0x70, 0x67, 0x1C, 0xFF, 0x07, 0xC0, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x87, 0xFF, 0x7F, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x6C, 0x0D, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x03, 0x70, 0x67, 0x1C, 0xFF, 0x07, 0xC0, 0x60, 0x07, 0x00,
  0x78, 0x03, 0x00, 0xFE, 0x1F, 0xF3, 0x0E, 0x60, 0xEC, 0x0D, 0x81, 0xB0,
  0x76, 0x1C, 0xFF, 0x1F, 0xC3, 0x1C, 0x61, 0x8C, 0x19, 0x81, 0xB0, 0x30,
  0x1F, 0x0F, 0xE7, 0x09, 0x80, 0x60, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0x80,
  0x70, 0x0C, 0x03, 0x41, 0xFF, 0xE3, 0xF0, 0xFF, 0xFF, 0xFC, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0x61, 0xDF, 0xE1, 0xF0, 0xE0,
  0x36, 0x03, 0x60, 0x76, 0x06, 0x30, 0x63, 0x06, 0x30, 0xC3, 0x8C, 0x18,
  0xC1, 0x98, 0x1D, 0x80, 0xD8, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xB3, 0x16, 0x72, 0xDE, 0xDB, 0x5B,
  0x4F, 0x79, 0xE7, 0x1C, 0xC3, 0x98, 0x70, 0xC0, 0xCC, 0x19, 0xC6, 0x19,
  0xC3, 0xB0, 0x3C, 0x03, 0x80, 0x70, 0x1E, 0x03, 0xE0, 0xCC, 0x38, 0xC6,
  0x1D, 0xC1, 0xB0, 0x38, 0x60, 0x36, 0x07, 0x70, 0x63, 0x0E, 0x38, 0xC1,
  0x9C, 0x1D, 0x80, 0xF0, 0x07, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00,
  0x60, 0x06, 0x00, 0x7F, 0xDF, 0xF0, 0x1C, 0x06, 0x03, 0x01, 0xC0, 0x60,
  0x30, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x3F, 0xFF, 0xFC, 0xFF, 0xFC,
  0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0xFF,
  0xC0, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C,
  0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x03, 0x80, 0xC0, 0x60,
  0x38, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0F, 0xFF, 0xC0, 0x0C, 0x03, 0xC0, 0x7C, 0x19, 0x83, 0x18, 0xC3,
  0x38, 0x32, 0x02, 0xFF, 0xFF, 0xFF, 0x4E, 0x71, 0x3F, 0x0F, 0xE0, 0x1C,
  0x03, 0x00, 0xC7, 0xF7, 0xFD, 0x83, 0xE0, 0xD8, 0x37, 0xFC, 0xFF, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x3F, 0x8F, 0xF3, 0x0E, 0xC1, 0xB0, 0x6C,
  0x1B, 0x06, 0xC1, 0xB0, 0x6C, 0x3B, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xF7,
  0x01, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x1C, 0x03, 0xFC, 0x3F,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC7, 0xB7, 0xFD, 0xC7, 0xE0, 0xF0,
  0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x37, 0x0C, 0xFF, 0x1F, 0x80, 0x1F, 0x0F,
  0xE7, 0x1F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x1C, 0x23, 0xF8,
  0x7E, 0x0F, 0x87, 0xF3, 0x84, 0xC0, 0x30, 0x3F, 0xEF, 0xF8, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x1F,
  0x8F, 0xF7, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xD8, 0x77,
  0xFC, 0x7B, 0x00, 0xD0, 0x67, 0xF9, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x07, 0xF3, 0xFD, 0x86, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0x80, 0x18, 0x07, 0x01, 0x80, 0x00, 0x00, 0x3F, 0x0F, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC4, 0x3F, 0x07,
  0xC0, 0x0E, 0x0E, 0x0E, 0x00, 0x00, 0x7F, 0x7F, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x07, 0x86, 0xFE, 0x7C, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x6C, 0x33, 0x18, 0xCC, 0x3E, 0x0F, 0x03,
  0xE0, 0xDC, 0x31, 0x8C, 0x33, 0x0E, 0xC1, 0xC0, 0xFC, 0x3F, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC4, 0x3F, 0x07, 0xC0, 0xFB, 0x9F, 0xFB, 0x33, 0x66, 0x3C,
  0xC7, 0x98, 0xF3, 0x1E, 0x63, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0xFE,
  0x7F, 0xB0, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78,
  0x30, 0x1E, 0x07, 0xF1, 0xC7, 0x70, 0x6C, 0x0D, 0x81, 0xB0, 0x36, 0x06,
  0xE0, 0xCE, 0x38, 0xFE, 0x0F, 0x00, 0xFC, 0x3F, 0xCC, 0x3B, 0x06, 0xC1,
  0xB0, 0x6C, 0x1B, 0x06, 0xC1, 0xB0, 0xEF, 0xF3, 0xF8, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0x1F, 0x8F, 0xF7, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xE0, 0xDC, 0x77, 0xFC, 0x7B, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x7F, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x7F,
  0xB0, 0x58, 0x0E, 0x03, 0xE0, 0x7C, 0x07, 0x01, 0xC1, 0xFF, 0xCF, 0xC0,
  0x30, 0x18, 0x0C, 0x06, 0x0F, 0xFF, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x06, 0x03, 0x01, 0xC4, 0x7E, 0x1F, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC1, 0xF0, 0xDF, 0xE7, 0xE0, 0xC0, 0xF8, 0x1B, 0x83,
  0x30, 0xE6, 0x18, 0xE3, 0x0C, 0xE1, 0x98, 0x1B, 0x03, 0xC0, 0x38, 0x06,
  0x00, 0xC0, 0x36, 0x03, 0x60, 0x36, 0x63, 0x67, 0x36, 0x72, 0x6F, 0x66,
  0xD6, 0x29, 0xE3, 0x8E, 0x38, 0xC3, 0x0C, 0xE0, 0xCC, 0x30, 0xCE, 0x1D,
  0x81, 0xE0, 0x1C, 0x03, 0x80, 0xD8, 0x33, 0x0E, 0x31, 0x83, 0x60, 0x70,
  0xE0, 0xCC, 0x19, 0x83, 0x30, 0xE3, 0x18, 0x63, 0x0C, 0x60, 0xD8, 0x1B,
  0x01, 0xE0, 0x38, 0x03, 0x00, 0xC0, 0x18, 0x3E, 0x07, 0x80, 0xFF, 0xFF,
  0xC1, 0xC0, 0xC0, 0xC0, 0xC0, 0xE0, 0x60, 0x60, 0x70, 0x3F, 0xFF, 0xF0,
  0x0F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x18, 0x3C,
  0x1E, 0x03, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0xF0, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x7C, 0x07, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x01, 0xE0, 0xF0, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x07, 0x1F, 0x0F, 0x00, 0x78, 0x6F, 0x8B, 0x3F, 0x41, 0xC0,
};

const GFXglyph UbuntuMono_Regular25pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 15, 13, 5, -15 },
  { 7, 6, 6, 13, 3, -17 },
  { 12, 11, 15, 13, 1, -15 },
  { 33, 10, 19, 13, 1, -17 },
  { 57, 12, 15, 13, 0, -15 },
  { 80, 11, 15, 13, 1, -15 },
  { 101, 2, 7, 13, 5, -17 },
  { 103, 7, 19, 13, 3, -15 },
  { 120, 7, 19, 13, 3, -15 },
  { 137, 10, 9, 13, 1, -15 },
  { 149, 10, 12, 13, 1, -13 },
  { 164, 5, 6, 13, 4, -3 },
  { 168, 6, 2, 13, 3, -7 },
  { 170, 4, 3, 13, 4, -3 },
  { 172, 9, 21, 13, 2, -17 },
  { 196, 10, 15, 13, 1, -15 },
  { 215, 9, 15, 13, 2, -15 },
  { 232, 10, 15, 13, 1, -15 },
  { 251, 10, 15, 13, 1, -15 },
  { 270, 11, 15, 13, 1, -15 },
  { 291, 9, 15, 13, 2, -15 },
  { 308, 10, 15, 13, 1, -15 },
  { 327, 9, 15, 13, 2, -15 },
  { 344, 10, 15, 13, 1, -15 },
  { 363, 10, 15, 13, 1, -15 },
  { 382, 4, 11, 13, 4, -11 },
  { 388, 5, 14, 13, 3, -11 },
  { 397, 10, 10, 13, 1, -11 },
  { 410, 10, 7, 13, 1, -10 },
  { 419, 10, 10, 13, 1, -11 },
  { 432, 8, 15, 13, 2, -15 },
  { 447, 11, 18, 13, 1, -15 },
  { 472, 12, 15, 13, 0, -15 },
  { 495, 10, 15, 13, 1, -15 },
  { 514, 11, 15, 13, 1, -15 },
  { 535, 11, 15, 13, 1, -15 },
  { 556, 10, 15, 13, 2, -15 },
  { 575, 9, 15, 13, 2, -15 },
  { 592, 10, 15, 13, 1, -15 },
  { 611, 10, 15, 13, 1, -15 },
  { 630, 8, 15, 13, 2, -15 },
  { 645, 10, 15, 13, 1, -15 },
  { 664, 10, 15, 13, 2, -15 },
  { 683, 10, 15, 13, 2, -15 },
  { 702, 11, 15, 13, 1, -15 },
  { 723, 10, 15, 13, 1, -15 },
  { 742, 11, 15, 13, 1, -15 },
  { 763, 9, 15, 13, 2, -15 },
  { 780, 11, 19, 13, 1, -15 },
  { 807, 11, 15, 13, 1, -15 },
  { 828, 10, 15, 13, 1, -15 },
  { 847, 11, 15, 13, 1, -15 },
  { 868, 10, 15, 13, 1, -15 },
  { 887, 12, 15, 13, 0, -15 },
  { 910, 11, 15, 13, 1, -15 },
  { 931, 11, 15, 13, 1, -15 },
  { 952, 12, 15, 13, 0, -15 },
  { 975, 10, 15, 13, 1, -15 },
  { 994, 6, 19, 13, 4, -15 },
  { 1009, 9, 21, 13, 2, -17 },
  { 1033, 6, 19, 13, 3, -15 },
  { 1048, 11, 8, 13, 1, -15 },
  { 1059, 12, 2, 13, 0, 2 },
  { 1062, 4, 4, 13, 4, -17 },
  { 1064, 10, 12, 13, 1, -12 },
  { 1079, 10, 17, 13, 2, -17 },
  { 1101, 10, 12, 13, 1, -12 },
  { 1116, 10, 17, 13, 1, -17 },
  { 1138, 10, 12, 13, 1, -12 },
  { 1153, 10, 17, 13, 2, -17 },
  { 1175, 10, 16, 13, 1, -12 },
  { 1195, 9, 17, 13, 2, -17 },
  { 1215, 10, 17, 13, 1, -17 },
  { 1237, 8, 21, 13, 2, -17 },
  { 1258, 10, 17, 13, 2, -17 },
  { 1280, 10, 17, 13, 1, -17 },
  { 1302, 11, 12, 13, 1, -12 },
  { 1319, 9, 12, 13, 2, -12 },
  { 1333, 11, 12, 13, 1, -12 },
  { 1350, 10, 16, 13, 2, -12 },
  { 1370, 10, 16, 13, 1, -12 },
  { 1390, 8, 12, 13, 3, -12 },
  { 1402, 9, 12, 13, 2, -12 },
  { 1416, 9, 16, 13, 2, -16 },
  { 1434, 9, 12, 13, 2, -12 },
  { 1448, 11, 12, 13, 1, -12 },
  { 1465, 12, 12, 13, 0, -12 },
  { 1483, 11, 12, 13, 1, -12 },
  { 1500, 11, 16, 13, 1, -12 },
  { 1522, 9, 12, 13, 2, -12 },
  { 1536, 9, 21, 13, 2, -17 },
  { 1560, 2, 21, 13, 5, -17 },
  { 1566, 9, 21, 13, 2, -17 },
  { 1590, 11, 4, 13, 1, -9 },
};

const GFXfont UbuntuMono_Regular25pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular25pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular25pt7bGlyphs,
  0x20, 0x7E, 25
};

#endif // _UBUNTUMONO_REGULAR25PT7B_H_
