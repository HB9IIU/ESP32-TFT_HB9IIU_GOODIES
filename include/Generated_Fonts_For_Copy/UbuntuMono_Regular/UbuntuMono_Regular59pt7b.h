#ifndef _UBUNTUMONO_REGULAR59PT7B_H_
#define _UBUNTUMONO_REGULAR59PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular59pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C,
  0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFE, 0x3C, 0xF0, 0x7F, 0xC1, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1,
  0xFF, 0x07, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xFF, 0x03, 0xBC, 0x0E, 0xE0,
  0x3B, 0x80, 0xE6, 0x03, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0,
  0x0F, 0x81, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1E, 0x00, 0x3C, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0, 0x3C, 0x00, 0x78,
  0x0F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x07, 0xC0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x80,
  0xF0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x7C, 0x0F, 0x80,
  0x1F, 0x03, 0xE0, 0x07, 0x80, 0xF0, 0x01, 0xE0, 0x3C, 0x00, 0x78, 0x0F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x03, 0xC0, 0x78, 0x00, 0xF0,
  0x1E, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x3F, 0xF0, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xFE,
  0x00, 0xE1, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7D, 0x80, 0x01, 0xFB, 0xE0,
  0x0F, 0xE7, 0xFF, 0xFF, 0x9F, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0x03, 0xFF,
  0x80, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80,
  0x01, 0xE7, 0xF8, 0x00, 0x78, 0xFF, 0x80, 0x1E, 0x3C, 0x78, 0x03, 0xC7,
  0x0F, 0x00, 0xF1, 0xE0, 0xF0, 0x3E, 0x3C, 0x1E, 0x07, 0x87, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x0F, 0x03, 0xC1, 0xE3, 0xE0, 0x78,
  0x3C, 0x78, 0x0F, 0x07, 0x9E, 0x00, 0xE1, 0xE3, 0xC0, 0x1E, 0x3C, 0xF0,
  0x01, 0xFF, 0x3E, 0x00, 0x3F, 0xC7, 0x80, 0x01, 0xF1, 0xE0, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x0F, 0x0F, 0x80, 0x03, 0xE7, 0xF8, 0x00, 0x79, 0xFF,
  0x80, 0x1E, 0x3C, 0xF0, 0x03, 0xCF, 0x0F, 0x00, 0xF1, 0xE1, 0xE0, 0x3E,
  0x38, 0x1C, 0x07, 0x87, 0x03, 0x81, 0xE0, 0xE0, 0x70, 0x3C, 0x1C, 0x0E,
  0x0F, 0x03, 0x81, 0xC3, 0xE0, 0x70, 0x38, 0x78, 0x0F, 0x0F, 0x1E, 0x01,
  0xE1, 0xE3, 0xC0, 0x1E, 0x78, 0xF0, 0x03, 0xFF, 0x3E, 0x00, 0x3F, 0xC7,
  0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xFC,
  0x00, 0x3F, 0xFF, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xC0, 0xF8, 0x01, 0xE0,
  0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x0F, 0x80, 0x78, 0x01,
  0xE0, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE3, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC,
  0x03, 0xC0, 0xFF, 0x80, 0xF0, 0x7F, 0xF0, 0x7C, 0x3E, 0x7E, 0x1E, 0x0F,
  0x8F, 0xC7, 0x87, 0xC1, 0xF1, 0xE1, 0xE0, 0x7E, 0x78, 0xF8, 0x0F, 0xFC,
  0x3E, 0x01, 0xFF, 0x0F, 0x80, 0x3F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x00,
  0xF8, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0xE1, 0xF8, 0x0F, 0xF8, 0x7F,
  0x0F, 0xDF, 0x0F, 0xFF, 0xF7, 0xC1, 0xFF, 0xF8, 0xF8, 0x3F, 0xF8, 0x3E,
  0x03, 0xF8, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xDE, 0xF7,
  0xBD, 0xCE, 0x00, 0x08, 0x00, 0x1C, 0x00, 0x3E, 0x00, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x1C, 0x00, 0x0C, 0x20, 0x00, 0x70, 0x00,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0x20, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x04, 0x07, 0x80, 0x9E, 0x0F, 0x0F, 0x3F, 0x9C,
  0x7E, 0x7F, 0xBB, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7B, 0xE0, 0x01, 0xF3, 0xE0,
  0x07, 0xC7, 0xE0, 0x1F, 0x87, 0xC0, 0x7E, 0x0F, 0xC0, 0x7C, 0x0F, 0x80,
  0x70, 0x1C, 0x00, 0x20, 0x10, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0xFE, 0x1F, 0xE1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xF0, 0x7E,
  0x03, 0xE0, 0x3E, 0x0F, 0xC3, 0xF8, 0xFF, 0x0F, 0xE0, 0xFC, 0x06, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1E, 0x3F, 0x9F,
  0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x1F, 0x83, 0xF0, 0x3F,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0x3E, 0x78, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x1E, 0xF8, 0x3C, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8,
  0xFE, 0x1F, 0xF8, 0xFE, 0x1F, 0xF8, 0x7E, 0x1F, 0xF8, 0x7C, 0x1F, 0xF8,
  0x3C, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8,
  0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7E,
  0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x01, 0xF8, 0x1F, 0x83, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xFE,
  0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xEF, 0x80, 0x7F, 0x3E, 0x01,
  0xF0, 0xF8, 0x02, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xE0, 0x7F, 0x87, 0x00, 0x3F, 0x08, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x01, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x83, 0xE0, 0x7F, 0x02, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x20, 0x00, 0x7E,
  0x78, 0x03, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3C, 0xF8, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3E,
  0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F,
  0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xE0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x90, 0x00, 0x7E, 0xF8, 0x07, 0xF3, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFC, 0x1F, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x1F, 0xF8,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x3F, 0xC0, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF1, 0xFF,
  0xFF, 0xF3, 0xFC, 0x07, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0xC0, 0x07,
  0xCF, 0x80, 0x1F, 0x1F, 0x80, 0x7E, 0x1F, 0x81, 0xF8, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC3, 0xF8, 0x3F, 0x87, 0xC0,
  0x1F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0xCF, 0xC0, 0x0F,
  0x8F, 0xC0, 0x3E, 0x0F, 0xE0, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xF0, 0xFF, 0x87, 0xC0, 0x3F, 0x9F,
  0x00, 0x3F, 0x3E, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x07, 0xDF, 0x00,
  0x0F, 0xBF, 0x00, 0x3F, 0x7F, 0x81, 0xFC, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF8, 0x3F, 0x87, 0xC0, 0x1F,
  0x1F, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7C, 0xFE,
  0x03, 0xF9, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x7F,
  0x8F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x1E, 0x3F, 0x9F, 0xFF, 0xFF, 0xFB,
  0xFD, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xC7, 0xF3, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF, 0x87,
  0x80, 0x03, 0xC0, 0xFE, 0x0F, 0xF1, 0xFF, 0x1F, 0xF0, 0xFF, 0x0F, 0xE0,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0xFF, 0x0F, 0xF1,
  0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x1F, 0xCF,
  0xF8, 0x7F, 0x07, 0xC0, 0x70, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x00,
  0xFE, 0x00, 0x00, 0x78, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0xF8, 0x07,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0x81, 0xFC, 0x40, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF8, 0x07, 0xF0, 0x7E, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x00, 0xF0,
  0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xE3, 0xE0, 0x00,
  0x78, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0xFF, 0xDF, 0x01, 0xFF, 0xF7, 0xC0,
  0xFF, 0xFD, 0xF0, 0x7F, 0xFF, 0x78, 0x3F, 0x87, 0xDE, 0x0F, 0x81, 0xFF,
  0x83, 0xE0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F, 0x01,
  0xFF, 0x87, 0xC0, 0x7F, 0xE1, 0xF0, 0x1F, 0xF8, 0x7C, 0x07, 0xFE, 0x1F,
  0x01, 0xF7, 0x87, 0xC0, 0x7D, 0xF1, 0xF0, 0x1F, 0x7C, 0x3E, 0x07, 0xDF,
  0x0F, 0x81, 0xF7, 0xC3, 0xF0, 0x7D, 0xF0, 0x7F, 0xFF, 0x3E, 0x0F, 0xFF,
  0xCF, 0x81, 0xFF, 0xF3, 0xF0, 0x1F, 0xE0, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x04, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xBE,
  0x00, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF1, 0xF0, 0x00,
  0x1F, 0x0F, 0x00, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x0F, 0x80, 0x03, 0xE0,
  0x78, 0x00, 0x3E, 0x07, 0x80, 0x03, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x3C, 0x00, 0x78, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0xF8,
  0x01, 0xE0, 0x0F, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F,
  0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0xC7, 0xC0, 0x00,
  0x7C, 0x7C, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x78, 0x00, 0x03, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xF0, 0x3F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xF8, 0x07, 0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF0, 0xF8,
  0x07, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF0, 0xF8, 0x03, 0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x1E, 0x0F, 0xC0, 0x06, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x02, 0x0F, 0xF0, 0x1E, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0xF8, 0x0F, 0xF0, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF8, 0xF8, 0x0F, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFE, 0x3F, 0xFF, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xF0, 0x1E, 0x0F, 0xC0,
  0x04, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0xC0, 0x1F, 0x0F, 0xF0, 0x3F, 0x07, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE2, 0x00, 0x1F, 0x9C, 0x00, 0x7C, 0x7C, 0x07, 0xF3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0xF8,
  0x00, 0x3E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x0F,
  0x80, 0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xE0, 0x1F, 0x81, 0xF0, 0x0F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0,
  0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE7, 0xE0, 0x01, 0xF7, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xBF, 0x80, 0x07, 0xCF, 0xE0, 0x03, 0xE3, 0xF8, 0x01, 0xF0,
  0x7E, 0x00, 0xF8, 0x1F, 0x80, 0x7C, 0x0F, 0xE0, 0x3E, 0x03, 0xF8, 0x1F,
  0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1,
  0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x1E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0xFC,
  0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x0F, 0xE0, 0x1F, 0xC3, 0xF8, 0x0F, 0xF0,
  0xEE, 0x03, 0xFC, 0x3B, 0xC0, 0xEF, 0x0E, 0xF0, 0x3B, 0xC7, 0x9C, 0x1E,
  0xF1, 0xE7, 0x87, 0xBC, 0x79, 0xE1, 0xCF, 0x1E, 0x38, 0xF3, 0xC7, 0x8F,
  0x3C, 0xF1, 0xE3, 0xCE, 0x3E, 0x78, 0x77, 0x8F, 0x9E, 0x1F, 0xE1, 0xE7,
  0x87, 0xF0, 0x79, 0xE0, 0xFC, 0x1E, 0x78, 0x3F, 0x07, 0x9E, 0x0F, 0x81,
  0xE7, 0x81, 0xE0, 0x79, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x1F, 0xF7, 0x80, 0x3F, 0xEF, 0x80, 0x7F, 0xCF, 0x00,
  0xFF, 0x9F, 0x01, 0xFF, 0x1E, 0x03, 0xFE, 0x3E, 0x07, 0xFC, 0x3C, 0x0F,
  0xF8, 0x7C, 0x1F, 0xF0, 0x78, 0x3F, 0xE0, 0xF8, 0x7F, 0xC0, 0xF0, 0xFF,
  0x81, 0xE1, 0xFF, 0x01, 0xE3, 0xFE, 0x03, 0xC7, 0xFC, 0x03, 0xCF, 0xF8,
  0x07, 0x9F, 0xF0, 0x0F, 0xBF, 0xE0, 0x0F, 0x7F, 0xC0, 0x1E, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x7C, 0x01, 0xF8, 0x1F, 0xC1, 0xFC,
  0x03, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF,
  0xFF, 0x8F, 0x80, 0x3F, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E,
  0xF8, 0x00, 0xFD, 0xF0, 0x03, 0xF3, 0xE0, 0x1F, 0xE7, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x3F,
  0xFF, 0xE0, 0x1F, 0xC1, 0xFC, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x1F, 0x00, 0x03, 0xE7, 0xC0, 0x00,
  0xFB, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBE, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F,
  0x80, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0xC1, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x01,
  0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x07, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0x00, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x07,
  0xC0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF0, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0x00, 0xFF,
  0x80, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC3, 0xFC, 0x0F,
  0x87, 0xE0, 0x03, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xB0, 0x00, 0x3E, 0x7C, 0x01, 0xFC, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x7E, 0x7E, 0x00, 0xFC, 0x3F, 0x81, 0xFC, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x3E, 0xFC, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0x1F,
  0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07, 0xBE,
  0x00, 0x01, 0xEF, 0x80, 0x00, 0x7B, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x07,
  0xBE, 0x00, 0x01, 0xE7, 0x83, 0xE0, 0x79, 0xE0, 0xF8, 0x1E, 0x78, 0x3F,
  0x07, 0x9E, 0x1F, 0xC1, 0xE7, 0x87, 0xF0, 0xF9, 0xE1, 0xDE, 0x3E, 0x78,
  0x77, 0x8F, 0x9E, 0x3C, 0xE3, 0xC7, 0x8E, 0x3C, 0xF1, 0xE3, 0x8F, 0x3C,
  0x79, 0xE1, 0xCF, 0x1E, 0x78, 0x7B, 0xC7, 0x9C, 0x1E, 0xF1, 0xEF, 0x07,
  0xBC, 0x3B, 0xC0, 0xEF, 0x0E, 0xE0, 0x3F, 0xC3, 0xF8, 0x0F, 0xF0, 0xFE,
  0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xE0,
  0xFC, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x07, 0xC7, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xC0, 0xF8, 0x01, 0xF0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x03, 0xE0,
  0xFC, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0xFC, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xDF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x0F,
  0x83, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x1F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x87, 0xC0,
  0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x03, 0xF0, 0x0F,
  0xC0, 0x3E, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0x3E, 0x0F,
  0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C,
  0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xE1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x1F, 0x01, 0xF8,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xC3, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x20, 0x38, 0x3E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x1F,
  0x07, 0x81, 0x80, 0x03, 0xFF, 0x00, 0x7F, 0xFF, 0x81, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x0C, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x7F, 0xEF,
  0x07, 0xFF, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0xDF, 0xE0, 0x1F, 0x7E,
  0x00, 0x3D, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x7C, 0x00,
  0x3D, 0xF0, 0x00, 0xF7, 0xF0, 0x03, 0xCF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x38, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x3F,
  0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xFC, 0x0F,
  0xE7, 0xE0, 0x0F, 0xCF, 0x80, 0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F,
  0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x03, 0xF7, 0xC0,
  0x0F, 0xCF, 0x80, 0x7F, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFE, 0x1F, 0xE0, 0x0C, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0,
  0x06, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x1F, 0xCF, 0x81, 0xFF, 0xFF, 0x07,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0x07, 0xF9, 0xF8, 0x01, 0xF3, 0xE0,
  0x03, 0xEF, 0xC0, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E,
  0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xF9, 0xFC, 0x01, 0xF1, 0xFE, 0x03, 0xE1,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81,
  0xFC, 0x0F, 0xE0, 0xFC, 0x01, 0xF0, 0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E,
  0x7C, 0x00, 0x0F, 0x3E, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x30, 0x1F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x01, 0xFC, 0x0F, 0x01, 0xF0, 0x01, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x7F, 0xFF, 0xF1, 0xFC, 0x03, 0xE7, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0xBF,
  0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xF0, 0x01,
  0xF3, 0xF0, 0x03, 0xE3, 0xF8, 0x1F, 0xC7, 0xFF, 0xFF, 0x87, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x01, 0xFE, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x18,
  0x03, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x7F,
  0xE0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE7, 0xF8, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFF, 0x3F, 0x01, 0xFD, 0xF0, 0x03, 0xEF, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x78, 0x01, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x06, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x3C, 0x0F, 0xC7, 0xFF, 0xF9, 0xFF, 0xFE, 0x1F, 0xFF, 0x80,
  0x7F, 0xC0, 0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x7E, 0xF8,
  0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xE0, 0xF8,
  0x0F, 0xC0, 0xF8, 0x1F, 0x80, 0xF8, 0x7F, 0x00, 0xF8, 0xFE, 0x00, 0xF9,
  0xFC, 0x00, 0xFB, 0xF8, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0xF9, 0xFC, 0x00, 0xF8, 0xFE, 0x00, 0xF8,
  0x3F, 0x00, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0xF8, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x06, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0xF8, 0x7F,
  0xF9, 0xFF, 0x3F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0x87, 0xF1, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x1E, 0x07,
  0xFC, 0x0F, 0x03, 0xFE, 0x07, 0x81, 0xFF, 0x03, 0xC0, 0xFF, 0x81, 0xE0,
  0x7F, 0xC0, 0xF0, 0x3F, 0xE0, 0x78, 0x1F, 0xF0, 0x3C, 0x0F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xE0, 0x0F, 0xFE, 0x07,
  0xFF, 0xFC, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7F, 0x7C, 0x00,
  0xFB, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1E, 0x00, 0x7F, 0x00, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC1,
  0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x3E, 0x7C, 0x00, 0x1F,
  0x3E, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x7C, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x07, 0xCF, 0xC0, 0x03, 0xE3, 0xE0,
  0x03, 0xF1, 0xF8, 0x03, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0x7F, 0x1F,
  0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x0F, 0xDF, 0x80, 0x3F,
  0x3F, 0xC0, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x03,
  0xE3, 0xF8, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF1, 0xFE, 0x03, 0xE7, 0xF0,
  0x07, 0xCF, 0xC0, 0x0F, 0xBF, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x07, 0xC7,
  0xF0, 0x3F, 0x87, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x03,
  0xFC, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xE3, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFE, 0x00, 0x6F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0x00, 0x61, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7D, 0x00, 0x03, 0xEF, 0xC0, 0x3F, 0xBF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xFC, 0x06, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xF8, 0x00,
  0xFF, 0x80, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8,
  0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F,
  0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0xBF, 0x00, 0x7C,
  0xFC, 0x03, 0xE7, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xC0, 0x7F,
  0xE0, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0xF9, 0xF0,
  0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xF8, 0x00,
  0x3E, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1E, 0xF0, 0x00,
  0x07, 0xDE, 0x03, 0xC0, 0xFB, 0xC0, 0x78, 0x1E, 0x7C, 0x1F, 0x03, 0xCF,
  0x83, 0xF0, 0x79, 0xF0, 0x7E, 0x0F, 0x1E, 0x1F, 0xC1, 0xE3, 0xC3, 0xFC,
  0x3C, 0x78, 0x7F, 0x8F, 0x8F, 0x1E, 0xF1, 0xE1, 0xE3, 0xCF, 0x3C, 0x3E,
  0x71, 0xE7, 0x83, 0xDE, 0x3C, 0xF0, 0x7B, 0xC3, 0xDE, 0x0F, 0xF0, 0x7F,
  0x81, 0xFE, 0x07, 0xF0, 0x3F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0xC0, 0x7E,
  0x01, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xC0, 0x3C, 0x00, 0x78,
  0x00, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x1F, 0x80, 0xFC, 0x03, 0xF0, 0x3E, 0x00, 0x7C, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0xFC, 0xF8, 0x00,
  0x3E, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0x1F,
  0x01, 0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xEF, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xCF,
  0x80, 0x07, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xFF, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFE, 0xFF, 0xFF, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x1F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xFF,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x1F, 0xFF, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0x80, 0x3F, 0xE0, 0x00,
  0x07, 0xC0, 0x03, 0x0F, 0xF8, 0x03, 0xCF, 0xFF, 0x01, 0xEF, 0xFF, 0xE1,
  0xF7, 0xC7, 0xFF, 0xF3, 0xC0, 0xFF, 0xF3, 0xC0, 0x1F, 0xF0, 0x60, 0x03,
  0xF0,
};

const GFXglyph UbuntuMono_Regular59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 30, 0, -1 },
  { 1, 8, 37, 30, 11, -37 },
  { 38, 14, 15, 30, 8, -40 },
  { 65, 26, 37, 30, 2, -37 },
  { 186, 23, 47, 30, 3, -41 },
  { 322, 27, 37, 30, 1, -37 },
  { 447, 26, 37, 30, 2, -37 },
  { 568, 5, 16, 30, 12, -40 },
  { 578, 16, 51, 30, 7, -41 },
  { 680, 16, 51, 30, 7, -41 },
  { 782, 23, 22, 30, 3, -37 },
  { 846, 24, 26, 30, 3, -28 },
  { 924, 12, 16, 30, 9, -8 },
  { 948, 13, 5, 30, 8, -18 },
  { 957, 9, 8, 30, 10, -8 },
  { 966, 21, 51, 30, 4, -41 },
  { 1100, 24, 37, 30, 3, -37 },
  { 1211, 22, 37, 30, 4, -37 },
  { 1313, 23, 37, 30, 3, -37 },
  { 1420, 23, 37, 30, 3, -37 },
  { 1527, 26, 37, 30, 2, -37 },
  { 1648, 22, 37, 30, 4, -37 },
  { 1750, 23, 37, 30, 3, -37 },
  { 1857, 23, 37, 30, 4, -37 },
  { 1964, 23, 37, 30, 3, -37 },
  { 2071, 23, 37, 30, 3, -37 },
  { 2178, 9, 27, 30, 10, -27 },
  { 2209, 12, 35, 30, 7, -27 },
  { 2262, 24, 23, 30, 3, -27 },
  { 2331, 24, 15, 30, 3, -23 },
  { 2376, 24, 23, 30, 3, -27 },
  { 2445, 19, 37, 30, 5, -37 },
  { 2533, 26, 45, 30, 2, -37 },
  { 2680, 28, 37, 30, 1, -37 },
  { 2810, 24, 37, 30, 3, -37 },
  { 2921, 24, 37, 30, 3, -37 },
  { 3032, 24, 37, 30, 3, -37 },
  { 3143, 22, 37, 30, 5, -37 },
  { 3245, 21, 37, 30, 5, -37 },
  { 3343, 24, 37, 30, 3, -37 },
  { 3454, 24, 37, 30, 3, -37 },
  { 3565, 19, 37, 30, 5, -37 },
  { 3653, 22, 37, 30, 3, -37 },
  { 3755, 25, 37, 30, 4, -37 },
  { 3871, 22, 37, 30, 5, -37 },
  { 3973, 26, 37, 30, 2, -37 },
  { 4094, 23, 37, 30, 3, -37 },
  { 4201, 26, 37, 30, 2, -37 },
  { 4322, 23, 37, 30, 4, -37 },
  { 4429, 26, 46, 30, 2, -37 },
  { 4579, 24, 37, 30, 3, -37 },
  { 4690, 23, 37, 30, 3, -37 },
  { 4797, 25, 37, 30, 2, -37 },
  { 4913, 24, 37, 30, 3, -37 },
  { 5024, 28, 37, 30, 1, -37 },
  { 5154, 26, 37, 30, 2, -37 },
  { 5275, 27, 37, 30, 1, -37 },
  { 5400, 28, 37, 30, 1, -37 },
  { 5530, 24, 37, 30, 3, -37 },
  { 5641, 15, 51, 30, 8, -41 },
  { 5737, 21, 51, 30, 4, -41 },
  { 5871, 14, 51, 30, 7, -41 },
  { 5961, 25, 20, 30, 2, -37 },
  { 6024, 29, 4, 30, 0, 6 },
  { 6039, 9, 10, 30, 10, -41 },
  { 6051, 22, 27, 30, 3, -27 },
  { 6126, 23, 41, 30, 4, -41 },
  { 6244, 24, 27, 30, 3, -27 },
  { 6325, 23, 41, 30, 2, -41 },
  { 6443, 25, 27, 30, 2, -27 },
  { 6528, 24, 41, 30, 4, -41 },
  { 6651, 23, 37, 30, 2, -27 },
  { 6758, 21, 41, 30, 4, -41 },
  { 6866, 24, 38, 30, 3, -38 },
  { 6980, 19, 48, 30, 4, -38 },
  { 7094, 24, 41, 30, 4, -41 },
  { 7217, 24, 41, 30, 3, -41 },
  { 7340, 25, 27, 30, 2, -27 },
  { 7425, 21, 27, 30, 4, -27 },
  { 7496, 25, 27, 30, 2, -27 },
  { 7581, 23, 37, 30, 4, -27 },
  { 7688, 23, 37, 30, 2, -27 },
  { 7795, 20, 27, 30, 6, -27 },
  { 7863, 22, 27, 30, 4, -27 },
  { 7938, 23, 36, 30, 4, -36 },
  { 8042, 21, 27, 30, 4, -27 },
  { 8113, 26, 27, 30, 2, -27 },
  { 8201, 27, 27, 30, 1, -27 },
  { 8293, 26, 27, 30, 2, -27 },
  { 8381, 25, 37, 30, 2, -27 },
  { 8497, 21, 27, 30, 4, -27 },
  { 8568, 20, 51, 30, 5, -41 },
  { 8696, 4, 51, 30, 13, -41 },
  { 8722, 21, 51, 30, 4, -41 },
  { 8856, 25, 8, 30, 2, -19 },
};

const GFXfont UbuntuMono_Regular59pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular59pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular59pt7bGlyphs,
  0x20, 0x7E, 59
};

#endif // _UBUNTUMONO_REGULAR59PT7B_H_
