#ifndef _UBUNTUMONO_REGULAR30PT7B_H_
#define _UBUNTUMONO_REGULAR30PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 30pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular30pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x62, 0x00, 0x07, 0xFF, 0x70, 0xC7,
  0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0x80, 0x0E, 0x30, 0x61, 0x83, 0x1C, 0x18,
  0xE0, 0xC6, 0x7F, 0xFF, 0xFF, 0xE3, 0x1C, 0x18, 0xE0, 0xC6, 0x0E, 0x30,
  0x61, 0x8F, 0xFF, 0xFF, 0xFC, 0xC6, 0x0E, 0x30, 0x71, 0x83, 0x0C, 0x18,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x0F, 0xE7, 0xFC, 0xE0, 0xB8, 0x07, 0x00,
  0xE0, 0x1E, 0x01, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x38, 0x03, 0x00,
  0x60, 0x0F, 0x03, 0xFF, 0xE7, 0xF0, 0x1C, 0x03, 0x80, 0x70, 0x78, 0x1F,
  0xC1, 0xB3, 0x0D, 0x18, 0xC8, 0xCE, 0x46, 0x63, 0x36, 0x1F, 0x30, 0x73,
  0x00, 0x38, 0x01, 0xBC, 0x19, 0xF0, 0xD9, 0x8C, 0xC4, 0xE6, 0x26, 0x31,
  0x61, 0x9B, 0x07, 0xF0, 0x3C, 0x0F, 0x01, 0xFC, 0x0C, 0x70, 0xE1, 0x87,
  0x0C, 0x38, 0xE0, 0xC6, 0x07, 0x60, 0x1E, 0x01, 0xE1, 0x9F, 0x8C, 0xCE,
  0x6E, 0x3F, 0x60, 0xF3, 0x03, 0x9C, 0x1C, 0xF1, 0xF3, 0xFD, 0x8F, 0x8E,
  0xFF, 0xFF, 0xD2, 0x01, 0x03, 0xC3, 0xC3, 0xC1, 0xC1, 0xC0, 0xC0, 0xE0,
  0x60, 0x30, 0x38, 0x1C, 0x0E, 0x07, 0x01, 0x80, 0xC0, 0x70, 0x18, 0x0E,
  0x03, 0x81, 0xE0, 0x78, 0x1C, 0x02, 0x40, 0x38, 0x1E, 0x07, 0x81, 0xC0,
  0x70, 0x18, 0x0E, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x0C, 0x06,
  0x07, 0x03, 0x03, 0x83, 0x83, 0xC3, 0xC3, 0xC0, 0x80, 0x0E, 0x01, 0xC0,
  0x38, 0x63, 0x3F, 0x5E, 0xFF, 0x83, 0x80, 0xD8, 0x3B, 0x8E, 0x38, 0x46,
  0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x83, 0xFF,
  0xFF, 0xFF, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x78, 0xF8, 0xE0, 0xC7, 0x9E, 0x30, 0xFF, 0xFC, 0x77, 0xFE, 0xE0,
  0x00, 0xE0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03,
  0x00, 0xE0, 0x1C, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x00,
  0x0F, 0x80, 0xFE, 0x0E, 0x38, 0xE0, 0xE7, 0x07, 0x30, 0x19, 0x80, 0xDC,
  0xE7, 0xE7, 0x3F, 0x39, 0xF9, 0xCF, 0xC0, 0x76, 0x03, 0x30, 0x19, 0xC1,
  0xCE, 0x0E, 0x38, 0xE0, 0xFE, 0x03, 0xE0, 0x07, 0x01, 0xE0, 0x7C, 0x3F,
  0x8F, 0x70, 0x8E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x0F, 0xFD, 0xFF, 0x80, 0x3F, 0x0F,
  0xF3, 0x87, 0x20, 0x60, 0x0E, 0x01, 0xC0, 0x30, 0x0E, 0x03, 0x80, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0x1F, 0xF1, 0x07, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x1E,
  0x1F, 0x03, 0xF0, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x07, 0x81,
  0xDF, 0xF9, 0xFC, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0xF8, 0x0F, 0xC0, 0x6E,
  0x06, 0x70, 0x73, 0x83, 0x1C, 0x30, 0xE3, 0x87, 0x18, 0x39, 0xC1, 0xCF,
  0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x3F,
  0xE7, 0xFC, 0xC0, 0x18, 0x03, 0x00, 0xE0, 0x1C, 0x03, 0xF0, 0x7F, 0x80,
  0x78, 0x03, 0x80, 0x70, 0x06, 0x00, 0xC0, 0x18, 0x07, 0xC1, 0xDF, 0xF9,
  0xFC, 0x00, 0x01, 0xC1, 0xF8, 0x78, 0x1C, 0x07, 0x00, 0xC0, 0x38, 0x06,
  0xF8, 0xFF, 0xDC, 0x1F, 0x03, 0xE0, 0x3C, 0x07, 0x80, 0xF8, 0x1F, 0x07,
  0x71, 0xC7, 0xF8, 0x7C, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x18, 0x00, 0x1F, 0x0F,
  0xF9, 0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF8, 0x3B, 0x86, 0x7F, 0x87, 0xF1,
  0xCF, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xEF, 0xF8, 0xFC,
  0x00, 0x1F, 0x0F, 0xF1, 0xC7, 0x70, 0x7C, 0x0F, 0x80, 0xF0, 0x1E, 0x03,
  0xE0, 0x7C, 0x1D, 0xFF, 0x9F, 0xB0, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x0F,
  0x1F, 0xC1, 0xE0, 0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x1D, 0xFF,
  0xB8, 0x39, 0xF7, 0xCE, 0x00, 0x00, 0x00, 0x00, 0x03, 0x9F, 0x7C, 0xF1,
  0x8E, 0xF3, 0x00, 0x00, 0x10, 0x07, 0xC0, 0xF8, 0x3F, 0x0F, 0xC0, 0x70,
  0x03, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x20, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x60, 0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1C, 0x03, 0xE0,
  0x7C, 0x0F, 0x81, 0xF0, 0x1C, 0x00, 0x80, 0x00, 0x7E, 0x7F, 0xA0, 0xE0,
  0x30, 0x18, 0x1C, 0x0C, 0x0E, 0x0E, 0x0E, 0x06, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x3C, 0x1E, 0x0E, 0x00, 0x07, 0xC0, 0xFF, 0x0F, 0x1C, 0x60,
  0x67, 0x03, 0xB0, 0x0D, 0x87, 0xFC, 0x7F, 0xE7, 0x1F, 0x30, 0xF9, 0x87,
  0xCC, 0x3E, 0x61, 0xF3, 0x0F, 0x98, 0x6C, 0xE3, 0x63, 0xFB, 0x8F, 0xCC,
  0x00, 0x70, 0x01, 0xE0, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0x80, 0x0F, 0x80,
  0x1B, 0x00, 0x36, 0x00, 0xEE, 0x01, 0x8C, 0x03, 0x18, 0x0E, 0x38, 0x18,
  0x70, 0x30, 0x60, 0x60, 0xC1, 0xC1, 0xC3, 0xFF, 0x87, 0xFF, 0x1C, 0x07,
  0x38, 0x0E, 0x60, 0x0C, 0xC0, 0x1B, 0x80, 0x38, 0xFF, 0x0F, 0xF8, 0xC1,
  0xCC, 0x0E, 0xC0, 0xEC, 0x0E, 0xC0, 0xCC, 0x1C, 0xFF, 0x8F, 0xF8, 0xC1,
  0xEC, 0x0E, 0xC0, 0x6C, 0x07, 0xC0, 0x6C, 0x0E, 0xC1, 0xEF, 0xFC, 0xFF,
  0x00, 0x07, 0xE0, 0x7F, 0xC7, 0x04, 0x70, 0x07, 0x00, 0x38, 0x01, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x01,
  0xC0, 0x07, 0x00, 0x3C, 0x10, 0xFF, 0xC1, 0xF8, 0xFE, 0x0F, 0xF8, 0xC3,
  0xCC, 0x0C, 0xC0, 0xEC, 0x06, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x06, 0xC0, 0xEC, 0x0C, 0xC3, 0xCF, 0xF8, 0xFE,
  0x00, 0xFF, 0xDF, 0xFB, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xFF, 0x9F, 0xF3, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xFF, 0xBF, 0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0x30, 0x0C, 0x00, 0x07, 0xE0, 0x7F, 0x87, 0x04, 0x70, 0x07, 0x00,
  0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x0F, 0xC0, 0x76,
  0x03, 0xB8, 0x1D, 0xC0, 0xE7, 0x07, 0x3C, 0x38, 0xFF, 0xC1, 0xFC, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC,
  0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0E, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x7F, 0xFF, 0xE0, 0x3F, 0xE7, 0xFC, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x30, 0x06, 0xC3, 0xDF, 0xF1, 0xF8, 0x00, 0xC0, 0x76, 0x07, 0x30, 0x71,
  0x83, 0x0C, 0x38, 0x63, 0x83, 0x38, 0x1B, 0x80, 0xF8, 0x07, 0xE0, 0x33,
  0x81, 0x8E, 0x0C, 0x38, 0x61, 0xE3, 0x07, 0x18, 0x1C, 0xC0, 0x76, 0x03,
  0xB0, 0x0E, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xF1, 0xE7,
  0x8F, 0x3C, 0x79, 0xB6, 0xCD, 0xB6, 0xED, 0xBF, 0x29, 0xF9, 0xCF, 0xCE,
  0x7C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x06,
  0xC0, 0x7C, 0x0F, 0x81, 0xF8, 0x3F, 0x87, 0xB0, 0xF7, 0x1E, 0x63, 0xCC,
  0x78, 0xCF, 0x19, 0xE1, 0xBC, 0x37, 0x83, 0xF0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x01, 0x80, 0x0F, 0x81, 0xFF, 0x0E, 0x38, 0xE0, 0xE6, 0x03, 0x70,
  0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03,
  0xF0, 0x1D, 0x80, 0xCE, 0x0E, 0x38, 0xE1, 0xFF, 0x03, 0xE0, 0xFF, 0x0F,
  0xFC, 0xE1, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE,
  0x1E, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x00, 0x0F, 0x81, 0xFF, 0x0E, 0x38, 0xE0, 0xE6, 0x03, 0x70,
  0x1F, 0x80, 0xF8, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x03,
  0xF0, 0x1F, 0x80, 0xCE, 0x0E, 0x78, 0xE1, 0xFF, 0x03, 0xE0, 0x0E, 0x00,
  0x38, 0x01, 0xE0, 0x07, 0xC0, 0x06, 0xFE, 0x0F, 0xF8, 0xC1, 0xCC, 0x0E,
  0xC0, 0xEC, 0x0E, 0xC0, 0xEC, 0x0E, 0xC0, 0xCC, 0x1C, 0xFF, 0x8F, 0xF0,
  0xC3, 0x0C, 0x38, 0xC1, 0x8C, 0x0C, 0xC0, 0xEC, 0x06, 0xC0, 0x70, 0x1F,
  0x8F, 0xF9, 0xC1, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x03, 0x80, 0x3E, 0x03,
  0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0xC0, 0xFF, 0xF9,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC1, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0xE0, 0x3F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x19, 0x80, 0xCE, 0x0E, 0x78,
  0xF1, 0xFF, 0x03, 0xE0, 0xE0, 0x0E, 0xC0, 0x19, 0xC0, 0x73, 0x80, 0xE7,
  0x01, 0xC6, 0x03, 0x0E, 0x0E, 0x1C, 0x1C, 0x18, 0x30, 0x30, 0x60, 0x71,
  0xC0, 0x63, 0x00, 0xC6, 0x01, 0xDC, 0x03, 0xB8, 0x03, 0x60, 0x07, 0xC0,
  0x0F, 0x80, 0x0E, 0x00, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01,
  0xE0, 0x0F, 0x00, 0xFC, 0xE7, 0xE7, 0x3F, 0x29, 0xFB, 0x6C, 0xDB, 0x66,
  0xDB, 0x3C, 0x79, 0xE3, 0xCF, 0x1E, 0x70, 0x73, 0x83, 0x9C, 0x1C, 0xE0,
  0x3B, 0x83, 0x9C, 0x1C, 0x71, 0xC1, 0x8C, 0x0E, 0xE0, 0x36, 0x01, 0xF0,
  0x07, 0x00, 0x38, 0x03, 0xE0, 0x1F, 0x01, 0xDC, 0x0C, 0x60, 0xE3, 0x8E,
  0x0E, 0x70, 0x77, 0x01, 0xF8, 0x0E, 0x60, 0x0C, 0xE0, 0x39, 0xC0, 0x71,
  0xC1, 0xC3, 0x83, 0x83, 0x86, 0x07, 0x1C, 0x07, 0x30, 0x0E, 0xE0, 0x0F,
  0x80, 0x1F, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0xFF, 0xEF, 0xFE, 0x00, 0xE0, 0x0C,
  0x01, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38,
  0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x3F, 0xFF, 0xE0, 0x0C, 0x01, 0x80,
  0x38, 0x03, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xE0, 0x1C, 0x01, 0x80, 0x38, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0,
  0x18, 0x03, 0x00, 0x70, 0x06, 0x00, 0xC0, 0x1C, 0xFF, 0xFC, 0x38, 0x70,
  0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x0E, 0x1C,
  0x38, 0x70, 0xE1, 0xFF, 0xFF, 0x07, 0x00, 0x38, 0x03, 0xE0, 0x3B, 0x81,
  0x8C, 0x1C, 0x70, 0xC1, 0x8E, 0x0E, 0xE0, 0x3A, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFC, 0x47, 0x1C, 0x71, 0x00, 0x3F, 0x0F, 0xF9, 0x87, 0x00, 0x70,
  0x0E, 0x00, 0xCF, 0xFB, 0xFF, 0xE0, 0x78, 0x0F, 0x01, 0xF0, 0x37, 0xFE,
  0x7F, 0xC0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xF0, 0xFF, 0xCF, 0x1E, 0xE0, 0xEE, 0x06, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x6E, 0x0E, 0xE1, 0xCF, 0xFC, 0x7F, 0x00, 0x07, 0xF0,
  0xFF, 0x8F, 0x04, 0xE0, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00, 0x60,
  0x03, 0x80, 0x1C, 0x00, 0x78, 0x21, 0xFF, 0x03, 0xF8, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0x3F, 0xF7, 0x8F,
  0x70, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x60, 0x77, 0x07,
  0x38, 0x73, 0xFF, 0x0F, 0xE0, 0x0F, 0x80, 0xFF, 0x0E, 0x3C, 0xE0, 0xE6,
  0x03, 0x70, 0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x00, 0x1C, 0x00, 0x70,
  0x41, 0xFF, 0x07, 0xF0, 0x03, 0xE0, 0xFF, 0x1E, 0x11, 0xC0, 0x18, 0x01,
  0x80, 0x18, 0x0F, 0xFE, 0xFF, 0xE1, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x00,
  0x0F, 0xE3, 0xFF, 0x78, 0x77, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x76, 0x07, 0x70, 0x73, 0xFF, 0x0F, 0xF0, 0x07, 0x00, 0x70, 0x07,
  0x60, 0xE7, 0xFC, 0x3F, 0x80, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0xF8, 0xFF, 0xDC, 0x3B, 0x83, 0xF0, 0x7E, 0x0F, 0xC1,
  0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0E, 0x1C, 0x03,
  0xC0, 0x1C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0xC0, 0x0C, 0x00,
  0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x20,
  0x7E, 0x03, 0xE0, 0x03, 0x81, 0xE0, 0x38, 0x00, 0x00, 0x1F, 0xF7, 0xFC,
  0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x06, 0x01, 0x90, 0xEF, 0xF1, 0xF8, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x0E, 0xE1, 0xEE, 0x3C,
  0xE7, 0x8E, 0xE0, 0xFC, 0x0F, 0x80, 0xFC, 0x0E, 0xE0, 0xE7, 0x8E, 0x1C,
  0xE1, 0xCE, 0x0E, 0xE0, 0x70, 0xFC, 0x0F, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x0E, 0x20, 0x7E, 0x03,
  0xE0, 0x7D, 0xE7, 0xFF, 0xB1, 0xCF, 0x8E, 0x3C, 0x71, 0xE3, 0x8F, 0x1C,
  0x78, 0xE3, 0xC7, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0C,
  0x7F, 0x1F, 0xFB, 0x87, 0x70, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0,
  0xFC, 0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xC0, 0x0F, 0x81, 0xFF, 0x1E,
  0x38, 0xE0, 0xE6, 0x03, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x01,
  0x9C, 0x1C, 0xF1, 0xC3, 0xFE, 0x07, 0xC0, 0x7F, 0x0F, 0xFC, 0xE1, 0xCE,
  0x0E, 0xE0, 0x6E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x06, 0xE0, 0xEE,
  0x1E, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00,
  0x0F, 0xE3, 0xFF, 0x38, 0x77, 0x07, 0x60, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x76, 0x07, 0x70, 0x77, 0x87, 0x3F, 0xF0, 0xFF, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x3F, 0xFF, 0xFE, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x1F,
  0xCF, 0xFB, 0x81, 0x70, 0x0E, 0x00, 0xF0, 0x0F, 0xC0, 0x7C, 0x01, 0xE0,
  0x1C, 0x03, 0xE0, 0x7F, 0xFC, 0xFF, 0x00, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0xFF, 0xEF, 0xFE, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x18, 0x01, 0x80, 0x1C, 0x01, 0xC2, 0x0F, 0xE0, 0x7E, 0xE0, 0xFC,
  0x1F, 0x83, 0xF0, 0x7E, 0x0F, 0xC1, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1F,
  0x83, 0xB8, 0x77, 0xFE, 0x3F, 0x80, 0xE0, 0x3F, 0x01, 0xD8, 0x0C, 0xE0,
  0xE7, 0x07, 0x18, 0x30, 0xE3, 0x87, 0x18, 0x18, 0xC0, 0xEE, 0x03, 0x60,
  0x1F, 0x00, 0x70, 0x03, 0x80, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x8E, 0x3C,
  0x71, 0xE3, 0x8F, 0x94, 0xED, 0xB6, 0x6D, 0xB3, 0x45, 0x9E, 0x3C, 0xF1,
  0xE7, 0x06, 0x18, 0x30, 0xE0, 0x33, 0x83, 0x8E, 0x38, 0x31, 0x81, 0xD8,
  0x07, 0xC0, 0x1C, 0x00, 0xE0, 0x0D, 0x80, 0xEE, 0x0E, 0x38, 0xE0, 0xE6,
  0x07, 0x70, 0x1C, 0x60, 0x3B, 0x81, 0x9C, 0x0C, 0xE0, 0xE3, 0x07, 0x1C,
  0x30, 0x61, 0x83, 0x1C, 0x1C, 0xC0, 0x66, 0x03, 0xF0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x3E, 0x00, 0x7F, 0xEF,
  0xFC, 0x07, 0x01, 0xC0, 0x70, 0x0E, 0x03, 0x80, 0xE0, 0x18, 0x07, 0x01,
  0xC0, 0x30, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xE1, 0xFC, 0x38, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x70, 0x0C, 0x0F, 0x81,
  0xF0, 0x06, 0x00, 0xE0, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x00, 0x70, 0x0F, 0xE0, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x1F, 0xC0, 0x38, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x1C, 0x01, 0x80, 0x3E, 0x07, 0xC1,
  0xC0, 0x38, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0xFE, 0x1F, 0x00, 0x3C, 0x1B, 0xF9, 0xF9, 0xFD, 0x83, 0xC0,
};

const GFXglyph UbuntuMono_Regular30pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 4, 19, 15, 5, -19 },
  { 11, 7, 7, 15, 4, -20 },
  { 18, 13, 19, 15, 1, -19 },
  { 49, 11, 24, 15, 2, -21 },
  { 82, 13, 19, 15, 1, -19 },
  { 113, 13, 19, 15, 1, -19 },
  { 144, 3, 8, 15, 6, -20 },
  { 147, 9, 24, 15, 3, -19 },
  { 174, 9, 24, 15, 3, -19 },
  { 201, 11, 11, 15, 2, -19 },
  { 217, 13, 14, 15, 1, -15 },
  { 240, 7, 8, 15, 4, -4 },
  { 247, 7, 2, 15, 4, -8 },
  { 249, 5, 4, 15, 5, -4 },
  { 252, 11, 26, 15, 2, -21 },
  { 288, 13, 19, 15, 1, -19 },
  { 319, 11, 19, 15, 2, -19 },
  { 346, 11, 19, 15, 2, -19 },
  { 373, 11, 19, 15, 2, -19 },
  { 400, 13, 19, 15, 1, -19 },
  { 431, 11, 19, 15, 2, -19 },
  { 458, 11, 19, 15, 2, -19 },
  { 485, 12, 19, 15, 2, -19 },
  { 514, 11, 19, 15, 2, -19 },
  { 541, 11, 19, 15, 2, -19 },
  { 568, 5, 14, 15, 5, -14 },
  { 577, 6, 18, 15, 4, -14 },
  { 591, 13, 12, 15, 1, -13 },
  { 611, 13, 8, 15, 1, -12 },
  { 624, 13, 12, 15, 1, -13 },
  { 644, 9, 19, 15, 3, -19 },
  { 666, 13, 23, 15, 1, -19 },
  { 704, 15, 19, 15, 0, -19 },
  { 740, 12, 19, 15, 2, -19 },
  { 769, 13, 19, 15, 1, -19 },
  { 800, 12, 19, 15, 2, -19 },
  { 829, 11, 19, 15, 3, -19 },
  { 856, 10, 19, 15, 3, -19 },
  { 880, 13, 19, 15, 1, -19 },
  { 911, 13, 19, 15, 1, -19 },
  { 942, 9, 19, 15, 3, -19 },
  { 964, 11, 19, 15, 2, -19 },
  { 991, 13, 19, 15, 2, -19 },
  { 1022, 11, 19, 15, 3, -19 },
  { 1049, 13, 19, 15, 1, -19 },
  { 1080, 11, 19, 15, 2, -19 },
  { 1107, 13, 19, 15, 1, -19 },
  { 1138, 12, 19, 15, 2, -19 },
  { 1167, 13, 24, 15, 1, -19 },
  { 1206, 12, 19, 15, 2, -19 },
  { 1235, 11, 19, 15, 2, -19 },
  { 1262, 13, 19, 15, 1, -19 },
  { 1293, 13, 19, 15, 1, -19 },
  { 1324, 15, 19, 15, 0, -19 },
  { 1360, 13, 19, 15, 1, -19 },
  { 1391, 13, 19, 15, 1, -19 },
  { 1422, 15, 19, 15, 0, -19 },
  { 1458, 12, 19, 15, 2, -19 },
  { 1487, 7, 24, 15, 4, -19 },
  { 1508, 11, 26, 15, 2, -21 },
  { 1544, 7, 24, 15, 4, -19 },
  { 1565, 13, 10, 15, 1, -19 },
  { 1582, 15, 2, 15, 0, 3 },
  { 1586, 5, 5, 15, 5, -21 },
  { 1590, 11, 14, 15, 2, -14 },
  { 1610, 12, 21, 15, 2, -21 },
  { 1642, 13, 14, 15, 1, -14 },
  { 1665, 12, 21, 15, 1, -21 },
  { 1697, 13, 14, 15, 1, -14 },
  { 1720, 12, 21, 15, 2, -21 },
  { 1752, 12, 19, 15, 1, -14 },
  { 1781, 11, 21, 15, 2, -21 },
  { 1810, 12, 19, 15, 2, -19 },
  { 1839, 10, 24, 15, 2, -19 },
  { 1869, 12, 21, 15, 2, -21 },
  { 1901, 12, 21, 15, 2, -21 },
  { 1933, 13, 14, 15, 1, -14 },
  { 1956, 11, 14, 15, 2, -14 },
  { 1976, 13, 14, 15, 1, -14 },
  { 1999, 12, 19, 15, 2, -14 },
  { 2028, 12, 19, 15, 1, -14 },
  { 2057, 10, 14, 15, 3, -14 },
  { 2075, 11, 14, 15, 2, -14 },
  { 2095, 12, 18, 15, 2, -18 },
  { 2122, 11, 14, 15, 2, -14 },
  { 2142, 13, 14, 15, 1, -14 },
  { 2165, 13, 14, 15, 1, -14 },
  { 2188, 13, 14, 15, 1, -14 },
  { 2211, 13, 19, 15, 1, -14 },
  { 2242, 11, 14, 15, 2, -14 },
  { 2262, 11, 26, 15, 2, -21 },
  { 2298, 3, 26, 15, 6, -21 },
  { 2308, 11, 26, 15, 2, -21 },
  { 2344, 13, 4, 15, 1, -10 },
};

const GFXfont UbuntuMono_Regular30pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular30pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular30pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _UBUNTUMONO_REGULAR30PT7B_H_
