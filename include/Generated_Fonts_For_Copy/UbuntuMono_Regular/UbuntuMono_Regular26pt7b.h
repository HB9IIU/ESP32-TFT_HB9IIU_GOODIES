#ifndef _UBUNTUMONO_REGULAR26PT7B_H_
#define _UBUNTUMONO_REGULAR26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular26pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFE, 0x48, 0x0F, 0xFF, 0xC7, 0x8F, 0x1E, 0x34, 0x48,
  0x80, 0x0C, 0xC3, 0x18, 0x63, 0x0C, 0x6F, 0xFF, 0xFF, 0xCC, 0x61, 0x8C,
  0x31, 0x86, 0x33, 0xFF, 0xFF, 0xF6, 0x30, 0xC6, 0x18, 0xC3, 0x30, 0x04,
  0x00, 0x80, 0x10, 0x0F, 0xC3, 0xFC, 0xE1, 0x18, 0x03, 0x00, 0x70, 0x07,
  0xC0, 0x7E, 0x03, 0xE0, 0x1C, 0x01, 0xC0, 0x3A, 0x06, 0x7F, 0xC7, 0xE0,
  0x10, 0x02, 0x00, 0x40, 0x38, 0x33, 0x61, 0x13, 0x19, 0x89, 0x8C, 0xCC,
  0x26, 0xC1, 0xBC, 0x07, 0x60, 0x06, 0xE0, 0x2D, 0x83, 0x64, 0x32, 0x31,
  0x91, 0x98, 0xC8, 0x86, 0xCC, 0x1C, 0x1E, 0x07, 0xE1, 0x8C, 0x31, 0x86,
  0x30, 0xEC, 0x0F, 0x01, 0xC6, 0x6C, 0xD8, 0xDB, 0x0F, 0x61, 0xCC, 0x1D,
  0xC7, 0x9F, 0xB9, 0xE3, 0xFF, 0xF4, 0x90, 0x04, 0x1C, 0x71, 0xC7, 0x0C,
  0x38, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x0C, 0x18, 0x38, 0x38, 0x38, 0x38,
  0x20, 0x41, 0xC1, 0xC1, 0xC1, 0xC1, 0x83, 0x03, 0x06, 0x0C, 0x18, 0x30,
  0x61, 0x83, 0x0E, 0x38, 0xE3, 0x82, 0x00, 0x0E, 0x01, 0xC1, 0x11, 0x3A,
  0xE3, 0xF8, 0x1C, 0x06, 0xC1, 0xDC, 0x31, 0x82, 0x20, 0x04, 0x00, 0x80,
  0x10, 0x02, 0x00, 0x41, 0xFF, 0xFF, 0xF8, 0x20, 0x04, 0x00, 0x80, 0x10,
  0x02, 0x00, 0x33, 0xDE, 0x71, 0x9B, 0x98, 0xFF, 0xC0, 0xFF, 0xF0, 0x01,
  0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x00,
  0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x66, 0x0D, 0xC1, 0xF3, 0x9E, 0x73, 0xCE,
  0x78, 0x0F, 0x83, 0xB0, 0x66, 0x0C, 0xE3, 0x8F, 0xE0, 0xF8, 0x0C, 0x0E,
  0x1F, 0x1F, 0x8C, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x61, 0xFE, 0xFF, 0x1F, 0x0F, 0xF1, 0x87, 0x20, 0x60, 0x0C, 0x01,
  0x80, 0x60, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x03, 0x00, 0xC0, 0x1F,
  0xFB, 0xFF, 0x7E, 0x7F, 0xB0, 0xC0, 0x70, 0x18, 0x1C, 0x1C, 0x7C, 0x3F,
  0x01, 0xC0, 0x60, 0x30, 0x1C, 0x1F, 0xFC, 0xFC, 0x01, 0x80, 0x70, 0x1E,
  0x06, 0xC1, 0x98, 0x33, 0x0C, 0x63, 0x0C, 0x61, 0x98, 0x33, 0xFF, 0xFF,
  0xF0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x7F, 0xBF, 0xD8, 0x0C, 0x06, 0x03,
  0x01, 0xF0, 0xFE, 0x07, 0x80, 0xC0, 0x60, 0x30, 0x1C, 0x1F, 0xFC, 0xFC,
  0x03, 0xC1, 0xF8, 0x78, 0x1C, 0x07, 0x00, 0xC0, 0x1F, 0xC3, 0xFE, 0xE1,
  0xDC, 0x1F, 0x83, 0xB0, 0x76, 0x0C, 0xE3, 0x8F, 0xE0, 0xF8, 0xFF, 0xFF,
  0xF0, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60, 0x38, 0x0C, 0x07, 0x01, 0x80,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x66,
  0x0C, 0xC1, 0x9C, 0x61, 0xF8, 0x3F, 0x8C, 0x39, 0x83, 0xE0, 0x3E, 0x0E,
  0xC1, 0x9F, 0xF0, 0xF8, 0x1F, 0x07, 0xF1, 0xC7, 0x30, 0x6E, 0x0D, 0xC1,
  0xF8, 0x3B, 0x87, 0x7F, 0xE3, 0xF8, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x1F,
  0x83, 0xC0, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x38, 0xE3, 0x8E, 0x00, 0x00,
  0x00, 0x38, 0xE3, 0x8E, 0x18, 0xEF, 0x10, 0x00, 0x40, 0x3C, 0x1F, 0x0F,
  0x0F, 0x81, 0xC0, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x3C, 0x01, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x40, 0x1E, 0x01,
  0xF0, 0x07, 0xC0, 0x3E, 0x01, 0xC0, 0xF8, 0x7C, 0x7C, 0x1E, 0x01, 0x00,
  0x00, 0x3E, 0x3F, 0x90, 0xE0, 0x70, 0x30, 0x18, 0x18, 0x18, 0x18, 0x0C,
  0x00, 0x00, 0x01, 0x81, 0xE0, 0xF0, 0x30, 0x0F, 0x83, 0xF8, 0xE3, 0x38,
  0x36, 0x06, 0xC0, 0xF0, 0xFE, 0x3F, 0xCE, 0x79, 0x8F, 0x31, 0xE6, 0x3C,
  0xE7, 0xCF, 0xD8, 0xFB, 0x00, 0x30, 0x07, 0x00, 0x7F, 0x03, 0xE0, 0x07,
  0x00, 0x38, 0x03, 0x60, 0x1B, 0x00, 0xD8, 0x0C, 0x60, 0x63, 0x03, 0x18,
  0x30, 0x61, 0x83, 0x0F, 0xF8, 0xFF, 0xE6, 0x03, 0x30, 0x19, 0x80, 0xDC,
  0x07, 0xFF, 0x1F, 0xF3, 0x87, 0x70, 0x6E, 0x0D, 0xC1, 0xB8, 0x67, 0xF8,
  0xFF, 0x9C, 0x3B, 0x83, 0xF0, 0x3E, 0x0F, 0xC3, 0xBF, 0xF7, 0xF8, 0x0F,
  0xC3, 0xFC, 0xE1, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0xC7, 0xF8, 0x7E, 0xFE, 0x1F, 0xE3,
  0x8E, 0x70, 0x6E, 0x0D, 0xC1, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x83,
  0xF0, 0x6E, 0x0D, 0xC7, 0x3F, 0xE7, 0xF0, 0xFF, 0xBF, 0xEE, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0xFE, 0xFF, 0xB8, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xFF,
  0xFF, 0xF0, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x0F, 0xC3, 0xFC,
  0xE1, 0x38, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x78, 0x0F, 0x81,
  0xB0, 0x37, 0x06, 0x70, 0xC7, 0xF8, 0x7E, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xC7, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE3, 0xFF, 0xFF, 0x3F,
  0xCF, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x01, 0xD0, 0x67, 0xF8, 0xF8, 0xC1, 0xD8, 0x33, 0x0E, 0x63,
  0x8C, 0xE1, 0xB8, 0x3E, 0x07, 0x80, 0xF8, 0x1B, 0x83, 0x38, 0x63, 0x8C,
  0x39, 0x83, 0x30, 0x76, 0x07, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xFF,
  0xFF, 0x60, 0xCC, 0x19, 0xC7, 0x38, 0xE5, 0x17, 0xB6, 0xF6, 0xDE, 0x53,
  0xCE, 0x79, 0xCF, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0,
  0x7C, 0x0F, 0xC1, 0xFC, 0x3D, 0x87, 0x98, 0xF3, 0x1E, 0x33, 0xC6, 0x78,
  0x4F, 0x0D, 0xE1, 0xBC, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0x1F, 0x07, 0xF1,
  0xC7, 0x70, 0x6C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3E, 0x0E, 0xE3, 0x8F, 0xE0, 0xF8, 0xFE, 0x3F, 0xEC, 0x3B, 0x07,
  0xC0, 0xF0, 0x3C, 0x1F, 0x0E, 0xFF, 0xBF, 0x8C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x6C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x0E, 0xE3, 0x8F, 0xE0,
  0xF8, 0x0E, 0x00, 0xE0, 0x0F, 0x80, 0x60, 0xFE, 0x1F, 0xF3, 0x87, 0x70,
  0x6E, 0x0D, 0xC1, 0xB8, 0x37, 0x0E, 0xFF, 0x9F, 0xC3, 0x8C, 0x71, 0xCE,
  0x19, 0xC1, 0xB8, 0x37, 0x03, 0x1F, 0x87, 0xF9, 0xC2, 0x30, 0x06, 0x00,
  0xE0, 0x1E, 0x01, 0xF8, 0x0F, 0x80, 0x38, 0x03, 0x00, 0x70, 0x0E, 0x83,
  0x9F, 0xF1, 0xF8, 0xFF, 0xFF, 0xFC, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xF0, 0x7E, 0x0E, 0xE3, 0x9F, 0xF0, 0xF8, 0xE0,
  0x3B, 0x01, 0x98, 0x0C, 0xC0, 0x67, 0x07, 0x18, 0x30, 0xC1, 0x87, 0x1C,
  0x18, 0xC0, 0xC6, 0x07, 0x30, 0x1B, 0x00, 0xD8, 0x07, 0xC0, 0x1C, 0x00,
  0xE0, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF3, 0x9E, 0x73,
  0xCA, 0x7B, 0x6F, 0x6D, 0xE8, 0xA7, 0x1C, 0xE3, 0x98, 0x33, 0x06, 0xE0,
  0x6C, 0x19, 0xC7, 0x18, 0xC3, 0xB8, 0x36, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xE0, 0x6C, 0x18, 0xC7, 0x1C, 0xC1, 0xB8, 0x3E, 0x03, 0x60, 0x3B, 0x01,
  0x9C, 0x1C, 0x60, 0xC3, 0x8E, 0x0C, 0x60, 0x77, 0x01, 0xB0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x7F,
  0xEF, 0xFC, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x80, 0x60, 0x18, 0x07, 0x00, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0F, 0xFF,
  0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06,
  0x01, 0x80, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x60, 0x18,
  0x0C, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x3F, 0xFF, 0x0E, 0x01, 0xC0, 0x6C, 0x0D, 0x83, 0x18, 0xE3,
  0x98, 0x37, 0x07, 0x40, 0x40, 0xFF, 0xFF, 0xFF, 0xC0, 0x47, 0x18, 0x61,
  0x00, 0x7E, 0x3F, 0x80, 0xE0, 0x30, 0x19, 0xFF, 0xFF, 0x83, 0xC1, 0xE0,
  0xFF, 0xE7, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0D, 0xE3,
  0xFC, 0xE3, 0xB0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x1F, 0x0E, 0xFF,
  0x3F, 0x80, 0x0F, 0xE7, 0xF9, 0xE0, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x07,
  0x00, 0x60, 0x0F, 0x00, 0xFF, 0x87, 0xF0, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x31, 0xFC, 0xFF, 0x71, 0xF8, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x0D, 0xC3, 0x3F, 0xC7, 0xF0, 0x1F, 0x07, 0xF1, 0xC7, 0x70, 0x6C,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x08, 0xFF, 0x0F, 0xC0, 0x0F,
  0xC3, 0xF8, 0x61, 0x1C, 0x03, 0x00, 0x60, 0x3F, 0xE7, 0xFC, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00,
  0x1F, 0xCF, 0xF7, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xDC,
  0x77, 0xFC, 0x7F, 0x00, 0xD0, 0x77, 0xF9, 0xF8, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0xF9, 0xFE, 0xC3, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x00, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x03, 0x88, 0x7F, 0x07, 0xC0, 0x06, 0x0F, 0x06, 0x00, 0x00, 0x7F, 0x7F,
  0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x87,
  0xFE, 0x7C, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x1F, 0x0E,
  0xC7, 0x33, 0x8D, 0x83, 0xC0, 0xF8, 0x33, 0x0C, 0x63, 0x0C, 0xC1, 0xB0,
  0x30, 0xFC, 0x1F, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x71, 0x07,
  0xE0, 0xF8, 0xFB, 0xDF, 0xFF, 0x39, 0xE3, 0x3C, 0x67, 0x8C, 0xF1, 0x9E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x30, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C,
  0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x30, 0x1F, 0x07, 0xF1,
  0xC7, 0x70, 0x7C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xE0, 0xEE, 0x38, 0xFE,
  0x0F, 0x80, 0xFE, 0x3F, 0xCC, 0x3B, 0x07, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC1, 0xF8, 0xEF, 0xF3, 0xF8, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x1F, 0xCF,
  0xF7, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xDC, 0x33, 0xFC,
  0x7F, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x7F, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x3F, 0x3F, 0xF8, 0x58, 0x0F, 0x03,
  0xE0, 0x7C, 0x07, 0x01, 0xC0, 0xFF, 0xEF, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xFF, 0xBF, 0xE3, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0E, 0x11, 0xFC, 0x3E, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC1, 0xF0, 0xDF, 0xE7, 0xF0, 0xC0, 0x7C, 0x0D, 0x83, 0x30, 0x67,
  0x1C, 0x63, 0x0C, 0x61, 0xDC, 0x1B, 0x03, 0xE0, 0x38, 0x07, 0x00, 0x60,
  0x13, 0x01, 0x98, 0x0C, 0xC6, 0x66, 0x73, 0x33, 0x99, 0x94, 0xCD, 0xB4,
  0x3D, 0xE1, 0xC7, 0x0E, 0x38, 0x60, 0xC0, 0xE0, 0xEC, 0x38, 0xC6, 0x0D,
  0x81, 0xF0, 0x1C, 0x03, 0x80, 0xD8, 0x31, 0x8E, 0x39, 0x83, 0x60, 0x30,
  0xE0, 0x6C, 0x1D, 0x83, 0x38, 0x63, 0x0C, 0x63, 0x0E, 0x60, 0xCC, 0x1F,
  0x01, 0xE0, 0x3C, 0x03, 0x00, 0x60, 0x18, 0x3E, 0x07, 0x80, 0xFF, 0xFF,
  0xC0, 0xC0, 0xC0, 0xE0, 0xE0, 0xE0, 0x60, 0x60, 0x70, 0x3F, 0xFF, 0xF0,
  0x0F, 0x8F, 0xC6, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x3C,
  0x1E, 0x03, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0xF8,
  0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7E, 0x03, 0x01, 0x80,
  0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0xE0, 0xF0, 0xE0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x8F, 0xC7, 0xC0, 0x38, 0x6F, 0xCF, 0x3F,
  0x61, 0xC0,
};

const GFXglyph UbuntuMono_Regular26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 3, 16, 13, 5, -16 },
  { 7, 7, 6, 13, 3, -18 },
  { 13, 11, 16, 13, 1, -16 },
  { 35, 11, 21, 13, 1, -18 },
  { 64, 13, 16, 13, 0, -16 },
  { 90, 11, 16, 13, 1, -16 },
  { 112, 3, 7, 13, 5, -18 },
  { 115, 7, 20, 13, 3, -16 },
  { 133, 7, 20, 13, 3, -16 },
  { 151, 11, 10, 13, 1, -16 },
  { 165, 11, 12, 13, 1, -13 },
  { 182, 5, 8, 13, 4, -4 },
  { 187, 5, 2, 13, 4, -8 },
  { 189, 3, 4, 13, 5, -4 },
  { 191, 9, 22, 13, 2, -18 },
  { 216, 11, 16, 13, 1, -16 },
  { 238, 9, 16, 13, 2, -16 },
  { 256, 11, 16, 13, 1, -16 },
  { 278, 9, 16, 13, 2, -16 },
  { 296, 11, 16, 13, 1, -16 },
  { 318, 9, 16, 13, 2, -16 },
  { 336, 11, 16, 13, 1, -16 },
  { 358, 10, 16, 13, 2, -16 },
  { 378, 11, 16, 13, 1, -16 },
  { 400, 11, 16, 13, 1, -16 },
  { 422, 3, 12, 13, 5, -12 },
  { 427, 6, 16, 13, 3, -12 },
  { 439, 11, 11, 13, 1, -12 },
  { 455, 11, 7, 13, 1, -10 },
  { 465, 11, 11, 13, 1, -12 },
  { 481, 9, 16, 13, 2, -16 },
  { 499, 11, 20, 13, 1, -16 },
  { 527, 13, 16, 13, 0, -16 },
  { 553, 11, 16, 13, 1, -16 },
  { 575, 11, 16, 13, 1, -16 },
  { 597, 11, 16, 13, 1, -16 },
  { 619, 10, 16, 13, 2, -16 },
  { 639, 9, 16, 13, 2, -16 },
  { 657, 11, 16, 13, 1, -16 },
  { 679, 11, 16, 13, 1, -16 },
  { 701, 9, 16, 13, 2, -16 },
  { 719, 10, 16, 13, 1, -16 },
  { 739, 11, 16, 13, 2, -16 },
  { 761, 10, 16, 13, 2, -16 },
  { 781, 11, 16, 13, 1, -16 },
  { 803, 11, 16, 13, 1, -16 },
  { 825, 11, 16, 13, 1, -16 },
  { 847, 10, 16, 13, 2, -16 },
  { 867, 11, 20, 13, 1, -16 },
  { 895, 11, 16, 13, 1, -16 },
  { 917, 11, 16, 13, 1, -16 },
  { 939, 11, 16, 13, 1, -16 },
  { 961, 11, 16, 13, 1, -16 },
  { 983, 13, 16, 13, 0, -16 },
  { 1009, 11, 16, 13, 1, -16 },
  { 1031, 11, 16, 13, 1, -16 },
  { 1053, 13, 16, 13, 0, -16 },
  { 1079, 11, 16, 13, 1, -16 },
  { 1101, 6, 20, 13, 4, -16 },
  { 1116, 9, 22, 13, 2, -18 },
  { 1141, 6, 20, 13, 3, -16 },
  { 1156, 11, 9, 13, 1, -16 },
  { 1169, 13, 2, 13, 0, 2 },
  { 1173, 5, 5, 13, 4, -18 },
  { 1177, 9, 12, 13, 2, -12 },
  { 1191, 10, 18, 13, 2, -18 },
  { 1214, 11, 12, 13, 1, -12 },
  { 1231, 10, 18, 13, 1, -18 },
  { 1254, 11, 12, 13, 1, -12 },
  { 1271, 11, 18, 13, 2, -18 },
  { 1296, 10, 16, 13, 1, -12 },
  { 1316, 9, 18, 13, 2, -18 },
  { 1337, 11, 17, 13, 1, -17 },
  { 1361, 8, 21, 13, 2, -17 },
  { 1382, 10, 18, 13, 2, -18 },
  { 1405, 11, 18, 13, 1, -18 },
  { 1430, 11, 12, 13, 1, -12 },
  { 1447, 9, 12, 13, 2, -12 },
  { 1461, 11, 12, 13, 1, -12 },
  { 1478, 10, 16, 13, 2, -12 },
  { 1498, 10, 16, 13, 1, -12 },
  { 1518, 8, 12, 13, 3, -12 },
  { 1530, 9, 12, 13, 2, -12 },
  { 1544, 10, 16, 13, 2, -16 },
  { 1564, 9, 12, 13, 2, -12 },
  { 1578, 11, 12, 13, 1, -12 },
  { 1595, 13, 12, 13, 0, -12 },
  { 1615, 11, 12, 13, 1, -12 },
  { 1632, 11, 16, 13, 1, -12 },
  { 1654, 9, 12, 13, 2, -12 },
  { 1668, 9, 22, 13, 2, -18 },
  { 1693, 2, 22, 13, 6, -18 },
  { 1699, 9, 22, 13, 2, -18 },
  { 1724, 11, 4, 13, 1, -9 },
};

const GFXfont UbuntuMono_Regular26pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular26pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular26pt7bGlyphs,
  0x20, 0x7E, 26
};

#endif // _UBUNTUMONO_REGULAR26PT7B_H_
