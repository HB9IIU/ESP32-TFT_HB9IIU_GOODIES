#ifndef _UBUNTUMONO_REGULAR64PT7B_H_
#define _UBUNTUMONO_REGULAR64PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 64pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular64pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E,
  0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7E, 0x7C, 0x7C, 0x3C, 0x3C, 0x3C,
  0x3C, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7E, 0x3C, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8,
  0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1E, 0x78,
  0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70,
  0x0E, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x78, 0x00, 0x78, 0x07, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF0,
  0x00, 0xF0, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xC0, 0x03,
  0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07,
  0xC0, 0x07, 0xC0, 0x78, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x0F, 0x00, 0x0F, 0x01,
  0xF0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x01, 0xE0, 0x1E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0xF8,
  0x3F, 0x00, 0x06, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x20, 0x00, 0x3F, 0x9F, 0x80, 0x3F,
  0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x7F, 0x80, 0x03, 0xC3,
  0xFF, 0x00, 0x1F, 0x1F, 0x3E, 0x00, 0x78, 0x78, 0x78, 0x03, 0xE1, 0xE0,
  0xF0, 0x0F, 0x0F, 0x03, 0xC0, 0x78, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0xC3, 0xE0, 0x3C, 0x0F, 0x0F,
  0x00, 0xF0, 0x3C, 0x7C, 0x03, 0xC0, 0xF1, 0xE0, 0x07, 0x83, 0xCF, 0x80,
  0x1E, 0x1E, 0x7C, 0x00, 0x7C, 0xF9, 0xE0, 0x00, 0xFF, 0xCF, 0x80, 0x01,
  0xFE, 0x3C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x0F, 0x8F, 0x80, 0x00,
  0x3C, 0x7F, 0x80, 0x01, 0xF3, 0xFF, 0x00, 0x07, 0x9F, 0x3E, 0x00, 0x3E,
  0x78, 0x78, 0x01, 0xF3, 0xC1, 0xE0, 0x07, 0x8F, 0x03, 0xC0, 0x3E, 0x3C,
  0x0F, 0x00, 0xF0, 0xF0, 0x3C, 0x07, 0x83, 0xC0, 0xF0, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC0, 0xF0, 0x3C, 0x1E, 0x03, 0xC0, 0xF0,
  0xF0, 0x0F, 0x07, 0x87, 0xC0, 0x1E, 0x1E, 0x1E, 0x00, 0x7C, 0xF8, 0xF8,
  0x00, 0xFF, 0xC7, 0xC0, 0x01, 0xFE, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x00,
  0x0F, 0xFF, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF0,
  0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0xC7, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x03, 0xFC, 0x07, 0xC0, 0x7F, 0xC0, 0x7C, 0x0F, 0xFE, 0x07, 0xC1,
  0xF7, 0xF0, 0x7C, 0x3F, 0x3F, 0x87, 0x83, 0xE1, 0xFC, 0x78, 0x7C, 0x0F,
  0xEF, 0x87, 0xC0, 0x7F, 0xF8, 0xFC, 0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xF0,
  0xF8, 0x00, 0xFF, 0x0F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x7F, 0x87, 0xFF,
  0xC3, 0xFF, 0xFE, 0x7C, 0x3F, 0xFF, 0xE7, 0xE1, 0xFF, 0xFC, 0x3E, 0x07,
  0xFF, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFB, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x78, 0x00, 0x02, 0x00, 0x01, 0xC0,
  0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x70, 0x00,
  0x08, 0x10, 0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0x00, 0x03, 0x80, 0x00, 0x40, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C,
  0x00, 0x60, 0x3C, 0x02, 0x78, 0x3C, 0x1E, 0xFE, 0x3C, 0x7F, 0xFF, 0xBD,
  0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xC0, 0x00, 0x7E,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xE7, 0xC0, 0x07, 0xE7,
  0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x81,
  0xF0, 0x07, 0x00, 0xE0, 0x03, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x1F,
  0xF0, 0xFF, 0x07, 0xF0, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC3, 0xF8, 0xFF,
  0x0F, 0xE0, 0xFC, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE,
  0x1E, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x07, 0xF8, 0x7F, 0x81, 0xF8, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xE7, 0xE0,
  0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x78, 0x3F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F, 0xC1,
  0xFF, 0x87, 0xF8, 0x7F, 0xE1, 0xFE, 0x1F, 0xF8, 0x3F, 0x07, 0xFE, 0x0F,
  0xC1, 0xFF, 0x81, 0xE0, 0x7F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x9F, 0x80, 0x07, 0xE7, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x07, 0xE0, 0x1F, 0x81, 0xFE, 0x1F, 0xE0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0xFF,
  0xBF, 0x01, 0xFC, 0x7E, 0x01, 0xE0, 0xFC, 0x03, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0x03,
  0xFC, 0x78, 0x01, 0xFC, 0x70, 0x00, 0xFC, 0x20, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x3C, 0x03,
  0xFC, 0x30, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x40, 0x00,
  0xFE, 0xF8, 0x03, 0xFE, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00,
  0x1F, 0x3E, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC3,
  0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00,
  0x3E, 0x03, 0xE0, 0x03, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x03, 0xE0,
  0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFE, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x40, 0x00, 0xFE, 0x78, 0x03, 0xFE,
  0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0xFF, 0x00, 0x7D, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFC, 0x7F, 0x80, 0xFF, 0x3F,
  0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F,
  0xDF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x7C, 0x00,
  0x0F, 0xDF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0x1F, 0x8F, 0xE0, 0x0F, 0xC1, 0xFE, 0x0F, 0xF0, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xFC,
  0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0,
  0x3F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7E, 0x00, 0x1F,
  0x1F, 0x80, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFE, 0x01, 0xF8, 0x1F, 0xE0,
  0xFC, 0x07, 0xFF, 0x7E, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xF8, 0x3F, 0xF0, 0xFC, 0x03, 0xFC,
  0x3E, 0x00, 0x3F, 0x9F, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE7, 0xFC, 0x0F, 0xF0,
  0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xF0, 0x07, 0xF1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x1F, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBF, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x0F, 0xDF,
  0x80, 0x03, 0xF7, 0xF0, 0x00, 0xFC, 0xFF, 0x01, 0xFF, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF,
  0x9F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x00, 0xFC,
  0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xF9, 0xFE,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x87, 0xF9, 0xFE, 0xFF, 0xFF, 0xFF, 0xFD,
  0xFE, 0x7F, 0x87, 0x80, 0x03, 0xC0, 0x7F, 0x83, 0xFC, 0x3F, 0xF1, 0xFF,
  0x8F, 0xFC, 0x3F, 0xC1, 0xFE, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xE0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF8, 0xFF, 0xC7, 0xFE,
  0x1F, 0xF0, 0xFF, 0x83, 0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3F, 0x0F,
  0xF1, 0xFF, 0x0F, 0xF0, 0x3E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x80,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xF0, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xE7, 0x80, 0xFF, 0x40, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0,
  0x1F, 0xE0, 0x7F, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7,
  0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x3F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xC1, 0xFF, 0x83, 0xF0, 0x3F, 0xF0, 0xFC, 0x07, 0xFE, 0x1F, 0x00,
  0xFF, 0xC3, 0xE0, 0x1F, 0xF8, 0x7C, 0x03, 0xFF, 0x0F, 0x80, 0x7F, 0xE1,
  0xF0, 0x0F, 0xFC, 0x3E, 0x01, 0xFF, 0x87, 0xC0, 0x3F, 0xF0, 0xFC, 0x07,
  0xFE, 0x0F, 0x80, 0xFF, 0xC1, 0xFC, 0x1F, 0xFC, 0x1F, 0xFF, 0xEF, 0x83,
  0xFF, 0xFD, 0xF0, 0x3F, 0xFF, 0xBF, 0x03, 0xFF, 0xF7, 0xE0, 0x0F, 0xF0,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x01, 0x00,
  0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0x7C, 0xF8, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x03,
  0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F,
  0x80, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x07, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xE0, 0xF8, 0x00, 0x07, 0xC3, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07,
  0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0x1F,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0x8F, 0xC0, 0x0F, 0xE3, 0xF0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3, 0xF0,
  0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xE3,
  0xF0, 0x03, 0xF0, 0xFC, 0x03, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0x7F, 0x8F, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00,
  0x0F, 0xEF, 0xC0, 0x1F, 0xF3, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xC3, 0xFE, 0x03, 0xE0, 0xFE, 0x00, 0x18, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x20,
  0xFF, 0x80, 0x7C, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x3F, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F,
  0x01, 0xFF, 0x0F, 0xC0, 0x1F, 0xE3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x3E, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x8F, 0xC0, 0x7F,
  0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xEF, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFE, 0x03, 0xE0, 0xFE, 0x00,
  0x38, 0x7F, 0x00, 0x02, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x07,
  0xDF, 0x80, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xFE, 0x00, 0x1F, 0x1F, 0xC0,
  0x07, 0xC7, 0xF8, 0x01, 0xF0, 0xFF, 0x80, 0xFC, 0x1F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xE0,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x20, 0x00, 0x7E, 0x38, 0x00, 0xFE, 0x7E, 0x03, 0xFC, 0x7F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x03,
  0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0xFC,
  0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x07, 0xE1, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x7E, 0x07, 0xC0, 0x1F, 0xC0, 0xF8, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x03,
  0xE0, 0x3F, 0x00, 0x7C, 0x0F, 0xC0, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0xFE,
  0x00, 0x3E, 0x3F, 0x80, 0x07, 0xCF, 0xE0, 0x00, 0xFB, 0xF8, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80,
  0x01, 0xF7, 0xF8, 0x00, 0x3E, 0x3F, 0x80, 0x07, 0xC3, 0xF8, 0x00, 0xF8,
  0x3F, 0x80, 0x1F, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x80, 0x7C, 0x03, 0xF8,
  0x0F, 0x80, 0x3F, 0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7F, 0x07, 0xC0,
  0x07, 0xF0, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFE,
  0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0xBE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x81, 0xF8,
  0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xFC, 0x01, 0xFC, 0x3F, 0xC0, 0x3F,
  0xC3, 0xFC, 0x03, 0xFC, 0x3D, 0xC0, 0x3F, 0xC3, 0xDE, 0x07, 0xBC, 0x3D,
  0xE0, 0x7B, 0xC3, 0xDE, 0x07, 0xBC, 0x3C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F,
  0x3E, 0x7C, 0xF0, 0xF3, 0xE7, 0xC7, 0x9E, 0x3E, 0x7C, 0x79, 0xE3, 0xE7,
  0xC7, 0x9E, 0x3E, 0x7C, 0x3D, 0xC3, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x3F,
  0xC3, 0xE7, 0xC1, 0xF8, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x1E,
  0x7C, 0x0F, 0x81, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80,
  0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x0F, 0xF7, 0x80, 0x0F, 0xF7,
  0xC0, 0x0F, 0xF3, 0xE0, 0x0F, 0xF3, 0xE0, 0x0F, 0xF1, 0xF0, 0x0F, 0xF1,
  0xF0, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0xF8, 0x0F, 0xF0, 0x7C, 0x0F, 0xF0,
  0x7C, 0x0F, 0xF0, 0x3C, 0x0F, 0xF0, 0x3E, 0x0F, 0xF0, 0x1E, 0x0F, 0xF0,
  0x1F, 0x0F, 0xF0, 0x0F, 0x0F, 0xF0, 0x0F, 0x8F, 0xF0, 0x0F, 0x8F, 0xF0,
  0x07, 0x8F, 0xF0, 0x07, 0xCF, 0xF0, 0x03, 0xCF, 0xF0, 0x03, 0xEF, 0xF0,
  0x01, 0xEF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF,
  0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xF8, 0x03, 0xFC, 0xF8, 0x00,
  0xFE, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0xFC, 0xF8, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x01, 0xF8, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1C, 0x3F,
  0xFC, 0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x3E, 0x01, 0xFF, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3, 0xE0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xE3,
  0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F,
  0xC3, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x0F,
  0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0x7C,
  0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E,
  0x00, 0x07, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x3F, 0xC0, 0x7C, 0x7F, 0x00, 0x0C, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x3F,
  0x70, 0x00, 0x7F, 0xFE, 0x01, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0xF9, 0xF8, 0x00,
  0x7E, 0x7E, 0x00, 0x1F, 0x9F, 0xC0, 0x0F, 0xE3, 0xFC, 0x0F, 0xF0, 0x7F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x0F, 0xDF, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7C, 0x3E, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0xF8,
  0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03,
  0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0x80,
  0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF0, 0x3E,
  0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x1F, 0x00,
  0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7,
  0x80, 0x00, 0x1E, 0x78, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x1E, 0x78, 0x00,
  0x01, 0xE7, 0xC1, 0xF0, 0x3E, 0x7C, 0x1F, 0x83, 0xE7, 0xC1, 0xF8, 0x3E,
  0x7C, 0x1F, 0x83, 0xE7, 0xC3, 0xFC, 0x3E, 0x7C, 0x3F, 0xC3, 0xE7, 0xC3,
  0xBC, 0x3E, 0x7C, 0x79, 0xE3, 0xE7, 0xC7, 0x9E, 0x3E, 0x7C, 0x79, 0xE3,
  0xE7, 0xCF, 0x0F, 0x3C, 0x7C, 0xF0, 0xF3, 0xC3, 0xCF, 0x0F, 0x3C, 0x3D,
  0xE0, 0x7B, 0xC3, 0xDE, 0x07, 0xBC, 0x3D, 0xE0, 0x7B, 0xC3, 0xFC, 0x03,
  0xFC, 0x3F, 0xC0, 0x3F, 0xC3, 0xFC, 0x03, 0xFC, 0x3F, 0x80, 0x3F, 0xC3,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0x3E, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x7E,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x01,
  0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1F,
  0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x7E, 0x3E, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x01, 0xF8, 0x7C, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xEF, 0x80,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x3F,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x83, 0xF0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xEF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0x78, 0x00, 0x07, 0x84, 0x00, 0x00, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x10, 0x07, 0x01, 0xF0, 0x3F, 0x03, 0xF0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x38, 0x02, 0x00, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1C, 0x01, 0xFE,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x7F, 0x80, 0x3F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x7F, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xE0,
  0x38, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0xFE, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0x03, 0xFC,
  0xFC, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0xFE, 0xF8, 0x01, 0xFC, 0xF8, 0x07, 0xFC, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0x87, 0xFE, 0x00, 0xC3, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x01, 0x83, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x7F, 0x1F, 0x03,
  0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F,
  0xC0, 0xFF, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0x7F, 0x00, 0x1F, 0x3F, 0x80, 0x1F, 0x3F, 0xE0, 0x1F, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xF8, 0x3F, 0xC3, 0xF0, 0x03,
  0xF9, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x06, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFC, 0x07,
  0x80, 0x7E, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x01, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x3F, 0xC0, 0x3F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7F, 0x00, 0x1F, 0x3F, 0xC0, 0xFF, 0x3F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x20, 0x00, 0x7E, 0x3C, 0x01, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x07, 0xFE, 0x00,
  0x38, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x7F, 0x80, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7, 0xE0, 0x3F, 0xCF, 0x80, 0x1F,
  0xDF, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xE0, 0x60, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0xE4, 0x00, 0x7E, 0x78, 0x1F, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF,
  0xF0, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x38, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xF8, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0xC0, 0xF8,
  0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x0F, 0x87, 0xF0, 0x03, 0xE3, 0xF8, 0x00,
  0xF9, 0xFC, 0x00, 0x3E, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xBF, 0x80, 0x03, 0xE7,
  0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x0F, 0xE0, 0x0F, 0x81, 0xFC, 0x03,
  0xE0, 0x3F, 0x80, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F,
  0x83, 0xE0, 0x03, 0xF0, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x0F, 0xCF, 0x80,
  0x03, 0xFB, 0xE0, 0x00, 0x7E, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x0F,
  0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x18,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0xFC, 0x1F, 0xFE, 0x7F, 0xC3, 0xFF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFD, 0xF0, 0xFF, 0x1F,
  0xBC, 0x0F, 0x81, 0xF7, 0x80, 0xF0, 0x1F, 0xF0, 0x1E, 0x03, 0xFE, 0x03,
  0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF8, 0x0F, 0x81, 0xFF, 0x01, 0xF0, 0x3F,
  0xE0, 0x3E, 0x07, 0xFC, 0x07, 0xC0, 0xFF, 0x80, 0xF8, 0x1F, 0xF0, 0x1F,
  0x03, 0xFE, 0x03, 0xE0, 0x7F, 0xC0, 0x7C, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xC0, 0x07, 0xFE,
  0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0x9F, 0x00, 0x7F, 0x3E, 0x00, 0x7F, 0x7C, 0x00, 0x7E, 0xF8, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0x3F, 0xC3, 0xF0, 0x03, 0xF1,
  0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xE7, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0xC0, 0xFF, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xF8, 0x07, 0xFC, 0xF8, 0x01, 0xFC,
  0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x7E,
  0xFC, 0x00, 0xFE, 0xFF, 0x03, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xF8, 0xFF, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F,
  0x3F, 0x80, 0x1F, 0x7F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7F, 0x00, 0x3F, 0x3F, 0xC0, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x80,
  0x1B, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x7F, 0x80, 0x7C, 0x7E, 0x00,
  0x08, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x60, 0x00, 0x3F, 0x7C, 0x00, 0xFE, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x70,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x01, 0x80, 0x7F, 0xFF, 0xC0,
  0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03,
  0xEF, 0xC0, 0x07, 0xDF, 0x80, 0x0F, 0xBF, 0x80, 0x1F, 0x3F, 0xC0, 0x3E,
  0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0,
  0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0x7C, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x0F, 0xC0, 0x3F,
  0x00, 0xFC, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x07,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xDE,
  0x00, 0x00, 0x1E, 0x7C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0x9F, 0x01, 0xE0, 0x3E, 0x7C, 0x07, 0xC0, 0xF9, 0xF0, 0x3F,
  0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x8F, 0x03, 0xF0, 0x3C, 0x3C, 0x0F, 0xE0,
  0xF0, 0xF8, 0x7F, 0x83, 0xC3, 0xE1, 0xFE, 0x1F, 0x0F, 0x87, 0x3C, 0x7C,
  0x3E, 0x3C, 0xF1, 0xF0, 0xF8, 0xF3, 0xC7, 0x81, 0xE3, 0x87, 0x9E, 0x07,
  0x9E, 0x1E, 0x78, 0x1E, 0x78, 0x79, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF,
  0x03, 0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F,
  0x80, 0x1E, 0x00, 0x1E, 0x00, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0x81, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF1, 0xF8,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x1F, 0x9F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0,
  0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x00, 0xF8,
  0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x3E, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F,
  0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x00,
  0x7E, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x01, 0xF0,
  0x3E, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0,
  0x00, 0xFC, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7C, 0xF8, 0x00, 0x03,
  0xEF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x04, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0xC0,
  0xFF, 0x80, 0x0F, 0x1F, 0xFE, 0x01, 0xE3, 0xFF, 0xF0, 0x1E, 0x3F, 0xFF,
  0xC3, 0xE7, 0xC3, 0xFF, 0xFC, 0x78, 0x0F, 0xFF, 0xC7, 0x80, 0x7F, 0xF8,
  0xF0, 0x01, 0xFF, 0x03, 0x00, 0x07, 0xC0,
};

const GFXglyph UbuntuMono_Regular64pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 32, 0, -1 },
  { 1, 8, 40, 32, 12, -40 },
  { 41, 16, 16, 32, 8, -43 },
  { 73, 28, 40, 32, 2, -40 },
  { 213, 26, 50, 32, 3, -44 },
  { 376, 30, 40, 32, 1, -40 },
  { 526, 28, 40, 32, 2, -40 },
  { 666, 6, 17, 32, 13, -43 },
  { 679, 18, 56, 32, 7, -45 },
  { 805, 18, 56, 32, 7, -45 },
  { 931, 24, 24, 32, 4, -40 },
  { 1003, 26, 28, 32, 3, -31 },
  { 1094, 12, 18, 32, 10, -9 },
  { 1121, 14, 5, 32, 9, -19 },
  { 1130, 10, 9, 32, 11, -9 },
  { 1142, 24, 56, 32, 4, -45 },
  { 1310, 26, 40, 32, 3, -40 },
  { 1440, 23, 40, 32, 5, -40 },
  { 1555, 24, 40, 32, 4, -40 },
  { 1675, 24, 40, 32, 4, -40 },
  { 1795, 28, 40, 32, 2, -40 },
  { 1935, 24, 40, 32, 4, -40 },
  { 2055, 26, 40, 32, 3, -40 },
  { 2185, 25, 40, 32, 4, -40 },
  { 2310, 26, 40, 32, 3, -40 },
  { 2440, 26, 40, 32, 3, -40 },
  { 2570, 10, 30, 32, 11, -30 },
  { 2608, 13, 39, 32, 8, -30 },
  { 2672, 26, 25, 32, 3, -29 },
  { 2754, 26, 18, 32, 3, -26 },
  { 2813, 26, 25, 32, 3, -29 },
  { 2895, 20, 40, 32, 6, -40 },
  { 2995, 27, 49, 32, 3, -40 },
  { 3161, 30, 40, 32, 1, -40 },
  { 3311, 26, 40, 32, 3, -40 },
  { 3441, 26, 40, 32, 3, -40 },
  { 3571, 26, 40, 32, 3, -40 },
  { 3701, 23, 40, 32, 6, -40 },
  { 3816, 22, 40, 32, 6, -40 },
  { 3926, 26, 40, 32, 3, -40 },
  { 4056, 26, 40, 32, 3, -40 },
  { 4186, 20, 40, 32, 6, -40 },
  { 4286, 24, 40, 32, 3, -40 },
  { 4406, 27, 40, 32, 4, -40 },
  { 4541, 23, 40, 32, 6, -40 },
  { 4656, 28, 40, 32, 2, -40 },
  { 4796, 24, 40, 32, 4, -40 },
  { 4916, 28, 40, 32, 2, -40 },
  { 5056, 24, 40, 32, 5, -40 },
  { 5176, 28, 50, 32, 2, -40 },
  { 5351, 26, 40, 32, 4, -40 },
  { 5481, 24, 40, 32, 4, -40 },
  { 5601, 28, 40, 32, 2, -40 },
  { 5741, 26, 40, 32, 3, -40 },
  { 5871, 30, 40, 32, 1, -40 },
  { 6021, 28, 40, 32, 2, -40 },
  { 6161, 28, 40, 32, 2, -40 },
  { 6301, 30, 40, 32, 1, -40 },
  { 6451, 26, 40, 32, 3, -40 },
  { 6581, 15, 56, 32, 9, -45 },
  { 6686, 24, 56, 32, 4, -45 },
  { 6854, 15, 56, 32, 8, -45 },
  { 6959, 26, 22, 32, 3, -40 },
  { 7031, 30, 4, 32, 1, 6 },
  { 7046, 11, 11, 32, 10, -44 },
  { 7062, 24, 30, 32, 4, -30 },
  { 7152, 24, 44, 32, 5, -44 },
  { 7284, 26, 30, 32, 3, -30 },
  { 7382, 24, 44, 32, 3, -44 },
  { 7514, 26, 30, 32, 3, -30 },
  { 7612, 27, 44, 32, 4, -44 },
  { 7761, 24, 41, 32, 3, -30 },
  { 7884, 23, 44, 32, 5, -44 },
  { 8011, 26, 43, 32, 3, -43 },
  { 8151, 20, 54, 32, 5, -43 },
  { 8286, 26, 44, 32, 5, -44 },
  { 8429, 26, 44, 32, 3, -44 },
  { 8572, 27, 30, 32, 3, -30 },
  { 8674, 23, 30, 32, 5, -30 },
  { 8761, 26, 30, 32, 3, -30 },
  { 8859, 24, 41, 32, 5, -30 },
  { 8982, 24, 41, 32, 3, -30 },
  { 9105, 21, 30, 32, 7, -30 },
  { 9184, 24, 30, 32, 4, -30 },
  { 9274, 25, 39, 32, 4, -39 },
  { 9396, 23, 30, 32, 4, -30 },
  { 9483, 28, 30, 32, 2, -30 },
  { 9588, 30, 30, 32, 1, -30 },
  { 9701, 28, 30, 32, 2, -30 },
  { 9806, 28, 41, 32, 2, -30 },
  { 9950, 22, 30, 32, 5, -30 },
  { 10033, 22, 56, 32, 5, -45 },
  { 10187, 5, 56, 32, 14, -45 },
  { 10222, 22, 56, 32, 5, -45 },
  { 10376, 28, 10, 32, 2, -22 },
};

const GFXfont UbuntuMono_Regular64pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular64pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular64pt7bGlyphs,
  0x20, 0x7E, 64
};

#endif // _UBUNTUMONO_REGULAR64PT7B_H_
