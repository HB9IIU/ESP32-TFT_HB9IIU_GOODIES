#ifndef _UBUNTUMONO_REGULAR62PT7B_H_
#define _UBUNTUMONO_REGULAR62PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 62pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular62pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F,
  0x0F, 0x87, 0xC3, 0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF0, 0x78, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0xFE, 0xFF, 0x7F, 0xBF, 0xFF, 0xE7, 0xF1, 0xF0, 0xF8, 0x3F, 0xF0, 0x7F,
  0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFE, 0x0F, 0xFC, 0x1F, 0xF0,
  0x1F, 0xE0, 0x3F, 0xC0, 0x7B, 0x80, 0xE7, 0x01, 0xCE, 0x03, 0x9C, 0x07,
  0x00, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xF0, 0x01, 0xE0, 0x3E, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF0, 0x01, 0xF0, 0x1E, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xF8, 0x0F, 0x00, 0x1F, 0x01, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0x80,
  0x0F, 0x81, 0xF0, 0x01, 0xE0, 0x3E, 0x00, 0x3C, 0x07, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0xF0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF8, 0x1F,
  0x00, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F,
  0x01, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFE, 0x0F, 0xF0, 0x0F, 0x07, 0xE0, 0x00, 0x83,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE2, 0x00, 0x03, 0xF3, 0xE0, 0x07, 0xF1, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0xFF, 0x00, 0x0F, 0x0F, 0xFC, 0x00, 0xF8, 0xF9, 0xE0, 0x07, 0x87, 0x87,
  0x80, 0x7C, 0x38, 0x3C, 0x03, 0xC3, 0xC0, 0xE0, 0x3C, 0x1E, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x0F, 0x0F, 0x01,
  0xE0, 0x78, 0xF0, 0x0F, 0x07, 0x8F, 0x80, 0x38, 0x3C, 0x78, 0x01, 0xE1,
  0xE7, 0x80, 0x0F, 0x9E, 0x7C, 0x00, 0x3F, 0xF3, 0xC0, 0x00, 0xFF, 0x3E,
  0x00, 0x03, 0xE1, 0xE0, 0x00, 0x00, 0x1E, 0x1F, 0x00, 0x01, 0xF3, 0xFC,
  0x00, 0x0F, 0x3F, 0xF0, 0x00, 0xF1, 0xE7, 0xC0, 0x07, 0x9E, 0x1E, 0x00,
  0x78, 0xF0, 0x70, 0x07, 0xC7, 0x03, 0xC0, 0x3C, 0x38, 0x1E, 0x03, 0xC3,
  0xC0, 0xF0, 0x3E, 0x1E, 0x07, 0x81, 0xE0, 0xF0, 0x3C, 0x1F, 0x03, 0x81,
  0xE0, 0xF0, 0x1C, 0x0F, 0x0F, 0x00, 0xF0, 0x70, 0xF8, 0x07, 0x87, 0x87,
  0x80, 0x1E, 0x7C, 0x78, 0x00, 0xFF, 0xC7, 0xC0, 0x03, 0xFC, 0x3C, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xC0,
  0x3C, 0x00, 0xF8, 0x07, 0x80, 0x1F, 0x00, 0xF0, 0x03, 0xE0, 0x1E, 0x00,
  0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x0F,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x1E, 0x07, 0xFE, 0x03, 0xC1, 0xFF, 0xE0,
  0x78, 0x7E, 0xFE, 0x1F, 0x0F, 0x8F, 0xE3, 0xC3, 0xE0, 0xFE, 0x78, 0x7C,
  0x0F, 0xEF, 0x1F, 0x00, 0xFF, 0xE3, 0xE0, 0x0F, 0xF8, 0x7C, 0x00, 0xFF,
  0x0F, 0x80, 0x0F, 0xE1, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x87, 0xE0,
  0x07, 0xF8, 0x7E, 0x01, 0xFF, 0x0F, 0xF1, 0xFF, 0xF0, 0xFF, 0xFF, 0xBF,
  0x0F, 0xFF, 0xE3, 0xE0, 0xFF, 0xF0, 0x7E, 0x07, 0xF8, 0x07, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xCE, 0x70, 0x00, 0x06,
  0x00, 0x07, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xF0, 0x01,
  0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xC0, 0x01,
  0xC0, 0x00, 0x60, 0x20, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x1F, 0x00, 0x07, 0x00, 0x03, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x10, 0x1F, 0x01, 0x3C, 0x1C, 0x1E, 0xFE, 0x38, 0xFF, 0xFF, 0x77,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xC0, 0x01, 0xF7, 0xC0, 0x07, 0xEF, 0xC0, 0x1F, 0x8F, 0xC0,
  0x3F, 0x1F, 0x80, 0xFC, 0x1F, 0x81, 0xF8, 0x3F, 0x00, 0xE0, 0x38, 0x00,
  0x80, 0x20, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xC0, 0x7F, 0x83, 0xFC, 0x1F, 0xF0, 0xFF, 0x87, 0xFC, 0x3F,
  0xE0, 0xFE, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x3F, 0x8F, 0xF8, 0x3F, 0x81,
  0xF0, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0xE0,
  0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01, 0xFC, 0x1F, 0xC0, 0xFC, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x3F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0xC0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x38, 0x1F, 0xF8, 0x3E, 0x0F, 0xFC,
  0x3F, 0x87, 0xFE, 0x1F, 0xC3, 0xFF, 0x0F, 0xE1, 0xFF, 0x87, 0xF0, 0xFF,
  0xC1, 0xF0, 0x7F, 0xE0, 0x70, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x01,
  0xF3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x1F, 0x80,
  0xFC, 0x0F, 0xE0, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0xE0,
  0x1F, 0xEF, 0x80, 0xFF, 0x3E, 0x03, 0xF8, 0xF8, 0x07, 0x83, 0xE0, 0x18,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x03, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF,
  0xFF, 0xF0, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF0, 0xFE, 0x07, 0xF8, 0xF8, 0x01, 0xF8, 0x70, 0x00, 0xF8, 0x20,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xFE, 0x00, 0x3F,
  0xFF, 0x01, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x83, 0xC0, 0x7F, 0x04, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00,
  0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x40, 0x00, 0xFD, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFB,
  0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xC0, 0xF8, 0x00, 0xF8, 0x1F,
  0x00, 0x3E, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x78, 0x00, 0xF8,
  0x1F, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF0, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x40, 0x00, 0xFC, 0xF0, 0x0F, 0xF3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x1F, 0xE0, 0x1F, 0xCF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x1F, 0x80, 0x7E, 0x0F, 0xE0, 0x7F, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0x81, 0xFC, 0x1F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x07,
  0xCF, 0x80, 0x03, 0xE7, 0xE0, 0x03, 0xF1, 0xF0, 0x01, 0xF0, 0xFC, 0x01,
  0xF8, 0x3F, 0x81, 0xF8, 0x1F, 0xF1, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0xFC, 0xFF, 0xC0, 0xF8, 0x0F, 0xF0, 0xF8,
  0x01, 0xF8, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x3F, 0x1F, 0xC0, 0x7F,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x03, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0xF8,
  0x00, 0x7C, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF,
  0x00, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xCF, 0xE0, 0x1F,
  0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x07, 0xFC,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x0F,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFC, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE3,
  0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xC7, 0xC0, 0x07, 0xC0, 0xFE, 0x1F,
  0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xC0, 0xFE, 0x1F, 0xF1, 0xFF, 0x1F, 0xF1, 0xFF, 0x0F,
  0xF0, 0x7F, 0x01, 0xF0, 0x3E, 0x07, 0xE3, 0xFC, 0xFF, 0x8F, 0xF0, 0xFC,
  0x06, 0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x60, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x3F,
  0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0xE3, 0xFF, 0xFE, 0x7F, 0xFF,
  0xE7, 0x81, 0xFC, 0x80, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0x83, 0xF8, 0x0F, 0xC0, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x1F, 0x00, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x0F, 0x9F,
  0x00, 0x01, 0xF3, 0xE0, 0x07, 0xFE, 0xF8, 0x07, 0xFF, 0xDF, 0x01, 0xFF,
  0xFB, 0xE0, 0x7F, 0xFF, 0x7C, 0x1F, 0xC3, 0xEF, 0x83, 0xE0, 0x7D, 0xF0,
  0xFC, 0x0F, 0xBE, 0x1F, 0x01, 0xF7, 0xC3, 0xE0, 0x3F, 0xF8, 0x7C, 0x07,
  0xFF, 0x1F, 0x00, 0xFF, 0xE3, 0xE0, 0x1F, 0xFC, 0x7C, 0x03, 0xEF, 0x87,
  0xC0, 0x7D, 0xF0, 0xF8, 0x0F, 0xBE, 0x1F, 0x01, 0xF7, 0xC3, 0xE0, 0x3E,
  0xF8, 0x3E, 0x07, 0xDF, 0x07, 0xE0, 0xFB, 0xF0, 0x7F, 0xFF, 0x3E, 0x07,
  0xFF, 0xE7, 0xC0, 0x7F, 0xFC, 0xFC, 0x03, 0xFC, 0x0F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x60, 0x03, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x0F, 0x1F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3C,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x00, 0xF0, 0x1E,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0x3E, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8,
  0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x01,
  0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0xF0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xF3, 0xE0, 0x00,
  0x0F, 0xBF, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7C, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x3F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0,
  0x01, 0xF9, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3,
  0xE0, 0x03, 0xF1, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0x80, 0x1F, 0xE7, 0xC0, 0x03,
  0xF3, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x7F, 0x7C,
  0x01, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFE, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFE, 0x07, 0xF8, 0x0F, 0x03, 0xF8, 0x00, 0x41, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x01, 0x03, 0xFE, 0x03, 0xE0, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0xF8, 0x0F, 0xF8, 0x3E,
  0x00, 0x7F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0x7E, 0xF8, 0x00,
  0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x3E, 0xF8,
  0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xFB, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xE3,
  0xE0, 0x03, 0xF0, 0xF8, 0x01, 0xFC, 0x3E, 0x01, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xCF, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F, 0x81, 0xF0, 0x7F, 0x00, 0x38,
  0x7F, 0x00, 0x04, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0xC0, 0x01, 0xF7, 0xE0, 0x00, 0xF9,
  0xF8, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x0F, 0xE0, 0x0F,
  0x87, 0xFC, 0x0F, 0xC1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x10, 0x00, 0x7E, 0x38, 0x01, 0xFC, 0xFC, 0x0F, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xE3, 0xE0, 0x01,
  0xF8, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x0F, 0x80, 0x3F, 0x03, 0xE0,
  0x1F, 0xC0, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x0F, 0x81, 0xF8, 0x03,
  0xE0, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0x9F, 0x80,
  0x03, 0xEF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFB, 0xFC, 0x00, 0x3E, 0x3F, 0x80, 0x0F,
  0x87, 0xF0, 0x03, 0xE0, 0xFE, 0x00, 0xF8, 0x1F, 0xC0, 0x3E, 0x03, 0xF8,
  0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03, 0xF8, 0x3E, 0x00,
  0x7F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xF8, 0x00, 0x7F, 0x3E,
  0x00, 0x0F, 0xCF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F,
  0xFE, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0x7C, 0x00, 0x7E, 0x1F, 0xC0, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x7F,
  0x00, 0x7F, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x7F,
  0x87, 0xBC, 0x1E, 0xF0, 0xF7, 0x83, 0xDE, 0x1E, 0xF0, 0x7B, 0xE7, 0xCF,
  0x1E, 0x3C, 0xF1, 0xE3, 0xC7, 0x9E, 0x3C, 0x78, 0xF3, 0xC3, 0xDE, 0x1E,
  0x78, 0x7B, 0xC3, 0xCF, 0x0F, 0x78, 0x79, 0xE0, 0xFE, 0x0F, 0x3C, 0x1F,
  0xC1, 0xE7, 0x83, 0xF8, 0x3C, 0xF0, 0x3E, 0x07, 0x9E, 0x07, 0xC0, 0xF3,
  0xC0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x79, 0xE0, 0x00,
  0x0F, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x0F, 0xFD, 0xF0, 0x07, 0xFE, 0x78,
  0x03, 0xFF, 0x3E, 0x01, 0xFF, 0x8F, 0x00, 0xFF, 0xC7, 0xC0, 0x7F, 0xE1,
  0xE0, 0x3F, 0xF0, 0xF8, 0x1F, 0xF8, 0x3C, 0x0F, 0xFC, 0x1F, 0x07, 0xFE,
  0x07, 0x83, 0xFF, 0x03, 0xE1, 0xFF, 0x80, 0xF0, 0xFF, 0xC0, 0x7C, 0x7F,
  0xE0, 0x3E, 0x3F, 0xF0, 0x0F, 0x9F, 0xF8, 0x07, 0xCF, 0xFC, 0x01, 0xE7,
  0xFE, 0x00, 0xFB, 0xFF, 0x00, 0x3D, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0,
  0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF9,
  0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0x80,
  0x7F, 0x9F, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03,
  0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xFB, 0xE0, 0x07, 0xF7, 0xC0, 0x3F, 0xCF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x3F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xF9, 0xF0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xE1, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xFC, 0x1F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1C, 0x3F, 0xFE, 0x00, 0x3F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFC, 0x03, 0xFC, 0x3F,
  0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC,
  0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x3F, 0x83, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x03, 0xF0, 0x3F,
  0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x00, 0xF8, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC3,
  0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF3, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x03, 0xE0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC1,
  0xFC, 0x07, 0xC1, 0xF8, 0x00, 0x60, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x20, 0x00, 0x3F, 0x3E, 0x00, 0xFF, 0x1F, 0xFF, 0xFF,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x01, 0xFF, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x7E, 0x3F,
  0x00, 0x7E, 0x1F, 0xC0, 0x7F, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F,
  0x3F, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3E,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x3E, 0x00, 0x3E,
  0x01, 0xF0, 0x01, 0xF0, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x01,
  0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF1, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x0F,
  0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xE7, 0x80, 0x00, 0x3C, 0xF0, 0x00, 0x07, 0x9E,
  0x00, 0x00, 0xF3, 0xC0, 0xF8, 0x1E, 0x78, 0x1F, 0x03, 0xCF, 0x07, 0xF0,
  0x79, 0xE0, 0xFE, 0x0F, 0x3C, 0x1F, 0xC1, 0xE7, 0x87, 0xBC, 0x3C, 0xF0,
  0xF7, 0x87, 0x9E, 0x1E, 0xF0, 0xF3, 0xC7, 0x8F, 0x1E, 0x78, 0xF1, 0xE3,
  0xCF, 0x1E, 0x3C, 0xF1, 0xF7, 0x83, 0xDE, 0x1E, 0xF0, 0x7B, 0xC3, 0xDE,
  0x0F, 0x78, 0x7F, 0x80, 0xFF, 0x0F, 0xF0, 0x1F, 0xE1, 0xFE, 0x03, 0xFC,
  0x3F, 0x80, 0x3F, 0x87, 0xF0, 0x07, 0xF0, 0xFE, 0x00, 0xFE, 0x1F, 0x80,
  0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0xC1, 0xF0,
  0x01, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x03, 0xF0,
  0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8,
  0xF8, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0x3F,
  0x00, 0x0F, 0x83, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7C, 0x07, 0xE0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x7F, 0xF0, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xDF, 0x00, 0x00, 0x7C, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x3E,
  0x1F, 0x80, 0x03, 0xF0, 0x7C, 0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF8, 0x1F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x3F, 0x1F, 0x80, 0x00, 0xF8, 0xF8, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x7E, 0xF8, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3E, 0x00,
  0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x1C, 0x00, 0x01, 0xC0,
  0x80, 0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x10, 0x0E, 0x07, 0x83, 0xF0,
  0x7E, 0x0F, 0xC1, 0xF8, 0x3E, 0x07, 0xC0, 0xF0, 0x10, 0x07, 0xFF, 0x00,
  0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0xFB, 0xE1, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0x7F, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0x7F, 0x00, 0x3E, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x1C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF1, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x3F, 0xE0, 0xFF, 0x1F, 0xC0, 0x1F, 0x8F,
  0xC0, 0x07, 0xE7, 0xE0, 0x01, 0xF3, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03,
  0xEF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7D, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0xDF, 0x80,
  0x0F, 0xCF, 0xC0, 0x07, 0xE7, 0xE0, 0x07, 0xE3, 0xF0, 0x1F, 0xE1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0xFF, 0x00, 0x70, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x03, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x01, 0xFE, 0x7E, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC7, 0xF8, 0x3F, 0xE3, 0xF0, 0x07, 0xF3, 0xF0, 0x01,
  0xF9, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C, 0x00,
  0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x7C,
  0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x80, 0x07, 0xE7, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x7E, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xE0, 0x7F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xF8, 0x00, 0x3E,
  0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x00,
  0x1F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x03, 0x01, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFE,
  0x07, 0x80, 0x7E, 0x00, 0x20, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xF8, 0xFC, 0x00, 0xFC,
  0xFC, 0x00, 0x7E, 0x7C, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00,
  0x0F, 0xDF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF9, 0xF8,
  0x00, 0xFC, 0xFE, 0x00, 0x7E, 0x3F, 0x81, 0xFF, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x0F, 0xF3, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x08, 0x00, 0x3F, 0x07, 0x80, 0x7F, 0x87, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x1C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x7F, 0xC0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE3, 0xF8,
  0x0F, 0xE7, 0xE0, 0x07, 0xCF, 0xC0, 0x0F, 0xDF, 0x80, 0x0F, 0xBF, 0x00,
  0x1F, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x20, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0xFC, 0x00, 0x1F, 0xE0,
  0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x1F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x20, 0x07, 0xE7, 0x80, 0xFC, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0x7F, 0x80, 0x1C, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x03, 0xF3, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x03, 0xF0,
  0x1F, 0xC0, 0xFC, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF1, 0xF8, 0x00, 0xFD, 0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xCF,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x3F, 0x07, 0xF0, 0x0F,
  0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xF8, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x3F,
  0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x04, 0x00, 0x7F, 0xFE, 0x00, 0x1F,
  0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0xF8, 0x3F,
  0xFC, 0xFF, 0x8F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0xF0, 0x7F, 0x1F,
  0xBC, 0x0F, 0x83, 0xEF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0, 0x3E,
  0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F, 0xF0,
  0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x03, 0xE0, 0x7F, 0xC0, 0xF8, 0x1F,
  0xF0, 0x3E, 0x07, 0xFC, 0x0F, 0x81, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xFE, 0x01, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x8F, 0xC0, 0x3F, 0x9F, 0x80, 0x1F,
  0xBF, 0x00, 0x3F, 0x7E, 0x00, 0x3E, 0xFC, 0x00, 0x7D, 0xF8, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00,
  0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x3E, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xC0, 0x3F,
  0x87, 0xE0, 0x07, 0xE3, 0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF, 0xC0,
  0x01, 0xF7, 0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3E, 0xFC,
  0x00, 0x1F, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x80, 0x03, 0xEF,
  0xC0, 0x03, 0xF7, 0xE0, 0x01, 0xF3, 0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF8,
  0xFF, 0x83, 0xFC, 0x7F, 0xFF, 0xFC, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8,
  0x0F, 0xCF, 0xF0, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0,
  0xFE, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0x7C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x80,
  0x01, 0xF7, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0xFC, 0x00, 0x3E, 0x3F,
  0x00, 0x3F, 0x1F, 0xE0, 0xFF, 0x87, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x07, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x03, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x6F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0xC7, 0xF0, 0x03, 0x8F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xA0, 0x00, 0x3F, 0x7C,
  0x01, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x00, 0xFF,
  0xF0, 0x00, 0x00, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xFC, 0x02, 0x00, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x0F, 0xF8, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x0F,
  0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x01, 0xFF, 0xE0, 0x03, 0xF7, 0xC0, 0x07, 0xEF, 0x80, 0x0F, 0xDF,
  0x80, 0x1F, 0x9F, 0x80, 0x3F, 0x3F, 0x80, 0x7E, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x1F, 0xFC, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0xFD, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xC0, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x07, 0xE0, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0xF0, 0x00, 0x01,
  0xE7, 0x80, 0x00, 0x0F, 0x3C, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x03, 0xCF,
  0x80, 0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x0F, 0x9F, 0x03,
  0xF0, 0x7C, 0x78, 0x3F, 0x83, 0xC3, 0xC1, 0xFC, 0x1E, 0x1E, 0x0F, 0xE0,
  0xF0, 0xF8, 0xF7, 0x87, 0x87, 0xC7, 0xBC, 0x7C, 0x3E, 0x3D, 0xE3, 0xE1,
  0xF3, 0xC7, 0x9E, 0x07, 0x9E, 0x3C, 0xF0, 0x3C, 0xE1, 0xE7, 0x81, 0xEF,
  0x07, 0xBC, 0x0F, 0x78, 0x3F, 0xE0, 0x7F, 0x80, 0xFE, 0x01, 0xFC, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0,
  0x1F, 0x00, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0xCF,
  0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0xE7, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x03, 0xF0,
  0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xCF, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0xFC, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x0F, 0x80, 0x07,
  0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xCF, 0x00, 0x00, 0xFB, 0xE0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x01, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFE, 0x01,
  0xFF, 0xF0, 0x1F, 0xC0, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x00, 0x3F,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x01, 0x81, 0xFE, 0x00, 0x3C,
  0x7F, 0xF0, 0x0F, 0x1F, 0xFF, 0x81, 0xE7, 0xC3, 0xF8, 0x7C, 0xF0, 0x3F,
  0xFF, 0x1E, 0x01, 0xFF, 0xC7, 0x80, 0x0F, 0xF0, 0x30, 0x00, 0xFC, 0x00,
};

const GFXglyph UbuntuMono_Regular62pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 31, 0, -1 },
  { 1, 9, 38, 31, 11, -38 },
  { 44, 15, 15, 31, 8, -42 },
  { 73, 27, 38, 31, 2, -38 },
  { 202, 25, 49, 31, 3, -43 },
  { 356, 29, 38, 31, 1, -38 },
  { 494, 27, 38, 31, 2, -38 },
  { 623, 5, 17, 31, 13, -42 },
  { 634, 17, 53, 31, 7, -43 },
  { 747, 17, 53, 31, 7, -43 },
  { 860, 23, 23, 31, 4, -38 },
  { 927, 25, 26, 31, 3, -29 },
  { 1009, 13, 16, 31, 9, -8 },
  { 1035, 13, 5, 31, 9, -18 },
  { 1044, 9, 8, 31, 11, -8 },
  { 1053, 23, 53, 31, 4, -43 },
  { 1206, 25, 38, 31, 3, -38 },
  { 1325, 22, 38, 31, 5, -38 },
  { 1430, 24, 38, 31, 4, -38 },
  { 1544, 23, 38, 31, 4, -38 },
  { 1654, 27, 38, 31, 2, -38 },
  { 1783, 23, 38, 31, 4, -38 },
  { 1893, 25, 38, 31, 3, -38 },
  { 2012, 24, 38, 31, 4, -38 },
  { 2126, 25, 38, 31, 3, -38 },
  { 2245, 25, 38, 31, 3, -38 },
  { 2364, 9, 28, 31, 11, -28 },
  { 2396, 12, 36, 31, 8, -28 },
  { 2450, 25, 25, 31, 3, -28 },
  { 2529, 25, 15, 31, 3, -24 },
  { 2576, 25, 25, 31, 3, -28 },
  { 2655, 19, 38, 31, 6, -38 },
  { 2746, 27, 46, 31, 2, -38 },
  { 2902, 29, 38, 31, 1, -38 },
  { 3040, 25, 38, 31, 3, -38 },
  { 3159, 26, 38, 31, 3, -38 },
  { 3283, 26, 38, 31, 3, -38 },
  { 3407, 23, 38, 31, 6, -38 },
  { 3517, 21, 38, 31, 6, -38 },
  { 3617, 25, 38, 31, 3, -38 },
  { 3736, 25, 38, 31, 3, -38 },
  { 3855, 19, 38, 31, 6, -38 },
  { 3946, 23, 38, 31, 3, -38 },
  { 4056, 26, 38, 31, 4, -38 },
  { 4180, 23, 38, 31, 6, -38 },
  { 4290, 27, 38, 31, 2, -38 },
  { 4419, 25, 38, 31, 3, -38 },
  { 4538, 27, 38, 31, 2, -38 },
  { 4667, 23, 38, 31, 5, -38 },
  { 4777, 27, 48, 31, 2, -38 },
  { 4939, 26, 38, 31, 3, -38 },
  { 5063, 25, 38, 31, 3, -38 },
  { 5182, 27, 38, 31, 2, -38 },
  { 5311, 25, 38, 31, 3, -38 },
  { 5430, 29, 38, 31, 1, -38 },
  { 5568, 27, 38, 31, 2, -38 },
  { 5697, 27, 38, 31, 2, -38 },
  { 5826, 29, 38, 31, 1, -38 },
  { 5964, 25, 38, 31, 3, -38 },
  { 6083, 15, 53, 31, 9, -43 },
  { 6183, 23, 53, 31, 4, -43 },
  { 6336, 15, 53, 31, 7, -43 },
  { 6436, 27, 21, 31, 2, -38 },
  { 6507, 31, 4, 31, 0, 6 },
  { 6523, 10, 11, 31, 10, -43 },
  { 6537, 23, 29, 31, 4, -29 },
  { 6621, 25, 43, 31, 4, -43 },
  { 6756, 25, 29, 31, 3, -29 },
  { 6847, 25, 43, 31, 2, -43 },
  { 6982, 26, 29, 31, 2, -29 },
  { 7077, 26, 43, 31, 4, -43 },
  { 7217, 25, 39, 31, 2, -29 },
  { 7339, 23, 43, 31, 4, -43 },
  { 7463, 25, 40, 31, 3, -40 },
  { 7588, 20, 50, 31, 4, -40 },
  { 7713, 26, 43, 31, 4, -43 },
  { 7853, 25, 43, 31, 3, -43 },
  { 7988, 26, 29, 31, 3, -29 },
  { 8083, 23, 29, 31, 4, -29 },
  { 8167, 27, 29, 31, 2, -29 },
  { 8265, 25, 39, 31, 4, -29 },
  { 8387, 25, 39, 31, 2, -29 },
  { 8509, 20, 29, 31, 7, -29 },
  { 8582, 23, 29, 31, 4, -29 },
  { 8666, 24, 38, 31, 4, -38 },
  { 8780, 23, 29, 31, 4, -29 },
  { 8864, 27, 29, 31, 2, -29 },
  { 8962, 29, 29, 31, 1, -29 },
  { 9068, 27, 29, 31, 2, -29 },
  { 9166, 27, 39, 31, 2, -29 },
  { 9298, 21, 29, 31, 5, -29 },
  { 9375, 21, 53, 31, 5, -43 },
  { 9515, 5, 53, 31, 13, -43 },
  { 9549, 21, 53, 31, 5, -43 },
  { 9689, 27, 9, 31, 2, -21 },
};

const GFXfont UbuntuMono_Regular62pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular62pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular62pt7bGlyphs,
  0x20, 0x7E, 62
};

#endif // _UBUNTUMONO_REGULAR62PT7B_H_
