#ifndef _UBUNTUMONO_REGULAR48PT7B_H_
#define _UBUNTUMONO_REGULAR48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular48pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x79, 0xE7, 0x0C, 0x00, 0x00, 0x00, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F,
  0x60, 0xE6, 0x06, 0x60, 0x66, 0x06, 0x01, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xC0, 0xE0, 0x07, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x38, 0x01,
  0xC0, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0E, 0x00, 0x70, 0x38, 0x01, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xFF, 0x81, 0xFF, 0xF8, 0xFF, 0xFE, 0x7E,
  0x03, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x07, 0xFC, 0x03,
  0xEF, 0xFF, 0xFB, 0xFF, 0xF8, 0x1F, 0xF8, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x38, 0xFE, 0x01,
  0xE7, 0xF8, 0x07, 0x3C, 0xF0, 0x3C, 0xE1, 0xC0, 0xE3, 0x87, 0x07, 0x0E,
  0x1C, 0x3C, 0x38, 0x70, 0xE0, 0xE1, 0xC7, 0x83, 0x87, 0x1C, 0x0E, 0x1C,
  0xE0, 0x3C, 0xF7, 0x80, 0x7F, 0x9C, 0x00, 0xFE, 0xF0, 0x01, 0xE3, 0x80,
  0x00, 0x1C, 0x78, 0x00, 0xF7, 0xF0, 0x03, 0x9F, 0xE0, 0x1E, 0xF3, 0xC0,
  0x73, 0x87, 0x03, 0x8E, 0x1C, 0x1E, 0x38, 0x70, 0x70, 0xE1, 0xC3, 0xC3,
  0x87, 0x0E, 0x0E, 0x1C, 0x70, 0x38, 0x73, 0xC0, 0xF3, 0xCE, 0x01, 0xFE,
  0x70, 0x07, 0xF3, 0xC0, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0xE0, 0x07, 0xC7, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x1C, 0x01, 0xC0,
  0x70, 0x07, 0x01, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x38, 0x01, 0xE1, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0x03,
  0xF8, 0x3C, 0x1F, 0xF0, 0xF0, 0xF3, 0xE3, 0xC7, 0x87, 0xCE, 0x1E, 0x0F,
  0xB8, 0x78, 0x1F, 0xE1, 0xE0, 0x3F, 0x0F, 0x00, 0x7C, 0x1E, 0x00, 0xF0,
  0x78, 0x07, 0xE1, 0xF0, 0x3F, 0x83, 0xE3, 0xFF, 0x0F, 0xFF, 0xBC, 0x1F,
  0xFC, 0x78, 0x1F, 0xC1, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x60,
  0x00, 0x10, 0x01, 0xC0, 0x0F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x0F, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x78,
  0x00, 0x40, 0x20, 0x01, 0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xE0,
  0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x78, 0x00, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x41, 0xE0, 0x9C, 0x30, 0xEF, 0xCC, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF,
  0x80, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x0F, 0x3C, 0x07, 0xCF, 0x81,
  0xE1, 0xE0, 0xF8, 0x7C, 0x1C, 0x0E, 0x01, 0x02, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x07, 0xE1, 0xFC, 0x7F, 0x1F, 0xC3, 0xF0, 0x78, 0x1E,
  0x3F, 0x3F, 0x8F, 0xC1, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x7E,
  0x7E, 0x7F, 0x7E, 0x3C, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0,
  0xF8, 0x3E, 0x07, 0xC3, 0xC0, 0x3C, 0x7C, 0x03, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x70, 0xFF,
  0x0F, 0x0F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF0, 0xF0, 0xFF, 0x0F, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xE7, 0xC0, 0x3E, 0x3C, 0x03, 0xC3, 0xE0, 0x7C, 0x1F, 0x0F, 0x80, 0xFF,
  0xF0, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xF7, 0x81, 0xE3, 0xC0, 0x41,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB, 0xFF, 0xFC, 0x07, 0xF0,
  0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xE0, 0xFC, 0x70, 0x0F, 0x90, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF,
  0xE1, 0xE0, 0xFC, 0x20, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0xC0, 0x01, 0xEC, 0x01, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x07,
  0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8,
  0x00, 0x7F, 0x80, 0x0F, 0x78, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC7,
  0x80, 0x78, 0x78, 0x07, 0x07, 0x80, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x07, 0x83, 0x80, 0x78, 0x78, 0x07, 0x87, 0x00, 0x78, 0xF0,
  0x07, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8,
  0x78, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFE,
  0x03, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x01, 0xE6, 0x01, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x3F, 0x81, 0xFF, 0xFC, 0x3F, 0xFF,
  0xC7, 0xC0, 0x7C, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01,
  0xEF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x1E, 0x78, 0x03,
  0xCF, 0x80, 0xF0, 0xF8, 0x3E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x3C,
  0x03, 0xC7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x7C, 0x03, 0xC3, 0xE0, 0x3C, 0x1F, 0x07, 0x80, 0xFF, 0xF0,
  0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1E, 0x3F, 0x83, 0xC0, 0x7C, 0x78, 0x03,
  0xE7, 0x80, 0x1E, 0x70, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00,
  0x0E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xF8, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F,
  0x07, 0xC3, 0xC0, 0x7C, 0xF0, 0x07, 0x9E, 0x00, 0x7B, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF8,
  0x03, 0xCF, 0x80, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0xFC, 0x03, 0xFE,
  0x00, 0x7E, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0x7F, 0x7E, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7E, 0x7F,
  0x7E, 0x3C, 0x0F, 0x07, 0xE1, 0xF8, 0x7F, 0x1F, 0x83, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07,
  0xE1, 0xF8, 0x7F, 0x1F, 0xC3, 0xE0, 0x78, 0x3E, 0x3F, 0x3F, 0x8F, 0x81,
  0x80, 0x00, 0x00, 0x20, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x07, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0x7E,
  0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xE0, 0xFF, 0xF8, 0x7F,
  0xFC, 0x60, 0x7E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xC0, 0xF8, 0x3E, 0x1E, 0x01, 0xE3, 0xE0, 0x0F, 0x3C, 0x00,
  0xF3, 0x80, 0x07, 0x78, 0x00, 0x77, 0x80, 0xFF, 0x70, 0x3F, 0xFF, 0x07,
  0xFF, 0xF0, 0xF8, 0x7F, 0x0F, 0x07, 0xF1, 0xE0, 0x7F, 0x1E, 0x07, 0xF1,
  0xE0, 0x7F, 0x1E, 0x07, 0xF1, 0xE0, 0x7F, 0x1E, 0x07, 0xF1, 0xE0, 0x7F,
  0x1E, 0x07, 0xF1, 0xE0, 0x7F, 0x0F, 0x07, 0x78, 0xF8, 0x77, 0x87, 0xFF,
  0x78, 0x3F, 0xF3, 0xC0, 0xFE, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x40, 0x3F, 0xFC, 0x01, 0xFF, 0xC0, 0x03,
  0xFC, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xE7,
  0x80, 0x01, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0x81,
  0xC0, 0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x01, 0xE0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0x70, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x38, 0x00, 0x3C, 0x78, 0x00, 0x1E, 0x78, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x7F, 0xE0, 0x1F, 0xFF, 0x83,
  0xFF, 0xF8, 0x78, 0x1F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F,
  0x03, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF, 0x07, 0xFF, 0xF8, 0xF0, 0x1F, 0x9E,
  0x00, 0xFB, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xFB, 0xC0, 0x7E, 0x7F,
  0xFF, 0x8F, 0xFF, 0xE1, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFC, 0x0E, 0x1F, 0x00, 0x21, 0xE0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x02,
  0x0F, 0xC0, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x7F, 0xC0,
  0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x3F, 0x0F, 0x01, 0xF1, 0xE0, 0x1F,
  0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3D,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3C, 0xF0, 0x0F, 0x9E, 0x03, 0xE3,
  0xC1, 0xF8, 0x7F, 0xFE, 0x0F, 0xFF, 0x81, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xFF, 0xF8, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xFF, 0xFB,
  0xFF, 0xFD, 0xFF, 0xFE, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xFE, 0x07, 0xFF, 0xF0, 0xFC, 0x0E, 0x1F, 0x00, 0x21, 0xE0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0xF3, 0xC0, 0x0F, 0x3E, 0x00,
  0xF1, 0xF0, 0x0F, 0x0F, 0xC0, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x07,
  0xF8, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7, 0xFF, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0xA0, 0x07, 0xBC,
  0x0F, 0xDF, 0xFF, 0xC7, 0xFF, 0xC0, 0xFF, 0x00, 0xF0, 0x01, 0xE7, 0x80,
  0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0x78, 0x0F, 0x03,
  0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x3C, 0xF8,
  0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3C, 0x3E, 0x01, 0xE0, 0xF8,
  0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x7C, 0x1E, 0x01, 0xF0, 0xF0,
  0x07, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xCF, 0x00, 0x1F,
  0x78, 0x00, 0x78, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C,
  0x03, 0xC3, 0xC0, 0x3E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x7E, 0x07, 0xE7,
  0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0x70, 0xEE, 0x77, 0x0E, 0xE7, 0x70, 0xEE,
  0x73, 0x9C, 0xE7, 0x39, 0xCF, 0xF3, 0x9C, 0xFF, 0x19, 0x8F, 0xF1, 0xF8,
  0xFF, 0x1F, 0x8F, 0xF0, 0xF8, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07, 0xFC,
  0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xBC, 0x07, 0xE7, 0x01, 0xF9, 0xE0,
  0x7E, 0x38, 0x1F, 0x8F, 0x07, 0xE1, 0xC1, 0xF8, 0x78, 0x7E, 0x0E, 0x1F,
  0x83, 0xC7, 0xE0, 0xF1, 0xF8, 0x1C, 0x7E, 0x07, 0x9F, 0x80, 0xE7, 0xE0,
  0x3D, 0xF8, 0x07, 0x7E, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xF0, 0x00, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8, 0x1E, 0x01, 0xE0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0,
  0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80,
  0x07, 0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xF8, 0x7E,
  0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xF0, 0x1F,
  0xFF, 0xC3, 0xFF, 0xFC, 0x78, 0x0F, 0xCF, 0x00, 0x7D, 0xE0, 0x07, 0xBC,
  0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0x80, 0xFC, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xC0, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8, 0x1E, 0x01, 0xE0, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x1E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01,
  0xE7, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80,
  0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x8F, 0x00, 0x3C, 0x3C, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xF8, 0x7E, 0x03,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x70, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8, 0x78, 0x1F,
  0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x03,
  0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x1F,
  0x3C, 0x0F, 0xC7, 0xFF, 0xF0, 0xFF, 0xFC, 0x1F, 0xFF, 0x03, 0xC1, 0xE0,
  0x78, 0x1E, 0x0F, 0x03, 0xC1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80, 0x78,
  0xF0, 0x0F, 0x9E, 0x00, 0xF3, 0xC0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3F,
  0xE0, 0x03, 0xC0, 0x03, 0xFC, 0x03, 0xFF, 0xE3, 0xFF, 0xF8, 0xF8, 0x1E,
  0x78, 0x01, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xD0,
  0x01, 0xFF, 0x00, 0xFB, 0xFF, 0xFC, 0xFF, 0xFE, 0x03, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0xC0, 0x3E, 0x3E, 0x07, 0xC1, 0xFF, 0xF8,
  0x0F, 0xFF, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x07,
  0x80, 0x78, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0xF0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0x78, 0x78, 0x01, 0xE1, 0xE0,
  0x07, 0x87, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x0F, 0x0F, 0xF0, 0xF0,
  0xFF, 0x1F, 0x0F, 0xF1, 0xF8, 0xFF, 0x1F, 0x8F, 0xF1, 0x98, 0xFF, 0x39,
  0xCE, 0xF3, 0x9C, 0xE7, 0x39, 0xCE, 0x77, 0x0E, 0xE7, 0x70, 0xEE, 0x77,
  0x0E, 0xE7, 0xE0, 0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0x7E, 0x7C, 0x03, 0xE7,
  0xC0, 0x3E, 0x7C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x03,
  0xE3, 0xC0, 0x0F, 0x07, 0x80, 0x78, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x00,
  0xF8, 0x7C, 0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0xF3, 0xC0, 0x07, 0xCF, 0x80, 0x1E, 0x1E, 0x00, 0xF0, 0x3C, 0x07, 0xC0,
  0xF8, 0x1E, 0x01, 0xE0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x3E,
  0x78, 0x00, 0x7B, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xF7,
  0x80, 0x07, 0x9E, 0x00, 0x1E, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xC3, 0xE0,
  0x1F, 0x07, 0x80, 0x78, 0x1F, 0x03, 0xE0, 0x3C, 0x0F, 0x00, 0xF8, 0x7C,
  0x01, 0xE1, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x3C, 0x00, 0x1F, 0xE0, 0x00,
  0x7F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xDF, 0xFF, 0xFB, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01,
  0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC,
  0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x81, 0xE0,
  0x78, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x80, 0x1F, 0xF0,
  0x00, 0xF2, 0x00, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x20, 0x70, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x04, 0x0F, 0xF8, 0x0F,
  0xFF, 0x83, 0xFF, 0xF0, 0xC0, 0x7E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xFF, 0xF1, 0xFF, 0xFD, 0xFF, 0xFF,
  0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0xC0, 0x3D, 0xFF, 0xFF, 0x3F, 0xFF, 0xC1, 0xFF, 0x80, 0x70,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x79, 0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0x87, 0xE7, 0xC0,
  0x3E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00,
  0x3F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x79, 0xE0, 0x3F, 0x3F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFE, 0x0F,
  0xFF, 0xE1, 0xF8, 0x06, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x60, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x0F,
  0xFC, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x81, 0xFC, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0xC3,
  0xFB, 0xE0, 0x1F, 0x78, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF3, 0xC0, 0x1E, 0x7E, 0x03,
  0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xF0, 0x1F, 0xFF, 0x83, 0xF0, 0x7C, 0x3C, 0x03, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xC1, 0xFF, 0xFC, 0x07, 0xFF,
  0xC0, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0x01, 0xFF, 0xF0, 0x3E,
  0x03, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFC, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F, 0x81, 0xF7,
  0xC0, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE,
  0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x01, 0xE7, 0xC0, 0xFC, 0x7F, 0xFF, 0x87,
  0xFF, 0xF0, 0x3F, 0x9E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0xC0, 0x7E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F,
  0xF0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xDF, 0xE0, 0xFF, 0xFE, 0x3F, 0xFF, 0xCF, 0x81, 0xF3,
  0xC0, 0x3E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x20,
  0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x3C, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFC, 0xFF, 0xF9, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x7B, 0x83, 0xE7, 0xFF, 0xDF, 0xFF, 0x07, 0xF8, 0x00, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x03,
  0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF3, 0xF0, 0x0F, 0x7C, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x3E, 0x00, 0xF1, 0xF0, 0x0F,
  0x0F, 0x80, 0xF0, 0x3C, 0x0F, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78,
  0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01, 0xF0, 0xFF, 0xC0, 0x1F, 0xF8,
  0x03, 0xFF, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x80, 0x7F, 0xF0, 0x07, 0xFF,
  0x00, 0x3F, 0x80, 0x3F, 0x0F, 0x8F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEF, 0x1F,
  0x1F, 0xF0, 0xF0, 0xFF, 0x0F, 0x07, 0xF0, 0xF0, 0x7F, 0x0F, 0x07, 0xF0,
  0xF0, 0x7F, 0x0F, 0x07, 0xF0, 0xF0, 0x7F, 0x0F, 0x07, 0xF0, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0x1F, 0xF0,
  0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xC0, 0x7C, 0xF0, 0x0F, 0xBC, 0x01, 0xEF,
  0x00, 0x7B, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF0,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x83, 0xF0, 0xFC, 0x3C, 0x03,
  0xC7, 0x80, 0x1E, 0x78, 0x01, 0xEF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3F, 0x0F, 0xC1,
  0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0x83,
  0xFF, 0xFC, 0x78, 0x0F, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0xBC, 0x00, 0xF7,
  0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1E, 0xF0, 0x03, 0xDF,
  0x00, 0xFB, 0xF0, 0x7E, 0x7F, 0xFF, 0x8F, 0xFF, 0xE1, 0xE7, 0xF0, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC,
  0x7F, 0xFF, 0x9F, 0x80, 0xF3, 0xC0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF,
  0x80, 0x7C, 0xFC, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xF3, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x07, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x02, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x07, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF1, 0xF0, 0x0C,
  0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x00, 0x03, 0xD0, 0x01, 0xF7, 0x80, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFE, 0x07, 0xFE, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xFF, 0xFE,
  0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x08, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xF8, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D,
  0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xF3, 0xE0, 0x3C, 0xFF, 0xFF, 0x1F,
  0xFF, 0xC0, 0xFF, 0x80, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x07,
  0x9F, 0x00, 0x3E, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xE0, 0x1E, 0x07,
  0x80, 0x78, 0x1E, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xE1,
  0xE0, 0x07, 0x87, 0x80, 0x1E, 0x1E, 0x00, 0x3C, 0xF0, 0x00, 0xF3, 0xC0,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3D, 0xC1, 0xE0, 0xE7, 0x07, 0x83,
  0x9C, 0x1E, 0x0E, 0x70, 0x7C, 0x39, 0xE3, 0xF1, 0xE7, 0x8F, 0xC7, 0x9E,
  0x33, 0x1E, 0x39, 0xCE, 0x70, 0xE7, 0x39, 0xC3, 0x98, 0x67, 0x0E, 0xE1,
  0xDC, 0x3F, 0x87, 0xF0, 0xFC, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8,
  0x1E, 0x01, 0xE0, 0x78, 0x07, 0x80, 0x7C, 0x00, 0xF8, 0xF0, 0x03, 0xC1,
  0xE0, 0x1E, 0x07, 0xC0, 0xF0, 0x0F, 0x87, 0xC0, 0x1E, 0x1E, 0x00, 0x3C,
  0xF0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xBC, 0x00, 0x3C, 0xF0, 0x01,
  0xE1, 0xE0, 0x0F, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x1E, 0x0F, 0x00,
  0x3C, 0x78, 0x00, 0xF9, 0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF7, 0x80, 0x0F,
  0x78, 0x01, 0xE7, 0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03,
  0xC1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0, 0x38, 0x0F, 0x07, 0x80, 0xF0,
  0x78, 0x07, 0x87, 0x80, 0x78, 0xF0, 0x07, 0x8F, 0x00, 0x3C, 0xF0, 0x03,
  0xDE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x83, 0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0xFF,
  0x9F, 0xFF, 0xE7, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x07, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0x00, 0x63,
  0xFC, 0x07, 0x7F, 0xE0, 0x77, 0x1F, 0x8E, 0xE0, 0x7F, 0xEE, 0x03, 0xFC,
  0x60, 0x0F, 0x80,
};

const GFXglyph UbuntuMono_Regular48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 6, 30, 24, 9, -30 },
  { 24, 12, 12, 24, 6, -33 },
  { 42, 22, 30, 24, 1, -30 },
  { 125, 18, 38, 24, 3, -33 },
  { 211, 22, 30, 24, 1, -30 },
  { 294, 22, 30, 24, 1, -30 },
  { 377, 4, 13, 24, 10, -33 },
  { 384, 14, 42, 24, 5, -34 },
  { 458, 14, 42, 24, 5, -34 },
  { 532, 18, 18, 24, 3, -30 },
  { 573, 20, 21, 24, 2, -23 },
  { 626, 10, 12, 24, 7, -6 },
  { 641, 10, 4, 24, 7, -14 },
  { 646, 8, 6, 24, 8, -6 },
  { 652, 18, 42, 24, 3, -34 },
  { 747, 20, 30, 24, 2, -30 },
  { 822, 17, 30, 24, 4, -30 },
  { 886, 18, 30, 24, 3, -30 },
  { 954, 18, 30, 24, 3, -30 },
  { 1022, 20, 30, 24, 2, -30 },
  { 1097, 18, 30, 24, 3, -30 },
  { 1165, 19, 30, 24, 3, -30 },
  { 1237, 19, 30, 24, 3, -30 },
  { 1309, 20, 30, 24, 2, -30 },
  { 1384, 19, 30, 24, 2, -30 },
  { 1456, 8, 22, 24, 8, -22 },
  { 1478, 10, 28, 24, 6, -22 },
  { 1513, 20, 19, 24, 2, -22 },
  { 1561, 20, 12, 24, 2, -19 },
  { 1591, 20, 19, 24, 2, -22 },
  { 1639, 16, 30, 24, 4, -30 },
  { 1699, 20, 36, 24, 2, -30 },
  { 1789, 24, 30, 24, 0, -30 },
  { 1879, 19, 30, 24, 3, -30 },
  { 1951, 20, 30, 24, 2, -30 },
  { 2026, 19, 30, 24, 3, -30 },
  { 2098, 18, 30, 24, 4, -30 },
  { 2166, 17, 30, 24, 4, -30 },
  { 2230, 20, 30, 24, 2, -30 },
  { 2305, 20, 30, 24, 2, -30 },
  { 2380, 16, 30, 24, 4, -30 },
  { 2440, 17, 30, 24, 3, -30 },
  { 2504, 21, 30, 24, 3, -30 },
  { 2583, 18, 30, 24, 4, -30 },
  { 2651, 20, 30, 24, 2, -30 },
  { 2726, 18, 30, 24, 3, -30 },
  { 2794, 22, 30, 24, 1, -30 },
  { 2877, 19, 30, 24, 3, -30 },
  { 2949, 22, 37, 24, 1, -30 },
  { 3051, 19, 30, 24, 3, -30 },
  { 3123, 18, 30, 24, 3, -30 },
  { 3191, 20, 30, 24, 2, -30 },
  { 3266, 20, 30, 24, 2, -30 },
  { 3341, 22, 30, 24, 1, -30 },
  { 3424, 20, 30, 24, 2, -30 },
  { 3499, 22, 30, 24, 1, -30 },
  { 3582, 22, 30, 24, 1, -30 },
  { 3665, 19, 30, 24, 3, -30 },
  { 3737, 11, 42, 24, 7, -34 },
  { 3795, 18, 42, 24, 3, -34 },
  { 3890, 11, 42, 24, 6, -34 },
  { 3948, 20, 16, 24, 2, -30 },
  { 3988, 24, 3, 24, 0, 5 },
  { 3997, 8, 8, 24, 8, -33 },
  { 4005, 18, 22, 24, 3, -22 },
  { 4055, 19, 33, 24, 3, -33 },
  { 4134, 20, 22, 24, 2, -22 },
  { 4189, 19, 33, 24, 2, -33 },
  { 4268, 20, 22, 24, 2, -22 },
  { 4323, 20, 33, 24, 3, -33 },
  { 4406, 19, 30, 24, 2, -22 },
  { 4478, 18, 33, 24, 3, -33 },
  { 4553, 19, 31, 24, 3, -31 },
  { 4627, 15, 39, 24, 3, -31 },
  { 4701, 20, 33, 24, 3, -33 },
  { 4784, 19, 33, 24, 3, -33 },
  { 4863, 20, 22, 24, 2, -22 },
  { 4918, 18, 22, 24, 3, -22 },
  { 4968, 20, 22, 24, 2, -22 },
  { 5023, 19, 30, 24, 3, -22 },
  { 5095, 19, 30, 24, 2, -22 },
  { 5167, 16, 22, 24, 5, -22 },
  { 5211, 18, 22, 24, 3, -22 },
  { 5261, 19, 29, 24, 3, -29 },
  { 5330, 18, 22, 24, 3, -22 },
  { 5380, 22, 22, 24, 1, -22 },
  { 5441, 22, 22, 24, 1, -22 },
  { 5502, 22, 22, 24, 1, -22 },
  { 5563, 20, 30, 24, 2, -22 },
  { 5638, 18, 22, 24, 3, -22 },
  { 5688, 17, 42, 24, 4, -34 },
  { 5778, 4, 42, 24, 10, -34 },
  { 5799, 17, 42, 24, 3, -34 },
  { 5889, 20, 7, 24, 2, -16 },
};

const GFXfont UbuntuMono_Regular48pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular48pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular48pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _UBUNTUMONO_REGULAR48PT7B_H_
