#ifndef _UBUNTUMONO_REGULAR10PT7B_H_
#define _UBUNTUMONO_REGULAR10PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 10pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular10pt7bBitmaps[] PROGMEM = {
  0x00, 0xF4, 0xB4, 0x32, 0xBE, 0xAF, 0xB0, 0x5E, 0x62, 0x7A, 0xCD, 0xB8,
  0x76, 0xCC, 0x62, 0x98, 0xE9, 0x34, 0xE0, 0x2A, 0x49, 0x11, 0x88, 0x92,
  0x54, 0x5D, 0x50, 0x21, 0x3E, 0x42, 0x00, 0x68, 0xE0, 0x80, 0x24, 0xA4,
  0xA4, 0x80, 0x72, 0xAB, 0x15, 0x38, 0x59, 0x25, 0xC0, 0xF4, 0xA9, 0xC0,
  0xE5, 0x13, 0xC0, 0x11, 0x95, 0xF1, 0x08, 0xF3, 0x93, 0xC0, 0x73, 0xDB,
  0xC0, 0xF2, 0x24, 0x44, 0xF7, 0xDB, 0xC0, 0xF6, 0xF3, 0x80, 0x90, 0x41,
  0xC0, 0x36, 0x0C, 0xF8, 0x3E, 0x60, 0xD8, 0xE4, 0xA0, 0x80, 0x72, 0x6F,
  0x5B, 0xA0, 0xC0, 0x22, 0x94, 0xA7, 0x44, 0xEA, 0xE9, 0xAE, 0x3A, 0x21,
  0x04, 0x3C, 0xEA, 0x99, 0xAE, 0xE8, 0xE8, 0x8F, 0xF2, 0x79, 0x00, 0x32,
  0x21, 0x14, 0xBC, 0x8C, 0x7F, 0x18, 0xC4, 0xE9, 0x25, 0xC0, 0xE4, 0x93,
  0xC0, 0xAC, 0xCC, 0xA9, 0x88, 0x88, 0x8F, 0x52, 0xB5, 0x58, 0xC4, 0xB7,
  0xFB, 0x40, 0x74, 0x63, 0x18, 0xB8, 0xE9, 0x9E, 0x88, 0x74, 0x63, 0x18,
  0xB8, 0x82, 0xEA, 0xAE, 0xAA, 0xF3, 0x13, 0xC0, 0xF9, 0x08, 0x42, 0x10,
  0x8C, 0x63, 0x15, 0x38, 0x8C, 0x54, 0xA5, 0x10, 0x8C, 0x6B, 0xD5, 0x28,
  0x52, 0x88, 0x45, 0x44, 0x8A, 0x94, 0x42, 0x10, 0xE2, 0x44, 0x8F, 0xF2,
  0x49, 0x27, 0x92, 0x24, 0x89, 0x20, 0xE4, 0x92, 0x4F, 0x22, 0xA2, 0xF8,
  0xC0, 0xE7, 0xDE, 0x88, 0xEA, 0x9A, 0xE0, 0x72, 0x20, 0x87, 0x00, 0x11,
  0x75, 0x95, 0x70, 0x72, 0xBF, 0x07, 0x00, 0x74, 0xE4, 0x44, 0x40, 0x75,
  0x99, 0x71, 0x70, 0x93, 0xDB, 0x68, 0xC0, 0xC4, 0x44, 0x60, 0x63, 0x92,
  0x49, 0xC0, 0x88, 0xAC, 0xCA, 0xA0, 0xC4, 0x44, 0x44, 0x60, 0xF5, 0x6B,
  0x18, 0x80, 0xF6, 0xDA, 0x72, 0xA2, 0xA7, 0x00, 0xEA, 0x9A, 0xE8, 0x80,
  0x75, 0x95, 0x71, 0x10, 0xF2, 0x48, 0xF3, 0x9E, 0x4E, 0x44, 0x46, 0xB6,
  0xDE, 0x8A, 0x94, 0xA2, 0x00, 0x8D, 0x6B, 0xA5, 0x00, 0x52, 0x88, 0xA5,
  0x00, 0x4A, 0x94, 0xA2, 0x13, 0x00, 0xE5, 0x4E, 0x69, 0x28, 0x92, 0x60,
  0xFF, 0x80, 0xC9, 0x22, 0x92, 0xC0, 0x6D, 0x80,
};

const GFXglyph UbuntuMono_Regular10pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 1, 6, 5, 2, -6 },
  { 2, 3, 2, 5, 1, -7 },
  { 3, 5, 6, 5, 0, -6 },
  { 7, 3, 8, 5, 1, -7 },
  { 10, 5, 6, 5, 0, -6 },
  { 14, 5, 6, 5, 0, -6 },
  { 18, 1, 3, 5, 2, -7 },
  { 19, 3, 8, 5, 1, -6 },
  { 22, 3, 8, 5, 1, -6 },
  { 25, 3, 4, 5, 1, -6 },
  { 27, 5, 5, 5, 0, -5 },
  { 31, 3, 2, 5, 1, -1 },
  { 32, 3, 1, 5, 1, -3 },
  { 33, 1, 1, 5, 2, -1 },
  { 34, 3, 9, 5, 1, -7 },
  { 38, 5, 6, 5, 0, -6 },
  { 42, 3, 6, 5, 1, -6 },
  { 45, 3, 6, 5, 1, -6 },
  { 48, 3, 6, 5, 1, -6 },
  { 51, 5, 6, 5, 0, -6 },
  { 55, 3, 6, 5, 1, -6 },
  { 58, 3, 6, 5, 1, -6 },
  { 61, 4, 6, 5, 1, -6 },
  { 64, 3, 6, 5, 1, -6 },
  { 67, 3, 6, 5, 1, -6 },
  { 70, 1, 4, 5, 2, -4 },
  { 71, 2, 5, 5, 1, -4 },
  { 73, 5, 3, 5, 0, -4 },
  { 75, 5, 3, 5, 0, -4 },
  { 77, 5, 3, 5, 0, -4 },
  { 79, 3, 6, 5, 1, -6 },
  { 82, 5, 7, 5, 0, -6 },
  { 87, 5, 6, 5, 0, -6 },
  { 91, 4, 6, 5, 1, -6 },
  { 94, 5, 6, 5, 0, -6 },
  { 98, 4, 6, 5, 1, -6 },
  { 101, 4, 6, 5, 1, -6 },
  { 104, 3, 6, 5, 1, -6 },
  { 107, 5, 6, 5, 0, -6 },
  { 111, 5, 6, 5, 0, -6 },
  { 115, 3, 6, 5, 1, -6 },
  { 118, 3, 6, 5, 1, -6 },
  { 121, 4, 6, 5, 1, -6 },
  { 124, 4, 6, 5, 1, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 3, 6, 5, 1, -6 },
  { 134, 5, 6, 5, 0, -6 },
  { 138, 4, 6, 5, 1, -6 },
  { 141, 5, 8, 5, 0, -6 },
  { 146, 4, 6, 5, 1, -6 },
  { 149, 3, 6, 5, 1, -6 },
  { 152, 5, 6, 5, 0, -6 },
  { 156, 5, 6, 5, 0, -6 },
  { 160, 5, 6, 5, 0, -6 },
  { 164, 5, 6, 5, 0, -6 },
  { 168, 5, 6, 5, 0, -6 },
  { 172, 5, 6, 5, 0, -6 },
  { 176, 4, 6, 5, 1, -6 },
  { 179, 3, 8, 5, 1, -6 },
  { 182, 3, 9, 5, 1, -7 },
  { 186, 3, 8, 5, 1, -6 },
  { 189, 5, 3, 5, 0, -6 },
  { 191, 5, 1, 5, 0, 1 },
  { 192, 1, 2, 5, 2, -7 },
  { 193, 3, 5, 5, 1, -5 },
  { 195, 4, 7, 5, 1, -7 },
  { 199, 5, 5, 5, 0, -5 },
  { 203, 4, 7, 5, 0, -7 },
  { 207, 5, 5, 5, 0, -5 },
  { 211, 4, 7, 5, 1, -7 },
  { 215, 4, 7, 5, 0, -5 },
  { 219, 3, 7, 5, 1, -7 },
  { 222, 4, 7, 5, 1, -7 },
  { 226, 3, 9, 5, 1, -7 },
  { 230, 4, 7, 5, 1, -7 },
  { 234, 4, 7, 5, 1, -7 },
  { 238, 5, 5, 5, 0, -5 },
  { 242, 3, 5, 5, 1, -5 },
  { 244, 5, 5, 5, 0, -5 },
  { 248, 4, 7, 5, 1, -5 },
  { 252, 4, 7, 5, 0, -5 },
  { 256, 3, 5, 5, 1, -5 },
  { 258, 3, 5, 5, 1, -5 },
  { 260, 4, 6, 5, 1, -6 },
  { 263, 3, 5, 5, 1, -5 },
  { 265, 5, 5, 5, 0, -5 },
  { 269, 5, 5, 5, 0, -5 },
  { 273, 5, 5, 5, 0, -5 },
  { 277, 5, 7, 5, 0, -5 },
  { 282, 3, 5, 5, 1, -5 },
  { 284, 3, 9, 5, 1, -7 },
  { 288, 1, 9, 5, 2, -7 },
  { 290, 3, 9, 5, 1, -7 },
  { 294, 5, 2, 5, 0, -4 },
};

const GFXfont UbuntuMono_Regular10pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular10pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular10pt7bGlyphs,
  0x20, 0x7E, 10
};

#endif // _UBUNTUMONO_REGULAR10PT7B_H_
