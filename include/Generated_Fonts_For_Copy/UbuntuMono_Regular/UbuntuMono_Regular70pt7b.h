#ifndef _UBUNTUMONO_REGULAR70PT7B_H_
#define _UBUNTUMONO_REGULAR70PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular70pt7bBitmaps[] PROGMEM = {
  0x00, 0x7F, 0x3F, 0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xFC, 0xFE, 0x7F, 0x3F,
  0x9F, 0xCF, 0xE7, 0xF3, 0xF9, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC7, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xC7, 0xC0, 0xF8, 0x0F, 0xFC, 0x07, 0xFE, 0x03, 0xFF, 0x01, 0xFF,
  0x80, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xFC, 0x07,
  0xFE, 0x03, 0xEF, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x79, 0xE0, 0x3C, 0xE0,
  0x0E, 0x70, 0x07, 0x00, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x1F, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x87, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x1F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x80, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0, 0x7E, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x0F,
  0x80, 0x7C, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xFE, 0x01, 0xF0, 0xFF,
  0x00, 0x02, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x40, 0x00, 0x0F, 0xEE, 0x00, 0x03,
  0xF9, 0xF8, 0x01, 0xFF, 0x7F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x87, 0xFE, 0x00, 0x0F,
  0x87, 0xFF, 0x80, 0x07, 0xC7, 0xC7, 0xC0, 0x07, 0xC3, 0xE1, 0xF0, 0x07,
  0xC1, 0xE0, 0x78, 0x03, 0xE0, 0xF0, 0x3C, 0x03, 0xE0, 0xF8, 0x1E, 0x01,
  0xF0, 0x7C, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x1F, 0x03, 0xE0,
  0xF8, 0x0F, 0x81, 0xE0, 0xF8, 0x07, 0xC0, 0xF0, 0x78, 0x01, 0xE0, 0x78,
  0x7C, 0x00, 0xF0, 0x3C, 0x7C, 0x00, 0x7C, 0x3E, 0x3E, 0x00, 0x3E, 0x3E,
  0x3E, 0x00, 0x0F, 0xFF, 0x3E, 0x00, 0x03, 0xFF, 0x1F, 0x00, 0x01, 0xFF,
  0x1F, 0x00, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x07, 0xC7, 0xF8, 0x00, 0x07, 0xC7, 0xFE, 0x00,
  0x03, 0xC7, 0xFF, 0x80, 0x03, 0xE3, 0xE3, 0xE0, 0x03, 0xE3, 0xE1, 0xF0,
  0x01, 0xF1, 0xE0, 0x78, 0x01, 0xF0, 0xF0, 0x3C, 0x01, 0xF0, 0x78, 0x1F,
  0x00, 0xF8, 0x3C, 0x0F, 0x80, 0xF8, 0x1E, 0x07, 0xC0, 0x7C, 0x0F, 0x03,
  0xE0, 0x7C, 0x07, 0x81, 0xF0, 0x7C, 0x03, 0xC0, 0xF8, 0x3E, 0x01, 0xE0,
  0x78, 0x3E, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0x7C, 0x3E, 0x1F, 0x00, 0x1F,
  0x1F, 0x1F, 0x00, 0x0F, 0xFF, 0x0F, 0x80, 0x03, 0xFF, 0x0F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x01, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F,
  0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xF8,
  0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x0F, 0x00, 0xFF, 0xC0, 0x1E, 0x03, 0xFF, 0xC0, 0x7C, 0x0F,
  0xFF, 0xC0, 0xF8, 0x1F, 0x9F, 0xC1, 0xF0, 0x7E, 0x1F, 0xC3, 0xE0, 0xF8,
  0x1F, 0xC7, 0xC3, 0xF0, 0x1F, 0xDF, 0x07, 0xC0, 0x1F, 0xFE, 0x1F, 0x80,
  0x1F, 0xFC, 0x3F, 0x00, 0x1F, 0xF0, 0x7E, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x83, 0xF0, 0x01,
  0xFF, 0x07, 0xF0, 0x0F, 0xFF, 0x0F, 0xFC, 0x7F, 0xFE, 0x0F, 0xFF, 0xFF,
  0x7E, 0x0F, 0xFF, 0xFC, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x81,
  0xF8, 0x03, 0xF8, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xDF, 0xBF, 0x3E,
  0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF0, 0xE0, 0x00, 0x01,
  0x00, 0x00, 0x70, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xFE, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00,
  0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xC0, 0x00, 0x10, 0x10,
  0x00, 0x07, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x1C, 0x00, 0x01, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x08, 0x07, 0xC0, 0x23,
  0xC0, 0xF8, 0x1E, 0x7F, 0x0F, 0x1F, 0xCF, 0xF9, 0xCF, 0xFB, 0xFF, 0xBB,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0x7E,
  0x00, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x1F,
  0xC1, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x3E, 0x03, 0xE0, 0x03, 0x80, 0x38,
  0x00, 0x30, 0x06, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x0F,
  0xF0, 0x1F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF, 0x83, 0xFE,
  0x03, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC1, 0xFF, 0x0F, 0xFC, 0x1F,
  0xF0, 0x3F, 0xC0, 0x7E, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xDF, 0xF1, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF,
  0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x01, 0xF7, 0xE0, 0x38, 0x0F, 0xFF, 0x03,
  0xF0, 0x7F, 0xF8, 0x3F, 0x83, 0xFF, 0xC1, 0xFC, 0x1F, 0xFE, 0x0F, 0xF0,
  0xFF, 0xF0, 0x7F, 0x07, 0xFF, 0x83, 0xF8, 0x3F, 0xFC, 0x0F, 0xC1, 0xFF,
  0xE0, 0x3C, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F,
  0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0xEF, 0x80, 0x3F, 0xF3, 0xE0, 0x07, 0xF0, 0xF8,
  0x01, 0xF0, 0x3E, 0x00, 0x30, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x3F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x07, 0xFF,
  0xFF, 0xE1, 0xFF, 0x03, 0xFE, 0x1F, 0x00, 0x1F, 0xC1, 0xC0, 0x01, 0xFC,
  0x20, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xE0, 0x7E, 0x03, 0xFE, 0x0F, 0x00,
  0x1F, 0xC0, 0x80, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x90, 0x00,
  0x0F, 0xE3, 0xE0, 0x0F, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03,
  0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x01, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x83, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x90, 0x00, 0x1F, 0xCF, 0x80, 0x3F, 0xF3, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC7, 0xFC, 0x03, 0xF7, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x3F, 0xE0, 0x1F, 0xF7, 0xE0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00,
  0x1F, 0xBF, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x3F, 0x87,
  0xF8, 0x1F, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xC1, 0xFF, 0x0F,
  0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x01,
  0xF9, 0xF0, 0x00, 0x1F, 0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7F, 0x00, 0x1F,
  0x87, 0xF0, 0x07, 0xF0, 0xFF, 0x81, 0xFC, 0x0F, 0xFC, 0x7F, 0x00, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0,
  0x1F, 0xC7, 0xFF, 0x03, 0xF0, 0x1F, 0xF0, 0xFC, 0x00, 0xFF, 0x3F, 0x00,
  0x0F, 0xE7, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x07, 0xF3, 0xFE, 0x03, 0xFE, 0x3F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFF, 0x80,
  0x7F, 0xCF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0x7F, 0xFE, 0xFC, 0x03, 0xFE, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x01, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x07, 0xF1, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xDF, 0xF1, 0xFC, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x3F, 0x8F, 0xFB, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0x8F, 0xE0, 0xF8,
  0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x87, 0xFF, 0x1F, 0xFC, 0x7F, 0xF0, 0xFF,
  0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x07, 0xF0, 0x3F, 0xE0, 0xFF, 0xC7,
  0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0,
  0x7F, 0x0F, 0xF8, 0xFF, 0xE3, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x60, 0x00,
  0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFC, 0x00,
  0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x20, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0x83,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0x87, 0x80, 0xFF, 0x88,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF0, 0x3F, 0x80, 0xFF, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0x3F, 0x3E, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x03, 0xFF,
  0xDF, 0x00, 0x3F, 0xFF, 0x7C, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x07, 0xF8, 0x3F, 0xFC, 0x1F, 0xC0, 0xFF, 0xF0,
  0x7E, 0x03, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0, 0x3F, 0xF8, 0x3F,
  0x00, 0xFF, 0xE0, 0xFC, 0x03, 0xFF, 0x83, 0xF0, 0x0F, 0xFF, 0x0F, 0xC0,
  0x3F, 0xFC, 0x3F, 0x00, 0xFF, 0xF0, 0xFC, 0x03, 0xFF, 0xC3, 0xF0, 0x0F,
  0xFF, 0x07, 0xE0, 0x3F, 0xFC, 0x1F, 0x80, 0xFF, 0xF0, 0x7F, 0x83, 0xF7,
  0xE0, 0xFF, 0xFF, 0xDF, 0x81, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xFD, 0xF8,
  0x07, 0xFF, 0xF3, 0xF0, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x0C,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x1F, 0x1F, 0x80,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x80, 0x07, 0xE0, 0x07, 0xC0,
  0x01, 0xF0, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x1F,
  0x80, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC,
  0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xE0, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0x0F, 0xC0,
  0x1F, 0xF0, 0xFC, 0x00, 0x7F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0x0F, 0xC0, 0x0F, 0xF8, 0xFC, 0x00, 0x3F, 0xCF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE, 0xFC,
  0x00, 0x3F, 0xCF, 0xC0, 0x0F, 0xFC, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x01, 0xF8, 0x1F, 0xE0,
  0x03, 0xC1, 0xFC, 0x00, 0x04, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0x03, 0xFF, 0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x0F, 0xC0, 0x7F, 0xE0, 0xFC, 0x00, 0xFF,
  0x0F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF8, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x7F,
  0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC3, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF,
  0x03, 0xFF, 0x01, 0xF8, 0x1F, 0xE0, 0x03, 0x81, 0xFC, 0x00, 0x04, 0x1F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x3F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00,
  0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFF, 0x80, 0x1F, 0x83, 0xFF, 0x01, 0xFC,
  0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F,
  0xFF, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE4,
  0x00, 0x07, 0xE7, 0x80, 0x07, 0xF3, 0xF0, 0x1F, 0xF3, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xC0,
  0x00, 0xFC, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F,
  0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x03, 0xF0,
  0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07,
  0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x3F, 0x7F, 0xC0, 0x00, 0xFC, 0x7F, 0x80, 0x03, 0xF0,
  0xFF, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x3F, 0x03, 0xFC, 0x00, 0xFC, 0x07,
  0xF8, 0x03, 0xF0, 0x0F, 0xF0, 0x0F, 0xC0, 0x1F, 0xC0, 0x3F, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC,
  0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0xCF,
  0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x03, 0xFB, 0xF0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7F,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xFC,
  0x00, 0xFE, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xF0, 0x07, 0xFC, 0x3F, 0xE0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFB, 0xC0, 0x7B, 0xE1, 0xF7, 0x80,
  0xF3, 0xC3, 0xEF, 0x83, 0xE7, 0x87, 0x8F, 0x07, 0x8F, 0x0F, 0x1E, 0x0F,
  0x1E, 0x1E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x78, 0x78, 0x78, 0x78, 0xF0,
  0xF0, 0xF0, 0xF9, 0xE1, 0xF3, 0xE0, 0xF7, 0x83, 0xE7, 0xC1, 0xEF, 0x07,
  0xCF, 0x83, 0xFE, 0x0F, 0x9F, 0x03, 0xFC, 0x1F, 0x3E, 0x07, 0xF0, 0x3E,
  0x7C, 0x0F, 0xE0, 0x7C, 0xF8, 0x0F, 0xC0, 0xF9, 0xF0, 0x1F, 0x01, 0xF3,
  0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xF8,
  0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xF8, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0x7F,
  0xEF, 0x80, 0x0F, 0xFC, 0xF8, 0x01, 0xFF, 0x9F, 0x80, 0x3F, 0xF1, 0xF0,
  0x07, 0xFE, 0x3F, 0x00, 0xFF, 0xC3, 0xE0, 0x1F, 0xF8, 0x7E, 0x03, 0xFF,
  0x07, 0xC0, 0x7F, 0xE0, 0xFC, 0x0F, 0xFC, 0x0F, 0x81, 0xFF, 0x81, 0xF8,
  0x3F, 0xF0, 0x1F, 0x07, 0xFE, 0x03, 0xE0, 0xFF, 0xC0, 0x3E, 0x1F, 0xF8,
  0x07, 0xC3, 0xFF, 0x00, 0x7C, 0x7F, 0xE0, 0x0F, 0x8F, 0xFC, 0x01, 0xF9,
  0xFF, 0x80, 0x1F, 0x3F, 0xF0, 0x03, 0xE7, 0xFE, 0x00, 0x3E, 0xFF, 0xC0,
  0x07, 0xDF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x81,
  0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0x3F,
  0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0,
  0x03, 0xF9, 0xF8, 0x03, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFC,
  0x01, 0xFE, 0x07, 0xFC, 0x07, 0xF8, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x9F,
  0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00,
  0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0xFF, 0x01, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFE, 0x0F, 0xC0, 0x1F, 0xF0, 0xFC, 0x00, 0x7F, 0x8F,
  0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x1F, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x00, 0xF8, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF8, 0x7F,
  0xC0, 0x7F, 0x0F, 0xE0, 0x01, 0xC3, 0xF8, 0x00, 0x08, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xB0, 0x00, 0x07, 0xF7, 0x80, 0x01, 0xFC, 0xFE,
  0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F,
  0xC0, 0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x0F, 0xF0,
  0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xF8, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x01,
  0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xEF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xBE, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x3E, 0x7C, 0x07, 0xC0, 0x7C,
  0xF8, 0x1F, 0x80, 0xF9, 0xF0, 0x3F, 0x81, 0xF3, 0xE0, 0x7F, 0x03, 0xE7,
  0xC1, 0xFE, 0x07, 0xCF, 0x83, 0xFE, 0x0F, 0x9F, 0x07, 0xBC, 0x1F, 0x3E,
  0x0F, 0x78, 0x3C, 0x7C, 0x3C, 0xF8, 0x78, 0x78, 0x78, 0xF0, 0xF0, 0xF0,
  0xF1, 0xE1, 0xE1, 0xE3, 0xE3, 0xE3, 0xC3, 0xC7, 0x83, 0xC7, 0x87, 0x8F,
  0x07, 0x8F, 0x0F, 0x3E, 0x0F, 0xBE, 0x1F, 0x78, 0x0F, 0x7C, 0x3E, 0xF0,
  0x1E, 0xF8, 0x7F, 0xE0, 0x3F, 0xF0, 0xFF, 0x80, 0x3F, 0xE1, 0xFF, 0x00,
  0x7F, 0x83, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x01, 0xFE, 0x07, 0xF0, 0x01,
  0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x3F, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0xFC, 0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB,
  0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F,
  0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F,
  0xDF, 0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01,
  0xF8, 0x1F, 0xC0, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x7E, 0x00,
  0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC,
  0xE0, 0x00, 0x03, 0x83, 0x00, 0x00, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x08, 0x01, 0x80, 0x3C, 0x07, 0xE0, 0x7F, 0x03,
  0xF8, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xE0, 0x04, 0x01, 0xFF,
  0xC0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x03, 0x80, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0xF9, 0xF0, 0x3F, 0xFF, 0xFC, 0x3F,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF7, 0xFC, 0x00, 0xFF,
  0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF7, 0xF8,
  0x00, 0x7D, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xE0, 0x1C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xF0, 0x03, 0xF7, 0xFF, 0xC0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFE, 0x3F, 0xF0, 0x3F, 0xC7,
  0xF0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xFB, 0xF0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x1F,
  0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0xFF, 0x8F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x07, 0xFE,
  0x00, 0x30, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x1C, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x07, 0xF8,
  0xFC, 0x07, 0xFF, 0xDF, 0x81, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xF9, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x07,
  0xEF, 0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB,
  0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFF, 0x00,
  0x1F, 0x8F, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0xFF, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x1F, 0x9F, 0x00,
  0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x02, 0x07, 0xFE, 0x00, 0xF0,
  0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x01, 0xFE, 0x03, 0xE0, 0x07, 0xF0, 0x00, 0x80, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x1F, 0xCF, 0xF0, 0x01, 0xF9, 0xF8, 0x00,
  0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xE7, 0xFC,
  0x07, 0xFC, 0x7F, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x60, 0x00, 0x7F, 0x8F, 0x80, 0x3F, 0xE1, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0xC0, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF3,
  0xFC, 0x07, 0xF9, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00,
  0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x20, 0x03, 0xFC, 0x1E, 0x00, 0x1F, 0xFF,
  0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE2, 0x00, 0x3F, 0x9F,
  0x01, 0xFC, 0x7F, 0xFF, 0xF3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x07, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xC0,
  0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x0F, 0xC1, 0xFE, 0x00, 0xFC,
  0x3F, 0xC0, 0x0F, 0xC7, 0xF8, 0x00, 0xFC, 0xFF, 0x00, 0x0F, 0xDF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0xFC, 0x3F,
  0x80, 0x0F, 0xC1, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x0F, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x20, 0x03, 0xFC, 0x1E, 0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0x07, 0xFF, 0xC7, 0xFE, 0x3F, 0xFF, 0xFF, 0xF9, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x7C, 0x1F, 0xE1, 0xFF, 0xE0, 0x7E,
  0x07, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F, 0x80, 0xFF, 0xC0, 0x7C, 0x07,
  0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x1F, 0x01, 0xFF, 0x80, 0xF8, 0x0F, 0xFC,
  0x07, 0xC0, 0x7F, 0xE0, 0x3E, 0x03, 0xFF, 0x01, 0xF0, 0x1F, 0xF8, 0x0F,
  0x80, 0xFF, 0xC0, 0x7C, 0x07, 0xFE, 0x03, 0xE0, 0x3F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0x03, 0xFF, 0x80, 0x7F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE7,
  0xF0, 0x0F, 0xFB, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01,
  0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC, 0x00,
  0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xC0,
  0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0xFF, 0x00,
  0x7F, 0x87, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF,
  0xE0, 0x00, 0xFE, 0x3F, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0xFF, 0x07, 0xF8,
  0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x0F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xE1, 0xFC, 0x03, 0xFE, 0x3F, 0x00, 0x1F, 0xE7, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0x1F, 0xDF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0x9F, 0xC0, 0x07, 0xF3,
  0xFE, 0x03, 0xFC, 0x7F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x3F, 0x7F, 0xFC, 0x07, 0xE3, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x0F, 0xCF, 0xF0, 0x01,
  0xF9, 0xFC, 0x00, 0x3F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F,
  0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF8, 0x00, 0x3F, 0x3F, 0x00,
  0x07, 0xE7, 0xF0, 0x01, 0xFC, 0x7F, 0x80, 0xFF, 0x87, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xF8, 0x01, 0xFE,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0x80, 0x06,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFC, 0x01,
  0xF1, 0xF8, 0x00, 0x09, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x40, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x02, 0x00, 0xFF, 0x00, 0xE0, 0x07, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x3F,
  0xF0, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xCF, 0xF0,
  0x07, 0xE7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xE0, 0xFE, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x01, 0xF8,
  0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x07,
  0xE0, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x00, 0x7C, 0xF8, 0x07, 0xC0, 0x3E, 0x7E, 0x03, 0xE0, 0x1F, 0x3F, 0x01,
  0xF8, 0x1F, 0x8F, 0x81, 0xFC, 0x0F, 0x87, 0xC0, 0xFE, 0x07, 0xC3, 0xE0,
  0x7F, 0x03, 0xE1, 0xF0, 0x7F, 0xC1, 0xF0, 0xF8, 0x3F, 0xE0, 0xF8, 0x7C,
  0x1E, 0xF0, 0x7C, 0x3F, 0x1F, 0x7C, 0x3C, 0x0F, 0x8F, 0xBE, 0x3E, 0x07,
  0xC7, 0x8F, 0x1F, 0x03, 0xE7, 0xC7, 0xCF, 0x81, 0xF3, 0xE3, 0xE7, 0xC0,
  0xF9, 0xE0, 0xF3, 0xE0, 0x7D, 0xF0, 0x7D, 0xE0, 0x1F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x0F, 0xF8, 0x07, 0xFC, 0x07, 0xFC, 0x03, 0xFC, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xC0, 0x7E, 0x00, 0x01,
  0xFC, 0x7E, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x3F,
  0x00, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x01, 0xF8, 0xFC, 0x00,
  0x03, 0xFB, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E,
  0xFE, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xF0, 0x03,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0,
  0x7E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x0F, 0xCF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x02, 0x03, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7F, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x60, 0x7F, 0xC0,
  0x03, 0xCF, 0xFF, 0x80, 0x1E, 0x7F, 0xFF, 0x01, 0xF7, 0xFF, 0xFE, 0x1F,
  0x3E, 0x1F, 0xFF, 0xFB, 0xE0, 0x3F, 0xFF, 0x9E, 0x00, 0x7F, 0xFC, 0xF0,
  0x00, 0xFF, 0x81, 0x80, 0x01, 0xF8, 0x00,
};

const GFXglyph UbuntuMono_Regular70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 35, 0, -1 },
  { 1, 9, 44, 35, 13, -43 },
  { 51, 17, 17, 35, 9, -48 },
  { 88, 31, 43, 35, 2, -43 },
  { 255, 27, 56, 35, 4, -49 },
  { 444, 33, 45, 35, 1, -44 },
  { 630, 31, 43, 35, 2, -43 },
  { 797, 7, 19, 35, 14, -48 },
  { 814, 19, 61, 35, 8, -49 },
  { 959, 19, 61, 35, 8, -49 },
  { 1104, 27, 26, 35, 4, -43 },
  { 1192, 29, 31, 35, 3, -34 },
  { 1305, 15, 18, 35, 10, -8 },
  { 1339, 15, 5, 35, 10, -20 },
  { 1349, 11, 9, 35, 12, -8 },
  { 1362, 25, 61, 35, 5, -49 },
  { 1553, 29, 45, 35, 3, -44 },
  { 1717, 26, 43, 35, 5, -43 },
  { 1857, 27, 44, 35, 4, -44 },
  { 2006, 27, 45, 35, 4, -44 },
  { 2158, 30, 43, 35, 3, -43 },
  { 2320, 26, 44, 35, 5, -43 },
  { 2463, 27, 44, 35, 4, -43 },
  { 2612, 28, 43, 35, 4, -43 },
  { 2763, 27, 45, 35, 4, -44 },
  { 2915, 27, 44, 35, 4, -44 },
  { 3064, 11, 32, 35, 12, -31 },
  { 3108, 14, 41, 35, 9, -31 },
  { 3180, 29, 28, 35, 3, -31 },
  { 3282, 29, 18, 35, 3, -27 },
  { 3348, 29, 28, 35, 3, -31 },
  { 3450, 23, 45, 35, 6, -44 },
  { 3580, 30, 52, 35, 3, -43 },
  { 3775, 33, 43, 35, 1, -43 },
  { 3953, 28, 43, 35, 4, -43 },
  { 4104, 29, 43, 35, 3, -43 },
  { 4260, 28, 43, 35, 4, -43 },
  { 4411, 26, 43, 35, 6, -43 },
  { 4551, 25, 43, 35, 6, -43 },
  { 4686, 29, 43, 35, 3, -43 },
  { 4842, 29, 43, 35, 3, -43 },
  { 4998, 23, 43, 35, 6, -43 },
  { 5122, 25, 43, 35, 4, -43 },
  { 5257, 30, 43, 35, 4, -43 },
  { 5419, 26, 43, 35, 6, -43 },
  { 5559, 31, 43, 35, 2, -43 },
  { 5726, 27, 43, 35, 4, -43 },
  { 5872, 31, 43, 35, 2, -43 },
  { 6039, 27, 43, 35, 5, -43 },
  { 6185, 31, 54, 35, 2, -43 },
  { 6395, 28, 43, 35, 4, -43 },
  { 6546, 27, 43, 35, 4, -43 },
  { 6692, 29, 43, 35, 3, -43 },
  { 6848, 29, 43, 35, 3, -43 },
  { 7004, 33, 43, 35, 1, -43 },
  { 7182, 31, 43, 35, 2, -43 },
  { 7349, 31, 43, 35, 2, -43 },
  { 7516, 33, 43, 35, 1, -43 },
  { 7694, 28, 43, 35, 4, -43 },
  { 7845, 17, 61, 35, 10, -49 },
  { 7975, 25, 61, 35, 5, -49 },
  { 8166, 17, 61, 35, 8, -49 },
  { 8296, 29, 24, 35, 3, -43 },
  { 8383, 33, 5, 35, 1, 7 },
  { 8404, 12, 12, 35, 11, -48 },
  { 8422, 26, 32, 35, 4, -32 },
  { 8526, 27, 49, 35, 5, -49 },
  { 8692, 29, 32, 35, 3, -32 },
  { 8808, 27, 49, 35, 3, -49 },
  { 8974, 29, 32, 35, 3, -32 },
  { 9090, 30, 49, 35, 4, -49 },
  { 9274, 27, 44, 35, 3, -32 },
  { 9423, 25, 49, 35, 5, -49 },
  { 9577, 28, 45, 35, 4, -45 },
  { 9735, 22, 57, 35, 5, -45 },
  { 9892, 28, 49, 35, 5, -49 },
  { 10064, 28, 49, 35, 4, -49 },
  { 10236, 29, 32, 35, 3, -32 },
  { 10352, 25, 32, 35, 5, -32 },
  { 10452, 29, 32, 35, 3, -32 },
  { 10568, 27, 44, 35, 5, -32 },
  { 10717, 27, 44, 35, 3, -32 },
  { 10866, 24, 32, 35, 7, -32 },
  { 10962, 25, 32, 35, 5, -32 },
  { 11062, 28, 42, 35, 4, -42 },
  { 11209, 25, 32, 35, 5, -32 },
  { 11309, 31, 32, 35, 2, -32 },
  { 11433, 33, 32, 35, 1, -32 },
  { 11565, 31, 32, 35, 2, -32 },
  { 11689, 29, 44, 35, 3, -32 },
  { 11849, 25, 32, 35, 5, -32 },
  { 11949, 24, 61, 35, 6, -49 },
  { 12132, 5, 61, 35, 15, -49 },
  { 12171, 24, 61, 35, 5, -49 },
  { 12354, 29, 10, 35, 3, -23 },
};

const GFXfont UbuntuMono_Regular70pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular70pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular70pt7bGlyphs,
  0x20, 0x7E, 70
};

#endif // _UBUNTUMONO_REGULAR70PT7B_H_
