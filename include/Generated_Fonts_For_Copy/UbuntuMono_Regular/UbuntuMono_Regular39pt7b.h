#ifndef _UBUNTUMONO_REGULAR39PT7B_H_
#define _UBUNTUMONO_REGULAR39PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular39pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xC6, 0x00,
  0x00, 0xEF, 0xFF, 0xEE, 0xE3, 0xF1, 0xF8, 0xFC, 0x3E, 0x1F, 0x0F, 0x87,
  0xC3, 0xE1, 0xA0, 0xC0, 0x03, 0x87, 0x01, 0xC3, 0x81, 0xC1, 0xC0, 0xE0,
  0xC0, 0x70, 0xE0, 0x38, 0x73, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x87,
  0x0E, 0x03, 0x87, 0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0x70, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xCE, 0x0E, 0x07, 0x0E, 0x03, 0x87,
  0x01, 0xC3, 0x80, 0xE1, 0xC0, 0xE0, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x7F, 0x03, 0xFF, 0x8F, 0xFF, 0x3E, 0x06, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0xB0, 0x1F, 0xFF, 0xFD, 0xFF, 0xF0, 0x7F, 0x80, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x3C, 0x03, 0x9F, 0x80, 0xEE, 0x70,
  0x73, 0x1C, 0x18, 0xC3, 0x0E, 0x30, 0xC7, 0x0C, 0x31, 0x83, 0x0C, 0xE0,
  0xE7, 0x30, 0x39, 0xDC, 0x07, 0xEE, 0x00, 0xF3, 0x00, 0x01, 0xCF, 0x00,
  0xEF, 0xE0, 0x3B, 0x98, 0x1C, 0xC7, 0x06, 0x71, 0xC3, 0x9C, 0x71, 0xC7,
  0x1C, 0x61, 0xC7, 0x38, 0x31, 0xDC, 0x0E, 0x67, 0x03, 0xFB, 0x80, 0x38,
  0x07, 0xC0, 0x07, 0xF8, 0x07, 0xFE, 0x07, 0x8F, 0x03, 0x83, 0x81, 0xC1,
  0xC0, 0xE0, 0xE0, 0x70, 0xE0, 0x1C, 0xF0, 0x0F, 0xF0, 0x03, 0xF0, 0x03,
  0xE0, 0xE3, 0xF8, 0x71, 0xDE, 0x39, 0xC7, 0x98, 0xE1, 0xFC, 0xF0, 0x7E,
  0x70, 0x1F, 0x3C, 0x07, 0x9E, 0x07, 0xC7, 0x87, 0xF3, 0xFF, 0xB8, 0xFF,
  0x9E, 0x1F, 0x07, 0xFF, 0xFF, 0xFF, 0x6C, 0x00, 0x40, 0x38, 0x0F, 0x83,
  0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x07,
  0x00, 0xE0, 0x1C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x38, 0x07, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0F,
  0x01, 0xF0, 0x1F, 0x01, 0xC0, 0x08, 0x20, 0x0E, 0x01, 0xE0, 0x1E, 0x01,
  0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x00, 0xE0, 0x1E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03,
  0xC0, 0x70, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x03, 0x80, 0xF0, 0x3C, 0x0F,
  0x07, 0xC0, 0x70, 0x04, 0x00, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x02, 0x1C,
  0x27, 0x99, 0xFF, 0xFF, 0xCF, 0xFF, 0x01, 0xC0, 0x07, 0xE0, 0x1D, 0xE0,
  0x79, 0xC1, 0xE3, 0xC1, 0xC3, 0x81, 0x04, 0x00, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x1C, 0x3E, 0x3F, 0x3F, 0x1F, 0x0E,
  0x3E, 0xFC, 0xF8, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x7B, 0xEF, 0xFE, 0x78,
  0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0x00, 0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E,
  0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E,
  0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x00, 0x07, 0xE0,
  0x1F, 0xF0, 0x3F, 0xF8, 0x3C, 0x3C, 0x78, 0x1C, 0x70, 0x1E, 0xF0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0E, 0xE3, 0x8F, 0xE3, 0xCF, 0xE3, 0xCF, 0xE3, 0xCF,
  0xE3, 0x8F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xF0, 0x0E, 0x70, 0x1E,
  0x78, 0x1C, 0x3C, 0x3C, 0x3F, 0xF8, 0x1F, 0xF0, 0x07, 0xC0, 0x01, 0xC0,
  0x0F, 0x00, 0x7C, 0x07, 0xF0, 0x7F, 0xC3, 0xEF, 0x04, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC1, 0xFF,
  0xF7, 0xFF, 0xDF, 0xFF, 0x0F, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3, 0x83, 0xE6,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x0F, 0xFF, 0xDF, 0xFF, 0xBF,
  0xFF, 0x0F, 0xC0, 0xFF, 0xE1, 0xFF, 0xE1, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0xF4, 0x03, 0xCF, 0xFF, 0xBF, 0xFE, 0x0F, 0xE0, 0x00, 0x1C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x1E, 0xE0, 0x0E,
  0x70, 0x0E, 0x38, 0x0E, 0x1C, 0x07, 0x0E, 0x07, 0x07, 0x07, 0x03, 0x83,
  0x81, 0xC3, 0x80, 0xE1, 0xC0, 0x71, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCE, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x00, 0x0C, 0x00, 0x70, 0x01, 0xFC, 0x07, 0xFE, 0x1F, 0xFC, 0x01, 0xF8,
  0x01, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0F,
  0xC0, 0xFB, 0xFF, 0xEF, 0xFF, 0x0F, 0xE0, 0x00, 0x3C, 0x01, 0xFC, 0x07,
  0xFC, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0x77, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x3E, 0xE0, 0x1E, 0xE0,
  0x0E, 0xE0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x7C,
  0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F,
  0xFC, 0x78, 0x3C, 0x70, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0x70, 0x0E, 0x78,
  0x1C, 0x7C, 0x3C, 0x3F, 0x78, 0x1F, 0xF0, 0x1F, 0xF8, 0x3C, 0xFC, 0x70,
  0x1E, 0xF0, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x0E, 0x78,
  0x3E, 0x7F, 0xFC, 0x3F, 0xF8, 0x0F, 0xE0, 0x07, 0xC0, 0x3F, 0xE0, 0xFF,
  0xE3, 0xC1, 0xE7, 0x01, 0xDE, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x1F, 0xC0, 0x3B, 0xC0, 0xF7, 0xFF, 0xE7, 0xFF, 0xC3, 0xFB, 0x80,
  0x0F, 0x00, 0x1C, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x3F, 0x0F, 0xFC,
  0x1F, 0xE0, 0x3E, 0x00, 0x7B, 0xEF, 0xFE, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xEF, 0xBF, 0xF9, 0xE0, 0x1E, 0x3E, 0x3F, 0x3E, 0x1E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3E, 0x3F, 0x3F, 0x1F,
  0x0E, 0x3E, 0xFC, 0xF8, 0xE0, 0x00, 0x02, 0x00, 0x1E, 0x00, 0x7F, 0x03,
  0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x1E, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x40, 0x00, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0x00, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFE, 0x00, 0xF8,
  0x00, 0x40, 0x00, 0x3F, 0x8F, 0xFC, 0xFF, 0xEC, 0x1F, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xE0,
  0x1C, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x3E, 0x03, 0xF0,
  0x3E, 0x01, 0xC0, 0x03, 0xF0, 0x0F, 0xF8, 0x1F, 0xFC, 0x3E, 0x1E, 0x38,
  0x0F, 0x78, 0x07, 0x70, 0x07, 0xF0, 0x07, 0xE0, 0x7F, 0xE1, 0xFF, 0xE3,
  0xFF, 0xE3, 0xC7, 0xE7, 0x87, 0xE7, 0x07, 0xE7, 0x07, 0xE7, 0x07, 0xE7,
  0x07, 0xE3, 0x87, 0xE3, 0xC7, 0xE3, 0xFF, 0xF1, 0xFF, 0x70, 0x7E, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x01,
  0xFC, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x01, 0xDC, 0x00, 0x3B,
  0x80, 0x07, 0x38, 0x01, 0xC7, 0x00, 0x38, 0xE0, 0x07, 0x0E, 0x01, 0xC1,
  0xC0, 0x38, 0x38, 0x07, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x0E, 0x07, 0x01,
  0xE0, 0xFF, 0xFC, 0x3F, 0xFF, 0x87, 0xFF, 0xF0, 0xE0, 0x0F, 0x1C, 0x00,
  0xE7, 0x00, 0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xC0,
  0xFF, 0xF0, 0xFF, 0xF8, 0xE0, 0x7C, 0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x1C,
  0xE0, 0x1C, 0xE0, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC,
  0xE0, 0x3E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E,
  0xE0, 0x1E, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0x7F, 0xC0, 0x01, 0xF8,
  0x07, 0xFF, 0x1F, 0xFE, 0x3F, 0x06, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3E, 0x02, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC, 0xFF, 0x80,
  0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0xF8, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0E,
  0xE0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1E,
  0xE0, 0x3C, 0xE0, 0xF8, 0xFF, 0xF8, 0xFF, 0xE0, 0x7F, 0x80, 0xFF, 0xFB,
  0xFF, 0xEF, 0xFF, 0xB8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xFD, 0xFF, 0xEF,
  0xFF, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0x01, 0xF8, 0x07, 0xFE, 0x1F,
  0xFE, 0x3F, 0x0E, 0x3C, 0x02, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x07, 0x7C, 0x07, 0x3E,
  0x07, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFC,
  0x7F, 0xF1, 0xFF, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xD0, 0x0F, 0x70, 0x7F, 0xFF,
  0xE7, 0xFF, 0x07, 0xF0, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x07, 0x9E, 0x07,
  0x8F, 0x07, 0x87, 0x87, 0x83, 0xC3, 0xC1, 0xE3, 0xC0, 0xF3, 0xC0, 0x7B,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xF0, 0x07, 0xBC, 0x03, 0xCF, 0x01,
  0xE3, 0xC0, 0xF0, 0xF0, 0x78, 0x3C, 0x3C, 0x0F, 0x1E, 0x03, 0xCF, 0x01,
  0xE7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0F, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x38, 0x0F, 0x1C, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xE3, 0xC1, 0xF3,
  0xF0, 0xD9, 0xD8, 0xEC, 0xEC, 0x76, 0x77, 0x33, 0x39, 0x99, 0x9C, 0xDC,
  0xEE, 0x7C, 0x77, 0x1E, 0x3B, 0x8F, 0x1D, 0xC7, 0x0E, 0xE0, 0x07, 0x70,
  0x03, 0xB8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F,
  0xC0, 0xFF, 0x81, 0xFB, 0x83, 0xF7, 0x07, 0xE7, 0x0F, 0xCE, 0x1F, 0x8E,
  0x3F, 0x1C, 0x7E, 0x1C, 0xFC, 0x39, 0xF8, 0x3B, 0xF0, 0x77, 0xE0, 0x7F,
  0xC0, 0xFF, 0x80, 0xFF, 0x01, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x07, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xC3, 0x80, 0xF3,
  0xC0, 0x39, 0xC0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0x70,
  0x03, 0xB8, 0x03, 0xDE, 0x01, 0xC7, 0x01, 0xE3, 0xE1, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x07, 0xE0, 0xFF, 0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE,
  0x01, 0xDC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0xF7, 0x03, 0xEF, 0xFF, 0x9F, 0xFE, 0x3F, 0xF0, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xC3, 0x80, 0xF3,
  0xC0, 0x39, 0xC0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xB8, 0x03, 0xDE, 0x01, 0xCF, 0x01, 0xE3, 0xE1, 0xE0, 0xFF, 0xF0,
  0x3F, 0xF0, 0x0F, 0xE0, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF0, 0x00, 0x38, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF, 0xF8, 0xE0,
  0x7C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x1E, 0xE0,
  0x1E, 0xE0, 0x1C, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0xFF, 0xE0, 0xE0,
  0xE0, 0xE0, 0x70, 0xE0, 0x78, 0xE0, 0x38, 0xE0, 0x3C, 0xE0, 0x1C, 0xE0,
  0x1E, 0xE0, 0x0E, 0xE0, 0x0F, 0x07, 0xF0, 0x3F, 0xF8, 0xFF, 0xF3, 0xE0,
  0x67, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x3A, 0x00, 0x77, 0x03, 0xFF, 0xFF, 0x9F, 0xFE,
  0x0F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0E, 0xF0, 0x0E, 0xF0, 0x1E, 0x78, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8,
  0x0F, 0xE0, 0x70, 0x00, 0xEE, 0x00, 0x3D, 0xE0, 0x07, 0x3C, 0x00, 0xE3,
  0x80, 0x1C, 0x70, 0x07, 0x8F, 0x00, 0xE1, 0xE0, 0x1C, 0x1C, 0x03, 0x83,
  0x80, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0xF0, 0x1E, 0x1C, 0x01,
  0xC3, 0x80, 0x38, 0xF0, 0x07, 0x1C, 0x00, 0x73, 0x80, 0x0E, 0xF0, 0x01,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1D,
  0xC0, 0x0E, 0xE0, 0x07, 0x70, 0x03, 0xB8, 0xE1, 0xDC, 0x78, 0xEE, 0x3C,
  0x77, 0x3E, 0x3B, 0x9B, 0x9D, 0xCC, 0xCC, 0xEE, 0x66, 0x76, 0x3B, 0x3B,
  0x1D, 0x9F, 0x86, 0xCF, 0x83, 0xE3, 0xC1, 0xF1, 0xE0, 0x78, 0xE0, 0x3C,
  0x70, 0x1E, 0x70, 0x07, 0x9E, 0x01, 0xC3, 0x80, 0xF0, 0xF0, 0x38, 0x1C,
  0x1E, 0x07, 0x87, 0x00, 0xF3, 0x80, 0x1D, 0xE0, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1D, 0xE0, 0x0F, 0x3C, 0x07, 0x87, 0x01, 0xC1, 0xE0, 0xF0, 0x38, 0x38,
  0x0F, 0x1E, 0x01, 0xC7, 0x00, 0x7B, 0xC0, 0x0E, 0x70, 0x01, 0xEF, 0x00,
  0x39, 0xE0, 0x0F, 0x1E, 0x01, 0xE3, 0xC0, 0x38, 0x38, 0x0F, 0x07, 0x81,
  0xC0, 0x78, 0x78, 0x0F, 0x0E, 0x00, 0xF3, 0xC0, 0x1E, 0xF0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x00, 0xE0,
  0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0,
  0x00, 0x38, 0x00, 0x07, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x03, 0x80, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xE0, 0x70, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0x80, 0x07, 0xC0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0E, 0xF0, 0x1E, 0x70, 0x1C, 0x38, 0x38, 0x3C, 0x78,
  0x1C, 0x70, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0x40, 0x04, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x20, 0xE1, 0xC1, 0xC1, 0xC1, 0xC1, 0x00,
  0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF1, 0x81, 0xE0, 0x01, 0xE0, 0x01, 0xC0,
  0x03, 0x87, 0xFF, 0x3F, 0xFE, 0xFF, 0xFD, 0xE0, 0x3F, 0x80, 0x7F, 0x00,
  0xFE, 0x01, 0xDE, 0x03, 0xBF, 0xFF, 0x3F, 0xFE, 0x1F, 0xF8, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xDF, 0x83, 0xFF, 0xC7, 0xFF, 0xCF, 0x87, 0xDC, 0x07,
  0xB8, 0x07, 0x70, 0x0F, 0xE0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xB8, 0x0F, 0x70, 0x3C, 0xFF, 0xF9, 0xFF, 0xC1, 0xFF,
  0x00, 0x03, 0xFC, 0x0F, 0xFE, 0x3F, 0xFE, 0x3E, 0x06, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x7E, 0x02, 0x3F, 0xFE, 0x0F, 0xFF, 0x03,
  0xFC, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x1F, 0xBC, 0x7F, 0xF9, 0xFF, 0xF7,
  0x83, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80,
  0x7F, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xBE, 0x0F, 0x3F, 0xFE,
  0x3F, 0xFC, 0x1F, 0xE0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E,
  0x70, 0x0E, 0xE0, 0x0E, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x7C, 0x04, 0x3F, 0xFC,
  0x1F, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0xF0,
  0x20, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x7F,
  0xFF, 0x3F, 0xFF, 0x9F, 0xFF, 0xC0, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xE0, 0xFF, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7F, 0x00,
  0xFF, 0x01, 0xEF, 0x07, 0xDF, 0xFF, 0x9F, 0xFF, 0x0F, 0xDE, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE6, 0x07, 0xCF, 0xFF, 0x1F, 0xFC, 0x1F, 0xE0, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0xBF, 0x0F, 0xFF, 0x3F, 0xFE, 0xE0, 0x7B, 0x80, 0xEE,
  0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x0F,
  0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC2, 0x03, 0xFE, 0x01, 0xFE, 0x00,
  0xFC, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x7F, 0xF7, 0xFF, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x70, 0x07, 0x00, 0xF4, 0x1E, 0xFF, 0xEF, 0xFC, 0x3F, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0xE0, 0x3C, 0xE0, 0x78,
  0xE0, 0xF0, 0xE3, 0xE0, 0xE7, 0xC0, 0xEF, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0xE7, 0x80, 0xE3, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x78,
  0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x1E, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x03, 0x80, 0x03, 0xC2, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0xFC,
  0x7E, 0x7C, 0xFF, 0xFE, 0xFF, 0xFE, 0xE3, 0xCF, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0x3F, 0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0, 0x3B, 0x80, 0xFE, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x70, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x78, 0x3C, 0xF0, 0x1E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0E, 0x70, 0x1E,
  0x7C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x7F, 0x81, 0xFF, 0xC3,
  0xFF, 0xE7, 0x03, 0xCE, 0x03, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xDC, 0x07, 0xBC, 0x1F,
  0x7F, 0xFC, 0xFF, 0xF1, 0xDF, 0x83, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xE0,
  0x77, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xDE, 0x0F, 0x9F, 0xFF, 0x1F,
  0xFE, 0x1F, 0xBC, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xE7,
  0xFF, 0xBC, 0x06, 0xE0, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0xC0, 0x3F, 0xC0,
  0x3F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1C, 0x00, 0x7C, 0x03, 0xFF, 0xFE,
  0xFF, 0xF0, 0xFF, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x82, 0x07, 0xFE,
  0x03, 0xFE, 0x01, 0xFC, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0xC0, 0xFF, 0x83, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F, 0xC0,
  0xF0, 0x03, 0xB8, 0x01, 0xDC, 0x01, 0xEF, 0x00, 0xE3, 0x80, 0x71, 0xC0,
  0x78, 0xF0, 0x38, 0x38, 0x3C, 0x1C, 0x1C, 0x0F, 0x0E, 0x03, 0x8F, 0x01,
  0xE7, 0x00, 0x77, 0x80, 0x3B, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x06,
  0xE1, 0xC3, 0xB8, 0x70, 0xEE, 0x1E, 0x39, 0xC7, 0x8E, 0x73, 0xE3, 0x9C,
  0xDC, 0xC7, 0x33, 0x31, 0xDC, 0xDC, 0x76, 0x3F, 0x0D, 0x87, 0xC3, 0xC1,
  0xF0, 0xF0, 0x78, 0x3C, 0x0E, 0x06, 0x03, 0x80, 0x70, 0x07, 0x1C, 0x07,
  0x8F, 0x03, 0x83, 0xC3, 0x80, 0xE3, 0x80, 0x7B, 0xC0, 0x1F, 0xC0, 0x07,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xFC, 0x00, 0xE7, 0x00, 0xE3, 0xC0,
  0xF0, 0xE0, 0xF0, 0x38, 0x70, 0x1E, 0x70, 0x07, 0x78, 0x01, 0xC0, 0x70,
  0x07, 0xBC, 0x03, 0xCE, 0x01, 0xC7, 0x00, 0xE3, 0xC0, 0xF0, 0xE0, 0x70,
  0x70, 0x38, 0x3C, 0x1C, 0x0E, 0x1E, 0x07, 0x0E, 0x01, 0xC7, 0x00, 0xE7,
  0x80, 0x7B, 0x80, 0x1D, 0xC0, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3C, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0xF8, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0x80, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x38,
  0x01, 0xE0, 0x0F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFC,
  0x0F, 0xF0, 0x7F, 0xC1, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x3F, 0x00, 0xF8, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F,
  0x00, 0x1C, 0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC, 0x07, 0xF8,
  0x3F, 0xE0, 0x0F, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x00, 0x3F, 0x00,
  0x78, 0x0F, 0xC0, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC3, 0xFE, 0x1F,
  0xE0, 0xFC, 0x00, 0x1E, 0x01, 0x9F, 0xC1, 0xDF, 0xF8, 0xEE, 0x3F, 0xE6,
  0x0F, 0xE3, 0x01, 0xE0,
};

const GFXglyph UbuntuMono_Regular39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 5, 24, 20, 7, -24 },
  { 16, 9, 10, 20, 5, -26 },
  { 28, 17, 24, 20, 1, -24 },
  { 79, 15, 31, 20, 2, -27 },
  { 138, 18, 24, 20, 1, -24 },
  { 192, 17, 24, 20, 1, -24 },
  { 243, 3, 10, 20, 8, -26 },
  { 247, 11, 34, 20, 4, -27 },
  { 294, 11, 34, 20, 4, -27 },
  { 341, 15, 14, 20, 2, -24 },
  { 368, 16, 17, 20, 2, -19 },
  { 402, 8, 10, 20, 6, -5 },
  { 412, 9, 3, 20, 5, -11 },
  { 416, 6, 5, 20, 7, -5 },
  { 420, 14, 33, 20, 3, -27 },
  { 478, 16, 24, 20, 2, -24 },
  { 526, 14, 24, 20, 3, -24 },
  { 568, 15, 24, 20, 2, -24 },
  { 613, 15, 24, 20, 2, -24 },
  { 658, 17, 24, 20, 1, -24 },
  { 709, 14, 24, 20, 3, -24 },
  { 751, 16, 24, 20, 2, -24 },
  { 799, 16, 24, 20, 2, -24 },
  { 847, 16, 24, 20, 2, -24 },
  { 895, 15, 24, 20, 2, -24 },
  { 940, 6, 18, 20, 7, -18 },
  { 954, 8, 23, 20, 5, -18 },
  { 977, 16, 15, 20, 2, -17 },
  { 1007, 16, 11, 20, 2, -16 },
  { 1029, 16, 15, 20, 2, -17 },
  { 1059, 12, 24, 20, 4, -24 },
  { 1095, 16, 29, 20, 2, -24 },
  { 1153, 19, 24, 20, 0, -24 },
  { 1210, 16, 24, 20, 2, -24 },
  { 1258, 16, 24, 20, 2, -24 },
  { 1306, 16, 24, 20, 2, -24 },
  { 1354, 14, 24, 20, 4, -24 },
  { 1396, 13, 24, 20, 4, -24 },
  { 1435, 16, 24, 20, 2, -24 },
  { 1483, 16, 24, 20, 2, -24 },
  { 1531, 13, 24, 20, 3, -24 },
  { 1570, 14, 24, 20, 2, -24 },
  { 1612, 17, 24, 20, 2, -24 },
  { 1663, 14, 24, 20, 4, -24 },
  { 1705, 17, 24, 20, 1, -24 },
  { 1756, 15, 24, 20, 2, -24 },
  { 1801, 17, 24, 20, 1, -24 },
  { 1852, 15, 24, 20, 3, -24 },
  { 1897, 17, 30, 20, 1, -24 },
  { 1961, 16, 24, 20, 2, -24 },
  { 2009, 15, 24, 20, 2, -24 },
  { 2054, 16, 24, 20, 2, -24 },
  { 2102, 16, 24, 20, 2, -24 },
  { 2150, 19, 24, 20, 0, -24 },
  { 2207, 17, 24, 20, 1, -24 },
  { 2258, 18, 24, 20, 1, -24 },
  { 2312, 19, 24, 20, 0, -24 },
  { 2369, 16, 24, 20, 2, -24 },
  { 2417, 9, 33, 20, 6, -27 },
  { 2455, 14, 33, 20, 3, -27 },
  { 2513, 9, 33, 20, 5, -27 },
  { 2551, 16, 13, 20, 2, -24 },
  { 2577, 19, 3, 20, 0, 4 },
  { 2585, 7, 7, 20, 6, -27 },
  { 2592, 15, 18, 20, 2, -18 },
  { 2626, 15, 27, 20, 3, -27 },
  { 2677, 16, 18, 20, 2, -18 },
  { 2713, 15, 27, 20, 2, -27 },
  { 2764, 16, 18, 20, 2, -18 },
  { 2800, 17, 27, 20, 2, -27 },
  { 2858, 15, 24, 20, 2, -18 },
  { 2903, 14, 27, 20, 3, -27 },
  { 2951, 16, 25, 20, 2, -25 },
  { 3001, 12, 31, 20, 3, -25 },
  { 3048, 16, 27, 20, 3, -27 },
  { 3102, 16, 27, 20, 2, -27 },
  { 3156, 16, 18, 20, 2, -18 },
  { 3192, 14, 18, 20, 3, -18 },
  { 3224, 16, 18, 20, 2, -18 },
  { 3260, 15, 24, 20, 3, -18 },
  { 3305, 15, 24, 20, 2, -18 },
  { 3350, 13, 18, 20, 4, -18 },
  { 3380, 14, 18, 20, 3, -18 },
  { 3412, 16, 24, 20, 2, -24 },
  { 3460, 14, 18, 20, 3, -18 },
  { 3492, 17, 18, 20, 1, -18 },
  { 3531, 18, 18, 20, 1, -18 },
  { 3572, 17, 18, 20, 1, -18 },
  { 3611, 17, 24, 20, 1, -18 },
  { 3662, 14, 18, 20, 3, -18 },
  { 3694, 14, 33, 20, 3, -27 },
  { 3752, 3, 33, 20, 8, -27 },
  { 3765, 13, 33, 20, 3, -27 },
  { 3819, 17, 6, 20, 1, -13 },
};

const GFXfont UbuntuMono_Regular39pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular39pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular39pt7bGlyphs,
  0x20, 0x7E, 39
};

#endif // _UBUNTUMONO_REGULAR39PT7B_H_
