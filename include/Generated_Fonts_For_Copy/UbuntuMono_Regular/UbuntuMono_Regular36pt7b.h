#ifndef _UBUNTUMONO_REGULAR36PT7B_H_
#define _UBUNTUMONO_REGULAR36PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 36pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular36pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0x66, 0x66, 0x00, 0x0E, 0xFF, 0xFE,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x07, 0x0E, 0x07,
  0x0E, 0x07, 0x0C, 0x07, 0x1C, 0x06, 0x1C, 0x0E, 0x1C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x30, 0x1C,
  0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x70, 0x38, 0x60, 0x30,
  0xE0, 0x70, 0xE0, 0x70, 0xE0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x0F, 0xE0, 0xFF, 0xE7, 0xFF, 0x9E, 0x04, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1F, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x40, 0x3F, 0xFF, 0xEF, 0xFF, 0x0F, 0xF0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x38, 0x07, 0x7E, 0x06, 0xE6, 0x0E,
  0xC6, 0x1C, 0xC6, 0x18, 0xC7, 0x38, 0xC6, 0x30, 0xC6, 0x60, 0xE6, 0xE0,
  0x7E, 0xC0, 0x3D, 0xC0, 0x03, 0x9C, 0x03, 0x7E, 0x07, 0x67, 0x06, 0x63,
  0x0C, 0x63, 0x1C, 0x63, 0x18, 0x63, 0x38, 0x63, 0x70, 0x67, 0x60, 0x7E,
  0xE0, 0x3C, 0x07, 0xC0, 0x1F, 0xE0, 0x3F, 0xF0, 0x3C, 0x70, 0x38, 0x70,
  0x38, 0x70, 0x38, 0x70, 0x38, 0xE0, 0x1D, 0xC0, 0x1F, 0x80, 0x1F, 0x0E,
  0x3F, 0x8E, 0x73, 0xCC, 0x71, 0xEC, 0xE0, 0xFC, 0xE0, 0x78, 0xE0, 0x38,
  0xF0, 0x7C, 0xF8, 0xFC, 0x7F, 0xEE, 0x3F, 0xCE, 0x1F, 0x07, 0xFF, 0xFE,
  0x66, 0x66, 0x66, 0x00, 0x80, 0xE0, 0x7C, 0x3C, 0x0E, 0x07, 0x03, 0xC0,
  0xE0, 0x70, 0x1C, 0x07, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0x80, 0x70, 0x1C, 0x07, 0x80, 0xE0, 0x3C, 0x07, 0x80,
  0xE0, 0x3C, 0x07, 0x80, 0xE0, 0x08, 0x40, 0x1C, 0x0F, 0x80, 0xE0, 0x1C,
  0x07, 0x80, 0xF0, 0x1C, 0x07, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x03, 0x80, 0xE0, 0x78, 0x1C,
  0x0F, 0x03, 0x81, 0xC0, 0xF0, 0xF8, 0x1C, 0x04, 0x00, 0x07, 0x80, 0x0E,
  0x00, 0x30, 0x10, 0xC2, 0x73, 0x3B, 0xFF, 0xF3, 0xFF, 0x01, 0xE0, 0x0F,
  0xC0, 0x73, 0x83, 0xCF, 0x0E, 0x1C, 0x08, 0x40, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x1E, 0x3E, 0x3F, 0x3F, 0x1E, 0x0E, 0x0E, 0x3C, 0xF8, 0x60,
  0xFF, 0xFF, 0xFF, 0x79, 0xEF, 0xDE, 0x78, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xE0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0xC0,
  0xFE, 0x01, 0xF8, 0x07, 0xE3, 0x1F, 0x9E, 0x7E, 0x79, 0xF9, 0xE7, 0xE3,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x3D, 0xC0, 0xE7, 0x87, 0x8F,
  0xFC, 0x1F, 0xE0, 0x3F, 0x00, 0x03, 0x80, 0x3C, 0x03, 0xE0, 0x3F, 0x07,
  0xB8, 0x79, 0xC3, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x0F, 0xC0, 0xFF, 0x8F, 0xFF, 0x1C, 0x3E,
  0x40, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x30, 0x01, 0xC0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0xC0,
  0x07, 0x00, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF, 0xF0, 0x1F, 0x81, 0xFF, 0x87,
  0xFF, 0x18, 0x3E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0xF0,
  0x3F, 0x80, 0xFE, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xF4, 0x07, 0xBF, 0xFE, 0xFF, 0xF0, 0xFE, 0x00, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xB8, 0x07, 0x38, 0x07,
  0x38, 0x0E, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x38, 0x38, 0x70, 0x38, 0x60,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x38, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x1F, 0xF8, 0xFF, 0xE3, 0xFF,
  0x8E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x3F, 0x00, 0xFF,
  0x83, 0xFF, 0x00, 0x7E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0xF4, 0x07, 0x9F, 0xFE, 0xFF, 0xF0, 0xFE, 0x00, 0x00, 0x78,
  0x0F, 0xE0, 0xFF, 0x87, 0xE0, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00,
  0xEF, 0xC3, 0xFF, 0xCF, 0xFF, 0xBC, 0x1F, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1D, 0xC0, 0xF7, 0x87, 0x8F, 0xFE, 0x1F, 0xF0, 0x3F,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x03, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0x0F, 0xC0, 0xFF, 0xC7, 0xFF, 0x9E, 0x1E, 0xF0,
  0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x0E, 0x78, 0x79, 0xFF, 0xC3, 0xFE, 0x07,
  0xFC, 0x38, 0xF9, 0xC0, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F,
  0x03, 0xDF, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFF, 0x87, 0xFF,
  0x1E, 0x1E, 0xF0, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7F, 0x83, 0xDF, 0xFF, 0x3F, 0xFC, 0x3F, 0x70, 0x03, 0x80, 0x0E, 0x00,
  0x78, 0x03, 0xC0, 0x7E, 0x1F, 0xF0, 0x7F, 0x01, 0xF0, 0x00, 0x79, 0xEF,
  0xDE, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xEF, 0xDE, 0x78, 0x1E,
  0x1E, 0x3F, 0x1E, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x1E, 0x3F, 0x1F, 0x1F, 0x0E, 0x0E, 0x3C, 0x78, 0x60, 0x00, 0x04, 0x00,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0x81, 0xF8, 0x0F, 0x80, 0x38, 0x00, 0xF8,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07,
  0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x00, 0x7C, 0x07, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x0C, 0x00, 0x00, 0x3F, 0x8F, 0xFC,
  0x7F, 0xE4, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x60, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x0E, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0,
  0x1E, 0x01, 0xF0, 0x1E, 0x00, 0xE0, 0x03, 0xF0, 0x07, 0xF8, 0x1F, 0xFC,
  0x1E, 0x1E, 0x3C, 0x0E, 0x38, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x7F,
  0x71, 0xFF, 0x63, 0xFF, 0xE3, 0xC7, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87,
  0xE3, 0x87, 0x73, 0xC7, 0x71, 0xFF, 0x71, 0xFF, 0x70, 0x7E, 0x38, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFC, 0x07, 0xFC, 0x01, 0xFC,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0x38, 0x01,
  0xCE, 0x00, 0x73, 0x80, 0x18, 0x70, 0x0E, 0x1C, 0x03, 0x87, 0x00, 0xC0,
  0xC0, 0x70, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x83, 0xFF, 0xF0, 0xFF, 0xFC,
  0x3F, 0xFF, 0x0E, 0x01, 0xC7, 0x00, 0x39, 0xC0, 0x0E, 0x70, 0x03, 0xB8,
  0x00, 0xF0, 0xFF, 0x83, 0xFF, 0x8F, 0xFF, 0x38, 0x3E, 0xE0, 0x3B, 0x80,
  0xEE, 0x03, 0xB8, 0x0E, 0xE0, 0xF3, 0xFF, 0x8F, 0xFE, 0x3F, 0xFC, 0xE0,
  0x7B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x07, 0xFF,
  0xFE, 0xFF, 0xF3, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0xF8, 0x7F, 0xF1, 0xF0,
  0x67, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF8, 0x31, 0xFF, 0xE0, 0xFF, 0xE0, 0x7E, 0x00, 0xFF,
  0x01, 0xFF, 0x83, 0xFF, 0xC7, 0x07, 0x8E, 0x07, 0x9C, 0x07, 0xB8, 0x07,
  0x70, 0x0E, 0xE0, 0x1D, 0xC0, 0x3B, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xFC,
  0x03, 0xB8, 0x07, 0x70, 0x0E, 0xE0, 0x3D, 0xC0, 0xF3, 0x83, 0xE7, 0xFF,
  0x8F, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0xFB, 0xFF, 0xEF, 0xFF, 0xB8, 0x00,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xFF, 0xCF, 0xFF,
  0x3F, 0xFC, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0xFF,
  0xBF, 0xFD, 0xFF, 0xEE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x3F, 0xF1,
  0xFF, 0xCF, 0x83, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07,
  0x70, 0x1D, 0xE0, 0x73, 0xC1, 0xCF, 0xFF, 0x0F, 0xFC, 0x1F, 0xE0, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x70, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xF8, 0xFF, 0xC7, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x3A, 0x03, 0xF8, 0x3D, 0xFF, 0xE7, 0xFE, 0x0F, 0xC0, 0xE0,
  0x1E, 0xE0, 0x3C, 0xE0, 0x38, 0xE0, 0x70, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3,
  0xC0, 0xE3, 0x80, 0xE7, 0x00, 0xEE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0xEF,
  0x80, 0xE3, 0xC0, 0xE1, 0xE0, 0xE0, 0xF0, 0xE0, 0x70, 0xE0, 0x78, 0xE0,
  0x3C, 0xE0, 0x1C, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x03, 0x80, 0x0E, 0x00,
  0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x38, 0x1C,
  0x38, 0x1C, 0x78, 0x1E, 0x7C, 0x3E, 0x6C, 0x36, 0x6C, 0x36, 0x6E, 0x76,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6,
  0x61, 0x86, 0xE0, 0x06, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x01, 0xFE,
  0x07, 0xF8, 0x1F, 0xF0, 0x7E, 0xE1, 0xFB, 0x87, 0xE7, 0x1F, 0x9C, 0x7E,
  0x39, 0xF8, 0xE7, 0xE1, 0x9F, 0x87, 0x7E, 0x0D, 0xF8, 0x3F, 0xE0, 0x7F,
  0x81, 0xFE, 0x07, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x70, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0E, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC1, 0xFE,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x3F, 0xFF,
  0xEF, 0xFE, 0x7F, 0xC3, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x3C,
  0x3C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x3F, 0xFC, 0x1F, 0xF8, 0x07,
  0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3E, 0x00,
  0x0E, 0xFF, 0x81, 0xFF, 0xC3, 0xFF, 0xC7, 0x07, 0xCE, 0x03, 0x9C, 0x07,
  0x38, 0x0E, 0x70, 0x1E, 0xE0, 0x39, 0xC0, 0x73, 0x83, 0xE7, 0xFF, 0x8F,
  0xFE, 0x1F, 0xF8, 0x38, 0x70, 0x70, 0x70, 0xE0, 0x71, 0xC0, 0xE3, 0x80,
  0xE7, 0x01, 0xCE, 0x01, 0xDC, 0x03, 0x80, 0x0F, 0xE0, 0xFF, 0xE7, 0xFF,
  0x9E, 0x04, 0x70, 0x01, 0x80, 0x07, 0x00, 0x1C, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x74, 0x07, 0xFF, 0xFE, 0xFF, 0xF0, 0x7F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0xC0, 0xF7, 0x87, 0x9F, 0xFE, 0x3F, 0xF0, 0x3F, 0x00, 0x70, 0x03, 0x9C,
  0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0x80,
  0x70, 0xF0, 0x1C, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x38, 0x70,
  0x0E, 0x1C, 0x03, 0x87, 0x00, 0x73, 0x80, 0x1C, 0xE0, 0x07, 0x38, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x06, 0x61, 0x86, 0x63, 0xC6, 0x63, 0xC6, 0x63, 0xC6, 0x66,
  0x66, 0x66, 0x66, 0x66, 0x66, 0x6E, 0x76, 0x6C, 0x36, 0x6C, 0x36, 0x7C,
  0x3E, 0x78, 0x1C, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0F, 0x70, 0x0E, 0x38,
  0x1C, 0x3C, 0x1C, 0x1C, 0x38, 0x1E, 0x78, 0x0E, 0x70, 0x07, 0xE0, 0x07,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E,
  0x70, 0x1E, 0x78, 0x1C, 0x38, 0x3C, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x70,
  0x0E, 0xE0, 0x07, 0x70, 0x03, 0x9C, 0x00, 0xE7, 0x80, 0x78, 0xE0, 0x1C,
  0x3C, 0x0F, 0x07, 0x03, 0x81, 0xE1, 0xE0, 0x38, 0x70, 0x0F, 0x3C, 0x01,
  0xCE, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0E,
  0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80,
  0x00, 0xE0, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x78,
  0x01, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0E, 0x00, 0x38, 0x01, 0xC0,
  0x07, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0,
  0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFE, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x3F, 0xFF, 0xFE, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x0E, 0x70, 0x1E, 0x70, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70,
  0x0E, 0x70, 0x0E, 0x20, 0x04, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x43, 0x87, 0x0E, 0x1C, 0x20, 0x1F, 0xC0, 0xFF, 0xC3, 0xFF, 0x88, 0x1E,
  0x00, 0x38, 0x00, 0x70, 0xFF, 0xCF, 0xFF, 0x78, 0x1F, 0xC0, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x77, 0xFF, 0xCF, 0xFF, 0x0F, 0xF8, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xEF, 0x83, 0xFF, 0x8F, 0xFF, 0x3C, 0x3C, 0xE0, 0x7B, 0x80, 0xEE,
  0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xB8, 0x0E, 0xE0, 0x7B,
  0x83, 0xCF, 0xFF, 0x3F, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xF3, 0xFF,
  0xDF, 0x02, 0x70, 0x03, 0xC0, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xF0, 0x13, 0xFF, 0xC7, 0xFF, 0x07,
  0xF8, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x07, 0xDC, 0x7F, 0xF3, 0xFF, 0xCF, 0x0F, 0x78, 0x1D,
  0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07,
  0x78, 0x1C, 0xF0, 0x73, 0xFF, 0xC7, 0xFF, 0x07, 0xF8, 0x03, 0xE0, 0x1F,
  0xF0, 0x7F, 0xF1, 0xE1, 0xF7, 0x80, 0xEE, 0x01, 0xDC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x8F,
  0xFF, 0x07, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x07, 0xFC, 0x1F, 0xF8, 0x78,
  0x30, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0xFF, 0xF9, 0xFF, 0xF3,
  0xFF, 0xE0, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x07, 0xF8, 0x7F, 0xF3, 0xFF, 0xCF, 0x07, 0x78,
  0x1D, 0xC0, 0x77, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC,
  0x07, 0x7C, 0x3C, 0xFF, 0xF1, 0xFF, 0xC1, 0xF7, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC8, 0x1F, 0x3F, 0xF9, 0xFF, 0xC1, 0xFC, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFF, 0x87,
  0xFF, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x07, 0xE0,
  0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07,
  0xE0, 0x38, 0x0E, 0x00, 0x7C, 0x01, 0xF0, 0x03, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x03, 0xFC, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x84, 0x1F, 0xF0, 0x3F, 0xC0, 0x7E, 0x01, 0xC0, 0x78, 0x0F,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x7F, 0xEF, 0xFC, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1F, 0x07, 0x7F, 0xEF, 0xF8,
  0x7E, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x3B, 0x81, 0xCE, 0x0E, 0x38, 0x70, 0xE7,
  0x83, 0xBC, 0x0F, 0xE0, 0x3F, 0x00, 0xFC, 0x03, 0xF8, 0x0E, 0x70, 0x38,
  0xF0, 0xE1, 0xE3, 0x83, 0x8E, 0x07, 0x38, 0x0E, 0xE0, 0x3C, 0xFF, 0x03,
  0xFC, 0x0F, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x10, 0x7F, 0xC0, 0xFF, 0x01, 0xF8, 0x7E, 0x78, 0xFF, 0xFE, 0xFF, 0xFE,
  0xE3, 0xCF, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87, 0xE1, 0x87,
  0xE1, 0x87, 0xE1, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0x7F, 0x87, 0xFF, 0x3F, 0xF9, 0xC1, 0xEE, 0x07,
  0x70, 0x3B, 0x81, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x38, 0x07, 0xE0, 0x1F, 0xF8,
  0x3F, 0xFC, 0x3C, 0x3C, 0x78, 0x1E, 0x70, 0x0E, 0x70, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C,
  0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x7F, 0x83, 0xFF, 0x0F, 0xFF, 0x38,
  0x3C, 0xE0, 0x7B, 0x80, 0xEE, 0x03, 0xB8, 0x0F, 0xE0, 0x3F, 0x80, 0xFE,
  0x03, 0xB8, 0x0E, 0xE0, 0x7B, 0xC3, 0xCF, 0xFF, 0x3F, 0xF8, 0xFF, 0x83,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xF3, 0xFF, 0xCF, 0x07, 0x78, 0x1D, 0xC0, 0x77, 0x01, 0xFC,
  0x07, 0xF0, 0x1F, 0xC0, 0x77, 0x01, 0xDC, 0x07, 0x78, 0x1C, 0xF0, 0xF3,
  0xFF, 0xC7, 0xFF, 0x07, 0xDC, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xEE, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x00, 0x0F, 0xF0, 0xFF, 0xE7, 0xFF, 0x9C,
  0x04, 0x70, 0x01, 0xC0, 0x07, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0xC0,
  0x0F, 0x80, 0x0F, 0x00, 0x1D, 0x80, 0xE7, 0xFF, 0xBF, 0xFC, 0x3F, 0xC0,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x43, 0xFF, 0x07,
  0xFC, 0x07, 0xE0, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xFC, 0x0E, 0xE0, 0x77, 0x03,
  0xBC, 0x1C, 0xFF, 0xE7, 0xFF, 0x0F, 0xF0, 0xE0, 0x07, 0xF0, 0x0E, 0x70,
  0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x38, 0x1C, 0x38, 0x1C, 0x3C, 0x38, 0x1C,
  0x38, 0x1C, 0x38, 0x0E, 0x70, 0x0E, 0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE1, 0x87, 0xE1, 0xC7, 0xE3, 0xC7, 0x63, 0xC6, 0x63, 0xC6, 0x66,
  0x66, 0x76, 0x6E, 0x76, 0x6E, 0x7C, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x38,
  0x1C, 0x38, 0x1C, 0x70, 0x0E, 0x78, 0x1C, 0x38, 0x3C, 0x1C, 0x38, 0x0E,
  0x70, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07,
  0xE0, 0x0E, 0x70, 0x1C, 0x38, 0x38, 0x1C, 0x38, 0x1C, 0x70, 0x0E, 0xE0,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x0E, 0x38, 0x0E, 0x38, 0x1C, 0x3C,
  0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0E, 0x38, 0x0E, 0x38, 0x0E, 0x38, 0x07,
  0x70, 0x07, 0x70, 0x03, 0xF0, 0x03, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x7F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3C, 0x03, 0x80, 0x70, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x03, 0xF0, 0x7F, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x0F,
  0x80, 0xF8, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x7F, 0x03, 0xF0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x0F, 0xE0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80, 0x1F, 0x01, 0xF0, 0x38, 0x03,
  0x80, 0x30, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x0F, 0xE0, 0xFC, 0x00, 0x1E, 0x06, 0x3F, 0x07, 0x7F,
  0xC6, 0x63, 0xFE, 0xE0, 0xFC, 0x60, 0x78,
};

const GFXglyph UbuntuMono_Regular36pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 4, 22, 18, 7, -22 },
  { 12, 8, 9, 18, 5, -24 },
  { 21, 16, 22, 18, 1, -22 },
  { 65, 14, 28, 18, 2, -25 },
  { 114, 16, 22, 18, 1, -22 },
  { 158, 16, 22, 18, 1, -22 },
  { 202, 4, 10, 18, 7, -24 },
  { 207, 10, 31, 18, 4, -25 },
  { 246, 10, 31, 18, 4, -25 },
  { 285, 14, 13, 18, 2, -22 },
  { 308, 14, 17, 18, 2, -18 },
  { 338, 8, 10, 18, 5, -5 },
  { 348, 8, 3, 18, 5, -11 },
  { 351, 6, 5, 18, 6, -5 },
  { 355, 14, 31, 18, 2, -25 },
  { 410, 14, 22, 18, 2, -22 },
  { 449, 13, 22, 18, 3, -22 },
  { 485, 14, 22, 18, 2, -22 },
  { 524, 14, 22, 18, 2, -22 },
  { 563, 16, 22, 18, 1, -22 },
  { 607, 14, 22, 18, 2, -22 },
  { 646, 14, 22, 18, 2, -22 },
  { 685, 14, 22, 18, 2, -22 },
  { 724, 14, 22, 18, 2, -22 },
  { 763, 14, 22, 18, 2, -22 },
  { 802, 6, 17, 18, 6, -17 },
  { 815, 8, 22, 18, 4, -17 },
  { 837, 14, 15, 18, 2, -17 },
  { 864, 14, 10, 18, 2, -14 },
  { 882, 14, 15, 18, 2, -17 },
  { 909, 12, 22, 18, 3, -22 },
  { 942, 16, 27, 18, 1, -22 },
  { 996, 18, 22, 18, 0, -22 },
  { 1046, 14, 22, 18, 2, -22 },
  { 1085, 15, 22, 18, 2, -22 },
  { 1127, 15, 22, 18, 2, -22 },
  { 1169, 14, 22, 18, 3, -22 },
  { 1208, 13, 22, 18, 3, -22 },
  { 1244, 14, 22, 18, 2, -22 },
  { 1283, 14, 22, 18, 2, -22 },
  { 1322, 12, 22, 18, 3, -22 },
  { 1355, 13, 22, 18, 2, -22 },
  { 1391, 16, 22, 18, 2, -22 },
  { 1435, 14, 22, 18, 3, -22 },
  { 1474, 16, 22, 18, 1, -22 },
  { 1518, 14, 22, 18, 2, -22 },
  { 1557, 16, 22, 18, 1, -22 },
  { 1601, 13, 22, 18, 3, -22 },
  { 1637, 16, 28, 18, 1, -22 },
  { 1693, 15, 22, 18, 2, -22 },
  { 1735, 14, 22, 18, 2, -22 },
  { 1774, 16, 22, 18, 1, -22 },
  { 1818, 14, 22, 18, 2, -22 },
  { 1857, 18, 22, 18, 0, -22 },
  { 1907, 16, 22, 18, 1, -22 },
  { 1951, 16, 22, 18, 1, -22 },
  { 1995, 18, 22, 18, 0, -22 },
  { 2045, 14, 22, 18, 2, -22 },
  { 2084, 9, 31, 18, 5, -25 },
  { 2119, 12, 31, 18, 3, -25 },
  { 2166, 9, 31, 18, 4, -25 },
  { 2201, 16, 12, 18, 1, -22 },
  { 2225, 18, 3, 18, 0, 3 },
  { 2232, 6, 6, 18, 6, -25 },
  { 2237, 14, 17, 18, 2, -17 },
  { 2267, 14, 25, 18, 3, -25 },
  { 2311, 14, 17, 18, 2, -17 },
  { 2341, 14, 25, 18, 1, -25 },
  { 2385, 15, 17, 18, 1, -17 },
  { 2417, 15, 25, 18, 2, -25 },
  { 2464, 14, 23, 18, 1, -17 },
  { 2505, 13, 25, 18, 3, -25 },
  { 2546, 14, 24, 18, 2, -24 },
  { 2588, 11, 30, 18, 3, -24 },
  { 2630, 14, 25, 18, 3, -25 },
  { 2674, 14, 25, 18, 2, -25 },
  { 2718, 16, 17, 18, 1, -17 },
  { 2752, 13, 17, 18, 3, -17 },
  { 2780, 16, 17, 18, 1, -17 },
  { 2814, 14, 23, 18, 3, -17 },
  { 2855, 14, 23, 18, 1, -17 },
  { 2896, 12, 17, 18, 4, -17 },
  { 2922, 14, 17, 18, 2, -17 },
  { 2952, 14, 22, 18, 2, -22 },
  { 2991, 13, 17, 18, 2, -17 },
  { 3019, 16, 17, 18, 1, -17 },
  { 3053, 16, 17, 18, 1, -17 },
  { 3087, 16, 17, 18, 1, -17 },
  { 3121, 16, 23, 18, 1, -17 },
  { 3167, 12, 17, 18, 3, -17 },
  { 3193, 12, 31, 18, 3, -25 },
  { 3240, 2, 31, 18, 8, -25 },
  { 3248, 12, 31, 18, 3, -25 },
  { 3295, 16, 6, 18, 1, -13 },
};

const GFXfont UbuntuMono_Regular36pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular36pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular36pt7bGlyphs,
  0x20, 0x7E, 36
};

#endif // _UBUNTUMONO_REGULAR36PT7B_H_
