#ifndef _UBUNTUMONO_REGULAR49PT7B_H_
#define _UBUNTUMONO_REGULAR49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular49pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x9E, 0x38, 0xE3, 0x80, 0x00, 0x00, 0x1E, 0xFF, 0xFF, 0xFF, 0xFD, 0xE0,
  0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0xFF, 0x07, 0x70, 0x77, 0x07,
  0x70, 0x77, 0x07, 0x60, 0x76, 0x06, 0x00, 0xE0, 0x70, 0x07, 0x81, 0xC0,
  0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01, 0xE0, 0xF0, 0x07, 0x03, 0xC0, 0x1C,
  0x0E, 0x00, 0xF0, 0x78, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC1, 0xE0, 0x70, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x01,
  0xC0, 0xF0, 0x07, 0x03, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1, 0xE0, 0xF0, 0x07, 0x83, 0xC0,
  0x1E, 0x0F, 0x00, 0x70, 0x3C, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0x80, 0x3C,
  0x1E, 0x00, 0xF0, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFC, 0x03, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xFF, 0x8F, 0xC0, 0x31, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x01, 0xF4,
  0x00, 0x3F, 0xE0, 0x1F, 0xBF, 0xFF, 0xF7, 0xFF, 0xFC, 0x7F, 0xFE, 0x03,
  0xFF, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x3C, 0x7F, 0x00, 0x71, 0xFF, 0x01, 0xE7, 0x9E,
  0x03, 0x8E, 0x1C, 0x0E, 0x1C, 0x38, 0x3C, 0x38, 0x78, 0x70, 0x70, 0x71,
  0xE0, 0xE1, 0xE3, 0x81, 0xC3, 0x8E, 0x03, 0x87, 0x3C, 0x07, 0x9E, 0x70,
  0x07, 0xF9, 0xC0, 0x07, 0xF7, 0x80, 0x07, 0xCE, 0x00, 0x00, 0x3C, 0xF8,
  0x00, 0x73, 0xF8, 0x01, 0xCF, 0xF8, 0x07, 0x9C, 0xF0, 0x0E, 0x70, 0xE0,
  0x3C, 0xE1, 0xC0, 0xF1, 0xC1, 0xC1, 0xC3, 0x83, 0x87, 0x87, 0x07, 0x0E,
  0x0E, 0x1E, 0x38, 0x1C, 0x38, 0xF0, 0x1C, 0xF1, 0xC0, 0x3F, 0xE7, 0x80,
  0x3F, 0x8E, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF,
  0x80, 0x7F, 0xFC, 0x03, 0xE1, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x81, 0xE0, 0x3C, 0x0E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x3C, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x03, 0x83, 0xFC, 0x1C, 0x3D,
  0xF0, 0xE3, 0xC7, 0xCF, 0x3C, 0x1F, 0x79, 0xE0, 0x7F, 0x8F, 0x01, 0xFC,
  0x78, 0x07, 0xE3, 0xC0, 0x1E, 0x1E, 0x00, 0xF8, 0xF8, 0x0F, 0xC7, 0xE1,
  0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xF9, 0xE3, 0xFF, 0x0F, 0x87, 0xE0, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0x77, 0x70, 0x00, 0x20, 0x03, 0x80, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x0F,
  0x00, 0xF8, 0x07, 0x80, 0x3C, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x70, 0x01, 0x00, 0x40, 0x03, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0,
  0x1E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x03,
  0xE0, 0x3E, 0x01, 0xF0, 0x1F, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x02, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x04, 0x0E,
  0x0C, 0xF1, 0xC7, 0xBF, 0xBB, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0x80, 0x3C,
  0x00, 0x0F, 0xC0, 0x03, 0xDC, 0x00, 0xFB, 0xC0, 0x1E, 0x7C, 0x07, 0xC7,
  0xC1, 0xF0, 0xF8, 0x1E, 0x0E, 0x00, 0x80, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x07, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0F, 0x07,
  0x83, 0xE3, 0xF3, 0xF8, 0x7C, 0x18, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x0F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x0F, 0xC3, 0xE0, 0x3E, 0x3C, 0x03,
  0xE7, 0xC0, 0x1E, 0x78, 0x01, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xFF, 0x87,
  0x0F, 0xF0, 0xF8, 0xFF, 0x0F, 0x8F, 0xF0, 0xF8, 0xFF, 0x0F, 0x8F, 0xF0,
  0x70, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0x80, 0x1F, 0x7C, 0x01, 0xE3, 0xC0, 0x3E, 0x3E, 0x03, 0xE3, 0xF0, 0xFC,
  0x1F, 0xFF, 0x80, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x1F, 0x80, 0x00, 0xF0,
  0x00, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x83, 0xF3,
  0xC1, 0xF1, 0xE0, 0x40, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x0F, 0xFF, 0xF7, 0xFF, 0xFB,
  0xFF, 0xFC, 0x07, 0xF0, 0x03, 0xFF, 0x81, 0xFF, 0xFC, 0x7F, 0xFF, 0x8F,
  0xC1, 0xF8, 0xE0, 0x1F, 0x10, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x07, 0xF0, 0x07, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0xFF, 0x87,
  0x81, 0xF8, 0x40, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFF, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00,
  0x07, 0xCC, 0x03, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF0, 0x03,
  0xC7, 0x80, 0x1C, 0x3C, 0x01, 0xE1, 0xE0, 0x1E, 0x0F, 0x00, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x78, 0x07, 0x83, 0x80,
  0x3C, 0x3C, 0x01, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x1F, 0xFF, 0xC3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x1F,
  0xF0, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xFF, 0xC0, 0x03, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xCC, 0x03, 0xF9, 0xFF,
  0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x0F, 0x80,
  0x0F, 0xF0, 0x07, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x79,
  0xFC, 0x0F, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE7, 0xE0, 0x7E, 0xF0,
  0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x1F, 0x7C, 0x07, 0xCF, 0xC1, 0xF8, 0xFF,
  0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0x81, 0xFF, 0xFC, 0x3F, 0x07, 0xE3, 0xC0, 0x3E,
  0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x7C, 0x01,
  0xE3, 0xE0, 0x3C, 0x3F, 0x8F, 0x81, 0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F,
  0xF8, 0x1F, 0x7F, 0xC3, 0xE0, 0xFE, 0x3C, 0x03, 0xE7, 0x80, 0x1F, 0x78,
  0x00, 0xF7, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x01, 0xF7,
  0xE0, 0x7E, 0x3F, 0xFF, 0xE1, 0xFF, 0xFC, 0x0F, 0xFF, 0x80, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x3F, 0x0F,
  0xC7, 0xC0, 0x3E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xFF, 0x80,
  0x0F, 0x78, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x7E,
  0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFD, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x3F, 0x00, 0x1F, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xE0,
  0x03, 0xE0, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x79, 0xFB, 0xFF, 0xFF, 0xFF, 0x9E, 0x00,
  0x0F, 0x07, 0xE1, 0xFC, 0x7F, 0x1F, 0xC7, 0xE0, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x07, 0xE1, 0xFC,
  0x7F, 0x1F, 0xC7, 0xF0, 0xFC, 0x0E, 0x07, 0x83, 0xC3, 0xF3, 0xF8, 0xF8,
  0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x60, 0x00, 0x07, 0x80,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x00, 0x03, 0xF0,
  0x01, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xF3,
  0xFF, 0xF7, 0xFF, 0xEC, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC1, 0xF8, 0x3F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xC7,
  0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC3, 0xFF, 0xFE, 0x1F, 0x0F, 0xF1,
  0xF0, 0x7F, 0x8F, 0x03, 0xFC, 0x78, 0x1F, 0xE3, 0xC0, 0xFF, 0x1E, 0x07,
  0xF8, 0xF0, 0x3F, 0xC7, 0xC1, 0xFE, 0x1F, 0x0F, 0x78, 0xFF, 0xFB, 0xC3,
  0xFF, 0xDE, 0x0F, 0xFE, 0xF8, 0x1F, 0xC3, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0xFF,
  0xF0, 0x01, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xF7, 0x80, 0x00, 0xE7,
  0x80, 0x01, 0xE7, 0x80, 0x01, 0xE3, 0xC0, 0x01, 0xC3, 0xC0, 0x03, 0xC3,
  0xC0, 0x03, 0xC1, 0xE0, 0x03, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x80,
  0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0x78, 0x0E, 0x00, 0x78, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFC, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x1E, 0x3C, 0x00,
  0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0x78, 0x00,
  0x0F, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01,
  0xF9, 0xE0, 0x0F, 0x3C, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x0F, 0x8F, 0xFF, 0xE1, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC7, 0x80, 0xFC, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x07,
  0xDE, 0x03, 0xFB, 0xFF, 0xFE, 0x7F, 0xFF, 0x8F, 0xFF, 0xE0, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x0F, 0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xE1,
  0xFC, 0x0F, 0x0F, 0x80, 0x10, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x10, 0xFE, 0x07, 0x83, 0xFF, 0xFC,
  0x0F, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0xC0, 0x0F, 0xFF,
  0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xF0, 0x3F, 0x8F, 0x00, 0xF8, 0xF0,
  0x07, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF,
  0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01,
  0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF0, 0x0F, 0x8F, 0x03,
  0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF,
  0xFF, 0x9F, 0xFF, 0xF3, 0xFF, 0xFE, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xFE,
  0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xC0, 0xE1, 0xF0, 0x02, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00, 0xF7,
  0xC0, 0x0F, 0x3C, 0x00, 0xF3, 0xE0, 0x0F, 0x3F, 0x00, 0xF1, 0xFC, 0x0F,
  0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xF0, 0x07, 0xF8, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x40, 0x0F, 0x9C, 0x0F, 0xEF,
  0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0xF0, 0x01, 0xF7,
  0x80, 0x1F, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x0F, 0x00, 0xF8, 0x78, 0x0F,
  0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x07, 0x8F, 0x80, 0x3C,
  0xF8, 0x01, 0xEF, 0xC0, 0x0F, 0x7C, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00,
  0x1E, 0xFC, 0x00, 0xF3, 0xF0, 0x07, 0x8F, 0xC0, 0x3C, 0x3F, 0x01, 0xE0,
  0xF8, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x83, 0xC0, 0x3E, 0x1E, 0x01, 0xF0,
  0xF0, 0x07, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0xF9, 0xE0, 0x03, 0xEF, 0x00,
  0x0F, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x3C, 0x01, 0xE1, 0xE0, 0x1F, 0x1F, 0x00, 0xF8,
  0xFC, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x03, 0xF1, 0xDC, 0x1F, 0xCE, 0xE0,
  0xEE, 0x77, 0x0E, 0x73, 0x9C, 0x73, 0x9C, 0xE3, 0x9C, 0xE7, 0x38, 0xE7,
  0x1D, 0xC7, 0x78, 0xEE, 0x3B, 0xC7, 0xE1, 0xDE, 0x1F, 0x0E, 0xF0, 0xF8,
  0x77, 0x87, 0x83, 0xBC, 0x00, 0x1D, 0xE0, 0x00, 0xEF, 0x00, 0x07, 0x78,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3C, 0xF0,
  0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xFC,
  0x03, 0xFB, 0x80, 0x7F, 0x78, 0x0F, 0xE7, 0x01, 0xFC, 0xF0, 0x3F, 0x8F,
  0x07, 0xF1, 0xE0, 0xFE, 0x1E, 0x1F, 0xC3, 0xC3, 0xF8, 0x38, 0x7F, 0x07,
  0x8F, 0xE0, 0x71, 0xFC, 0x0F, 0x3F, 0x80, 0xE7, 0xF0, 0x1E, 0xFE, 0x01,
  0xDF, 0xC0, 0x3B, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x83,
  0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x79,
  0xE0, 0x01, 0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7,
  0xC0, 0x07, 0x8F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x01, 0xFF,
  0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x01, 0xFF, 0x00, 0xFB, 0xC0, 0x7C, 0xFF, 0xFE,
  0x3F, 0xFF, 0x0F, 0xFE, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFE, 0x00,
  0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0x83, 0xF0, 0xF8, 0x07, 0xC3, 0xC0,
  0x0F, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xF7, 0x80, 0x03,
  0xDE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0, 0x07, 0x8F, 0x00, 0x3E,
  0x3E, 0x01, 0xF0, 0x7E, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x07, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xC0, 0x7F, 0xE0, 0x0F, 0xFF, 0xC0, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0xF0, 0x1F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x07, 0x8F,
  0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0xFF, 0xE0, 0xFF, 0xFC, 0x0F, 0xFF, 0x80,
  0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x03, 0xCF, 0x00,
  0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x03, 0xFC, 0x01, 0xFF, 0xF0, 0x7F,
  0xFF, 0x1F, 0xFF, 0xC7, 0xE0, 0x78, 0xF0, 0x01, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x80, 0x03,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x1F, 0x40, 0x03, 0xDE, 0x01, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF,
  0xC7, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0x80,
  0x1F, 0x7C, 0x03, 0xE3, 0xE0, 0x7E, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0x00, 0x3F, 0xC0, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xE0, 0x00,
  0xF7, 0xC0, 0x01, 0xE7, 0x80, 0x03, 0xCF, 0x00, 0x0F, 0x9F, 0x00, 0x1E,
  0x1E, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x78, 0x01, 0xE0, 0xF8, 0x03, 0xC0,
  0xF0, 0x07, 0x81, 0xE0, 0x1F, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07,
  0x80, 0xF0, 0x0F, 0x03, 0xC0, 0x0F, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xF7,
  0x80, 0x01, 0xEF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xBC, 0x00, 0x1D,
  0xE0, 0x00, 0xEF, 0x0F, 0x07, 0x78, 0x78, 0x3B, 0xC3, 0xE1, 0xDE, 0x3F,
  0x0E, 0xF1, 0xFC, 0x77, 0x8E, 0xE3, 0x9C, 0xE7, 0x1C, 0xE7, 0x3C, 0xE7,
  0x38, 0xE7, 0x3B, 0x87, 0x39, 0xDC, 0x3D, 0xCE, 0xE0, 0xFC, 0x7E, 0x07,
  0xE3, 0xF0, 0x3F, 0x1F, 0x80, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x3E, 0x1E,
  0x00, 0xF0, 0x78, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xE0, 0x0F, 0x07, 0x80,
  0x7C, 0x1F, 0x01, 0xE0, 0x3C, 0x0F, 0x80, 0xF8, 0x3C, 0x01, 0xE1, 0xF0,
  0x03, 0xC7, 0x80, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xF3, 0xE0, 0x07, 0xC7, 0x80,
  0x1E, 0x1F, 0x00, 0xF8, 0x3C, 0x03, 0xC0, 0xF8, 0x1E, 0x01, 0xF0, 0x78,
  0x03, 0xC3, 0xC0, 0x0F, 0x9F, 0x00, 0x1E, 0x78, 0x00, 0x7F, 0xE0, 0x00,
  0xF0, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xF3, 0xE0, 0x03,
  0xC7, 0xC0, 0x07, 0x87, 0x80, 0x1F, 0x0F, 0x80, 0x3C, 0x0F, 0x00, 0xF8,
  0x1F, 0x01, 0xE0, 0x1F, 0x07, 0xC0, 0x3E, 0x0F, 0x00, 0x3E, 0x3C, 0x00,
  0x3C, 0x78, 0x00, 0x7D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x03, 0xEF,
  0x00, 0x1E, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x07, 0x80, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x78, 0x07, 0x87, 0xC0, 0x1E, 0x3C, 0x00, 0xFB, 0xE0, 0x03,
  0xDE, 0x00, 0x1E, 0x20, 0x00, 0x40, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x20, 0x70, 0xF8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x02,
  0x0F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xF0, 0xFF, 0xFE, 0x10, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC1, 0xFF, 0xF1, 0xFF,
  0xFC, 0xFF, 0xFF, 0x7C, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFE, 0x00, 0xFF, 0xC0, 0x3D, 0xFF, 0xFF, 0x7F, 0xFF, 0xC7,
  0xFF, 0xF0, 0x7F, 0xF0, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x9F, 0x80, 0xFF, 0xFE,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xE0, 0xFC, 0xF8, 0x07, 0xCF, 0x80,
  0x3E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x3E, 0xF8, 0x07, 0xCF, 0x81, 0xFC, 0xFF, 0xFF, 0x8F, 0xFF, 0xF0,
  0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0xC0, 0x63, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0xC0, 0x31, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0xFC, 0xF0, 0xFF, 0xFE, 0x3F, 0xFF,
  0xCF, 0xFF, 0xF9, 0xF8, 0x3F, 0x7C, 0x01, 0xEF, 0x00, 0x3F, 0xE0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBE, 0x00, 0xF7, 0xC0, 0x1E,
  0x7E, 0x03, 0xC7, 0xFF, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0x3F, 0xE0,
  0x01, 0xFC, 0x00, 0x7F, 0xF0, 0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0x07,
  0xE7, 0xC0, 0x1F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x41,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xE0, 0x3E, 0x03, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x01, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF3, 0xF0, 0x1E, 0xF8, 0x03, 0xDE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFE, 0x00, 0x7B, 0xC0, 0x0F, 0x7C, 0x01, 0xEF, 0xC0, 0xFC, 0xFF,
  0xFF, 0x8F, 0xFF, 0xF0, 0xFF, 0xFE, 0x07, 0xF3, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0xC0, 0x3F, 0x1F, 0xFF, 0xC7, 0xFF,
  0xF8, 0xFF, 0xFC, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xEF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0xFF, 0xFB, 0xE0, 0x7E, 0xF8, 0x07, 0xFE, 0x01, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x07,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x06, 0x03, 0xFF, 0xC0, 0x3F,
  0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3C, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x70, 0x3E, 0x7F, 0xFE, 0x7F, 0xFC,
  0x7F, 0xF8, 0x0F, 0xE0, 0x38, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x3E, 0xF8, 0x07,
  0xCF, 0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x83, 0xE0, 0xF8, 0x7C, 0x0F, 0x8F,
  0x80, 0xF9, 0xF0, 0x0F, 0xBE, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF,
  0xC0, 0x0F, 0xFE, 0x00, 0xF9, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x7C, 0x0F,
  0x83, 0xE0, 0xF8, 0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x07, 0xCF, 0x80, 0x3E,
  0xF8, 0x01, 0xEF, 0x80, 0x1F, 0xFF, 0xC0, 0x1F, 0xF8, 0x03, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0xC0, 0x7F, 0xF8, 0x07, 0xFF, 0x00, 0xFF, 0xE0,
  0x07, 0xF0, 0x3F, 0x0F, 0x87, 0xFE, 0xFF, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0x0F, 0x8F, 0x78, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x0E, 0x0F, 0xF0,
  0x70, 0x7F, 0x83, 0x83, 0xFC, 0x1C, 0x1F, 0xE0, 0xE0, 0xFF, 0x07, 0x07,
  0xF8, 0x38, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F,
  0xC0, 0x01, 0xE0, 0x1F, 0xF8, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3, 0xFF, 0xFE,
  0xF8, 0x1F, 0xBE, 0x01, 0xFF, 0x80, 0x7F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF8, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3C, 0x01, 0xF8, 0x00, 0x3F, 0xF8,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x83, 0xF0, 0x7E, 0x3E, 0x01, 0xF1, 0xE0,
  0x07, 0xDF, 0x00, 0x1E, 0xF8, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D,
  0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDF, 0x00,
  0x1E, 0x78, 0x01, 0xF3, 0xE0, 0x1F, 0x0F, 0xC1, 0xF8, 0x3F, 0xFF, 0x80,
  0xFF, 0xF8, 0x03, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x1F, 0xF0, 0x0F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0xF8, 0x1F, 0xCF, 0x80, 0x7C, 0xF8,
  0x03, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xEF,
  0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1E, 0xF8, 0x01, 0xEF, 0x80, 0x1E,
  0xF8, 0x03, 0xEF, 0x80, 0x7C, 0xFE, 0x0F, 0xCF, 0xFF, 0xF8, 0xFF, 0xFF,
  0x0F, 0xFF, 0xE0, 0xFB, 0xF8, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0xFC, 0x3F, 0xFF, 0x8F, 0xFF, 0xF3,
  0xF0, 0x1E, 0xFC, 0x03, 0xDF, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x80, 0x3C, 0xFC, 0x1F, 0x9F,
  0xFF, 0xF1, 0xFF, 0xFE, 0x1F, 0xFF, 0xC0, 0xFE, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x07, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0xFE, 0x7C,
  0x01, 0x9E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0x3F, 0xF8, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0xFC,
  0x00, 0x0F, 0x00, 0x03, 0xD0, 0x00, 0xF7, 0x80, 0x7D, 0xFF, 0xFF, 0xFF,
  0xFF, 0x9F, 0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x0C, 0x0F, 0xFF, 0x81, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0xFF, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xF7, 0xE0,
  0x3C, 0xFF, 0xFF, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F, 0xE0, 0x78, 0x00,
  0x3D, 0xE0, 0x01, 0xF7, 0xC0, 0x07, 0x9F, 0x00, 0x1E, 0x3C, 0x00, 0xF8,
  0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x07, 0x80, 0x7C, 0x1E, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x1E,
  0x00, 0x7C, 0x78, 0x00, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00,
  0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3B, 0xC0, 0x00, 0x77, 0x80,
  0x00, 0xEF, 0x00, 0x03, 0xCE, 0x07, 0x07, 0x9C, 0x1E, 0x0F, 0x38, 0x3E,
  0x1E, 0x78, 0x7C, 0x3C, 0xF0, 0xF8, 0x71, 0xE3, 0xF0, 0xE3, 0xC7, 0x71,
  0xC3, 0x8C, 0xE7, 0x87, 0x39, 0xCF, 0x0E, 0x71, 0xDE, 0x1C, 0xC3, 0xB8,
  0x3F, 0x87, 0xF0, 0x7F, 0x07, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x81,
  0xF0, 0x1E, 0x03, 0xC0, 0x3C, 0x07, 0x80, 0x38, 0x00, 0x7C, 0x00, 0x78,
  0xF0, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0xC0, 0x78, 0x0F, 0x83, 0xC0, 0x1E,
  0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xC0, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00,
  0x3E, 0xF0, 0x00, 0xF1, 0xE0, 0x07, 0x87, 0xC0, 0x3C, 0x0F, 0x81, 0xF0,
  0x1E, 0x07, 0x80, 0x7C, 0x3C, 0x00, 0xF9, 0xF0, 0x01, 0xE7, 0x80, 0x07,
  0xC0, 0xF8, 0x00, 0xF3, 0xC0, 0x07, 0x9E, 0x00, 0x3C, 0xF8, 0x03, 0xE3,
  0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x7C, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x1E, 0x1C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x70,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x70, 0x00, 0x07, 0x80, 0x20, 0xF8, 0x01,
  0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0x80, 0xFF, 0xC0, 0xFF, 0xE0, 0x78, 0x00, 0x38, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07,
  0xFF, 0x01, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01,
  0xC0, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xF8,
  0x00, 0xFC, 0x01, 0xFE, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x81, 0xFF, 0x80, 0xFF, 0x80, 0x7F, 0x00, 0x00, 0x0F, 0x00, 0x21,
  0xFE, 0x03, 0xDF, 0xF8, 0x1C, 0xFF, 0xF1, 0xEF, 0x1F, 0xFF, 0x70, 0x3F,
  0xF3, 0x80, 0x7F, 0x0C, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Regular49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 25, 0, -1 },
  { 1, 6, 30, 25, 9, -30 },
  { 24, 12, 12, 25, 6, -33 },
  { 42, 22, 30, 25, 1, -30 },
  { 125, 19, 39, 25, 3, -34 },
  { 218, 23, 30, 25, 1, -30 },
  { 305, 21, 30, 25, 2, -30 },
  { 384, 4, 13, 25, 10, -33 },
  { 391, 13, 42, 25, 6, -34 },
  { 460, 13, 42, 25, 6, -34 },
  { 529, 19, 18, 25, 3, -30 },
  { 572, 20, 21, 25, 2, -23 },
  { 625, 10, 14, 25, 7, -7 },
  { 643, 11, 4, 25, 7, -15 },
  { 649, 7, 7, 25, 9, -7 },
  { 656, 18, 42, 25, 3, -34 },
  { 751, 20, 30, 25, 2, -30 },
  { 826, 17, 30, 25, 4, -30 },
  { 890, 19, 30, 25, 3, -30 },
  { 962, 19, 30, 25, 3, -30 },
  { 1034, 21, 30, 25, 2, -30 },
  { 1113, 19, 30, 25, 3, -30 },
  { 1185, 19, 30, 25, 3, -30 },
  { 1257, 19, 30, 25, 3, -30 },
  { 1329, 20, 30, 25, 2, -30 },
  { 1404, 20, 30, 25, 2, -30 },
  { 1479, 7, 23, 25, 9, -23 },
  { 1500, 10, 30, 25, 6, -23 },
  { 1538, 20, 19, 25, 2, -22 },
  { 1586, 20, 12, 25, 2, -19 },
  { 1616, 20, 19, 25, 2, -22 },
  { 1664, 15, 30, 25, 5, -30 },
  { 1721, 21, 37, 25, 2, -30 },
  { 1819, 24, 30, 25, 0, -30 },
  { 1909, 19, 30, 25, 3, -30 },
  { 1981, 21, 30, 25, 2, -30 },
  { 2060, 20, 30, 25, 3, -30 },
  { 2135, 19, 30, 25, 4, -30 },
  { 2207, 18, 30, 25, 4, -30 },
  { 2275, 20, 30, 25, 2, -30 },
  { 2350, 20, 30, 25, 2, -30 },
  { 2425, 16, 30, 25, 4, -30 },
  { 2485, 18, 30, 25, 3, -30 },
  { 2553, 21, 30, 25, 3, -30 },
  { 2632, 19, 30, 25, 4, -30 },
  { 2704, 21, 30, 25, 2, -30 },
  { 2783, 19, 30, 25, 3, -30 },
  { 2855, 22, 30, 25, 1, -30 },
  { 2938, 18, 30, 25, 4, -30 },
  { 3006, 22, 38, 25, 1, -30 },
  { 3111, 20, 30, 25, 3, -30 },
  { 3186, 19, 30, 25, 3, -30 },
  { 3258, 21, 30, 25, 2, -30 },
  { 3337, 20, 30, 25, 2, -30 },
  { 3412, 23, 30, 25, 1, -30 },
  { 3499, 21, 30, 25, 2, -30 },
  { 3578, 22, 30, 25, 1, -30 },
  { 3661, 23, 30, 25, 1, -30 },
  { 3748, 19, 30, 25, 3, -30 },
  { 3820, 12, 42, 25, 7, -34 },
  { 3883, 18, 42, 25, 3, -34 },
  { 3978, 12, 42, 25, 6, -34 },
  { 4041, 21, 17, 25, 2, -30 },
  { 4086, 24, 3, 25, 0, 5 },
  { 4095, 8, 9, 25, 8, -34 },
  { 4104, 18, 23, 25, 3, -23 },
  { 4156, 20, 34, 25, 3, -34 },
  { 4241, 20, 23, 25, 2, -23 },
  { 4299, 19, 34, 25, 2, -34 },
  { 4380, 20, 23, 25, 2, -23 },
  { 4438, 21, 34, 25, 3, -34 },
  { 4528, 19, 31, 25, 2, -23 },
  { 4602, 18, 34, 25, 3, -34 },
  { 4679, 19, 33, 25, 3, -33 },
  { 4758, 16, 41, 25, 3, -33 },
  { 4840, 20, 34, 25, 3, -34 },
  { 4925, 19, 34, 25, 3, -34 },
  { 5006, 21, 23, 25, 2, -23 },
  { 5067, 18, 23, 25, 3, -23 },
  { 5119, 21, 23, 25, 2, -23 },
  { 5180, 20, 31, 25, 3, -23 },
  { 5258, 19, 31, 25, 2, -23 },
  { 5332, 16, 23, 25, 5, -23 },
  { 5378, 18, 23, 25, 3, -23 },
  { 5430, 19, 30, 25, 3, -30 },
  { 5502, 18, 23, 25, 3, -23 },
  { 5554, 22, 23, 25, 1, -23 },
  { 5618, 23, 23, 25, 1, -23 },
  { 5685, 22, 23, 25, 1, -23 },
  { 5749, 21, 31, 25, 2, -23 },
  { 5831, 17, 23, 25, 4, -23 },
  { 5880, 17, 42, 25, 4, -34 },
  { 5970, 4, 42, 25, 10, -34 },
  { 5991, 17, 42, 25, 4, -34 },
  { 6081, 21, 8, 25, 2, -17 },
};

const GFXfont UbuntuMono_Regular49pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular49pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular49pt7bGlyphs,
  0x20, 0x7E, 49
};

#endif // _UBUNTUMONO_REGULAR49PT7B_H_
