#ifndef _UBUNTUMONO_REGULAR55PT7B_H_
#define _UBUNTUMONO_REGULAR55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular55pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xCF, 0x9F, 0x3E, 0x3C, 0x78, 0xF1, 0xC3, 0x87, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xE7, 0xFF, 0xFF, 0xFF, 0x7E, 0x78, 0xF0, 0x7F, 0x83, 0xFC, 0x1F,
  0xE0, 0xFF, 0x07, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x81, 0xDC,
  0x0E, 0xE0, 0x77, 0x03, 0xB0, 0x1C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F,
  0x00, 0x3E, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81,
  0xE0, 0x03, 0xC0, 0xF0, 0x03, 0xE0, 0x78, 0x01, 0xE0, 0x7C, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E,
  0x07, 0xC0, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x03,
  0xE0, 0x78, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x87, 0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xE0, 0x3C,
  0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07,
  0x80, 0x1F, 0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xF8,
  0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xF0, 0x06, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x90, 0x00, 0x3E, 0x78, 0x03, 0xFB,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x07, 0x8F, 0xF0, 0x03, 0xC7, 0xFE,
  0x00, 0xF1, 0xE7, 0x80, 0x78, 0xF0, 0xE0, 0x3C, 0x3C, 0x3C, 0x0F, 0x0F,
  0x0F, 0x07, 0x83, 0x81, 0xC1, 0xC0, 0xE0, 0x70, 0xF0, 0x38, 0x1C, 0x78,
  0x0F, 0x0F, 0x1E, 0x03, 0xC3, 0xCF, 0x00, 0xF0, 0xE3, 0x80, 0x1E, 0x79,
  0xE0, 0x07, 0xFE, 0xF0, 0x00, 0xFF, 0x3C, 0x00, 0x0F, 0x1E, 0x00, 0x00,
  0x0F, 0x1F, 0x00, 0x03, 0xCF, 0xE0, 0x01, 0xE7, 0xFC, 0x00, 0x7B, 0xC7,
  0x80, 0x3C, 0xF1, 0xE0, 0x1E, 0x38, 0x38, 0x07, 0x8E, 0x0E, 0x03, 0xC3,
  0x83, 0x80, 0xE0, 0xE0, 0xF0, 0x78, 0x38, 0x38, 0x3C, 0x0E, 0x0E, 0x0F,
  0x03, 0x83, 0x87, 0x80, 0xF1, 0xE1, 0xC0, 0x3C, 0x78, 0xF0, 0x07, 0xFC,
  0x78, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0x0F, 0xC0, 0x3E, 0x07,
  0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07,
  0x80, 0x3E, 0x07, 0x80, 0x1E, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x0F, 0xBE,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3C, 0x1F, 0xF0,
  0x3C, 0x3F, 0xF8, 0x3C, 0x3E, 0xFC, 0x3C, 0x7C, 0x7E, 0x78, 0x78, 0x3F,
  0x78, 0xF8, 0x1F, 0xF8, 0xF0, 0x0F, 0xF0, 0xF0, 0x07, 0xF0, 0xF0, 0x03,
  0xF0, 0xF0, 0x01, 0xF0, 0xF8, 0x03, 0xF8, 0xFC, 0x07, 0xF8, 0x7E, 0x1F,
  0xFC, 0x7F, 0xFF, 0x3C, 0x3F, 0xFF, 0x3E, 0x1F, 0xFC, 0x1E, 0x07, 0xF0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0x7B, 0xDE, 0xF7, 0x39, 0xC0, 0x00,
  0x08, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0x00, 0x04, 0x20, 0x00, 0x70, 0x01, 0xF0, 0x07, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0,
  0x07, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7E, 0x01, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x0E, 0x00, 0x10, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x30, 0x3C, 0x09, 0xE1, 0xC3, 0xCF, 0xCE, 0x7F, 0x7F, 0xB7, 0xFF, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00,
  0x1F, 0x7C, 0x01, 0xF9, 0xF0, 0x1F, 0x87, 0xC0, 0xF8, 0x3F, 0x03, 0xC0,
  0xE0, 0x04, 0x06, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x07, 0x81,
  0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x1F, 0xC1, 0xF8, 0x1F, 0x07, 0xC3, 0xFB,
  0xFE, 0x7F, 0x87, 0xC0, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0x07, 0xE0, 0xF8, 0x0F, 0xC7, 0xC0, 0x1F,
  0x1F, 0x00, 0x3E, 0x78, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBE,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC1, 0xC1, 0xFF, 0x0F, 0x87, 0xFC, 0x3F,
  0x1F, 0xF0, 0xFC, 0x7F, 0xC3, 0xF1, 0xFF, 0x0F, 0x87, 0xFC, 0x1C, 0x1F,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E, 0xF8,
  0x00, 0xF9, 0xE0, 0x03, 0xE7, 0xC0, 0x0F, 0x9F, 0x00, 0x7C, 0x3E, 0x03,
  0xF0, 0xFC, 0x1F, 0x81, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xFC, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0xE7, 0xC0, 0x7C,
  0x7C, 0x06, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x03, 0xFC, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFF, 0xC7, 0xE0, 0xFE, 0x38, 0x01, 0xF8, 0x80, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x03, 0xFC,
  0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x83, 0xC0, 0xFE, 0x18,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F,
  0xFE, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF4,
  0x00, 0x1F, 0x3C, 0x03, 0xF9, 0xFF, 0xFF, 0x9F, 0xFF, 0xF8, 0x7F, 0xFF,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x7D,
  0xF0, 0x00, 0x79, 0xF0, 0x00, 0xF1, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xE1,
  0xF0, 0x03, 0xC1, 0xF0, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01,
  0xF0, 0x78, 0x01, 0xF0, 0x78, 0x01, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xFC, 0x03,
  0xFF, 0xF0, 0x3F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xEF, 0x00,
  0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFC, 0x03, 0xFE,
  0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE3,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF3, 0xF8, 0x0F,
  0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7B, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xE0, 0x01, 0xE7, 0xC0,
  0x0F, 0x9F, 0x00, 0x3E, 0x3E, 0x01, 0xF0, 0xFE, 0x0F, 0xC1, 0xFF, 0xFE,
  0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xFE,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xF1, 0xF0, 0x07, 0xC7,
  0xC0, 0x0F, 0x9E, 0x00, 0x3E, 0x78, 0x00, 0x79, 0xE0, 0x03, 0xE7, 0x80,
  0x0F, 0x9F, 0x00, 0x3C, 0x7E, 0x01, 0xF0, 0xFC, 0x0F, 0x83, 0xFC, 0x7C,
  0x07, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x01, 0xF3, 0xFE, 0x0F,
  0x81, 0xFC, 0x7C, 0x01, 0xF9, 0xE0, 0x03, 0xEF, 0x80, 0x07, 0xBC, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1E,
  0xFC, 0x00, 0xF9, 0xFC, 0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xFC, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0x07, 0xE1, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x3E, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xBC,
  0x00, 0x1E, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xDF, 0x00,
  0x1F, 0x7F, 0x01, 0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x03, 0xFC, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x03, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x3F, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x3C, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3C, 0x07, 0x83, 0xF8, 0x7F, 0x8F, 0xF1, 0xFE, 0x3F,
  0x81, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x0F, 0xE1, 0xFE, 0x3F, 0xC7, 0xF8,
  0xFF, 0x0F, 0xE0, 0x78, 0x1F, 0x1F, 0xCF, 0xF1, 0xFC, 0x3F, 0x03, 0x00,
  0x00, 0x00, 0x08, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFF, 0x00,
  0x3F, 0xF8, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xC0,
  0x03, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x40, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xFC,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F,
  0x80, 0x00, 0xF0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xFF,
  0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0x70, 0x3F, 0x90, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x0F, 0xE0, 0xFC, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x3E, 0x1E, 0x00,
  0x1E, 0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x03,
  0xFF, 0x78, 0x0F, 0xFF, 0x78, 0x1F, 0xFF, 0x78, 0x3F, 0xFF, 0xF8, 0x7E,
  0x1F, 0xF8, 0x7C, 0x1F, 0xF8, 0x78, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8,
  0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8, 0x1F, 0xF8, 0xF8,
  0x1F, 0xF8, 0x78, 0x1F, 0x78, 0x7C, 0x1F, 0x78, 0x7E, 0x1F, 0x7C, 0x3F,
  0xFF, 0x7C, 0x1F, 0xFF, 0x7C, 0x0F, 0xFF, 0x3E, 0x03, 0xFC, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF8, 0x08, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xF7, 0xC0,
  0x00, 0x1E, 0x78, 0x00, 0x07, 0x8F, 0x00, 0x00, 0xF1, 0xF0, 0x00, 0x1E,
  0x1E, 0x00, 0x07, 0x83, 0xC0, 0x00, 0xF0, 0x7C, 0x00, 0x1E, 0x07, 0x80,
  0x07, 0x80, 0xF0, 0x00, 0xF0, 0x1F, 0x00, 0x1E, 0x01, 0xE0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0x00,
  0xF0, 0x01, 0xE0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0x03, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1E, 0x1F,
  0x00, 0x03, 0xC3, 0xC0, 0x00, 0x7C, 0x78, 0x00, 0x0F, 0x9F, 0x00, 0x01,
  0xF3, 0xE0, 0x00, 0x1E, 0x78, 0x00, 0x03, 0xEF, 0x00, 0x00, 0x7C, 0x3F,
  0xF8, 0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF0, 0x0F,
  0xE3, 0xC0, 0x0F, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xF3,
  0xC0, 0x03, 0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xC0,
  0x3F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0x8F, 0x00, 0x7F, 0x3C, 0x00, 0x7E, 0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xFF,
  0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x3E, 0xF0, 0x01, 0xFB, 0xC0, 0x1F, 0xCF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F, 0xE0, 0x78, 0x7E,
  0x00, 0x23, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x08, 0x7F, 0x80, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0,
  0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0xF0, 0x1F, 0xC3, 0xC0, 0x1F, 0x8F,
  0x00, 0x3F, 0x3C, 0x00, 0x7C, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00,
  0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xFB, 0xC0, 0x03, 0xEF, 0x00, 0x1F, 0x3C, 0x00, 0xFC,
  0xF0, 0x07, 0xE3, 0xC0, 0x7F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF,
  0xFE, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFE, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF8, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFB, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x0F, 0xE0, 0x78, 0x7E, 0x00, 0x23, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x3D,
  0xF0, 0x00, 0xF7, 0xE0, 0x03, 0xCF, 0xC0, 0x0F, 0x3F, 0x80, 0x3C, 0x7F,
  0x81, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF,
  0x00, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF4, 0x00, 0x3E, 0x70, 0x03, 0xE7, 0xC0, 0xFE, 0xFF,
  0xFF, 0xC7, 0xFF, 0xF8, 0x3F, 0xFF, 0x00, 0x7F, 0x80, 0xF0, 0x00, 0xFD,
  0xE0, 0x03, 0xF3, 0xC0, 0x07, 0xC7, 0x80, 0x1F, 0x0F, 0x00, 0x7E, 0x1E,
  0x01, 0xF8, 0x3C, 0x03, 0xE0, 0x78, 0x0F, 0x80, 0xF0, 0x3E, 0x01, 0xE0,
  0xF8, 0x03, 0xC3, 0xF0, 0x07, 0x8F, 0xC0, 0x0F, 0x3F, 0x00, 0x1E, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0,
  0x03, 0xCF, 0xC0, 0x07, 0x8F, 0xC0, 0x0F, 0x0F, 0xC0, 0x1E, 0x0F, 0xC0,
  0x3C, 0x0F, 0xC0, 0x78, 0x0F, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x1F, 0x83,
  0xC0, 0x1F, 0x87, 0x80, 0x1F, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3F, 0x3C,
  0x00, 0x3E, 0x78, 0x00, 0x7E, 0xF0, 0x00, 0x7D, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3E, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x3F, 0x00, 0xFC, 0x3F, 0x01, 0xFC, 0x3F, 0x81, 0xDC, 0x7F, 0x81, 0xDC,
  0x7B, 0x83, 0xDC, 0x7B, 0x83, 0xDC, 0x7B, 0xC3, 0x9C, 0x79, 0xC7, 0x9E,
  0x79, 0xC7, 0x9E, 0x79, 0xE7, 0x1E, 0x78, 0xE7, 0x1E, 0x78, 0xEF, 0x1E,
  0x78, 0xFE, 0x1E, 0x78, 0x7E, 0x1E, 0x70, 0x7E, 0x1E, 0xF0, 0x7C, 0x1E,
  0xF0, 0x3C, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF,
  0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x3F, 0xFC, 0x01,
  0xFF, 0xF0, 0x0F, 0xF7, 0x80, 0x7F, 0x9E, 0x03, 0xFC, 0xF0, 0x1F, 0xE3,
  0xC0, 0xFF, 0x1E, 0x07, 0xF8, 0x78, 0x3F, 0xC3, 0xC1, 0xFE, 0x0F, 0x0F,
  0xF0, 0x78, 0x7F, 0x81, 0xE3, 0xFC, 0x0F, 0x1F, 0xE0, 0x7C, 0xFF, 0x01,
  0xE7, 0xF8, 0x0F, 0x3F, 0xC0, 0x3D, 0xFE, 0x01, 0xEF, 0xF0, 0x07, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x83, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x3E, 0x00, 0xF8, 0x1F, 0x83, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE1, 0xFF, 0xFF, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xE0, 0x07,
  0xDF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x3E,
  0xF8, 0x03, 0xF7, 0xC0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xF0, 0x7F, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0,
  0x1F, 0x83, 0xF8, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7C,
  0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E,
  0xF8, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x7E, 0x00, 0x7C,
  0x3E, 0x00, 0xFC, 0x1F, 0x83, 0xF8, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1C, 0x3F, 0xF8, 0x03, 0xFF, 0xFC, 0x0F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0xF8, 0x0F, 0xE3, 0xE0, 0x0F, 0xCF, 0x80,
  0x1F, 0x3E, 0x00, 0x3C, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xCF, 0x80, 0x1F, 0x3E,
  0x00, 0xFC, 0xF8, 0x0F, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x03, 0xE0,
  0xF8, 0x07, 0x83, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF8,
  0x01, 0xF3, 0xE0, 0x03, 0xCF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x03, 0xFF, 0xFC,
  0x3F, 0xFF, 0xE3, 0xF0, 0x1E, 0x3F, 0x00, 0x11, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF6, 0x00, 0x0F, 0xBC, 0x01, 0xFB, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFC, 0x3F, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00,
  0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0x7C, 0x01, 0xF9, 0xFC, 0x0F, 0xC3, 0xFF,
  0xFF, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0xF8, 0x00,
  0x07, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x79, 0xE0, 0x00, 0x3E, 0x7C,
  0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x07, 0x83, 0xE0, 0x01, 0xE0, 0x78, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xC0, 0x0F, 0x00, 0xF0, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0x78, 0x0F, 0x80,
  0x1F, 0x03, 0xC0, 0x07, 0xC0, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x1E,
  0x00, 0x0F, 0x87, 0x80, 0x01, 0xE3, 0xE0, 0x00, 0x7C, 0xF0, 0x00, 0x1F,
  0x3C, 0x00, 0x03, 0xDF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00,
  0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x3C, 0x1E, 0xF0, 0x7C, 0x1E, 0xF0, 0x7E,
  0x1E, 0x78, 0x7E, 0x1E, 0x78, 0xFE, 0x1E, 0x78, 0xEE, 0x1E, 0x78, 0xEF,
  0x1E, 0x79, 0xE7, 0x1E, 0x79, 0xC7, 0x1C, 0x79, 0xC7, 0x9C, 0x7B, 0xC3,
  0x9C, 0x7B, 0x83, 0x9C, 0x7B, 0x83, 0xDC, 0x7F, 0x81, 0xDC, 0x7F, 0x01,
  0xDC, 0x7F, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x3E, 0x00,
  0xFC, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0x1F, 0x1F, 0x00,
  0x0F, 0x8F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x01,
  0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x07, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x81, 0xF0,
  0x07, 0xC0, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x7C,
  0x00, 0x1F, 0x3E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0xF9, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC3, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE1, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF, 0xFD,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3D, 0xF0, 0x00, 0xF9, 0xE0, 0x01, 0xE3, 0xE0, 0x07, 0xC3, 0xE0, 0x1F,
  0x07, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x87, 0xC0,
  0x0F, 0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0xF0, 0x00,
  0x3C, 0x40, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x38, 0x3E, 0x0F, 0x83, 0xC1,
  0xF0, 0x7C, 0x1F, 0x07, 0x81, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0x80, 0x7F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0xFE, 0x1F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x9F, 0xFF, 0xFD, 0xFC, 0x03, 0xEF, 0x80, 0x1F,
  0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xF7, 0xC0,
  0x0F, 0xBF, 0x00, 0x7D, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0x0F, 0xFF, 0xF8,
  0x0F, 0xFE, 0x00, 0x70, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x1F,
  0xC0, 0x7B, 0xFF, 0x83, 0xFF, 0xFE, 0x1F, 0xFF, 0xF8, 0xFE, 0x0F, 0xE7,
  0xC0, 0x1F, 0xBC, 0x00, 0x7D, 0xE0, 0x01, 0xEF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07,
  0xDE, 0x00, 0x3E, 0xF0, 0x03, 0xE7, 0xC0, 0x7F, 0x3F, 0xFF, 0xF1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xE0, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0xE0, 0x7F, 0xFF, 0x87, 0xFF, 0xFE, 0x3F, 0xC0, 0x18, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x61, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0x03, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0xFE, 0x7C, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0x3F, 0x83, 0xFC, 0xF8, 0x03, 0xF7, 0xE0, 0x07, 0xDF,
  0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F,
  0x78, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3F,
  0x00, 0x7C, 0x7F, 0x01, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03, 0xFF,
  0xFC, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0xFF,
  0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x1F, 0x87, 0xE0, 0x1F, 0x8F, 0x80, 0x1F,
  0x3E, 0x00, 0x1E, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x01, 0xF8, 0x06, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF,
  0x1F, 0x80, 0x7C, 0xFC, 0x01, 0xF7, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0x78, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x3F, 0x81, 0xFC, 0x7F,
  0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x01, 0xFE, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE3,
  0x00, 0x7F, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xC0, 0xFF, 0xFE, 0x00, 0xFF,
  0xC0, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF3, 0xFC, 0x0F, 0xFF,
  0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x0F, 0xCF, 0x00, 0x3E, 0xF0,
  0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0x01, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x08, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x1E, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF3, 0xFF, 0xF9, 0xFF,
  0xFC, 0xFF, 0xFE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0xB8, 0x1F,
  0x9F, 0xFF, 0xDF, 0xFF, 0xCF, 0xFF, 0xC0, 0x7F, 0x80, 0x70, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xCF,
  0x00, 0x3E, 0x3C, 0x01, 0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x7C, 0x0F, 0x07,
  0xE0, 0x3C, 0x3F, 0x00, 0xF1, 0xF8, 0x03, 0xCF, 0xC0, 0x0F, 0x7E, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x0F, 0x3F, 0x00, 0x3C,
  0x7E, 0x00, 0xF0, 0xFC, 0x03, 0xC1, 0xF8, 0x0F, 0x01, 0xF0, 0x3C, 0x03,
  0xE0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F, 0x8F, 0x00, 0x3F, 0x3C, 0x00, 0x7E,
  0xF0, 0x00, 0xFB, 0xC0, 0x01, 0xF0, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x20, 0x0F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x3F, 0x80, 0x1F, 0xC3, 0xE0, 0xFF, 0xEF, 0xF8, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0xF0, 0x7E, 0x3E, 0xF0, 0x7C, 0x1E, 0xF0, 0x3C, 0x1E,
  0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F,
  0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F, 0xF0, 0x3C, 0x1F,
  0xF0, 0x3C, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0x0F, 0xF8, 0x0F,
  0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xF0, 0x0F, 0xCF, 0x00, 0x3E,
  0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0xFF,
  0xFF, 0x81, 0xF8, 0x3F, 0x87, 0xE0, 0x1F, 0x1F, 0x80, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0x78, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x01, 0xF1, 0xF0, 0x03, 0xE3,
  0xF0, 0x0F, 0x83, 0xF0, 0x7F, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE1, 0xFF, 0xFF, 0x8F, 0x80, 0xFE, 0x78, 0x01, 0xF3, 0xC0, 0x07, 0xDE,
  0x00, 0x3E, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0, 0x03, 0xEF, 0x80, 0x3F,
  0x7F, 0x07, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xF7, 0xFF, 0x07, 0x8F,
  0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF,
  0x1F, 0xC0, 0x7C, 0xFC, 0x01, 0xF3, 0xE0, 0x07, 0xDF, 0x00, 0x1F, 0x7C,
  0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x1F, 0x3E, 0x00, 0x7C, 0xFE,
  0x07, 0xF1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x03, 0xF9,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x07, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0xBC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x00, 0x03, 0xFF, 0x01, 0xFF, 0xFE, 0x3F, 0xFF, 0xC7, 0xFF, 0xFC, 0x7E,
  0x00, 0xCF, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFC, 0xFF, 0xFF, 0x81, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xBF, 0xFF, 0xFE, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x20, 0x1F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x7F,
  0xFC, 0x00, 0x7F, 0x80, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F,
  0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x80,
  0x1F, 0xF8, 0x01, 0xFF, 0x80, 0x1F, 0x7C, 0x01, 0xF7, 0xF0, 0x1F, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xF0, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0x7C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3E, 0x00, 0xF8,
  0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x0F, 0x01, 0xF0,
  0x0F, 0x81, 0xE0, 0x07, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xC7, 0xC0,
  0x03, 0xC7, 0xC0, 0x03, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x78,
  0x1E, 0xF0, 0x3C, 0x0F, 0x78, 0x3E, 0x0F, 0x3C, 0x1F, 0x87, 0x9E, 0x0F,
  0xC3, 0xCF, 0x07, 0xE1, 0xE3, 0xC7, 0xF0, 0xF1, 0xE3, 0xBC, 0x78, 0xF1,
  0xCE, 0x3C, 0x79, 0xE7, 0x1C, 0x3C, 0xE3, 0xDE, 0x1E, 0x70, 0xEF, 0x07,
  0x70, 0x77, 0x83, 0xF8, 0x3F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x1C,
  0x00, 0xF8, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x1F, 0x00,
  0xF8, 0x1F, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x07, 0xC3, 0xC0, 0x07, 0xE7,
  0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xE7, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x0F, 0x81,
  0xF0, 0x1F, 0x00, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x3E, 0xF8, 0x00,
  0x7D, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x0F,
  0x87, 0x80, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0xF8, 0x1E, 0x01, 0xF0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x78, 0x1F, 0x00, 0xF8, 0x3E, 0x00,
  0xF0, 0x78, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xC7, 0x80, 0x07,
  0xCF, 0x00, 0x07, 0xBE, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF0,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0xF0, 0x0F,
  0xFE, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x1F, 0xFC, 0x03, 0xFF,
  0xC0, 0x7F, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x7F, 0xF8, 0x0F, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0x80,
  0x0C, 0x3F, 0xC0, 0x1C, 0xFF, 0xE0, 0x7B, 0xFF, 0xF1, 0xF7, 0x87, 0xFF,
  0xDE, 0x07, 0xFF, 0xBC, 0x03, 0xFE, 0x30, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Regular55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 28, 0, -1 },
  { 1, 7, 34, 28, 10, -34 },
  { 31, 13, 14, 28, 7, -37 },
  { 54, 25, 34, 28, 1, -34 },
  { 161, 22, 43, 28, 3, -38 },
  { 280, 26, 34, 28, 1, -34 },
  { 391, 24, 34, 28, 2, -34 },
  { 493, 5, 15, 28, 11, -37 },
  { 503, 15, 48, 28, 6, -39 },
  { 593, 15, 48, 28, 6, -39 },
  { 683, 21, 20, 28, 3, -34 },
  { 736, 22, 24, 28, 3, -27 },
  { 802, 11, 14, 28, 8, -7 },
  { 822, 12, 4, 28, 8, -16 },
  { 828, 8, 7, 28, 10, -7 },
  { 835, 20, 47, 28, 4, -38 },
  { 953, 22, 34, 28, 3, -34 },
  { 1047, 20, 34, 28, 4, -34 },
  { 1132, 21, 34, 28, 3, -34 },
  { 1222, 21, 34, 28, 3, -34 },
  { 1312, 24, 34, 28, 2, -34 },
  { 1414, 20, 34, 28, 4, -34 },
  { 1499, 22, 34, 28, 3, -34 },
  { 1593, 22, 34, 28, 3, -34 },
  { 1687, 22, 34, 28, 3, -34 },
  { 1781, 22, 34, 28, 3, -34 },
  { 1875, 8, 25, 28, 10, -25 },
  { 1900, 11, 32, 28, 7, -25 },
  { 1944, 22, 22, 28, 3, -25 },
  { 2005, 22, 15, 28, 3, -22 },
  { 2047, 22, 22, 28, 3, -25 },
  { 2108, 18, 34, 28, 5, -34 },
  { 2185, 24, 41, 28, 2, -34 },
  { 2308, 27, 34, 28, 0, -34 },
  { 2423, 22, 34, 28, 3, -34 },
  { 2517, 22, 34, 28, 3, -34 },
  { 2611, 22, 34, 28, 3, -34 },
  { 2705, 20, 34, 28, 5, -34 },
  { 2790, 19, 34, 28, 5, -34 },
  { 2871, 22, 34, 28, 3, -34 },
  { 2965, 23, 34, 28, 2, -34 },
  { 3063, 18, 34, 28, 5, -34 },
  { 3140, 20, 34, 28, 3, -34 },
  { 3225, 23, 34, 28, 4, -34 },
  { 3323, 20, 34, 28, 5, -34 },
  { 3408, 24, 34, 28, 2, -34 },
  { 3510, 21, 34, 28, 3, -34 },
  { 3600, 24, 34, 28, 2, -34 },
  { 3702, 21, 34, 28, 4, -34 },
  { 3792, 24, 42, 28, 2, -34 },
  { 3918, 22, 34, 28, 3, -34 },
  { 4012, 21, 34, 28, 3, -34 },
  { 4102, 23, 34, 28, 2, -34 },
  { 4200, 22, 34, 28, 3, -34 },
  { 4294, 26, 34, 28, 1, -34 },
  { 4405, 24, 34, 28, 2, -34 },
  { 4507, 25, 34, 28, 1, -34 },
  { 4614, 26, 34, 28, 1, -34 },
  { 4725, 22, 34, 28, 3, -34 },
  { 4819, 13, 47, 28, 8, -38 },
  { 4896, 20, 47, 28, 4, -38 },
  { 5014, 14, 47, 28, 6, -38 },
  { 5097, 23, 19, 28, 2, -34 },
  { 5152, 27, 4, 28, 0, 5 },
  { 5166, 9, 10, 28, 9, -38 },
  { 5178, 21, 26, 28, 3, -26 },
  { 5247, 21, 38, 28, 4, -38 },
  { 5347, 22, 26, 28, 3, -26 },
  { 5419, 22, 38, 28, 2, -38 },
  { 5524, 23, 26, 28, 2, -26 },
  { 5599, 24, 38, 28, 3, -38 },
  { 5713, 22, 35, 28, 2, -26 },
  { 5810, 20, 38, 28, 4, -38 },
  { 5905, 22, 37, 28, 3, -37 },
  { 6007, 17, 46, 28, 4, -37 },
  { 6105, 22, 38, 28, 4, -38 },
  { 6210, 22, 38, 28, 3, -38 },
  { 6315, 24, 26, 28, 2, -26 },
  { 6393, 20, 26, 28, 4, -26 },
  { 6458, 23, 26, 28, 2, -26 },
  { 6533, 21, 35, 28, 4, -26 },
  { 6625, 22, 35, 28, 2, -26 },
  { 6722, 18, 26, 28, 6, -26 },
  { 6781, 20, 26, 28, 4, -26 },
  { 6846, 22, 34, 28, 3, -34 },
  { 6940, 20, 26, 28, 4, -26 },
  { 7005, 24, 26, 28, 2, -26 },
  { 7083, 25, 26, 28, 1, -26 },
  { 7165, 24, 26, 28, 2, -26 },
  { 7243, 23, 35, 28, 2, -26 },
  { 7344, 19, 26, 28, 4, -26 },
  { 7406, 19, 47, 28, 4, -38 },
  { 7518, 4, 47, 28, 12, -38 },
  { 7542, 19, 47, 28, 4, -38 },
  { 7654, 23, 8, 28, 2, -18 },
};

const GFXfont UbuntuMono_Regular55pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular55pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular55pt7bGlyphs,
  0x20, 0x7E, 55
};

#endif // _UBUNTUMONO_REGULAR55PT7B_H_
