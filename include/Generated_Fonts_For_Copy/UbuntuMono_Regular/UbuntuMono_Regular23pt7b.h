#ifndef _UBUNTUMONO_REGULAR23PT7B_H_
#define _UBUNTUMONO_REGULAR23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular23pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0xDB, 0x40, 0x3E, 0xC0, 0xCF, 0x3C, 0xB2, 0xCA, 0x20,
  0x19, 0x86, 0x61, 0x18, 0xC4, 0xFF, 0xFF, 0xF3, 0x30, 0x8C, 0x23, 0x3F,
  0xFF, 0xFD, 0x98, 0x46, 0x31, 0x80, 0x0C, 0x06, 0x0F, 0xCF, 0xE6, 0x13,
  0x01, 0x80, 0xF8, 0x3F, 0x03, 0xC0, 0x60, 0x34, 0x1F, 0xFD, 0xF8, 0x18,
  0x0C, 0x06, 0x00, 0x70, 0x69, 0x1B, 0x22, 0x64, 0xCC, 0xB0, 0x94, 0x1D,
  0x80, 0x2E, 0x0F, 0x63, 0x64, 0x4C, 0x99, 0x92, 0x36, 0x83, 0x80, 0x3C,
  0x1F, 0x86, 0x61, 0x88, 0x66, 0x0F, 0x07, 0x99, 0xF6, 0xCF, 0xB1, 0xCC,
  0x33, 0x1E, 0xFF, 0x8E, 0x30, 0xFF, 0xE0, 0x08, 0x73, 0x18, 0x63, 0x0C,
  0x30, 0x82, 0x0C, 0x30, 0xC1, 0x87, 0x0E, 0x1C, 0x20, 0x83, 0x86, 0x0C,
  0x18, 0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x18, 0x63, 0x18, 0xE2, 0x00, 0x0C,
  0x06, 0x13, 0x7F, 0xF1, 0xE0, 0xF0, 0xDC, 0x44, 0x0C, 0x06, 0x03, 0x01,
  0x8F, 0xFF, 0xFC, 0x30, 0x18, 0x0C, 0x06, 0x00, 0x39, 0xCE, 0x37, 0x30,
  0xFF, 0xC0, 0xFF, 0x80, 0x03, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0xC0, 0xC0, 0xC0,
  0x1E, 0x1F, 0x98, 0xEC, 0x3C, 0x1E, 0x6F, 0x73, 0x99, 0xC1, 0xE0, 0xD8,
  0x6C, 0x73, 0xF0, 0xF0, 0x08, 0x38, 0x78, 0xD8, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3E, 0x3F, 0x90, 0xE0, 0x30, 0x18,
  0x18, 0x08, 0x0C, 0x08, 0x08, 0x08, 0x0C, 0x07, 0xFB, 0xFC, 0x3E, 0x3F,
  0x90, 0xC0, 0x30, 0x10, 0x18, 0x78, 0x3E, 0x03, 0x80, 0xC0, 0x68, 0x7F,
  0xF3, 0xF0, 0x03, 0x01, 0xC0, 0xF0, 0x6C, 0x33, 0x18, 0xC6, 0x33, 0x0C,
  0xFF, 0xFF, 0xF0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x7F, 0x7F, 0x60, 0x40,
  0x40, 0x78, 0xFE, 0x07, 0x03, 0x03, 0x03, 0x87, 0xFE, 0xFC, 0x07, 0x0F,
  0x8E, 0x0E, 0x06, 0x02, 0xF3, 0xFD, 0x83, 0xC1, 0xE0, 0xF8, 0x6C, 0x77,
  0xF0, 0xF0, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x04, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x1E, 0x3F, 0x98, 0xF8, 0x36, 0x1B,
  0x98, 0xF8, 0x7E, 0x63, 0xE0, 0xF0, 0x7C, 0x37, 0xF9, 0xF0, 0x3E, 0x3F,
  0x98, 0xF8, 0x3C, 0x1E, 0x0F, 0x86, 0xFF, 0x3F, 0x80, 0xC0, 0xC1, 0xE7,
  0xE3, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x73, 0x9C, 0x00, 0x00, 0x06, 0x73,
  0x8D, 0xCC, 0x00, 0x00, 0x81, 0xE1, 0xF1, 0xE0, 0xC0, 0x1E, 0x01, 0xF0,
  0x1E, 0x00, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x40,
  0x3C, 0x03, 0xE0, 0x1E, 0x01, 0xC1, 0xE3, 0xE3, 0xC0, 0x40, 0x00, 0x7D,
  0xFE, 0x18, 0x30, 0x61, 0x86, 0x08, 0x30, 0x00, 0x01, 0x83, 0x86, 0x00,
  0x1F, 0x0F, 0xE7, 0x19, 0x83, 0xC0, 0xF1, 0xFC, 0xFF, 0x63, 0xD8, 0xF6,
  0x3C, 0xFF, 0x1F, 0x60, 0x18, 0x03, 0x00, 0xFE, 0x0F, 0x80, 0x0E, 0x01,
  0xE0, 0x2C, 0x0D, 0x81, 0x98, 0x23, 0x0C, 0x61, 0x84, 0x30, 0xCF, 0xF9,
  0xFF, 0x30, 0x36, 0x07, 0x80, 0xC0, 0xFE, 0x7F, 0xB0, 0xF8, 0x3C, 0x1E,
  0x1B, 0xF9, 0xFE, 0xC1, 0xE0, 0xF0, 0x78, 0x3F, 0xFF, 0xF0, 0x0F, 0x0F,
  0xE7, 0x09, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x06, 0x01,
  0xC2, 0x3F, 0x87, 0xE0, 0xFC, 0x3F, 0xCC, 0x33, 0x06, 0xC1, 0xB0, 0x2C,
  0x0F, 0x03, 0xC0, 0xB0, 0x6C, 0x1B, 0x0C, 0xFF, 0x3F, 0x00, 0xFF, 0x7F,
  0xB0, 0x18, 0x0C, 0x06, 0x03, 0xF9, 0xFC, 0xC0, 0x60, 0x30, 0x18, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0x0F, 0x1F, 0xDC, 0x2C, 0x0C, 0x06, 0x03, 0x01,
  0x81, 0xC0, 0xE0, 0x58, 0x2E, 0x13, 0xF8, 0xFC, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x04,
  0xFF, 0xFC, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xCF, 0xFF,
  0xC0, 0x3F, 0x9F, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0x68, 0x6F, 0xF3, 0xF0, 0xC1, 0xB0, 0xEC, 0x33, 0x18, 0xCC, 0x37,
  0x0F, 0x83, 0x60, 0xCC, 0x31, 0x8C, 0x33, 0x06, 0xC1, 0xF0, 0x30, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18,
  0x0F, 0xFF, 0xFC, 0x61, 0x98, 0x66, 0x3B, 0xCA, 0xD2, 0xB5, 0xAD, 0xCB,
  0x72, 0xCC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x30, 0xC0, 0xF0, 0x7C,
  0x3E, 0x1D, 0x8E, 0xC7, 0x33, 0x99, 0xC6, 0xE3, 0x70, 0xB8, 0x7C, 0x1E,
  0x0C, 0x1E, 0x1F, 0xC6, 0x3B, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x19, 0x8E, 0x7F, 0x0F, 0x80, 0xFC, 0xFE, 0xC3, 0xC3, 0xC1,
  0xC3, 0xC3, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1E, 0x1F, 0xC6,
  0x3B, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x19, 0x8E,
  0x7F, 0x0F, 0x80, 0xC0, 0x38, 0x07, 0x80, 0x60, 0xFE, 0x3F, 0xCC, 0x3B,
  0x06, 0xC1, 0xB0, 0x6C, 0x33, 0xFC, 0xFE, 0x31, 0x8C, 0x33, 0x0C, 0xC1,
  0xB0, 0x60, 0x1F, 0x3F, 0xD8, 0x4C, 0x06, 0x03, 0x80, 0xF8, 0x1E, 0x03,
  0x80, 0xC0, 0x68, 0x3F, 0xF9, 0xF0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0xF0,
  0x7C, 0x37, 0xF1, 0xF0, 0xC0, 0x6C, 0x0D, 0x81, 0xB0, 0x66, 0x0C, 0x61,
  0x8C, 0x21, 0x8C, 0x19, 0x83, 0x20, 0x6C, 0x07, 0x80, 0xE0, 0x1C, 0x00,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF3, 0x2D, 0xCB, 0x72, 0xD6, 0xB4,
  0xAF, 0x2B, 0x8E, 0x63, 0x98, 0x60, 0xC1, 0x98, 0x66, 0x30, 0xCC, 0x36,
  0x07, 0x80, 0xC0, 0x70, 0x1E, 0x0D, 0xC7, 0x31, 0x86, 0xC1, 0xB0, 0x30,
  0xE0, 0x6C, 0x0D, 0x83, 0x18, 0x63, 0x98, 0x33, 0x07, 0xC0, 0x70, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x00, 0x7F, 0xBF, 0xC0, 0x60,
  0x60, 0x60, 0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0F, 0xFF, 0xFC,
  0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xFF, 0xF0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30, 0x30, 0x18,
  0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x04, 0x06, 0x06, 0x06, 0x03, 0xFF, 0xC6,
  0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0xFF, 0xC0, 0x0C, 0x07,
  0x01, 0x60, 0xCC, 0x63, 0x18, 0x6C, 0x19, 0x02, 0xFF, 0xFF, 0xFC, 0x8C,
  0x62, 0x7E, 0x1F, 0x80, 0x60, 0x33, 0xFB, 0xFF, 0x87, 0x83, 0xE1, 0xBF,
  0xCF, 0xE0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xE3, 0xF9, 0x8E, 0xC3,
  0x60, 0xF0, 0x78, 0x3C, 0x36, 0x3B, 0xF9, 0xF8, 0x1F, 0x9F, 0xDC, 0x1C,
  0x0C, 0x06, 0x03, 0x01, 0xC0, 0x70, 0x1F, 0xC7, 0xE0, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x19, 0xFD, 0xFE, 0xC7, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1B,
  0x0D, 0xFE, 0x3F, 0x1E, 0x3F, 0x98, 0x78, 0x3F, 0xFF, 0xFF, 0x01, 0x80,
  0x60, 0xBF, 0xC7, 0xC0, 0x0F, 0x87, 0xF1, 0x84, 0x60, 0x18, 0x3F, 0xEF,
  0xF8, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1F, 0xBF, 0xD8, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xE1, 0xBF, 0xCF,
  0xE0, 0x34, 0x3B, 0xF9, 0xF8, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0xFE,
  0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x18, 0x1C, 0x06,
  0x00, 0x00, 0x07, 0xC3, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80,
  0xE4, 0x3E, 0x0F, 0x0C, 0x1C, 0x30, 0x00, 0x0F, 0xDF, 0x83, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x07, 0x1F, 0xF7, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x1B, 0x19, 0x98, 0xD8, 0x78, 0x3C, 0x1B, 0x0C, 0xC6,
  0x33, 0x0D, 0x87, 0xF8, 0x7C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE4, 0x3E, 0x0F, 0xF7, 0x3F, 0xEC,
  0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFC,
  0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1E, 0x1F,
  0xC6, 0x3B, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x06, 0x63, 0x9F, 0xC1, 0xE0,
  0xFC, 0x7F, 0x31, 0xD8, 0x6C, 0x1E, 0x0F, 0x07, 0x86, 0xC7, 0x7F, 0x3F,
  0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0xBF, 0xD8, 0x78, 0x3C, 0x1E, 0x0F,
  0x07, 0x83, 0x61, 0xBF, 0xCF, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x7F, 0xFF,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7E, 0xFE, 0xC2,
  0xC0, 0xF0, 0x7E, 0x0F, 0x03, 0x83, 0xFF, 0xFC, 0x18, 0x0C, 0x06, 0x1F,
  0xFF, 0xF8, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x11, 0xF8, 0x7C,
  0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0xC3, 0xC3, 0xC3, 0xFF, 0x3F, 0xC0,
  0xF0, 0x6C, 0x19, 0x86, 0x63, 0x18, 0xC3, 0x30, 0xD8, 0x1E, 0x07, 0x00,
  0xC0, 0xC0, 0x68, 0x0D, 0x19, 0xB3, 0x36, 0xE6, 0xDE, 0x9A, 0xD3, 0xCE,
  0x39, 0xC6, 0x38, 0xC2, 0x00, 0xC1, 0x98, 0xC3, 0x30, 0xD8, 0x1C, 0x03,
  0x01, 0xE0, 0xDC, 0x63, 0x18, 0x6C, 0x1C, 0xC0, 0x98, 0x66, 0x19, 0x86,
  0x61, 0x0C, 0xC3, 0x30, 0x68, 0x1E, 0x03, 0x80, 0xC0, 0x30, 0x18, 0x3E,
  0x0F, 0x00, 0xFF, 0xFF, 0x06, 0x0C, 0x18, 0x38, 0x30, 0x60, 0xC0, 0xFF,
  0xFF, 0x0F, 0x1F, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0xE0, 0x30,
  0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x1F, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xF8, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x0C, 0x07,
  0x0C, 0x08, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xF8, 0xF0, 0x70, 0xFF,
  0x2C, 0xFA, 0x1C,
};

const GFXglyph UbuntuMono_Regular23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 3, 14, 12, 4, -14 },
  { 7, 6, 6, 12, 3, -16 },
  { 12, 10, 14, 12, 1, -14 },
  { 30, 9, 18, 12, 1, -16 },
  { 51, 11, 14, 12, 0, -14 },
  { 71, 10, 14, 12, 1, -14 },
  { 89, 2, 6, 12, 5, -16 },
  { 91, 6, 18, 12, 3, -14 },
  { 105, 6, 18, 12, 3, -14 },
  { 119, 9, 8, 12, 1, -14 },
  { 128, 9, 10, 12, 1, -11 },
  { 140, 5, 6, 12, 3, -3 },
  { 144, 5, 2, 12, 3, -7 },
  { 146, 3, 3, 12, 4, -3 },
  { 148, 8, 20, 12, 2, -16 },
  { 168, 9, 14, 12, 1, -14 },
  { 184, 8, 14, 12, 2, -14 },
  { 198, 9, 14, 12, 1, -14 },
  { 214, 9, 14, 12, 1, -14 },
  { 230, 10, 14, 12, 1, -14 },
  { 248, 8, 14, 12, 2, -14 },
  { 262, 9, 14, 12, 1, -14 },
  { 278, 9, 14, 12, 1, -14 },
  { 294, 9, 14, 12, 1, -14 },
  { 310, 9, 14, 12, 1, -14 },
  { 326, 3, 10, 12, 4, -10 },
  { 330, 5, 13, 12, 3, -10 },
  { 339, 10, 9, 12, 1, -10 },
  { 351, 9, 7, 12, 1, -9 },
  { 359, 10, 9, 12, 1, -10 },
  { 371, 7, 14, 12, 2, -14 },
  { 384, 10, 17, 12, 1, -14 },
  { 406, 11, 14, 12, 0, -14 },
  { 426, 9, 14, 12, 1, -14 },
  { 442, 10, 14, 12, 1, -14 },
  { 460, 10, 14, 12, 1, -14 },
  { 478, 9, 14, 12, 2, -14 },
  { 494, 8, 14, 12, 2, -14 },
  { 508, 9, 14, 12, 1, -14 },
  { 524, 9, 14, 12, 1, -14 },
  { 540, 7, 14, 12, 2, -14 },
  { 553, 9, 14, 12, 1, -14 },
  { 569, 10, 14, 12, 1, -14 },
  { 587, 9, 14, 12, 2, -14 },
  { 603, 10, 14, 12, 1, -14 },
  { 621, 9, 14, 12, 1, -14 },
  { 637, 10, 14, 12, 1, -14 },
  { 655, 8, 14, 12, 2, -14 },
  { 669, 10, 18, 12, 1, -14 },
  { 692, 10, 14, 12, 1, -14 },
  { 710, 9, 14, 12, 1, -14 },
  { 726, 10, 14, 12, 1, -14 },
  { 744, 9, 14, 12, 1, -14 },
  { 760, 11, 14, 12, 0, -14 },
  { 780, 10, 14, 12, 1, -14 },
  { 798, 10, 14, 12, 1, -14 },
  { 816, 11, 14, 12, 0, -14 },
  { 836, 9, 14, 12, 1, -14 },
  { 852, 6, 18, 12, 3, -14 },
  { 866, 8, 20, 12, 2, -16 },
  { 886, 5, 18, 12, 3, -14 },
  { 898, 10, 8, 12, 1, -14 },
  { 908, 11, 2, 12, 0, 2 },
  { 911, 4, 4, 12, 4, -16 },
  { 913, 9, 11, 12, 1, -11 },
  { 926, 9, 16, 12, 2, -16 },
  { 944, 9, 11, 12, 1, -11 },
  { 957, 9, 16, 12, 1, -16 },
  { 975, 9, 11, 12, 1, -11 },
  { 988, 10, 16, 12, 1, -16 },
  { 1008, 9, 15, 12, 1, -11 },
  { 1025, 8, 16, 12, 2, -16 },
  { 1041, 9, 16, 12, 1, -16 },
  { 1059, 7, 20, 12, 2, -16 },
  { 1077, 9, 16, 12, 2, -16 },
  { 1095, 9, 16, 12, 1, -16 },
  { 1113, 10, 11, 12, 1, -11 },
  { 1127, 8, 11, 12, 2, -11 },
  { 1138, 10, 11, 12, 1, -11 },
  { 1152, 9, 15, 12, 2, -11 },
  { 1169, 9, 15, 12, 1, -11 },
  { 1186, 8, 11, 12, 2, -11 },
  { 1197, 8, 11, 12, 2, -11 },
  { 1208, 9, 14, 12, 1, -14 },
  { 1224, 8, 11, 12, 2, -11 },
  { 1235, 10, 11, 12, 1, -11 },
  { 1249, 11, 11, 12, 0, -11 },
  { 1265, 10, 11, 12, 1, -11 },
  { 1279, 10, 15, 12, 1, -11 },
  { 1298, 8, 11, 12, 2, -11 },
  { 1309, 8, 20, 12, 2, -16 },
  { 1329, 2, 20, 12, 5, -16 },
  { 1334, 8, 20, 12, 2, -16 },
  { 1354, 10, 4, 12, 1, -8 },
};

const GFXfont UbuntuMono_Regular23pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular23pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular23pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _UBUNTUMONO_REGULAR23PT7B_H_
