#ifndef _UBUNTUMONO_REGULAR44PT7B_H_
#define _UBUNTUMONO_REGULAR44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular44pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7,
  0x1C, 0x30, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFF, 0xF7, 0x80, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xE1, 0xF0, 0x7C, 0x0C,
  0x01, 0xC1, 0xC0, 0x1C, 0x1C, 0x03, 0xC1, 0xC0, 0x3C, 0x3C, 0x03, 0x83,
  0x80, 0x38, 0x38, 0x03, 0x83, 0x8F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x07, 0x07, 0x00, 0x70, 0x70, 0x0F, 0x07, 0x00, 0xF0, 0xF0, 0x0E,
  0x0F, 0x00, 0xE0, 0xE0, 0x0E, 0x0E, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1C, 0x1C, 0x01, 0xC1, 0xC0, 0x3C, 0x1C, 0x03, 0xC3, 0xC0,
  0x38, 0x3C, 0x03, 0x83, 0x80, 0x38, 0x38, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xF0,
  0xF8, 0x0C, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x7F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x40, 0x07, 0x9E, 0x03, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x0F,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0xF7, 0xF0, 0x0E, 0x73, 0x81, 0xCE, 0x38, 0x1C, 0xE3,
  0x83, 0x8E, 0x18, 0x70, 0xC1, 0x87, 0x0E, 0x18, 0xE0, 0xE1, 0x8E, 0x0E,
  0x39, 0xC0, 0xE3, 0xB8, 0x07, 0x3B, 0x80, 0x7F, 0x70, 0x03, 0xEF, 0x7C,
  0x00, 0xEF, 0xE0, 0x1D, 0xCE, 0x01, 0xDC, 0x70, 0x39, 0xC7, 0x07, 0x18,
  0x70, 0x71, 0x83, 0x0E, 0x18, 0x31, 0xE1, 0x87, 0x1C, 0x1C, 0x73, 0x81,
  0xC7, 0x38, 0x1C, 0xE7, 0x00, 0xFE, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x00,
  0xFF, 0x80, 0x1F, 0xFC, 0x01, 0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0xE0,
  0x3C, 0x0E, 0x03, 0xC1, 0xC0, 0x1C, 0x3C, 0x01, 0xE7, 0x80, 0x0F, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC1, 0xC1, 0xFC, 0x1C, 0x3D, 0xE1, 0xC3, 0x8F,
  0x1C, 0x78, 0x7B, 0xC7, 0x03, 0xF8, 0xF0, 0x3F, 0x8F, 0x01, 0xF8, 0xF0,
  0x0F, 0x07, 0x00, 0xF8, 0x78, 0x1F, 0xC7, 0xE7, 0xFC, 0x3F, 0xF9, 0xE1,
  0xFF, 0x1E, 0x07, 0xC0, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF6, 0x66, 0x00,
  0x40, 0x0E, 0x01, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x38, 0x07, 0x80, 0x78, 0x07, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0x70,
  0x07, 0x80, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xE0, 0x04, 0x20, 0x07, 0x00, 0xF8,
  0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C, 0x01,
  0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01,
  0xE0, 0x1C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0xF0, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x80, 0x70, 0x02, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x41, 0xC2, 0xF1, 0x8F, 0xFD, 0xBF, 0xFF, 0xFF, 0x7F, 0xFE, 0x03,
  0xC0, 0x07, 0xE0, 0x0F, 0x70, 0x1E, 0x78, 0x3C, 0x3C, 0x3C, 0x3C, 0x08,
  0x10, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x1E, 0x3F, 0x3F, 0x3F,
  0x3F, 0x1F, 0x0F, 0x0E, 0x3E, 0xFC, 0xF8, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x03,
  0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x80,
  0x79, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x0C, 0x3F, 0xC7, 0x8F,
  0xF1, 0xF3, 0xFC, 0x7C, 0xFF, 0x1E, 0x3F, 0xC3, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0E, 0x78, 0x07, 0x9E, 0x01, 0xE3, 0xC0,
  0xF0, 0xF8, 0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFE, 0xE0, 0x78, 0xE0,
  0x60, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x3F, 0xFF,
  0x3F, 0xFF, 0x3F, 0xFF, 0x0F, 0xE0, 0x1F, 0xFC, 0x3F, 0xFF, 0x1F, 0x0F,
  0xCE, 0x01, 0xE2, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xE0, 0x0F, 0xE0, 0x7F, 0xF8, 0xFF, 0xFC, 0x70, 0x7E, 0x40, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x7C,
  0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F,
  0xC0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x03, 0xDC, 0x00, 0xF3,
  0x80, 0x3C, 0x70, 0x07, 0x0E, 0x01, 0xE1, 0xC0, 0x78, 0x38, 0x0E, 0x07,
  0x03, 0xC0, 0xE0, 0x70, 0x1C, 0x1C, 0x03, 0x83, 0x80, 0x70, 0xE0, 0x0E,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xE0, 0x00, 0x1C,
  0x00, 0x03, 0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38,
  0x00, 0x1F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x3F,
  0xF0, 0x3F, 0xFC, 0x01, 0xFE, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0x1F, 0xC0,
  0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xE0, 0x00, 0x1F, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0xBF, 0x81, 0xFF, 0xF8, 0x7F, 0xFF,
  0x3F, 0x03, 0xEF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xF7,
  0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x03, 0x9E, 0x01, 0xE3, 0xC0, 0x78, 0xF8,
  0x7C, 0x1F, 0xFE, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF,
  0xF0, 0xF8, 0x7C, 0x78, 0x07, 0x9E, 0x01, 0xE7, 0x00, 0x39, 0xC0, 0x0E,
  0x78, 0x07, 0x9E, 0x01, 0xE3, 0xC0, 0xF0, 0xFC, 0x78, 0x1F, 0xFC, 0x03,
  0xFF, 0x01, 0xEF, 0xE0, 0xF0, 0x7C, 0x78, 0x07, 0x9C, 0x00, 0xEF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x79, 0xF0, 0x3E,
  0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F, 0x80, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x0F, 0x1E, 0x01, 0xE7, 0x00, 0x7B, 0xC0,
  0x0E, 0xF0, 0x03, 0xBC, 0x00, 0xFF, 0x00, 0x3D, 0xC0, 0x0F, 0x78, 0x03,
  0xDF, 0x03, 0xF3, 0xFF, 0xF8, 0x7F, 0xFE, 0x07, 0xF7, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x0F,
  0xE0, 0x3F, 0xF0, 0x0F, 0xF0, 0x03, 0xE0, 0x00, 0x7B, 0xFF, 0xFF, 0xFD,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE, 0x0F,
  0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3C, 0x3F, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x78, 0x78,
  0x7C, 0xFC, 0x7C, 0x30, 0x00, 0x00, 0x00, 0x80, 0x01, 0xF0, 0x01, 0xFC,
  0x01, 0xFE, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0xF0,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x01, 0xFC, 0x00, 0x1F, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00, 0x1E,
  0x00, 0x0F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x07,
  0xF8, 0x00, 0x3F, 0x00, 0x03, 0xC0, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8,
  0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x00, 0x00,
  0x1F, 0xC3, 0xFF, 0xCF, 0xFF, 0x98, 0x1F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0x83, 0xC3, 0xC0, 0x3C,
  0x78, 0x07, 0x9E, 0x00, 0x73, 0xC0, 0x0E, 0x70, 0x01, 0xFE, 0x03, 0xFF,
  0xC1, 0xFF, 0xF8, 0x7F, 0xFF, 0x1F, 0x1F, 0xC3, 0xC3, 0xF8, 0xF0, 0x7F,
  0x1E, 0x0F, 0xE3, 0xC1, 0xFC, 0x78, 0x3F, 0x8F, 0x07, 0xF9, 0xE0, 0xFF,
  0x1C, 0x1F, 0xE3, 0xC3, 0xFC, 0x3F, 0xFB, 0x83, 0xFF, 0x78, 0x3F, 0x8F,
  0x00, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x01, 0xDE, 0x00, 0x07, 0x38, 0x00,
  0x3C, 0xF0, 0x00, 0xE3, 0xC0, 0x03, 0x87, 0x00, 0x1E, 0x1E, 0x00, 0x70,
  0x78, 0x01, 0xC0, 0xE0, 0x0F, 0x03, 0xC0, 0x3C, 0x0F, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x1E, 0x01, 0xE0, 0x7F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFC, 0x3C, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x80, 0x07, 0x1E, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xC0, 0x01, 0xE7, 0x00, 0x03, 0x80, 0x7F, 0xF0,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F, 0x3C, 0x01, 0xCF,
  0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0x3C, 0x03, 0xCF, 0x03, 0xE3, 0xFF,
  0xF0, 0xFF, 0xF8, 0x3F, 0xFF, 0x8F, 0x01, 0xF3, 0xC0, 0x1E, 0xF0, 0x03,
  0xBC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF,
  0x00, 0x7B, 0xC0, 0x7E, 0xFF, 0xFF, 0x3F, 0xFF, 0x07, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x0E, 0x1E, 0x00, 0x8F, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x08, 0x7E, 0x07, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x0F, 0xE0,
  0x7F, 0xC0, 0x3F, 0xFE, 0x0F, 0xFF, 0xC3, 0xC1, 0xF8, 0xF0, 0x1F, 0x3C,
  0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0E, 0xF0, 0x07, 0xBC,
  0x03, 0xEF, 0x01, 0xF3, 0xC1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xBC, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xE0, 0xFF, 0xFC, 0x7E, 0x0E, 0x1E, 0x00, 0x8F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0xF3,
  0xE0, 0x3C, 0x7E, 0x0F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F, 0xF0, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0x0F, 0xFF, 0x0F, 0xFF, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x20, 0x0F, 0x78, 0x3E,
  0x7F, 0xFE, 0x7F, 0xF8, 0x0F, 0xE0, 0xE0, 0x07, 0x9C, 0x01, 0xF3, 0x80,
  0x3C, 0x70, 0x0F, 0x0E, 0x03, 0xC1, 0xC0, 0xF8, 0x38, 0x3E, 0x07, 0x0F,
  0x80, 0xE1, 0xE0, 0x1C, 0x78, 0x03, 0x9E, 0x00, 0x77, 0x80, 0x0F, 0xE0,
  0x01, 0xFF, 0x00, 0x3B, 0xF0, 0x07, 0x3F, 0x00, 0xE1, 0xF0, 0x1C, 0x1E,
  0x03, 0x81, 0xE0, 0x70, 0x3E, 0x0E, 0x03, 0xE1, 0xC0, 0x3E, 0x38, 0x03,
  0xC7, 0x00, 0x7C, 0xE0, 0x07, 0x9C, 0x00, 0x7B, 0x80, 0x0F, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x3E, 0x07,
  0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3, 0x60, 0x6C, 0x37, 0x0E, 0xC3, 0x70,
  0xEC, 0x73, 0x0C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x19, 0x8E, 0x71,
  0xF8, 0xE7, 0x1F, 0x8E, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7,
  0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x00, 0x0F, 0xF0, 0x00,
  0xF0, 0xF0, 0x03, 0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x0F, 0xFE, 0x03,
  0xFF, 0x80, 0xFF, 0xF0, 0x3F, 0xDC, 0x0F, 0xF7, 0x83, 0xFC, 0xE0, 0xFF,
  0x3C, 0x3F, 0xC7, 0x0F, 0xF1, 0xE3, 0xFC, 0x38, 0xFF, 0x0F, 0x3F, 0xC1,
  0xCF, 0xF0, 0x73, 0xFC, 0x0E, 0xFF, 0x03, 0xBF, 0xC0, 0x7F, 0xF0, 0x1F,
  0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x3C, 0x01, 0xF8, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x70, 0x00,
  0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x70,
  0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1,
  0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0xE0,
  0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xEF, 0x00, 0xF7, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0xF7, 0x81, 0xFB, 0xFF, 0xF9, 0xFF, 0xF0, 0xFF, 0xE0, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xFF, 0x01, 0xF0, 0xF8, 0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78,
  0x01, 0xE7, 0x80, 0x1E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0xF7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01,
  0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xF0, 0xF8, 0x0F, 0xFF, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0x1C, 0x7F, 0xE0, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0xC0, 0xFC, 0xF0, 0x0F, 0x3C, 0x01, 0xEF, 0x00,
  0x7B, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1C,
  0xF0, 0x0F, 0x3C, 0x0F, 0x8F, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3C,
  0x1E, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x1E, 0x3C, 0x03, 0x8F, 0x00,
  0xF3, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xFC,
  0x03, 0xFF, 0xC1, 0xFF, 0xF0, 0xF8, 0x3C, 0x78, 0x01, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xE4,
  0x00, 0x79, 0xE0, 0x7E, 0x7F, 0xFF, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDE,
  0x01, 0xE7, 0x80, 0x79, 0xF0, 0x7E, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0x7F,
  0x80, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xE3, 0x80, 0x1E, 0x3C, 0x01, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xC0, 0x38, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x0E, 0x07, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x70, 0xE0, 0x07, 0x8E,
  0x00, 0x79, 0xE0, 0x07, 0x9E, 0x00, 0x3D, 0xC0, 0x03, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF,
  0x00, 0x0F, 0xF0, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E,
  0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0x00, 0xE7, 0x00, 0x0E, 0x70, 0xF0,
  0xE7, 0x0F, 0x0E, 0x70, 0xF0, 0xE7, 0x1F, 0x8E, 0x71, 0xF8, 0xE7, 0x19,
  0x8E, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x0C, 0xC3, 0x70, 0xEC, 0x37,
  0x0E, 0xC3, 0x60, 0x6C, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x07, 0xC3,
  0xC0, 0x3C, 0x3C, 0x03, 0xC0, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03,
  0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0x79,
  0xE0, 0x07, 0x9E, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00,
  0x79, 0xE0, 0x07, 0x9E, 0x00, 0xF0, 0xF0, 0x1E, 0x07, 0x81, 0xE0, 0x78,
  0x3C, 0x03, 0xC3, 0xC0, 0x3C, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0xF0, 0x00,
  0xF0, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x78,
  0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x1F, 0x07, 0x80,
  0xF0, 0xF0, 0x0F, 0x8E, 0x00, 0x79, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xF7, 0xFF, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0,
  0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07,
  0x80, 0x03, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0,
  0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x03,
  0xCF, 0x00, 0xE1, 0xC0, 0x78, 0x78, 0x1C, 0x0E, 0x0F, 0x03, 0xC7, 0x80,
  0x79, 0xE0, 0x1E, 0xF0, 0x03, 0xFC, 0x00, 0xF2, 0x00, 0x10, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x20, 0x70, 0xF0, 0x78, 0x3C,
  0x1E, 0x0E, 0x04, 0x1F, 0xF0, 0x3F, 0xFC, 0x3F, 0xFE, 0x30, 0x3E, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x0F, 0xFF, 0x3F, 0xFF, 0x7F,
  0xFF, 0xF8, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x0F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xFC, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3D, 0xFC, 0x1F, 0xFF, 0x0F, 0xFF, 0xE7, 0xE1,
  0xF3, 0xC0, 0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F,
  0x78, 0x0F, 0xBC, 0x0F, 0x9F, 0xFF, 0x8F, 0xFF, 0x81, 0xFF, 0x00, 0x01,
  0xFF, 0x01, 0xFF, 0xE1, 0xFF, 0xF8, 0xFC, 0x06, 0x3C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3F,
  0x00, 0x87, 0xFF, 0xF0, 0x7F, 0xFC, 0x07, 0xFC, 0x00, 0x03, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC1, 0xFD, 0xE1, 0xFF, 0xF3, 0xFF, 0xF9,
  0xF0, 0xFD, 0xE0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xCF, 0x81, 0xE3, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xF0,
  0x03, 0xF8, 0x03, 0xFF, 0x81, 0xFF, 0xF0, 0xF8, 0x3E, 0x78, 0x07, 0x9C,
  0x00, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x01, 0x07, 0xFF, 0xC0, 0xFF, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x7F, 0xF0, 0x3F, 0xFC, 0x1F, 0x03, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC,
  0xFF, 0xFF, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xFF, 0xCF, 0xFF, 0xE7,
  0xC0, 0xF7, 0x80, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3D, 0xE0,
  0x1E, 0xF8, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xC1, 0xFD, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0xC0, 0x7E, 0x7F, 0xFE, 0x3F, 0xFE,
  0x07, 0xF8, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF7,
  0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0x07, 0x80, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x80,
  0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0xFC, 0x00, 0x70, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0xFF, 0xF3,
  0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0x98, 0x1E, 0x7F, 0xF3, 0xFF, 0xC1, 0xFC, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x7B, 0xC0, 0x3C, 0xF0,
  0x1E, 0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xC7, 0xC0, 0xF3, 0xE0, 0x3D, 0xF0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3D, 0xF0, 0x0F, 0x1E, 0x03,
  0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0xF0,
  0x07, 0xBC, 0x01, 0xF0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x70, 0x00, 0x1E, 0x08, 0x07, 0xFF, 0x00, 0xFF, 0xC0, 0x0F, 0xC0,
  0x7F, 0x1E, 0x3F, 0xFF, 0xEF, 0xFF, 0xFF, 0x87, 0x8F, 0xE1, 0xE1, 0xF8,
  0x78, 0x7E, 0x1E, 0x1F, 0x87, 0x87, 0xE1, 0xE1, 0xF8, 0x78, 0x7E, 0x1E,
  0x1F, 0x87, 0x87, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x3F, 0xE0, 0xFF,
  0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0x03, 0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07,
  0x9E, 0x01, 0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x80, 0x79, 0xE0,
  0x1E, 0x3E, 0x1F, 0x07, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x01, 0xF7, 0x80, 0x7B, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1D, 0xE0, 0x1E, 0xF8, 0x3E, 0x7F, 0xFF,
  0x3F, 0xFE, 0x1E, 0xFE, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x07, 0xFF,
  0xC7, 0xFF, 0xE7, 0xC0, 0xF7, 0xC0, 0x7B, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x3E, 0x0F, 0x9F, 0xFF, 0xC3, 0xFF,
  0xE0, 0xFE, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x03, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0x0F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x78,
  0x06, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F,
  0xF0, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0x00, 0x0F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xFF, 0xFE, 0xFF, 0xFC, 0x1F, 0xF0, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x03, 0xFF, 0xFD,
  0xFF, 0xFE, 0xFF, 0xFF, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x04, 0x0F, 0xFF,
  0x03, 0xFF, 0x80, 0x7F, 0x00, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x78,
  0x0F, 0x7C, 0x0F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFC, 0xF0, 0x00, 0xF7,
  0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x03, 0xC3, 0xC0, 0x3C,
  0x3C, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x80, 0xE0, 0x70, 0x0F, 0x0F,
  0x00, 0xF0, 0xF0, 0x07, 0x9E, 0x00, 0x79, 0xE0, 0x03, 0x9C, 0x00, 0x3F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x07, 0x0F, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x70, 0xF8, 0xE7, 0x1F, 0x8E,
  0x71, 0xF8, 0xE7, 0xB9, 0xDE, 0x3B, 0x9D, 0xC3, 0xB9, 0xDC, 0x3F, 0x0F,
  0xC3, 0xF0, 0xFC, 0x3E, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0,
  0x38, 0x78, 0x01, 0xE3, 0xC0, 0x3C, 0x3E, 0x07, 0x81, 0xE0, 0x70, 0x0F,
  0x0F, 0x00, 0x79, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0x9C, 0x00, 0x79, 0xE0,
  0x0F, 0x0F, 0x01, 0xE0, 0x78, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x78, 0x01,
  0xE7, 0x00, 0x1E, 0xF0, 0x03, 0xDC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0E,
  0x78, 0x07, 0x8F, 0x01, 0xE3, 0xC0, 0x70, 0x70, 0x1C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0xE0, 0x3C, 0x78, 0x07, 0x1E, 0x01, 0xE7, 0x00, 0x7B,
  0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x1F, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xC0, 0x00, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0x00, 0x3E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0x01, 0xFF,
  0x03, 0xFF, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0xFF,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x03, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0xFE, 0x00, 0x1E,
  0x00, 0xDF, 0xE0, 0x77, 0xFE, 0x1F, 0x87, 0xFE, 0xE0, 0x7F, 0xB0, 0x07,
  0x80,
};

const GFXglyph UbuntuMono_Regular44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 10, 11, 22, 6, -30 },
  { 36, 20, 27, 22, 1, -27 },
  { 104, 18, 34, 22, 2, -30 },
  { 181, 20, 27, 22, 1, -27 },
  { 249, 20, 27, 22, 1, -27 },
  { 317, 4, 12, 22, 9, -30 },
  { 323, 12, 38, 22, 5, -31 },
  { 380, 12, 38, 22, 5, -31 },
  { 437, 16, 16, 22, 3, -27 },
  { 469, 18, 19, 22, 2, -21 },
  { 512, 8, 12, 22, 7, -6 },
  { 524, 10, 3, 22, 6, -12 },
  { 528, 6, 6, 22, 8, -6 },
  { 533, 16, 38, 22, 3, -31 },
  { 609, 18, 27, 22, 2, -27 },
  { 670, 16, 27, 22, 3, -27 },
  { 724, 17, 27, 22, 3, -27 },
  { 782, 16, 27, 22, 3, -27 },
  { 836, 19, 27, 22, 2, -27 },
  { 901, 16, 27, 22, 3, -27 },
  { 955, 18, 27, 22, 2, -27 },
  { 1016, 17, 27, 22, 3, -27 },
  { 1074, 18, 27, 22, 2, -27 },
  { 1135, 18, 27, 22, 2, -27 },
  { 1196, 6, 20, 22, 8, -20 },
  { 1211, 9, 26, 22, 5, -20 },
  { 1241, 18, 17, 22, 2, -20 },
  { 1280, 18, 11, 22, 2, -17 },
  { 1305, 18, 17, 22, 2, -20 },
  { 1344, 14, 27, 22, 4, -27 },
  { 1392, 19, 33, 22, 2, -27 },
  { 1471, 22, 27, 22, 0, -27 },
  { 1546, 18, 27, 22, 2, -27 },
  { 1607, 18, 27, 22, 2, -27 },
  { 1668, 18, 27, 22, 2, -27 },
  { 1729, 16, 27, 22, 4, -27 },
  { 1783, 15, 27, 22, 4, -27 },
  { 1834, 18, 27, 22, 2, -27 },
  { 1895, 18, 27, 22, 2, -27 },
  { 1956, 14, 27, 22, 4, -27 },
  { 2004, 16, 27, 22, 2, -27 },
  { 2058, 19, 27, 22, 3, -27 },
  { 2123, 16, 27, 22, 4, -27 },
  { 2177, 20, 27, 22, 1, -27 },
  { 2245, 18, 27, 22, 2, -27 },
  { 2306, 20, 27, 22, 1, -27 },
  { 2374, 17, 27, 22, 3, -27 },
  { 2432, 20, 34, 22, 1, -27 },
  { 2517, 18, 27, 22, 2, -27 },
  { 2578, 18, 27, 22, 2, -27 },
  { 2639, 18, 27, 22, 2, -27 },
  { 2700, 18, 27, 22, 2, -27 },
  { 2761, 20, 27, 22, 1, -27 },
  { 2829, 20, 27, 22, 1, -27 },
  { 2897, 20, 27, 22, 1, -27 },
  { 2965, 20, 27, 22, 1, -27 },
  { 3033, 18, 27, 22, 2, -27 },
  { 3094, 11, 38, 22, 6, -31 },
  { 3147, 16, 38, 22, 3, -31 },
  { 3223, 11, 38, 22, 5, -31 },
  { 3276, 18, 15, 22, 2, -27 },
  { 3310, 22, 3, 22, 0, 4 },
  { 3319, 8, 8, 22, 7, -31 },
  { 3327, 16, 20, 22, 3, -20 },
  { 3367, 17, 30, 22, 3, -30 },
  { 3431, 18, 20, 22, 2, -20 },
  { 3476, 17, 30, 22, 2, -30 },
  { 3540, 18, 20, 22, 2, -20 },
  { 3585, 18, 30, 22, 3, -30 },
  { 3653, 17, 27, 22, 2, -20 },
  { 3711, 16, 30, 22, 3, -30 },
  { 3771, 18, 28, 22, 2, -28 },
  { 3834, 14, 35, 22, 3, -28 },
  { 3896, 18, 30, 22, 3, -30 },
  { 3964, 18, 30, 22, 2, -30 },
  { 4032, 18, 20, 22, 2, -20 },
  { 4077, 16, 20, 22, 3, -20 },
  { 4117, 18, 20, 22, 2, -20 },
  { 4162, 17, 27, 22, 3, -20 },
  { 4220, 17, 27, 22, 2, -20 },
  { 4278, 14, 20, 22, 5, -20 },
  { 4313, 16, 20, 22, 3, -20 },
  { 4353, 17, 26, 22, 3, -26 },
  { 4409, 16, 20, 22, 3, -20 },
  { 4449, 20, 20, 22, 1, -20 },
  { 4499, 20, 20, 22, 1, -20 },
  { 4549, 20, 20, 22, 1, -20 },
  { 4599, 18, 27, 22, 2, -20 },
  { 4660, 16, 20, 22, 3, -20 },
  { 4700, 16, 38, 22, 3, -31 },
  { 4776, 4, 38, 22, 9, -31 },
  { 4795, 16, 38, 22, 3, -31 },
  { 4871, 18, 6, 22, 2, -14 },
};

const GFXfont UbuntuMono_Regular44pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular44pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular44pt7bGlyphs,
  0x20, 0x7E, 44
};

#endif // _UBUNTUMONO_REGULAR44PT7B_H_
