#ifndef _UBUNTUMONO_REGULAR14PT7B_H_
#define _UBUNTUMONO_REGULAR14PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular14pt7bBitmaps[] PROGMEM = {
  0x00, 0xFE, 0x80, 0xB6, 0x80, 0x24, 0x4B, 0xF9, 0x42, 0x85, 0x3F, 0xA4,
  0x48, 0x23, 0xE1, 0x0E, 0x1C, 0x31, 0xF1, 0x08, 0x65, 0x4A, 0xA3, 0x41,
  0x05, 0x8A, 0xA5, 0x4C, 0x38, 0x91, 0x21, 0x87, 0x4A, 0xB3, 0x26, 0x74,
  0xF0, 0x2F, 0x49, 0x24, 0xCC, 0x80, 0x99, 0x92, 0x49, 0x7A, 0x00, 0x27,
  0x4C, 0xA5, 0x00, 0x21, 0x09, 0xF2, 0x10, 0x80, 0x6F, 0x00, 0xE0, 0xE0,
  0x08, 0xC4, 0x23, 0x10, 0x8C, 0x42, 0x31, 0x00, 0x74, 0x63, 0x5A, 0xC6,
  0x31, 0x70, 0x33, 0xAC, 0x63, 0x18, 0xC6, 0xF8, 0x74, 0xC2, 0x31, 0x11,
  0x10, 0xF8, 0x74, 0xC2, 0x37, 0x04, 0x21, 0xF0, 0x0C, 0x38, 0xF1, 0x64,
  0xC9, 0xBF, 0x86, 0x0C, 0x7A, 0x10, 0xE1, 0x84, 0x21, 0xF0, 0x3A, 0x21,
  0xE8, 0xC6, 0x39, 0x70, 0xF8, 0x44, 0x22, 0x10, 0x8C, 0x40, 0x74, 0x63,
  0x97, 0x46, 0x31, 0x70, 0x74, 0xE3, 0x18, 0xBC, 0x22, 0xE0, 0xE0, 0x01,
  0xC0, 0xE0, 0x01, 0x96, 0x0B, 0xA0, 0xE0, 0x80, 0xF8, 0x01, 0xF0, 0x83,
  0x82, 0xE8, 0x00, 0xF0, 0xC2, 0x23, 0x10, 0x80, 0x60, 0x7B, 0x28, 0xEF,
  0xAE, 0xBA, 0xEF, 0x81, 0x03, 0x80, 0x10, 0x50, 0xA1, 0x44, 0x48, 0x9F,
  0x22, 0x82, 0xF4, 0xE3, 0x3F, 0x46, 0x31, 0xF0, 0x7E, 0x61, 0x08, 0x42,
  0x18, 0x78, 0xF4, 0xE3, 0x18, 0xC6, 0x33, 0xF0, 0xFC, 0x21, 0x0F, 0xC2,
  0x10, 0xF8, 0xFC, 0x21, 0x0F, 0xC2, 0x10, 0x80, 0x7E, 0x61, 0x08, 0x46,
  0x39, 0x78, 0x8C, 0x63, 0x1F, 0xC6, 0x31, 0x88, 0xF9, 0x08, 0x42, 0x10,
  0x84, 0xF8, 0x78, 0x42, 0x10, 0x84, 0x33, 0xF0, 0x8A, 0x69, 0x28, 0xC2,
  0x89, 0x22, 0x8C, 0x84, 0x21, 0x08, 0x42, 0x10, 0xF8, 0x44, 0xD9, 0xB3,
  0x66, 0xCA, 0x91, 0x22, 0xC6, 0x8E, 0x73, 0x5A, 0xCE, 0x73, 0x88, 0x38,
  0x89, 0x16, 0x3C, 0x78, 0xD1, 0x22, 0x38, 0xF4, 0x63, 0x18, 0xFA, 0x10,
  0x80, 0x38, 0x89, 0x16, 0x3C, 0x78, 0xD1, 0x22, 0x38, 0x20, 0x30, 0xF4,
  0x63, 0x1F, 0x4A, 0x51, 0x88, 0x7C, 0x61, 0x83, 0x04, 0x31, 0xF0, 0xF9,
  0x08, 0x42, 0x10, 0x84, 0x20, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x70, 0xC2,
  0x89, 0x12, 0x26, 0x45, 0x0A, 0x14, 0x10, 0xC6, 0x89, 0x12, 0xA7, 0x4D,
  0x9B, 0x36, 0x44, 0x44, 0xD8, 0xA1, 0xC1, 0x07, 0x0A, 0x22, 0x44, 0xC6,
  0x89, 0x91, 0x43, 0x82, 0x04, 0x08, 0x10, 0xF8, 0x44, 0x62, 0x21, 0x10,
  0xF8, 0xF2, 0x49, 0x24, 0x93, 0x80, 0x86, 0x10, 0x86, 0x10, 0x86, 0x10,
  0x86, 0x10, 0xE4, 0x92, 0x49, 0x27, 0x80, 0x22, 0x95, 0x18, 0x80, 0xFE,
  0x4C, 0x70, 0x42, 0xF8, 0xC5, 0xE0, 0x84, 0x21, 0xE8, 0xC6, 0x31, 0x8F,
  0x80, 0x7E, 0x21, 0x08, 0x61, 0xE0, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0x8B,
  0xC0, 0x74, 0x63, 0xF8, 0x41, 0xE0, 0x3D, 0x84, 0x3E, 0x41, 0x04, 0x10,
  0x41, 0x00, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0xF0, 0x84, 0x21, 0xE8, 0xC6,
  0x31, 0x8C, 0x40, 0x60, 0x38, 0x42, 0x10, 0x84, 0x38, 0x30, 0x71, 0x11,
  0x11, 0x11, 0xF0, 0x82, 0x08, 0x22, 0x92, 0x8C, 0x2C, 0x9A, 0x20, 0xE1,
  0x08, 0x42, 0x10, 0x84, 0x21, 0xC0, 0xFA, 0xAA, 0xEB, 0x8E, 0x38, 0xC0,
  0xF4, 0x63, 0x18, 0xC6, 0x20, 0x74, 0x63, 0x18, 0xC5, 0xC0, 0xF4, 0x63,
  0x18, 0xC7, 0xD0, 0x80, 0x7C, 0x63, 0x18, 0xC5, 0xE1, 0x08, 0x7E, 0x31,
  0x8C, 0x63, 0x00, 0x7C, 0x30, 0xE0, 0xC7, 0xC0, 0x42, 0x3E, 0x84, 0x21,
  0x0C, 0x38, 0x8C, 0x63, 0x18, 0xC5, 0xE0, 0x44, 0x89, 0x11, 0x42, 0x85,
  0x04, 0x00, 0x83, 0x25, 0x53, 0x66, 0xCD, 0x91, 0x00, 0x44, 0x50, 0xE0,
  0x82, 0x8D, 0x91, 0x00, 0x45, 0x16, 0x4A, 0x28, 0x61, 0x04, 0x60, 0xF8,
  0x8C, 0x44, 0x63, 0xE0, 0x39, 0x08, 0x46, 0x61, 0x84, 0x21, 0x08, 0x70,
  0xFF, 0xF0, 0xE1, 0x08, 0x43, 0x0C, 0xC4, 0x21, 0x09, 0xC0, 0xED, 0xC0,
};

const GFXglyph UbuntuMono_Regular14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 1, 9, 7, 3, -9 },
  { 3, 3, 3, 7, 2, -10 },
  { 5, 7, 9, 7, 0, -9 },
  { 13, 5, 11, 7, 1, -10 },
  { 20, 7, 9, 7, 0, -9 },
  { 28, 7, 9, 7, 0, -9 },
  { 36, 1, 4, 7, 3, -10 },
  { 37, 3, 11, 7, 2, -9 },
  { 42, 3, 11, 7, 2, -9 },
  { 47, 5, 5, 7, 1, -9 },
  { 51, 5, 7, 7, 1, -7 },
  { 56, 3, 3, 7, 2, -1 },
  { 58, 3, 1, 7, 2, -4 },
  { 59, 3, 1, 7, 2, -1 },
  { 60, 5, 12, 7, 1, -10 },
  { 68, 5, 9, 7, 1, -9 },
  { 74, 5, 9, 7, 1, -9 },
  { 80, 5, 9, 7, 1, -9 },
  { 86, 5, 9, 7, 1, -9 },
  { 92, 7, 9, 7, 0, -9 },
  { 100, 5, 9, 7, 1, -9 },
  { 106, 5, 9, 7, 1, -9 },
  { 112, 5, 9, 7, 1, -9 },
  { 118, 5, 9, 7, 1, -9 },
  { 124, 5, 9, 7, 1, -9 },
  { 130, 3, 6, 7, 2, -6 },
  { 133, 3, 8, 7, 2, -6 },
  { 136, 5, 5, 7, 1, -6 },
  { 140, 5, 4, 7, 1, -6 },
  { 143, 5, 5, 7, 1, -6 },
  { 147, 5, 9, 7, 1, -9 },
  { 153, 6, 11, 7, 1, -9 },
  { 162, 7, 9, 7, 0, -9 },
  { 170, 5, 9, 7, 1, -9 },
  { 176, 5, 9, 7, 1, -9 },
  { 182, 5, 9, 7, 1, -9 },
  { 188, 5, 9, 7, 1, -9 },
  { 194, 5, 9, 7, 1, -9 },
  { 200, 5, 9, 7, 1, -9 },
  { 206, 5, 9, 7, 1, -9 },
  { 212, 5, 9, 7, 1, -9 },
  { 218, 5, 9, 7, 1, -9 },
  { 224, 6, 9, 7, 1, -9 },
  { 231, 5, 9, 7, 1, -9 },
  { 237, 7, 9, 7, 0, -9 },
  { 245, 5, 9, 7, 1, -9 },
  { 251, 7, 9, 7, 0, -9 },
  { 259, 5, 9, 7, 1, -9 },
  { 265, 7, 11, 7, 0, -9 },
  { 275, 5, 9, 7, 1, -9 },
  { 281, 5, 9, 7, 1, -9 },
  { 287, 5, 9, 7, 1, -9 },
  { 293, 5, 9, 7, 1, -9 },
  { 299, 7, 9, 7, 0, -9 },
  { 307, 7, 9, 7, 0, -9 },
  { 315, 7, 9, 7, 0, -9 },
  { 323, 7, 9, 7, 0, -9 },
  { 331, 5, 9, 7, 1, -9 },
  { 337, 3, 11, 7, 2, -9 },
  { 342, 5, 12, 7, 1, -10 },
  { 350, 3, 11, 7, 2, -9 },
  { 355, 5, 5, 7, 1, -9 },
  { 359, 7, 1, 7, 0, 1 },
  { 360, 3, 2, 7, 2, -9 },
  { 361, 5, 7, 7, 1, -7 },
  { 366, 5, 10, 7, 1, -10 },
  { 373, 5, 7, 7, 1, -7 },
  { 378, 5, 10, 7, 1, -10 },
  { 385, 5, 7, 7, 1, -7 },
  { 390, 6, 10, 7, 1, -10 },
  { 398, 5, 9, 7, 1, -7 },
  { 404, 5, 10, 7, 1, -10 },
  { 411, 5, 9, 7, 1, -9 },
  { 417, 4, 11, 7, 1, -9 },
  { 423, 6, 10, 7, 1, -10 },
  { 431, 5, 10, 7, 1, -10 },
  { 438, 6, 7, 7, 1, -7 },
  { 444, 5, 7, 7, 1, -7 },
  { 449, 5, 7, 7, 1, -7 },
  { 454, 5, 9, 7, 1, -7 },
  { 460, 5, 9, 7, 1, -7 },
  { 466, 5, 7, 7, 1, -7 },
  { 471, 5, 7, 7, 1, -7 },
  { 476, 5, 9, 7, 1, -9 },
  { 482, 5, 7, 7, 1, -7 },
  { 487, 7, 7, 7, 0, -7 },
  { 494, 7, 7, 7, 0, -7 },
  { 501, 7, 7, 7, 0, -7 },
  { 508, 6, 9, 7, 0, -7 },
  { 515, 5, 7, 7, 1, -7 },
  { 520, 5, 12, 7, 1, -10 },
  { 528, 1, 12, 7, 3, -10 },
  { 530, 5, 12, 7, 1, -10 },
  { 538, 5, 2, 7, 1, -5 },
};

const GFXfont UbuntuMono_Regular14pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular14pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular14pt7bGlyphs,
  0x20, 0x7E, 14
};

#endif // _UBUNTUMONO_REGULAR14PT7B_H_
