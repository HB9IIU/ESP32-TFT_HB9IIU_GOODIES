#ifndef _UBUNTUMONO_REGULAR17PT7B_H_
#define _UBUNTUMONO_REGULAR17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular17pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xF5, 0x4C, 0xD9, 0x99, 0x12, 0x12, 0x12, 0xFF, 0x26, 0x24,
  0x24, 0xFF, 0x64, 0x6C, 0x4C, 0x10, 0x21, 0xF6, 0x0C, 0x18, 0x1C, 0x0E,
  0x04, 0x0E, 0x17, 0xC1, 0x02, 0x00, 0x61, 0xD2, 0x96, 0xD4, 0x68, 0x08,
  0x17, 0x35, 0x2D, 0x45, 0x47, 0x71, 0x93, 0x26, 0xC7, 0x0C, 0xAD, 0x4E,
  0x8D, 0x19, 0xD8, 0xD5, 0x40, 0x11, 0xD8, 0x8C, 0x42, 0x10, 0x86, 0x10,
  0xC3, 0x08, 0x86, 0x18, 0x61, 0x08, 0x63, 0x10, 0x8C, 0x44, 0x40, 0x11,
  0xA8, 0xE1, 0xC6, 0x89, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02, 0x04, 0x00,
  0xEF, 0x00, 0xF0, 0xE0, 0x04, 0x30, 0xC2, 0x18, 0x61, 0x04, 0x30, 0x82,
  0x18, 0x41, 0x0C, 0x00, 0x38, 0x9B, 0x14, 0x3B, 0x76, 0xE1, 0xC3, 0xC4,
  0x98, 0xE0, 0x11, 0xCD, 0x04, 0x10, 0x41, 0x04, 0x10, 0x47, 0xC0, 0x79,
  0x18, 0x10, 0x20, 0xC3, 0x0C, 0x30, 0x61, 0x83, 0xF8, 0x79, 0x18, 0x10,
  0x20, 0xC7, 0x03, 0x02, 0x05, 0x1B, 0xE0, 0x0C, 0x38, 0xF1, 0x64, 0xD9,
  0xA3, 0x7F, 0x0C, 0x18, 0x30, 0x7C, 0x81, 0x02, 0x07, 0x81, 0x81, 0x03,
  0x05, 0x1B, 0xE0, 0x1C, 0x61, 0x06, 0x0F, 0x90, 0xA1, 0xC3, 0xC4, 0x88,
  0xE0, 0xFE, 0x08, 0x30, 0x41, 0x82, 0x04, 0x18, 0x20, 0x40, 0x80, 0x79,
  0x8A, 0x16, 0x24, 0xCF, 0x33, 0x43, 0x87, 0x89, 0xE0, 0x79, 0x9A, 0x14,
  0x38, 0x78, 0xDF, 0x02, 0x0C, 0x33, 0x80, 0xE0, 0x01, 0xC0, 0x70, 0x00,
  0x06, 0x2C, 0x06, 0x39, 0xC4, 0x07, 0x03, 0x81, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x80, 0xE0, 0x70, 0x31, 0xCE, 0x20, 0x00, 0xF4, 0xC2, 0x31, 0x98,
  0x8C, 0x40, 0x18, 0x3C, 0x8B, 0x0C, 0xF9, 0x36, 0x6C, 0xD9, 0x93, 0xBD,
  0x03, 0x03, 0xC0, 0x18, 0x1C, 0x14, 0x34, 0x26, 0x22, 0x62, 0x7E, 0x43,
  0x41, 0xC1, 0xF9, 0x1A, 0x14, 0x28, 0xDF, 0x21, 0x43, 0x87, 0x0B, 0xE0,
  0x3C, 0xC7, 0x04, 0x08, 0x10, 0x20, 0x40, 0xC0, 0xC4, 0xF0, 0xF1, 0x1A,
  0x14, 0x38, 0x70, 0xE1, 0xC3, 0x85, 0x1B, 0xC0, 0xFA, 0x08, 0x20, 0x83,
  0xE8, 0x20, 0x82, 0x0F, 0xC0, 0xFE, 0x08, 0x20, 0x83, 0xE8, 0x20, 0x82,
  0x08, 0x00, 0x3C, 0xC7, 0x04, 0x08, 0x10, 0x21, 0xC3, 0xC6, 0xCC, 0xF8,
  0x87, 0x0E, 0x1C, 0x38, 0x7F, 0xE1, 0xC3, 0x87, 0x0E, 0x18, 0xF9, 0x08,
  0x42, 0x10, 0x84, 0x21, 0x3E, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x06,
  0x3F, 0x80, 0x87, 0x1A, 0x24, 0xCB, 0x1C, 0x2C, 0x4C, 0x8D, 0x0E, 0x18,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x82, 0x0F, 0xC0, 0xC5, 0x9B, 0x35,
  0x7A, 0xF6, 0xE4, 0xC1, 0x83, 0x06, 0x08, 0xC7, 0x8F, 0x9D, 0x3B, 0x72,
  0xE5, 0xC7, 0x8F, 0x0E, 0x18, 0x3C, 0x62, 0x43, 0x43, 0x41, 0xC1, 0x41,
  0x43, 0x43, 0x62, 0x3C, 0xF9, 0x8B, 0x1E, 0x3C, 0x78, 0xBE, 0x60, 0xC1,
  0x83, 0x00, 0x3C, 0x62, 0x43, 0x43, 0x41, 0xC1, 0x41, 0x43, 0x43, 0x62,
  0x3C, 0x08, 0x0C, 0x02, 0xF9, 0x1A, 0x14, 0x28, 0x51, 0xBE, 0x4C, 0x8D,
  0x0A, 0x18, 0x7D, 0x8B, 0x06, 0x06, 0x07, 0x03, 0x03, 0x07, 0x0B, 0xE0,
  0xFE, 0x20, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x87, 0x0E,
  0x1C, 0x38, 0x70, 0xE1, 0xC3, 0x87, 0x89, 0xE0, 0xC1, 0x41, 0x43, 0x62,
  0x62, 0x26, 0x26, 0x34, 0x14, 0x1C, 0x18, 0x83, 0x06, 0x0C, 0x1B, 0x36,
  0xEB, 0xD7, 0xCD, 0x9B, 0x10, 0x43, 0x62, 0x26, 0x34, 0x18, 0x18, 0x1C,
  0x34, 0x26, 0x62, 0x43, 0xC1, 0x43, 0x62, 0x26, 0x34, 0x1C, 0x18, 0x08,
  0x08, 0x08, 0x08, 0xFE, 0x08, 0x30, 0xC1, 0x06, 0x08, 0x30, 0x41, 0x83,
  0xF8, 0xFE, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x7C, 0xC1, 0x04,
  0x18, 0x20, 0x83, 0x04, 0x10, 0x61, 0x82, 0x0C, 0x30, 0x40, 0xF1, 0x11,
  0x11, 0x11, 0x11, 0x11, 0x1F, 0x30, 0x71, 0xA2, 0x6C, 0x50, 0xC0, 0xFF,
  0x99, 0x00, 0x78, 0x10, 0x5F, 0xC6, 0x1C, 0x5F, 0xC1, 0x83, 0x06, 0x0F,
  0x98, 0xB1, 0xE3, 0xC7, 0x8F, 0x37, 0xC0, 0x3C, 0x83, 0x04, 0x08, 0x18,
  0x10, 0x1F, 0x04, 0x10, 0x41, 0x7F, 0x18, 0x61, 0x86, 0x1C, 0x5F, 0x39,
  0x8A, 0x1F, 0xF8, 0x10, 0x30, 0x1E, 0x1E, 0x60, 0x81, 0x0F, 0xC4, 0x08,
  0x10, 0x20, 0x40, 0x81, 0x00, 0x7F, 0x18, 0x61, 0x86, 0x1C, 0x5F, 0x04,
  0x3F, 0x80, 0xC3, 0x0C, 0x30, 0xFB, 0x3C, 0x71, 0xC7, 0x1C, 0x71, 0x70,
  0x03, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x3C, 0x18, 0x07, 0xC3, 0x0C,
  0x30, 0xC3, 0x0C, 0x30, 0xC2, 0xF0, 0xC1, 0x83, 0x06, 0x0C, 0x59, 0x34,
  0x70, 0xF1, 0xB3, 0x36, 0x30, 0xF0, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xC0, 0xF0, 0xFD, 0x2E, 0x4C, 0x99, 0x30, 0x60, 0xC1, 0xFB,
  0x3C, 0x71, 0xC7, 0x1C, 0x71, 0x79, 0x8A, 0x1C, 0x38, 0x70, 0xF1, 0x3C,
  0xF9, 0x9B, 0x1E, 0x3C, 0x78, 0xF1, 0x7C, 0xC1, 0x83, 0x00, 0x7F, 0x18,
  0x61, 0x86, 0x1C, 0x5F, 0x04, 0x10, 0x40, 0xFC, 0x21, 0x08, 0x42, 0x10,
  0x7F, 0x0C, 0x1C, 0x1C, 0x18, 0x7E, 0x20, 0x43, 0xF1, 0x02, 0x04, 0x08,
  0x10, 0x20, 0x3C, 0xC7, 0x1C, 0x71, 0xC7, 0x14, 0x5F, 0x87, 0x0F, 0x12,
  0x64, 0x8D, 0x0E, 0x18, 0xC1, 0xC1, 0x49, 0x59, 0x5F, 0x56, 0x66, 0x62,
  0x62, 0x26, 0x3C, 0x18, 0x1C, 0x34, 0x62, 0x43, 0x87, 0x89, 0x12, 0x26,
  0xC5, 0x0E, 0x0C, 0x10, 0x63, 0x80, 0xFC, 0x31, 0x84, 0x21, 0x84, 0x3F,
  0x1C, 0xC3, 0x0C, 0x30, 0x82, 0x30, 0x20, 0x83, 0x0C, 0x30, 0xC1, 0xC0,
  0xFF, 0xFE, 0xF0, 0x41, 0x04, 0x10, 0x41, 0x83, 0x18, 0x41, 0x04, 0x10,
  0x4F, 0x00, 0xE3, 0x38,
};

const GFXglyph UbuntuMono_Regular17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 2, 11, 9, 3, -11 },
  { 4, 4, 4, 9, 2, -12 },
  { 6, 8, 11, 9, 0, -11 },
  { 17, 7, 14, 9, 1, -12 },
  { 30, 8, 11, 9, 0, -11 },
  { 41, 7, 11, 9, 1, -11 },
  { 51, 2, 5, 9, 3, -12 },
  { 53, 5, 14, 9, 2, -11 },
  { 62, 5, 14, 9, 2, -11 },
  { 71, 7, 6, 9, 1, -11 },
  { 77, 7, 7, 9, 1, -8 },
  { 84, 3, 3, 9, 3, -1 },
  { 86, 4, 1, 9, 2, -5 },
  { 87, 3, 1, 9, 3, -1 },
  { 88, 6, 15, 9, 1, -12 },
  { 100, 7, 11, 9, 1, -11 },
  { 110, 6, 11, 9, 1, -11 },
  { 119, 7, 11, 9, 1, -11 },
  { 129, 7, 11, 9, 1, -11 },
  { 139, 7, 11, 9, 1, -11 },
  { 149, 7, 11, 9, 1, -11 },
  { 159, 7, 11, 9, 1, -11 },
  { 169, 7, 11, 9, 1, -11 },
  { 179, 7, 11, 9, 1, -11 },
  { 189, 7, 11, 9, 1, -11 },
  { 199, 3, 6, 9, 3, -6 },
  { 202, 4, 8, 9, 2, -6 },
  { 206, 7, 7, 9, 1, -8 },
  { 213, 7, 4, 9, 1, -6 },
  { 217, 7, 7, 9, 1, -8 },
  { 224, 5, 11, 9, 2, -11 },
  { 231, 7, 13, 9, 1, -11 },
  { 243, 8, 11, 9, 0, -11 },
  { 254, 7, 11, 9, 1, -11 },
  { 264, 7, 11, 9, 1, -11 },
  { 274, 7, 11, 9, 1, -11 },
  { 284, 6, 11, 9, 2, -11 },
  { 293, 6, 11, 9, 2, -11 },
  { 302, 7, 11, 9, 1, -11 },
  { 312, 7, 11, 9, 1, -11 },
  { 322, 5, 11, 9, 2, -11 },
  { 329, 6, 11, 9, 1, -11 },
  { 338, 7, 11, 9, 1, -11 },
  { 348, 6, 11, 9, 2, -11 },
  { 357, 7, 11, 9, 1, -11 },
  { 367, 7, 11, 9, 1, -11 },
  { 377, 8, 11, 9, 0, -11 },
  { 388, 7, 11, 9, 1, -11 },
  { 398, 8, 14, 9, 0, -11 },
  { 412, 7, 11, 9, 1, -11 },
  { 422, 7, 11, 9, 1, -11 },
  { 432, 7, 11, 9, 1, -11 },
  { 442, 7, 11, 9, 1, -11 },
  { 452, 8, 11, 9, 0, -11 },
  { 463, 7, 11, 9, 1, -11 },
  { 473, 8, 11, 9, 0, -11 },
  { 484, 8, 11, 9, 0, -11 },
  { 495, 7, 11, 9, 1, -11 },
  { 505, 5, 14, 9, 2, -11 },
  { 514, 6, 15, 9, 1, -12 },
  { 526, 4, 14, 9, 2, -11 },
  { 533, 7, 6, 9, 1, -11 },
  { 539, 8, 1, 9, 0, 2 },
  { 540, 3, 3, 9, 3, -12 },
  { 542, 6, 8, 9, 1, -8 },
  { 548, 7, 12, 9, 1, -12 },
  { 559, 7, 8, 9, 1, -8 },
  { 566, 6, 12, 9, 1, -12 },
  { 575, 7, 8, 9, 1, -8 },
  { 582, 7, 12, 9, 1, -12 },
  { 593, 6, 11, 9, 1, -8 },
  { 602, 6, 12, 9, 1, -12 },
  { 611, 7, 10, 9, 1, -10 },
  { 620, 6, 13, 9, 1, -10 },
  { 630, 7, 12, 9, 1, -12 },
  { 641, 7, 12, 9, 1, -12 },
  { 652, 7, 8, 9, 1, -8 },
  { 659, 6, 8, 9, 1, -8 },
  { 665, 7, 8, 9, 1, -8 },
  { 672, 7, 11, 9, 1, -8 },
  { 682, 6, 11, 9, 1, -8 },
  { 691, 5, 8, 9, 2, -8 },
  { 696, 6, 8, 9, 1, -8 },
  { 702, 7, 10, 9, 1, -10 },
  { 711, 6, 8, 9, 1, -8 },
  { 717, 7, 8, 9, 1, -8 },
  { 724, 8, 8, 9, 0, -8 },
  { 732, 8, 8, 9, 0, -8 },
  { 740, 7, 11, 9, 1, -8 },
  { 750, 6, 8, 9, 1, -8 },
  { 756, 6, 15, 9, 1, -12 },
  { 768, 1, 15, 9, 4, -12 },
  { 770, 6, 15, 9, 1, -12 },
  { 782, 7, 2, 9, 1, -5 },
};

const GFXfont UbuntuMono_Regular17pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular17pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular17pt7bGlyphs,
  0x20, 0x7E, 17
};

#endif // _UBUNTUMONO_REGULAR17PT7B_H_
