#ifndef _UBUNTUMONO_REGULAR6PT7B_H_
#define _UBUNTUMONO_REGULAR6PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 6pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular6pt7bBitmaps[] PROGMEM = {
  0x00, 0xF0, 0x00, 0x3F, 0x40, 0x51, 0xF4, 0xB9, 0xD0, 0x5B, 0xF0, 0xC0,
  0xF8, 0xF8, 0x48, 0x00, 0x5D, 0x00, 0xC0, 0x80, 0x80, 0x29, 0x20, 0x56,
  0xF0, 0x49, 0x20, 0x45, 0x60, 0xC4, 0xF0, 0x0B, 0x80, 0x78, 0xF0, 0x5A,
  0xF0, 0xE9, 0x20, 0x57, 0xF0, 0x55, 0xA0, 0xA0, 0xB0, 0x38, 0x80, 0x40,
  0x8E, 0x00, 0xF0, 0x57, 0xF6, 0x5B, 0xD0, 0xD7, 0xF0, 0x72, 0x70, 0xD6,
  0xE0, 0xEA, 0xE8, 0x72, 0xF0, 0xB7, 0xD0, 0xF0, 0x64, 0xF0, 0xBB, 0x50,
  0x28, 0xB7, 0xD0, 0xBE, 0xD0, 0x56, 0xF0, 0xD7, 0x40, 0x56, 0xD4, 0xD7,
  0x50, 0x71, 0xF0, 0xE9, 0x20, 0xB6, 0xF0, 0xB6, 0xA0, 0xBE, 0xD0, 0xA9,
  0x50, 0xB5, 0x20, 0xE9, 0x60, 0x70, 0x09, 0x20, 0x70, 0x54, 0x40, 0x80,
  0x4F, 0x80, 0x9A, 0xF0, 0x73, 0x00, 0x2E, 0xF0, 0x5F, 0x00, 0x5D, 0x00,
  0x75, 0xF0, 0x9A, 0xD0, 0x59, 0x20, 0x55, 0x40, 0x97, 0x50, 0x49, 0x20,
  0xFE, 0x80, 0xD6, 0x80, 0x57, 0x80, 0xD7, 0xC0, 0x77, 0x90, 0xE8, 0x4B,
  0x80, 0x1D, 0x20, 0xB7, 0x80, 0xB5, 0x00, 0xBE, 0x80, 0xAA, 0x80, 0xB5,
  0x60, 0x6B, 0x00, 0x4A, 0x24, 0xF8, 0x48, 0xA4, 0xE0,
};

const GFXglyph UbuntuMono_Regular6pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 1, 4, 3, 1, -4 },
  { 2, 1, 1, 3, 1, -4 },
  { 3, 3, 4, 3, 0, -4 },
  { 5, 3, 5, 3, 0, -4 },
  { 7, 3, 4, 3, 0, -4 },
  { 9, 3, 4, 3, 0, -4 },
  { 11, 1, 2, 3, 1, -4 },
  { 12, 1, 5, 3, 1, -4 },
  { 13, 1, 5, 3, 1, -4 },
  { 14, 3, 3, 3, 0, -4 },
  { 16, 3, 3, 3, 0, -3 },
  { 18, 1, 2, 3, 1, -1 },
  { 19, 1, 1, 3, 1, -2 },
  { 20, 1, 1, 3, 1, -1 },
  { 21, 3, 5, 3, 0, -4 },
  { 23, 3, 4, 3, 0, -4 },
  { 25, 3, 4, 3, 0, -4 },
  { 27, 3, 4, 3, 0, -4 },
  { 29, 3, 4, 3, 0, -4 },
  { 31, 3, 4, 3, 0, -4 },
  { 33, 3, 4, 3, 0, -4 },
  { 35, 3, 4, 3, 0, -4 },
  { 37, 3, 4, 3, 0, -4 },
  { 39, 3, 4, 3, 0, -4 },
  { 41, 3, 4, 3, 0, -4 },
  { 43, 1, 3, 3, 1, -3 },
  { 44, 1, 4, 3, 1, -3 },
  { 45, 3, 3, 3, 0, -3 },
  { 47, 3, 1, 3, 0, -2 },
  { 48, 3, 3, 3, 0, -3 },
  { 50, 1, 4, 3, 1, -4 },
  { 51, 3, 5, 3, 0, -4 },
  { 53, 3, 4, 3, 0, -4 },
  { 55, 3, 4, 3, 0, -4 },
  { 57, 3, 4, 3, 0, -4 },
  { 59, 3, 4, 3, 0, -4 },
  { 61, 2, 4, 3, 1, -4 },
  { 62, 2, 4, 3, 1, -4 },
  { 63, 3, 4, 3, 0, -4 },
  { 65, 3, 4, 3, 0, -4 },
  { 67, 1, 4, 3, 1, -4 },
  { 68, 3, 4, 3, 0, -4 },
  { 70, 3, 4, 3, 0, -4 },
  { 72, 2, 4, 3, 1, -4 },
  { 73, 3, 4, 3, 0, -4 },
  { 75, 3, 4, 3, 0, -4 },
  { 77, 3, 4, 3, 0, -4 },
  { 79, 3, 4, 3, 0, -4 },
  { 81, 3, 5, 3, 0, -4 },
  { 83, 3, 4, 3, 0, -4 },
  { 85, 3, 4, 3, 0, -4 },
  { 87, 3, 4, 3, 0, -4 },
  { 89, 3, 4, 3, 0, -4 },
  { 91, 3, 4, 3, 0, -4 },
  { 93, 3, 4, 3, 0, -4 },
  { 95, 3, 4, 3, 0, -4 },
  { 97, 3, 4, 3, 0, -4 },
  { 99, 3, 4, 3, 0, -4 },
  { 101, 1, 5, 3, 1, -4 },
  { 102, 3, 5, 3, 0, -4 },
  { 104, 1, 5, 3, 1, -4 },
  { 105, 3, 2, 3, 0, -4 },
  { 106, 3, 1, 3, 0, 0 },
  { 107, 1, 1, 3, 1, -4 },
  { 108, 3, 3, 3, 0, -3 },
  { 110, 3, 4, 3, 0, -4 },
  { 112, 3, 3, 3, 0, -3 },
  { 114, 3, 4, 3, 0, -4 },
  { 116, 3, 3, 3, 0, -3 },
  { 118, 3, 4, 3, 0, -4 },
  { 120, 3, 4, 3, 0, -3 },
  { 122, 3, 4, 3, 0, -4 },
  { 124, 3, 4, 3, 0, -4 },
  { 126, 2, 5, 3, 0, -4 },
  { 128, 3, 4, 3, 0, -4 },
  { 130, 3, 4, 3, 0, -4 },
  { 132, 3, 3, 3, 0, -3 },
  { 134, 3, 3, 3, 0, -3 },
  { 136, 3, 3, 3, 0, -3 },
  { 138, 3, 4, 3, 0, -3 },
  { 140, 3, 4, 3, 0, -3 },
  { 142, 2, 3, 3, 1, -3 },
  { 143, 3, 3, 3, 0, -3 },
  { 145, 3, 4, 3, 0, -4 },
  { 147, 3, 3, 3, 0, -3 },
  { 149, 3, 3, 3, 0, -3 },
  { 151, 3, 3, 3, 0, -3 },
  { 153, 3, 3, 3, 0, -3 },
  { 155, 3, 4, 3, 0, -3 },
  { 157, 3, 3, 3, 0, -3 },
  { 159, 3, 5, 3, 0, -4 },
  { 161, 1, 5, 3, 1, -4 },
  { 162, 3, 5, 3, 0, -4 },
  { 164, 3, 1, 3, 0, -2 },
};

const GFXfont UbuntuMono_Regular6pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular6pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular6pt7bGlyphs,
  0x20, 0x7E, 6
};

#endif // _UBUNTUMONO_REGULAR6PT7B_H_
