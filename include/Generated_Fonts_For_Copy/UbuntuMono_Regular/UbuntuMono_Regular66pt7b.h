#ifndef _UBUNTUMONO_REGULAR66PT7B_H_
#define _UBUNTUMONO_REGULAR66PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 66pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular66pt7bBitmaps[] PROGMEM = {
  0x00, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F,
  0x1F, 0x8F, 0xC7, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x1F, 0x0F, 0x87, 0xC3,
  0xE1, 0xF0, 0xF8, 0x7C, 0x3C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x3F, 0xBF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFE, 0x3E, 0x00,
  0xF8, 0x3F, 0xF0, 0x7F, 0xE0, 0xFF, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC,
  0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0x80, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x07, 0xB8, 0x0E, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE1, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x03, 0xE0, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1, 0xF0,
  0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E,
  0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x7F, 0xC0, 0x3E, 0x1F, 0xC0, 0x01, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE4, 0x00, 0x03, 0xF9, 0xF0, 0x03, 0xFC, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x3F, 0xE0, 0x00, 0xF0, 0xFF, 0xE0, 0x03, 0xE1,
  0xE3, 0xC0, 0x07, 0x87, 0x87, 0xC0, 0x1F, 0x0F, 0x07, 0x80, 0x7C, 0x1E,
  0x0F, 0x00, 0xF0, 0x78, 0x1E, 0x03, 0xE0, 0xF0, 0x3C, 0x0F, 0x81, 0xE0,
  0x7C, 0x1E, 0x03, 0xC0, 0xF8, 0x7C, 0x07, 0x81, 0xF0, 0xF0, 0x0F, 0x03,
  0xC3, 0xE0, 0x1F, 0x07, 0x8F, 0x80, 0x1E, 0x0F, 0x1E, 0x00, 0x3C, 0x3E,
  0x7C, 0x00, 0x7C, 0x7C, 0xF0, 0x00, 0x7F, 0xF3, 0xE0, 0x00, 0xFF, 0xEF,
  0x80, 0x00, 0xFF, 0x9E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0xF8, 0x00, 0x03, 0xE7, 0xFC, 0x00, 0x0F, 0x9F, 0xFC, 0x00, 0x1E, 0x3C,
  0x78, 0x00, 0x7C, 0xF8, 0x78, 0x01, 0xF1, 0xE0, 0xF0, 0x03, 0xE3, 0xC1,
  0xE0, 0x0F, 0x87, 0x81, 0xE0, 0x1E, 0x0F, 0x03, 0xC0, 0x7C, 0x3E, 0x07,
  0x81, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x0F, 0x80, 0xF0, 0x3C,
  0x1E, 0x01, 0xE0, 0xF8, 0x7C, 0x03, 0xC1, 0xE1, 0xF0, 0x07, 0xC3, 0xC3,
  0xC0, 0x07, 0x8F, 0x0F, 0x80, 0x0F, 0xFE, 0x1E, 0x00, 0x0F, 0xF8, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF8,
  0x0F, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8, 0xFC,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x07, 0xC0, 0x7F, 0xC0, 0x3E, 0x07, 0xFF, 0x81, 0xF0, 0x7E,
  0xFC, 0x0F, 0x07, 0xE3, 0xF0, 0x78, 0x3E, 0x0F, 0xC7, 0xC3, 0xF0, 0x3F,
  0x3E, 0x1F, 0x00, 0xFD, 0xF1, 0xF8, 0x03, 0xFF, 0x0F, 0xC0, 0x1F, 0xF8,
  0x7E, 0x00, 0x7F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x03, 0xFC, 0x1F, 0xC0, 0x7F, 0xF0, 0xFF, 0x8F,
  0xFF, 0xC3, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xF1, 0xF8, 0x7F, 0xFF, 0x0F,
  0xC0, 0xFF, 0xF0, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x73, 0x80, 0x00, 0x01, 0x00, 0x00,
  0xE0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8,
  0x00, 0x0E, 0x00, 0x01, 0x00, 0x10, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0xE0, 0x00, 0x10,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x01, 0x80, 0xF8, 0x0C,
  0xF0, 0x7C, 0x1E, 0x7E, 0x1C, 0x3F, 0x7F, 0xCE, 0x7F, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xEF, 0x80, 0x03, 0xF7, 0xE0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0xFE, 0x01, 0xF8, 0x3F, 0x01, 0xFC, 0x1F, 0xC0, 0x7C, 0x07, 0xC0, 0x1E,
  0x03, 0xC0, 0x02, 0x00, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3F, 0x83, 0xFC,
  0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x3F, 0xE1, 0xFF, 0x07, 0xF8, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0xFE, 0x1F, 0xE3, 0xFE, 0x1F, 0xE0, 0xFC, 0x03, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x3E,
  0x3F, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xC1, 0xFE, 0x07, 0xE0, 0x0F, 0xC1, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x1F,
  0x87, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xC0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xFF, 0xE0, 0x70, 0x3F,
  0xFC, 0x1F, 0x07, 0xFF, 0x87, 0xF0, 0xFF, 0xF0, 0xFE, 0x1F, 0xFE, 0x1F,
  0xC3, 0xFF, 0xC3, 0xF8, 0x7F, 0xF8, 0x7F, 0x0F, 0xFF, 0x07, 0xC1, 0xFF,
  0xE0, 0x70, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00,
  0x1F, 0xBE, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF1, 0xF0, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xF0, 0x07,
  0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xF0, 0x7F, 0x80, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF,
  0x00, 0x7F, 0xDF, 0x00, 0xFF, 0x1F, 0x00, 0x7E, 0x1F, 0x00, 0x78, 0x1F,
  0x00, 0x60, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xF8, 0x1F, 0xF1, 0xF0,
  0x03, 0xF8, 0xE0, 0x00, 0xFC, 0x20, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xC1, 0xF0, 0x1F, 0xE0, 0x40, 0x03, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x90,
  0x00, 0x1F, 0xCF, 0x00, 0x3F, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00,
  0x3E, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00, 0xF0,
  0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x83, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x98, 0x00, 0x1F, 0xCF, 0x80, 0x7F, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF1, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0x3E, 0x00, 0x0F, 0xCF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x1F, 0x9F,
  0x80, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFF, 0x03, 0xF8, 0x1F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0x81, 0xFF,
  0x0F, 0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0,
  0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0xF8,
  0xFC, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xF8, 0x1F, 0xC0,
  0x7E, 0x03, 0xFF, 0x1F, 0x80, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x03, 0xF1, 0xFF, 0xC0, 0xFC, 0x07,
  0xFC, 0x3F, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF9, 0xF0, 0x00, 0x3F, 0x3E,
  0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF9, 0xFC,
  0x00, 0x7F, 0x1F, 0xE0, 0x3F, 0xC3, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x81, 0xFE, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0xF9,
  0xFC, 0x00, 0x1F, 0x1F, 0xE0, 0x1F, 0xE3, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0x83, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0x8F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xF8,
  0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x3F, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0xFE, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF1, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF7, 0xF1, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFE, 0x0F,
  0xF8, 0x3F, 0xE0, 0xFF, 0x81, 0xFC, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x7F, 0x03, 0xFE, 0x0F, 0xF8,
  0x3F, 0xE0, 0xFF, 0xC3, 0xFF, 0x07, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x7C,
  0x03, 0xF0, 0x1F, 0x83, 0xFC, 0x3F, 0xE0, 0x7F, 0x01, 0xF0, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF,
  0xC0, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xE0, 0x00, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x20, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x03, 0xFF, 0xE0, 0x01,
  0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xFC, 0x3F,
  0xFF, 0xF1, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3C, 0x07, 0xF9, 0x80, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x80, 0x01,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0,
  0x00, 0x7E, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x7F, 0x83, 0xFC, 0x0F, 0xE0, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x3F,
  0x7E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x7F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF,
  0xFF, 0x83, 0xFC, 0x1F, 0xF8, 0x3F, 0x01, 0xFF, 0x83, 0xF0, 0x1F, 0xF8,
  0x7E, 0x01, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x7E, 0x01, 0xFF, 0x87, 0xC0,
  0x1F, 0xF8, 0x7C, 0x01, 0xFF, 0x87, 0xE0, 0x1F, 0xF8, 0x7E, 0x01, 0xFF,
  0x83, 0xE0, 0x1F, 0xF8, 0x3E, 0x01, 0xFF, 0xC3, 0xF0, 0x1F, 0xFC, 0x1F,
  0xC1, 0xF7, 0xC1, 0xFF, 0xFF, 0x7C, 0x0F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF,
  0x7E, 0x03, 0xFF, 0xF3, 0xF0, 0x0F, 0xF8, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x01, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x7C, 0x7C, 0x00,
  0x00, 0xF8, 0xF8, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x07, 0xC1, 0xF0, 0x00,
  0x0F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0x1F, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80,
  0x03, 0xE0, 0x1F, 0x00, 0x07, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0xFE, 0x1F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xF8, 0x7C, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x07,
  0xDF, 0x80, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0x3E, 0x3F, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3E, 0x00, 0xFF, 0x8F,
  0x80, 0x0F, 0xE3, 0xE0, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F,
  0xCF, 0x80, 0x03, 0xF3, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3E, 0x00,
  0x0F, 0x8F, 0x80, 0x07, 0xE3, 0xE0, 0x03, 0xF0, 0xF8, 0x07, 0xF8, 0x3F,
  0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFF, 0x8F, 0x80, 0x1F, 0xF3, 0xE0, 0x01, 0xFC, 0xF8, 0x00,
  0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xEF, 0x80, 0x07, 0xFB, 0xE0, 0x07,
  0xFC, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xF8, 0x0F, 0x83, 0xFC, 0x00, 0x30, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0x01, 0x07, 0xFE, 0x01, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3E, 0x03, 0xFF, 0x0F, 0x80, 0x1F, 0xE3,
  0xE0, 0x03, 0xF8, 0xF8, 0x00, 0x7F, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x01,
  0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xBE,
  0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x7F,
  0x3E, 0x00, 0x3F, 0x8F, 0x80, 0x1F, 0xE3, 0xE0, 0x3F, 0xF0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xE7, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xF8, 0x1F,
  0x83, 0xFC, 0x00, 0x70, 0xFE, 0x00, 0x04, 0x1F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBF,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x1F, 0x3F, 0x80, 0x03, 0xE3, 0xF8, 0x00, 0x7C, 0x3F,
  0xC0, 0x0F, 0x87, 0xFE, 0x03, 0xF0, 0x7F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xF8, 0x00, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x40, 0x00, 0x7E,
  0x70, 0x01, 0xFC, 0x7C, 0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xEF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F,
  0xC0, 0xFC, 0x03, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x07, 0xE0, 0x0F,
  0xC0, 0xFE, 0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x7F,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0xFD, 0xFE, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0xFC, 0x7F, 0x80,
  0x0F, 0xC3, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x0F, 0xC0, 0xFF, 0x00, 0xFC,
  0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0x80, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x0F,
  0xE0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x8F,
  0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x07, 0xEF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0x81, 0xFC, 0x01, 0xFE, 0x1F, 0xE0, 0x0F, 0xF0, 0xFF, 0x00,
  0x7F, 0x87, 0xFC, 0x03, 0xFC, 0x3D, 0xE0, 0x3D, 0xE1, 0xEF, 0x01, 0xEF,
  0x0F, 0x7C, 0x0F, 0x78, 0x79, 0xE0, 0xF3, 0xC3, 0xCF, 0x07, 0x9E, 0x1E,
  0x78, 0x3C, 0xF0, 0xF1, 0xE3, 0xC7, 0xC7, 0x8F, 0x1E, 0x3E, 0x7C, 0x78,
  0xF1, 0xF3, 0xE1, 0xEF, 0x0F, 0x9F, 0x0F, 0x78, 0x7C, 0xF8, 0x7B, 0xC3,
  0xE7, 0xC1, 0xFC, 0x1F, 0x3E, 0x0F, 0xE0, 0xF9, 0xF0, 0x7F, 0x07, 0xCF,
  0x81, 0xF0, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x00, 0x0F, 0x9F, 0x00,
  0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x7F,
  0xFE, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFE, 0xF8, 0x03, 0xFF, 0x7C, 0x01, 0xFF, 0x9F, 0x00, 0xFF, 0xCF, 0x80,
  0x7F, 0xE3, 0xE0, 0x3F, 0xF1, 0xF0, 0x1F, 0xF8, 0x7C, 0x0F, 0xFC, 0x3E,
  0x07, 0xFE, 0x0F, 0x83, 0xFF, 0x07, 0xC1, 0xFF, 0x81, 0xF0, 0xFF, 0xC0,
  0xF8, 0x7F, 0xE0, 0x3E, 0x3F, 0xF0, 0x1F, 0x1F, 0xF8, 0x07, 0x8F, 0xFC,
  0x03, 0xE7, 0xFE, 0x00, 0xF3, 0xFF, 0x00, 0x7D, 0xFF, 0x80, 0x3E, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF8, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0, 0x3F, 0xC0,
  0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF0,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x1F, 0x3F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7C, 0x3F, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x1F, 0xC0, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC7, 0xC0,
  0x0F, 0xF3, 0xE0, 0x01, 0xFD, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x1F, 0x7C,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xDF, 0x00, 0x1F, 0xEF, 0x80, 0x3F,
  0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xF0,
  0x3F, 0xC0, 0x7F, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x07,
  0xE1, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x1F, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x7E,
  0x3F, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x07, 0xF0, 0x3F,
  0xC0, 0xFF, 0x80, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x30, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xC1, 0xF0, 0x07, 0xFC, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x03, 0xF8,
  0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C, 0x7C, 0x00,
  0x0F, 0x8F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x01,
  0xF8, 0x7C, 0x00, 0x7F, 0x0F, 0x80, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xE0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x8F, 0x80,
  0x01, 0xF1, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7E,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFE, 0x01, 0xF1, 0xFC,
  0x00, 0x10, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0xA0,
  0x00, 0x0F, 0xDC, 0x00, 0x0F, 0xFF, 0xC0, 0x1F, 0xEF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xCF,
  0xE0, 0x03, 0xF8, 0xFC, 0x00, 0xFE, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x7C, 0x3F, 0x00,
  0x00, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x0F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x00,
  0xF8, 0x07, 0xE0, 0x01, 0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x7C, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0xC0,
  0x01, 0xF0, 0x1F, 0x00, 0x03, 0xF0, 0x3E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00,
  0x1F, 0x1F, 0x00, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x7D, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x7C, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07,
  0xCF, 0x80, 0x00, 0x3E, 0x7C, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x0F, 0x9F,
  0x07, 0xF0, 0x7C, 0xF8, 0x3F, 0x83, 0xE7, 0xC1, 0xFC, 0x1F, 0x3E, 0x1E,
  0xF0, 0xF9, 0xF0, 0xF7, 0x87, 0xCF, 0x87, 0xBC, 0x3E, 0x7C, 0x78, 0xF1,
  0xF3, 0xE3, 0xC7, 0x8F, 0x0F, 0x1E, 0x3C, 0x78, 0x79, 0xE0, 0xF3, 0xC3,
  0xCF, 0x07, 0x9E, 0x1E, 0x78, 0x3C, 0xF0, 0xF7, 0x81, 0xF7, 0x87, 0xBC,
  0x07, 0xBC, 0x3D, 0xE0, 0x3D, 0xE1, 0xFE, 0x01, 0xFF, 0x0F, 0xF0, 0x07,
  0xF8, 0x7F, 0x80, 0x3F, 0x83, 0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7E,
  0x00, 0x01, 0xF3, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7E,
  0xFC, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7F, 0x7F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7E, 0x3F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFD,
  0xF8, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3E, 0x00, 0x01, 0xF8,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF,
  0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07,
  0xE0, 0x3F, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x0F, 0x8F, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xF7, 0x80, 0x00, 0x3C, 0x20, 0x00, 0x02, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x10, 0x06, 0x01, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x00, 0x40, 0x03, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81, 0xFF, 0xFF,
  0xE0, 0x60, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x0F,
  0xFD, 0xF8, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0x7F,
  0x80, 0x3F, 0xBF, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x1F, 0xBF, 0xC0, 0x0F, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x38, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0xFE, 0x00,
  0xFB, 0xFF, 0xC0, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0x8F, 0xF8, 0x1F, 0xE7, 0xE0, 0x07, 0xF3, 0xE0, 0x01, 0xFD, 0xF0, 0x00,
  0x7E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFF,
  0x00, 0x03, 0xFF, 0x80, 0x03, 0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x01, 0xFD,
  0xF0, 0x01, 0xFC, 0xFC, 0x03, 0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x03, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x18, 0x3F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0x1F, 0x01, 0xFF, 0xEF,
  0x83, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF3, 0xFC, 0x0F,
  0xF9, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xFC, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xF7,
  0xE0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xFC, 0x00, 0x3E, 0x7F, 0x00, 0x1F,
  0x1F, 0xE0, 0x0F, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0x3F, 0xC0, 0xFF, 0x0F, 0xE0, 0x07, 0xF3, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x60, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xF0,
  0x1E, 0x00, 0xFC, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF,
  0xFF, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF9, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x3E, 0xFE, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x3F,
  0x3F, 0xC0, 0x7F, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFE, 0xF8, 0x03, 0xFC, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE4, 0x00,
  0x0F, 0xE3, 0xC0, 0x1F, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF9, 0xFF, 0x00, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFE, 0x03, 0xFC,
  0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x18, 0x00, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x80, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x40, 0x07, 0xF7, 0x80, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFC,
  0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF0,
  0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x1F, 0xC0, 0x3E, 0x07,
  0xF0, 0x07, 0xC1, 0xFC, 0x00, 0xF8, 0x7F, 0x00, 0x1F, 0x1F, 0xC0, 0x03,
  0xE7, 0xF0, 0x00, 0x7D, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x07, 0xDF, 0xC0, 0x00, 0xF9, 0xFC, 0x00, 0x1F,
  0x1F, 0xC0, 0x03, 0xE0, 0xFE, 0x00, 0x7C, 0x0F, 0xE0, 0x0F, 0x80, 0xFE,
  0x01, 0xF0, 0x0F, 0xE0, 0x3E, 0x00, 0xFE, 0x07, 0xC0, 0x0F, 0xC0, 0xF8,
  0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F,
  0xCF, 0x80, 0x01, 0xFD, 0xF0, 0x00, 0x1F, 0x80, 0xFF, 0xFC, 0x00, 0x3F,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0x80, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x7C, 0x0F, 0xFF, 0x9F, 0xF0, 0xFF, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xEF, 0x83, 0xF8, 0x7E, 0xF8,
  0x1F, 0x03, 0xEF, 0x81, 0xF0, 0x3E, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0,
  0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF,
  0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F,
  0x01, 0xFF, 0x81, 0xF0, 0x1F, 0xF8, 0x1F, 0x01, 0xFF, 0x80, 0x00, 0x1F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8,
  0x00, 0x01, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFC, 0x03, 0xFC, 0xF8, 0x00, 0xFC,
  0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3E,
  0xF8, 0x00, 0x3E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0, 0x0F, 0xE3,
  0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0xFB, 0xF0, 0x00,
  0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7E, 0xF8,
  0x00, 0x0F, 0x9F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0xFE, 0x3F, 0x80, 0x3F,
  0x83, 0xFC, 0x1F, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xE0, 0x1F, 0xE3, 0xE0, 0x03, 0xF9, 0xF0, 0x00, 0xFE, 0xF8, 0x00,
  0x3F, 0x7C, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0xFE,
  0xFC, 0x00, 0xFE, 0x7F, 0x80, 0xFF, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xDF, 0xFE, 0x03, 0xE3, 0xFC, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xF8, 0xFF, 0x00, 0xFC, 0xFE, 0x00, 0x3E, 0xFE, 0x00, 0x1F, 0x7E, 0x00,
  0x0F, 0xBF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF,
  0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7D, 0xF8, 0x00, 0x3E, 0xFE, 0x00, 0x1F,
  0x3F, 0x80, 0x1F, 0x9F, 0xE0, 0x3F, 0xC7, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0x7C, 0x01, 0xFC, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFB, 0xFC,
  0x00, 0x6F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xE1, 0xFC, 0x01, 0xE1, 0xF8, 0x00, 0x10, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x60, 0x00, 0x3F, 0x3F, 0x00, 0x7F, 0x9F, 0xFF, 0xFF, 0xCF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x0F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF8, 0x06, 0x00, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E,
  0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3F, 0xC0, 0x3F, 0x1F, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xF0, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7C, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xE0, 0x3E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F,
  0xBE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0x1F, 0x3E, 0x03, 0xE0, 0x3E, 0x7C,
  0x07, 0xC0, 0x7C, 0xF8, 0x0F, 0x80, 0xF9, 0xF0, 0x1F, 0x81, 0xF1, 0xE0,
  0x7F, 0x03, 0xC3, 0xE0, 0xFE, 0x07, 0x87, 0xC1, 0xFC, 0x1F, 0x0F, 0x87,
  0xBC, 0x3E, 0x1F, 0x0F, 0x78, 0x7C, 0x3E, 0x1E, 0xF0, 0xF8, 0x7C, 0x78,
  0xF1, 0xE0, 0x78, 0xF1, 0xE3, 0xC0, 0xF9, 0xE3, 0xC7, 0x81, 0xF7, 0x83,
  0xDF, 0x03, 0xEF, 0x07, 0xBE, 0x07, 0xDE, 0x0F, 0x78, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0xC0, 0x3F, 0x80, 0x3F,
  0x80, 0x7F, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x0F, 0x80, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0xFC, 0x00, 0x7E, 0x07, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x3F, 0x3E, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xF3, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F,
  0x3F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F,
  0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x03,
  0xF0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x1F, 0x83,
  0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0xFC, 0x7C, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x7E, 0x7C, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x40, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFF, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x07, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF,
  0x00, 0x07, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x07,
  0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x1F,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x40, 0x7F, 0xC0, 0x07, 0xC7, 0xFF, 0x80, 0x3C, 0x7F, 0xFF,
  0x03, 0xE3, 0xFF, 0xFE, 0x3F, 0x3F, 0x1F, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF,
  0x8F, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0xFF, 0x80, 0x80, 0x01, 0xF0, 0x00,
};

const GFXglyph UbuntuMono_Regular66pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 33, 0, -1 },
  { 1, 9, 41, 33, 12, -41 },
  { 48, 15, 16, 33, 9, -45 },
  { 78, 29, 41, 33, 2, -41 },
  { 227, 26, 52, 33, 4, -46 },
  { 396, 31, 41, 33, 1, -41 },
  { 555, 29, 41, 33, 2, -41 },
  { 704, 5, 18, 33, 14, -45 },
  { 716, 18, 57, 33, 7, -46 },
  { 845, 18, 57, 33, 7, -46 },
  { 974, 25, 24, 33, 4, -41 },
  { 1049, 27, 29, 33, 3, -32 },
  { 1147, 13, 18, 33, 10, -9 },
  { 1177, 15, 5, 33, 9, -19 },
  { 1187, 9, 9, 33, 12, -9 },
  { 1198, 23, 57, 33, 5, -46 },
  { 1362, 27, 41, 33, 3, -41 },
  { 1501, 24, 41, 33, 5, -41 },
  { 1624, 25, 41, 33, 4, -41 },
  { 1753, 25, 41, 33, 4, -41 },
  { 1882, 29, 41, 33, 2, -41 },
  { 2031, 25, 41, 33, 4, -41 },
  { 2160, 26, 41, 33, 4, -41 },
  { 2294, 26, 41, 33, 4, -41 },
  { 2428, 27, 41, 33, 3, -41 },
  { 2567, 27, 41, 33, 3, -41 },
  { 2706, 9, 30, 33, 12, -30 },
  { 2740, 14, 39, 33, 8, -30 },
  { 2809, 27, 27, 33, 3, -30 },
  { 2901, 27, 18, 33, 3, -26 },
  { 2962, 27, 27, 33, 3, -30 },
  { 3054, 21, 41, 33, 6, -41 },
  { 3162, 28, 50, 33, 3, -41 },
  { 3337, 31, 41, 33, 1, -41 },
  { 3496, 26, 41, 33, 4, -41 },
  { 3630, 27, 41, 33, 3, -41 },
  { 3769, 26, 41, 33, 4, -41 },
  { 3903, 24, 41, 33, 6, -41 },
  { 4026, 23, 41, 33, 6, -41 },
  { 4144, 27, 41, 33, 3, -41 },
  { 4283, 27, 41, 33, 3, -41 },
  { 4422, 21, 41, 33, 6, -41 },
  { 4530, 24, 41, 33, 4, -41 },
  { 4653, 28, 41, 33, 4, -41 },
  { 4797, 24, 41, 33, 6, -41 },
  { 4920, 29, 41, 33, 2, -41 },
  { 5069, 25, 41, 33, 4, -41 },
  { 5198, 29, 41, 33, 2, -41 },
  { 5347, 25, 41, 33, 5, -41 },
  { 5476, 29, 51, 33, 2, -41 },
  { 5661, 27, 41, 33, 4, -41 },
  { 5800, 25, 41, 33, 4, -41 },
  { 5929, 27, 41, 33, 3, -41 },
  { 6068, 27, 41, 33, 3, -41 },
  { 6207, 31, 41, 33, 1, -41 },
  { 6366, 29, 41, 33, 2, -41 },
  { 6515, 29, 41, 33, 2, -41 },
  { 6664, 31, 41, 33, 1, -41 },
  { 6823, 26, 41, 33, 4, -41 },
  { 6957, 16, 57, 33, 9, -46 },
  { 7071, 23, 57, 33, 5, -46 },
  { 7235, 16, 57, 33, 8, -46 },
  { 7349, 27, 22, 33, 3, -41 },
  { 7424, 31, 5, 33, 1, 6 },
  { 7444, 11, 12, 33, 11, -46 },
  { 7461, 25, 31, 33, 4, -31 },
  { 7558, 25, 46, 33, 5, -46 },
  { 7702, 27, 31, 33, 3, -31 },
  { 7807, 25, 46, 33, 3, -46 },
  { 7951, 27, 31, 33, 3, -31 },
  { 8056, 28, 46, 33, 4, -46 },
  { 8217, 25, 42, 33, 3, -31 },
  { 8349, 24, 46, 33, 5, -46 },
  { 8487, 26, 44, 33, 4, -44 },
  { 8630, 20, 55, 33, 5, -44 },
  { 8768, 27, 46, 33, 5, -46 },
  { 8924, 26, 46, 33, 4, -46 },
  { 9074, 28, 31, 33, 3, -31 },
  { 9183, 24, 31, 33, 5, -31 },
  { 9276, 27, 31, 33, 3, -31 },
  { 9381, 25, 42, 33, 5, -31 },
  { 9513, 25, 42, 33, 3, -31 },
  { 9645, 22, 31, 33, 7, -31 },
  { 9731, 25, 31, 33, 4, -31 },
  { 9828, 26, 41, 33, 4, -41 },
  { 9962, 24, 31, 33, 4, -31 },
  { 10055, 29, 31, 33, 2, -31 },
  { 10168, 31, 31, 33, 1, -31 },
  { 10289, 29, 31, 33, 2, -31 },
  { 10402, 28, 42, 33, 2, -31 },
  { 10549, 23, 31, 33, 5, -31 },
  { 10639, 23, 57, 33, 5, -46 },
  { 10803, 5, 57, 33, 14, -46 },
  { 10839, 23, 57, 33, 5, -46 },
  { 11003, 29, 10, 33, 2, -22 },
};

const GFXfont UbuntuMono_Regular66pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular66pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular66pt7bGlyphs,
  0x20, 0x7E, 66
};

#endif // _UBUNTUMONO_REGULAR66PT7B_H_
