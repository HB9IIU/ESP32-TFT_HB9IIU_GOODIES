#ifndef _UBUNTUMONO_REGULAR42PT7B_H_
#define _UBUNTUMONO_REGULAR42PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 42pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular42pt7bBitmaps[] PROGMEM = {
  0x00, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x73, 0x9C, 0xE7, 0x39, 0xCE, 0x00,
  0x00, 0x07, 0x7F, 0xFF, 0xFB, 0x80, 0xF1, 0xFE, 0x3F, 0xC7, 0xF8, 0xFF,
  0x1C, 0xC1, 0x98, 0x33, 0x06, 0x60, 0xCC, 0x18, 0x03, 0xC3, 0x80, 0x70,
  0x70, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x78, 0x0F, 0x0E, 0x01, 0xC1,
  0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x1C, 0x3C, 0x07, 0x87,
  0x00, 0xE0, 0xE0, 0x1C, 0x1C, 0x03, 0x87, 0x80, 0xF0, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x8E, 0x0E, 0x01, 0xC3, 0xC0, 0x78, 0x70,
  0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07, 0x0F, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF,
  0xF8, 0xF8, 0x0C, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x80,
  0x0E, 0x70, 0x1F, 0x7F, 0xFF, 0x1F, 0xFF, 0x03, 0xFE, 0x00, 0x1C, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0x3C, 0x00, 0xEF,
  0xE0, 0x3B, 0x9C, 0x0E, 0x71, 0xC1, 0xCC, 0x38, 0x71, 0x87, 0x0E, 0x30,
  0xE3, 0x86, 0x1C, 0xE0, 0xC3, 0x9C, 0x1C, 0x77, 0x03, 0x9C, 0xC0, 0x3F,
  0xB8, 0x03, 0xCE, 0x00, 0x01, 0xCF, 0x00, 0x77, 0xF0, 0x1C, 0xE7, 0x03,
  0xB8, 0xE0, 0xE7, 0x1C, 0x1C, 0xE1, 0x87, 0x1C, 0x31, 0xC3, 0x86, 0x38,
  0x71, 0xCE, 0x0E, 0x39, 0xC0, 0xE7, 0x70, 0x1F, 0xDC, 0x00, 0xF0, 0x03,
  0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x1E, 0x03, 0xC1, 0xC0, 0x70,
  0x38, 0x0E, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x38, 0x03, 0xCF, 0x00, 0x3F,
  0xC0, 0x07, 0xE0, 0x00, 0xF8, 0x38, 0x3F, 0x87, 0x0F, 0x78, 0xE3, 0xC7,
  0x9C, 0x70, 0x7B, 0x8E, 0x07, 0xE3, 0xC0, 0xFC, 0x78, 0x0F, 0x8F, 0x00,
  0xF0, 0xF0, 0x3F, 0x1F, 0x1F, 0xE1, 0xFF, 0xDE, 0x1F, 0xF1, 0xC1, 0xF8,
  0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x40, 0x38, 0x0F, 0x83, 0xE0,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x38, 0x0F, 0x01,
  0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x3C, 0x07, 0x80, 0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0x00, 0x20, 0x40, 0x0E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00,
  0xE0, 0x1C, 0x03, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x70,
  0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x01, 0xC0, 0x20, 0x00, 0x01, 0xC0,
  0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x06, 0x1C, 0x33, 0xCE, 0x79, 0xFB,
  0xFC, 0x7F, 0xFC, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xDE, 0x01, 0xC7, 0x81,
  0xE3, 0xC0, 0xE0, 0xE0, 0x10, 0x40, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70,
  0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x0E,
  0x0F, 0x87, 0xE7, 0xF1, 0xF8, 0x7C, 0x1C, 0x1E, 0x3E, 0x7E, 0x1E, 0x0C,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0xFB, 0xFF, 0xF7, 0xC7, 0x00, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78,
  0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xFC, 0x07,
  0xFF, 0x07, 0xC7, 0xC7, 0x80, 0xE3, 0xC0, 0x79, 0xC0, 0x1D, 0xE0, 0x0F,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x71, 0xFC, 0x7C, 0xFE, 0x3E, 0x3F, 0x1F,
  0x1F, 0x87, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEE,
  0x00, 0xE7, 0x80, 0xF3, 0xC0, 0x70, 0xF8, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8,
  0x01, 0xF0, 0x00, 0x00, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0xFE, 0x07, 0xFC,
  0x1F, 0xB8, 0x1E, 0x70, 0x30, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x3F, 0xFF,
  0x7F, 0xFE, 0xFF, 0xFC, 0x07, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x0F, 0x07,
  0xC2, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x01, 0xC0, 0x01, 0xE0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xBF, 0xFF, 0xC0,
  0x0F, 0xE0, 0x1F, 0xFC, 0x1F, 0xFF, 0x07, 0x07, 0xC2, 0x01, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x1F, 0x00,
  0xFF, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x79, 0x80,
  0xF8, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xF7, 0x80, 0x39, 0xE0,
  0x1C, 0x78, 0x0E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0xE0, 0x78, 0x38,
  0x1E, 0x1C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x78, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x3F, 0xFE, 0x3F, 0xFE, 0x3F,
  0xFE, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x7F, 0xF8, 0x01, 0xFC, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x1E, 0xC0, 0x7C, 0xFF, 0xFC, 0xFF, 0xF0, 0x3F, 0xC0, 0x00,
  0x1E, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C, 0xFC, 0x0F, 0xFF,
  0x8F, 0xFF, 0xE7, 0xC0, 0xFB, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xEE, 0x00, 0xF7, 0x80, 0x73, 0xC0, 0x78, 0xF8, 0x7C,
  0x3F, 0xFC, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0x70, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x07, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x07,
  0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0xF3, 0x80, 0x39,
  0xC0, 0x1C, 0xE0, 0x0E, 0x78, 0x07, 0x3C, 0x07, 0x0F, 0x07, 0x87, 0xF7,
  0x80, 0xFF, 0x80, 0xFF, 0xE0, 0xF1, 0xF8, 0xF0, 0x3E, 0x70, 0x07, 0x78,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x39, 0xF0, 0x7C,
  0x7F, 0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x0F,
  0xFF, 0x0F, 0x87, 0xC7, 0x80, 0xF3, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0E,
  0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xEF, 0x00, 0xF7, 0xC0, 0xF9, 0xFF,
  0xFC, 0x7F, 0xFE, 0x0F, 0xEE, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0xE0, 0x7F, 0xC0, 0x3F, 0xC0,
  0x1E, 0x00, 0x00, 0x38, 0xFB, 0xFF, 0xF7, 0xC7, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0E, 0x3E, 0xFF, 0xFD, 0xF1, 0xC0, 0x0E, 0x0F, 0x8F,
  0xE7, 0xF1, 0xF0, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x38, 0x3E, 0x1F, 0x9F, 0xC7, 0xE1, 0xF0, 0x70, 0x78, 0xF9, 0xF8,
  0x78, 0x30, 0x00, 0x00, 0x01, 0x00, 0x03, 0xC0, 0x0F, 0xE0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x00, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x40, 0x00, 0x3C, 0x00, 0x3F, 0x80, 0x0F, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0x80,
  0x0F, 0xC0, 0x1F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0xF0, 0x00, 0x40, 0x00, 0x00, 0x3F, 0xC7, 0xFF, 0x3F, 0xFC, 0x81, 0xF0,
  0x07, 0x80, 0x1C, 0x00, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x80, 0x38, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0x70, 0x00,
  0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x78, 0x3C, 0x3C, 0x07, 0x8E,
  0x00, 0xE7, 0x80, 0x39, 0xC0, 0x0F, 0x70, 0x03, 0xFC, 0x0F, 0xFE, 0x0F,
  0xFF, 0x87, 0xFF, 0xE1, 0xE3, 0xF8, 0xF0, 0xFE, 0x38, 0x3F, 0x8E, 0x0F,
  0xE3, 0x83, 0xF8, 0xE0, 0xFE, 0x38, 0x3F, 0x8F, 0x0F, 0xF1, 0xE3, 0xFC,
  0x7F, 0xF7, 0x0F, 0xFD, 0xC0, 0xFE, 0x78, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xF8,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xB8, 0x00, 0x1D,
  0xC0, 0x01, 0xEF, 0x00, 0x0E, 0x38, 0x00, 0x71, 0xC0, 0x07, 0x8F, 0x00,
  0x38, 0x38, 0x01, 0xC1, 0xC0, 0x1E, 0x0F, 0x00, 0xE0, 0x38, 0x07, 0x01,
  0xC0, 0x38, 0x0E, 0x03, 0x80, 0x78, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x0F,
  0xFF, 0xF8, 0x70, 0x01, 0xC3, 0x80, 0x0E, 0x1C, 0x00, 0x71, 0xE0, 0x03,
  0xCE, 0x00, 0x1E, 0x70, 0x00, 0x77, 0x80, 0x03, 0x80, 0x7F, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x1E, 0xF0, 0x0E, 0x78, 0x0F, 0x3C, 0x0F, 0x1F, 0xFF, 0x0F, 0xFF,
  0x87, 0xFF, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x7B, 0xC0, 0xFD, 0xFF, 0xFC,
  0xFF, 0xFC, 0x3F, 0xF0, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3,
  0xE0, 0xF3, 0xE0, 0x11, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x06, 0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF,
  0x00, 0x7F, 0x80, 0x7F, 0xF8, 0x3F, 0xFE, 0x1E, 0x0F, 0x8F, 0x01, 0xE7,
  0x80, 0x7B, 0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x01, 0xEF, 0x00, 0xF7, 0x80, 0xF3,
  0xC1, 0xF1, 0xFF, 0xF0, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0xFF, 0xFD, 0xFF,
  0xFB, 0xFF, 0xF7, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xCF, 0xFF, 0x9F, 0xFF,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00, 0x01,
  0xFC, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xE0, 0xE3, 0xE0, 0x11, 0xE0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x07, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xDC, 0x00, 0xEF, 0x00, 0x77, 0xC0, 0x39, 0xF0, 0x1C, 0x7C, 0x0E,
  0x1F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0E, 0x00, 0x0E, 0x40, 0x1E, 0x70, 0x3E, 0xFF, 0xFC, 0x7F, 0xF8,
  0x1F, 0xE0, 0xE0, 0x0F, 0x38, 0x03, 0xCE, 0x01, 0xE3, 0x80, 0xF0, 0xE0,
  0x7C, 0x38, 0x1E, 0x0E, 0x0F, 0x03, 0x87, 0x80, 0xE3, 0xC0, 0x39, 0xF0,
  0x0E, 0xF8, 0x03, 0xBC, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x0E, 0xF8, 0x03,
  0x9F, 0x00, 0xE3, 0xE0, 0x38, 0x7C, 0x0E, 0x0F, 0x83, 0x81, 0xF0, 0xE0,
  0x3C, 0x38, 0x07, 0x8E, 0x00, 0xF3, 0x80, 0x3C, 0xE0, 0x07, 0xB8, 0x01,
  0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x6C, 0x1B, 0x0D, 0xC3, 0x73, 0xB8, 0xEE, 0x73, 0x19, 0xCE,
  0x63, 0x39, 0xCE, 0xE7, 0x38, 0xDC, 0xE7, 0x1B, 0x1C, 0xE3, 0xE3, 0x9C,
  0x3C, 0x73, 0x87, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC0, 0x07, 0x38,
  0x00, 0xE7, 0x00, 0x1C, 0xE0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3C, 0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x80,
  0x7F, 0xC0, 0x3F, 0x70, 0x1F, 0xB8, 0x0F, 0xCE, 0x07, 0xE7, 0x03, 0xF1,
  0xC1, 0xF8, 0xE0, 0xFC, 0x38, 0x7E, 0x1C, 0x3F, 0x07, 0x1F, 0x83, 0x8F,
  0xC0, 0xE7, 0xE0, 0x73, 0xF0, 0x3D, 0xF8, 0x0E, 0xFC, 0x07, 0x7E, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xC0,
  0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x0F, 0x07, 0x83, 0xC0, 0x78,
  0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80, 0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xC0, 0x07, 0x3C, 0x01, 0xE7,
  0x80, 0x3C, 0x78, 0x0F, 0x07, 0x83, 0xC0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00,
  0x7F, 0x00, 0x7F, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x1E, 0xF0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFC, 0x0F, 0x07, 0x83, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0x80,
  0x0E, 0x70, 0x01, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xEE, 0x00,
  0x39, 0xC0, 0x07, 0x3C, 0x01, 0xE7, 0x80, 0x3C, 0x78, 0x0F, 0x0F, 0x83,
  0xE0, 0xFF, 0xF8, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0x1C, 0x7F, 0xE0,
  0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0x7B, 0xC0,
  0x3D, 0xE0, 0x0E, 0xF0, 0x07, 0x78, 0x07, 0xBC, 0x03, 0xDE, 0x03, 0xCF,
  0x03, 0xE7, 0xFF, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0xF0, 0x70, 0x78, 0x3C,
  0x3C, 0x0E, 0x1E, 0x03, 0x8F, 0x01, 0xE7, 0x80, 0x73, 0xC0, 0x3D, 0xE0,
  0x0E, 0xF0, 0x07, 0xF8, 0x01, 0xC0, 0x03, 0xF8, 0x07, 0xFF, 0x0F, 0xFF,
  0x87, 0x81, 0xC7, 0x80, 0x23, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x78,
  0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x7A, 0x00, 0x79, 0xC0, 0x7D, 0xFF, 0xFC, 0x7F, 0xFC, 0x07,
  0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x38, 0x00, 0x1C,
  0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E,
  0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7B, 0xC0, 0x79, 0xF0, 0x7C, 0x7F,
  0xFC, 0x1F, 0xFC, 0x03, 0xF8, 0x00, 0xE0, 0x00, 0xEF, 0x00, 0x0E, 0xF0,
  0x01, 0xEF, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x80, 0x1C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x38, 0x03, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xE0, 0xF0, 0x0E, 0x0E, 0x00, 0xE0, 0xE0, 0x0F, 0x1E,
  0x00, 0xF1, 0xE0, 0x07, 0x1C, 0x00, 0x7B, 0xC0, 0x07, 0xBC, 0x00, 0x3B,
  0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xF7, 0x00, 0x1C, 0xE0,
  0x03, 0x9C, 0x00, 0x73, 0x80, 0x0E, 0x70, 0x01, 0xCE, 0x00, 0x39, 0xC3,
  0x87, 0x38, 0xF0, 0xE7, 0x1F, 0x1C, 0xE3, 0x63, 0x9C, 0xEC, 0x73, 0x9D,
  0xCE, 0x73, 0x19, 0xCE, 0x63, 0x39, 0xDC, 0x77, 0x3B, 0x0E, 0xC3, 0x60,
  0xD8, 0x7C, 0x1F, 0x0F, 0x83, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x87, 0x80,
  0xF0, 0x78, 0x01, 0xCF, 0x00, 0x78, 0xF0, 0x1E, 0x1E, 0x03, 0xC1, 0xE0,
  0xF0, 0x1C, 0x1C, 0x03, 0xC7, 0x80, 0x3C, 0xE0, 0x07, 0xBC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x00, 0xF8, 0x00, 0x0E, 0x00, 0x03, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xBC, 0x00, 0xE3, 0x80, 0x3C, 0x78, 0x0F, 0x07,
  0x81, 0xE0, 0xF0, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x03,
  0xDE, 0x00, 0x3C, 0xF0, 0x01, 0xEF, 0x00, 0x1E, 0x70, 0x01, 0xC7, 0x80,
  0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x78, 0x3C, 0x07, 0x81, 0xE0, 0xF0, 0x1E,
  0x0F, 0x00, 0xF1, 0xE0, 0x0F, 0x1E, 0x00, 0x7B, 0xC0, 0x03, 0xB8, 0x00,
  0x3F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00,
  0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xE0, 0x00, 0x0E, 0x00, 0x7F, 0xFF, 0xBF, 0xFF,
  0xDF, 0xFF, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1C, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0xE0, 0x38, 0x0E,
  0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80,
  0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x00,
  0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0,
  0x01, 0xE0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFC, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C,
  0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xC0, 0x01, 0xF0, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0xF7, 0x80, 0x71, 0xC0, 0x78, 0xF0, 0x38, 0x38, 0x3C,
  0x1E, 0x3C, 0x07, 0x9E, 0x03, 0xDE, 0x00, 0xFE, 0x00, 0x3B, 0x00, 0x18,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x20, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC1, 0x00, 0x0F, 0xF0, 0x1F, 0xFC, 0x1F, 0xFE, 0x10, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x00, 0x07, 0x07, 0xFF, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C,
  0x07, 0x70, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x7C, 0x07, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xFE, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE7, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF8, 0x3E, 0xF0, 0x1E, 0xE0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x1E, 0xE0, 0x7E, 0xFF, 0xFC, 0xFF,
  0xF0, 0x3F, 0xC0, 0x01, 0xFE, 0x07, 0xFF, 0x87, 0xFF, 0xC7, 0xE0, 0x27,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x03, 0x1F, 0xFF, 0x87, 0xFF, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x07, 0xE7, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x1F,
  0x78, 0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x07, 0x7E, 0x07,
  0x3F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC, 0x03, 0xF0, 0x07, 0xFE, 0x0F, 0xFF,
  0x87, 0xC3, 0xE7, 0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0xFC, 0x04, 0x3F, 0xFF, 0x07, 0xFF, 0x80, 0xFF, 0x00, 0x00,
  0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xE0, 0xF0, 0x30, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x3F, 0xFF, 0x9F, 0xFF,
  0xCF, 0xFF, 0xE0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x07, 0xFC, 0x1F, 0xFF, 0x3F, 0xFF, 0x7C, 0x07, 0x78, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x07, 0xF0, 0x07, 0xF8, 0x07, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07,
  0xE7, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x60, 0x3E, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xBF, 0x87, 0xFF, 0xCF, 0xFF, 0xDE, 0x07, 0xB8, 0x07, 0xF0, 0x0F, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xE0,
  0x07, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x70, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x00,
  0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x07, 0xC2, 0x01, 0xFF, 0x80, 0x7F, 0xC0, 0x1F, 0x80, 0x00, 0xF0,
  0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF9, 0xFF, 0xCF, 0xFE, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3D, 0x83,
  0xDF, 0xFE, 0xFF, 0xE1, 0xFC, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x03, 0xDC, 0x03, 0xCE, 0x03, 0xC7, 0x03, 0xC3,
  0x83, 0xC1, 0xC7, 0xC0, 0xE7, 0xC0, 0x77, 0xC0, 0x3F, 0x80, 0x1F, 0xE0,
  0x0E, 0xF8, 0x07, 0x1E, 0x03, 0x87, 0x81, 0xC1, 0xE0, 0xE0, 0x78, 0x70,
  0x1E, 0x38, 0x07, 0x9C, 0x01, 0xEE, 0x00, 0x78, 0xFF, 0x80, 0x7F, 0xC0,
  0x3F, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07,
  0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03, 0x80, 0x01, 0xC0, 0x00, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xF0, 0x80, 0x7F, 0xE0, 0x1F, 0xF0, 0x07, 0xE0, 0x7E, 0x3E,
  0x7F, 0xFF, 0xBF, 0xFF, 0xFC, 0x7C, 0xFE, 0x1C, 0x3F, 0x0E, 0x1F, 0x87,
  0x0F, 0xC3, 0x87, 0xE1, 0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xE0, 0x3F, 0xE1, 0xFF, 0xF3, 0xFF, 0xF7, 0x01, 0xEE, 0x01,
  0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0,
  0x1F, 0x80, 0x38, 0x07, 0xF0, 0x0F, 0xFE, 0x0F, 0xFF, 0x8F, 0x83, 0xE7,
  0x80, 0xF7, 0x80, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3D, 0xE0, 0x3C, 0xF8,
  0x3E, 0x3F, 0xFE, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0xFF, 0xF0,
  0xFF, 0xFC, 0xE0, 0x7E, 0xE0, 0x1E, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x1E, 0xF8, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xE7, 0xE0, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0x03, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0x7E, 0x07, 0x78, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0x78, 0x07, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF,
  0x07, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x00, 0x0F, 0xF8, 0x7F, 0xF9, 0xFF, 0xF7, 0xC0, 0x6F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x03,
  0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xF8, 0x1F, 0xFF, 0xFD, 0xFF, 0xF0,
  0x7F, 0x80, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x82, 0x07, 0xFF,
  0x07, 0xFF, 0x01, 0xFC, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xBE, 0x07, 0x7F, 0xFE,
  0x7F, 0xFC, 0x3F, 0xE0, 0xF0, 0x01, 0xEE, 0x00, 0x39, 0xE0, 0x0F, 0x3C,
  0x01, 0xE3, 0x80, 0x38, 0x78, 0x0F, 0x0F, 0x01, 0xE0, 0xE0, 0x38, 0x1E,
  0x0F, 0x01, 0xC1, 0xC0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0x71, 0xC0, 0x0F,
  0x78, 0x00, 0xEE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03,
  0x80, 0x00, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x0E, 0x0F, 0xE1, 0xC3, 0xDC, 0x3C, 0x73, 0x8F, 0x8E, 0x71, 0xF1, 0xCE,
  0x37, 0x39, 0xCE, 0xE7, 0x39, 0xDC, 0xE3, 0xF1, 0xF8, 0x7E, 0x3F, 0x0F,
  0x83, 0xE1, 0xF0, 0x7C, 0x3E, 0x0F, 0x83, 0x80, 0xE0, 0x70, 0x1C, 0x00,
  0x78, 0x03, 0xC7, 0x80, 0xF0, 0xF0, 0x1C, 0x0F, 0x07, 0x80, 0xF1, 0xE0,
  0x0F, 0x78, 0x01, 0xEE, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x0F, 0xE0, 0x01, 0xDC, 0x00, 0x79, 0xC0, 0x1E, 0x3C, 0x07, 0x83, 0xC0,
  0xE0, 0x3C, 0x38, 0x07, 0x8F, 0x00, 0x7B, 0xC0, 0x07, 0x80, 0xF0, 0x03,
  0xF8, 0x03, 0xDC, 0x01, 0xEF, 0x00, 0xE7, 0x80, 0x71, 0xC0, 0x78, 0xF0,
  0x3C, 0x78, 0x1C, 0x1C, 0x0E, 0x0F, 0x0F, 0x03, 0x87, 0x01, 0xE3, 0x80,
  0xF3, 0xC0, 0x39, 0xC0, 0x1E, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x3C, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x07, 0xFC, 0x0F, 0xF8,
  0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E,
  0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80,
  0x1E, 0x01, 0xFC, 0x03, 0xE0, 0x07, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0xFC, 0x0F, 0xF8,
  0x07, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFE, 0x01, 0xFF, 0x03, 0xFE, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xFC, 0x00, 0xF8, 0x07, 0xF0, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC1, 0xFF, 0x03, 0xFE, 0x07, 0xF0, 0x00,
  0x1E, 0x01, 0xBF, 0xC1, 0xDF, 0xF8, 0xFC, 0x7F, 0xEC, 0x0F, 0xF6, 0x01,
  0xE0,
};

const GFXglyph UbuntuMono_Regular42pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 21, 0, -1 },
  { 1, 5, 26, 21, 8, -26 },
  { 18, 11, 10, 21, 5, -29 },
  { 32, 19, 26, 21, 1, -26 },
  { 94, 17, 33, 21, 2, -29 },
  { 165, 19, 26, 21, 1, -26 },
  { 227, 19, 26, 21, 1, -26 },
  { 289, 3, 11, 21, 9, -29 },
  { 294, 11, 36, 21, 5, -29 },
  { 344, 11, 36, 21, 5, -29 },
  { 394, 17, 15, 21, 2, -26 },
  { 426, 17, 19, 21, 2, -21 },
  { 467, 9, 12, 21, 6, -6 },
  { 481, 9, 3, 21, 6, -12 },
  { 485, 7, 6, 21, 7, -6 },
  { 491, 15, 36, 21, 3, -29 },
  { 559, 17, 26, 21, 2, -26 },
  { 615, 15, 26, 21, 3, -26 },
  { 664, 17, 26, 21, 2, -26 },
  { 720, 17, 26, 21, 2, -26 },
  { 776, 18, 26, 21, 2, -26 },
  { 835, 16, 26, 21, 3, -26 },
  { 887, 17, 26, 21, 2, -26 },
  { 943, 16, 26, 21, 3, -26 },
  { 995, 17, 26, 21, 2, -26 },
  { 1051, 17, 26, 21, 2, -26 },
  { 1107, 7, 20, 21, 7, -20 },
  { 1125, 9, 26, 21, 5, -20 },
  { 1155, 17, 17, 21, 2, -19 },
  { 1192, 17, 11, 21, 2, -17 },
  { 1216, 17, 17, 21, 2, -19 },
  { 1253, 13, 26, 21, 4, -26 },
  { 1296, 18, 32, 21, 2, -26 },
  { 1368, 21, 26, 21, 0, -26 },
  { 1437, 17, 26, 21, 2, -26 },
  { 1493, 17, 26, 21, 2, -26 },
  { 1549, 17, 26, 21, 2, -26 },
  { 1605, 15, 26, 21, 4, -26 },
  { 1654, 15, 26, 21, 4, -26 },
  { 1703, 17, 26, 21, 2, -26 },
  { 1759, 17, 26, 21, 2, -26 },
  { 1815, 13, 26, 21, 4, -26 },
  { 1858, 16, 26, 21, 2, -26 },
  { 1910, 18, 26, 21, 3, -26 },
  { 1969, 15, 26, 21, 4, -26 },
  { 2018, 19, 26, 21, 1, -26 },
  { 2080, 17, 26, 21, 2, -26 },
  { 2136, 19, 26, 21, 1, -26 },
  { 2198, 16, 26, 21, 3, -26 },
  { 2250, 19, 32, 21, 1, -26 },
  { 2326, 17, 26, 21, 2, -26 },
  { 2382, 17, 26, 21, 2, -26 },
  { 2438, 17, 26, 21, 2, -26 },
  { 2494, 17, 26, 21, 2, -26 },
  { 2550, 20, 26, 21, 1, -26 },
  { 2615, 19, 26, 21, 1, -26 },
  { 2677, 19, 26, 21, 1, -26 },
  { 2739, 20, 26, 21, 1, -26 },
  { 2804, 17, 26, 21, 2, -26 },
  { 2860, 10, 36, 21, 6, -29 },
  { 2905, 15, 36, 21, 3, -29 },
  { 2973, 10, 36, 21, 5, -29 },
  { 3018, 17, 14, 21, 2, -26 },
  { 3048, 21, 3, 21, 0, 4 },
  { 3056, 7, 7, 21, 7, -29 },
  { 3063, 16, 19, 21, 2, -19 },
  { 3101, 16, 29, 21, 3, -29 },
  { 3159, 17, 19, 21, 2, -19 },
  { 3200, 16, 29, 21, 2, -29 },
  { 3258, 17, 19, 21, 2, -19 },
  { 3299, 17, 29, 21, 3, -29 },
  { 3361, 16, 26, 21, 2, -19 },
  { 3413, 15, 29, 21, 3, -29 },
  { 3468, 17, 27, 21, 2, -27 },
  { 3526, 13, 34, 21, 3, -27 },
  { 3582, 17, 29, 21, 3, -29 },
  { 3644, 17, 29, 21, 2, -29 },
  { 3706, 17, 19, 21, 2, -19 },
  { 3747, 15, 19, 21, 3, -19 },
  { 3783, 17, 19, 21, 2, -19 },
  { 3824, 16, 26, 21, 3, -19 },
  { 3876, 16, 26, 21, 2, -19 },
  { 3928, 14, 19, 21, 4, -19 },
  { 3962, 15, 19, 21, 3, -19 },
  { 3998, 16, 25, 21, 3, -25 },
  { 4048, 15, 19, 21, 3, -19 },
  { 4084, 19, 19, 21, 1, -19 },
  { 4130, 19, 19, 21, 1, -19 },
  { 4176, 19, 19, 21, 1, -19 },
  { 4222, 17, 26, 21, 2, -19 },
  { 4278, 15, 19, 21, 3, -19 },
  { 4314, 15, 36, 21, 3, -29 },
  { 4382, 3, 36, 21, 9, -29 },
  { 4396, 15, 36, 21, 3, -29 },
  { 4464, 17, 6, 21, 2, -14 },
};

const GFXfont UbuntuMono_Regular42pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular42pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular42pt7bGlyphs,
  0x20, 0x7E, 42
};

#endif // _UBUNTUMONO_REGULAR42PT7B_H_
