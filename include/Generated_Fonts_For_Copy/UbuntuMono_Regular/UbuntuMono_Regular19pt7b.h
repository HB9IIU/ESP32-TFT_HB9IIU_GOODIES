#ifndef _UBUNTUMONO_REGULAR19PT7B_H_
#define _UBUNTUMONO_REGULAR19PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 19pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular19pt7bBitmaps[] PROGMEM = {
  0x00, 0x6D, 0xB6, 0x90, 0x0F, 0xB0, 0xCE, 0x52, 0x94, 0x80, 0x32, 0x32,
  0x26, 0xFF, 0xFF, 0x64, 0x64, 0x64, 0xFF, 0xFF, 0x4C, 0xC8, 0x10, 0x10,
  0x3E, 0x7E, 0xC0, 0xC0, 0x70, 0x7C, 0x0E, 0x02, 0x82, 0xFE, 0x7C, 0x10,
  0x10, 0x71, 0xA8, 0xB4, 0xDA, 0x45, 0x43, 0xE0, 0x2C, 0x39, 0x14, 0x92,
  0x59, 0x28, 0x60, 0x78, 0x7C, 0xCC, 0x48, 0x78, 0x72, 0xDA, 0x8E, 0x84,
  0xCE, 0xFA, 0x73, 0xFA, 0x80, 0x08, 0xCC, 0xC4, 0x63, 0x18, 0xC6, 0x10,
  0xC3, 0x0C, 0x20, 0x43, 0x0C, 0x21, 0x84, 0x21, 0x08, 0x46, 0x23, 0x71,
  0x00, 0x18, 0x33, 0x4F, 0xF1, 0x05, 0x99, 0x00, 0x10, 0x10, 0x10, 0x10,
  0xFF, 0x10, 0x10, 0x10, 0x10, 0x67, 0x72, 0x6C, 0xF0, 0x7D, 0x80, 0x06,
  0x0C, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x10, 0x60, 0xC1, 0x06, 0x0C, 0x10,
  0x60, 0x3C, 0x7E, 0xC6, 0xC2, 0xC3, 0x9B, 0x9B, 0xC3, 0xC2, 0xC6, 0x7E,
  0x3C, 0x08, 0x31, 0xA2, 0x40, 0x81, 0x02, 0x04, 0x08, 0x11, 0xFB, 0xF0,
  0x7D, 0xFD, 0x18, 0x30, 0x60, 0x82, 0x08, 0x20, 0x83, 0xFF, 0xF0, 0x7D,
  0xF9, 0x18, 0x30, 0x67, 0x8F, 0x03, 0x03, 0x0F, 0xFB, 0xE0, 0x0C, 0x0C,
  0x1C, 0x34, 0x64, 0x44, 0xC4, 0xFF, 0xFF, 0x04, 0x04, 0x04, 0x7E, 0xFD,
  0x83, 0x07, 0x8F, 0xC1, 0x81, 0x03, 0x0F, 0xFB, 0xE0, 0x0E, 0x3E, 0x70,
  0x40, 0xFC, 0xFE, 0xC6, 0xC3, 0xC2, 0xC6, 0x7E, 0x3C, 0xFF, 0xFF, 0x06,
  0x06, 0x0C, 0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x30, 0x3C, 0x7E, 0xC6,
  0xC2, 0xE6, 0x7C, 0x7E, 0xC6, 0x83, 0xC2, 0xFE, 0x7C, 0x3C, 0x7E, 0xC6,
  0xC2, 0xC2, 0xC2, 0x7E, 0x3E, 0x06, 0x0C, 0x78, 0x70, 0x7D, 0x80, 0x1F,
  0x60, 0x37, 0x30, 0x00, 0x37, 0x33, 0x24, 0x02, 0x1C, 0x70, 0xC0, 0x70,
  0x1C, 0x02, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x0E, 0x03, 0x0E, 0x70,
  0xC0, 0x7B, 0xF8, 0xC2, 0x18, 0xC2, 0x00, 0x01, 0x87, 0x18, 0x3C, 0x7E,
  0x63, 0xC3, 0xC3, 0x8F, 0x9F, 0x93, 0x93, 0xDF, 0xCF, 0xC0, 0x60, 0x3E,
  0x1E, 0x0C, 0x0E, 0x05, 0x82, 0xC3, 0x21, 0x18, 0x8C, 0xC6, 0x7F, 0x3F,
  0xD0, 0x78, 0x30, 0xFC, 0xFE, 0xC6, 0xC6, 0xC6, 0xFC, 0xFE, 0xC6, 0xC3,
  0xC6, 0xFE, 0xFC, 0x1E, 0x7F, 0x62, 0xC0, 0xC0, 0x80, 0x80, 0xC0, 0xC0,
  0x61, 0x7F, 0x3E, 0xF8, 0xFC, 0xC6, 0xC2, 0xC3, 0xC3, 0xC3, 0xC3, 0xC2,
  0xC6, 0xFC, 0xF8, 0xFD, 0xFA, 0x04, 0x08, 0x1F, 0xBF, 0x40, 0x81, 0x03,
  0xFF, 0xF0, 0xFF, 0xF8, 0x20, 0x83, 0xFF, 0xE0, 0x82, 0x08, 0x20, 0x1E,
  0x7F, 0x62, 0xC0, 0xC0, 0x80, 0x83, 0xC3, 0xC3, 0x63, 0x7F, 0x3F, 0x83,
  0x83, 0x83, 0x83, 0x83, 0xFF, 0xFF, 0x83, 0x83, 0x83, 0x83, 0x83, 0xFF,
  0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xFF, 0x7E, 0xFC, 0x18, 0x30,
  0x60, 0xC1, 0x83, 0x07, 0x0F, 0xF3, 0xC0, 0xC3, 0xC6, 0xCC, 0xD8, 0xF8,
  0xF0, 0xF0, 0xD8, 0xCC, 0xC6, 0xC3, 0xC3, 0x81, 0x02, 0x04, 0x08, 0x10,
  0x20, 0x40, 0x81, 0x03, 0xFF, 0xF0, 0xC6, 0xC6, 0xA6, 0xA6, 0xAB, 0xAB,
  0x9B, 0x9B, 0x83, 0x83, 0x83, 0x83, 0xC3, 0x86, 0x8D, 0x19, 0x32, 0x62,
  0xC5, 0x8F, 0x0E, 0x1C, 0x10, 0x3C, 0x7E, 0xC6, 0xC3, 0x83, 0x83, 0x83,
  0x83, 0xC3, 0xC6, 0x7E, 0x3C, 0xFC, 0xFE, 0xC6, 0xC3, 0xC3, 0xC6, 0xFE,
  0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C, 0x7E, 0xC6, 0xC3, 0x83, 0x83, 0x83,
  0x83, 0xC3, 0xC6, 0x7E, 0x3C, 0x18, 0x0E, 0x06, 0xF8, 0xFE, 0xC6, 0xC2,
  0xC2, 0xC6, 0xFC, 0xF8, 0xCC, 0xC4, 0xC6, 0xC3, 0x3C, 0xFF, 0x0E, 0x06,
  0x0F, 0x07, 0x83, 0x03, 0x07, 0xFB, 0xE0, 0xFF, 0xFF, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x83, 0x83, 0x83, 0x83, 0x83,
  0x83, 0x83, 0x83, 0xC3, 0xC6, 0x7E, 0x3C, 0xC0, 0xA0, 0xD8, 0x6C, 0x26,
  0x11, 0x18, 0xCC, 0x64, 0x16, 0x0F, 0x07, 0x01, 0x80, 0x83, 0x83, 0x83,
  0x83, 0x9B, 0x9B, 0xAB, 0xAA, 0xA6, 0xA6, 0xC6, 0xC6, 0x61, 0x91, 0x8C,
  0x82, 0xC1, 0xC0, 0x60, 0x70, 0x3C, 0x32, 0x11, 0x98, 0x48, 0x30, 0xC1,
  0xB0, 0xD8, 0x46, 0x63, 0x20, 0xF0, 0x70, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xFF, 0xFF, 0x06, 0x04, 0x0C, 0x18, 0x30, 0x20, 0x60, 0xC0, 0xFF,
  0xFF, 0xF8, 0x88, 0x88, 0x88, 0x88, 0x88, 0x88, 0xF0, 0xC0, 0x81, 0x83,
  0x02, 0x06, 0x0C, 0x08, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x81, 0x83, 0xF8,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8F, 0xE0, 0x18, 0x38, 0x2C,
  0x66, 0xC2, 0x83, 0xFF, 0x80, 0x4C, 0x80, 0x7C, 0xFC, 0x09, 0xFC, 0x38,
  0x70, 0xFF, 0x7E, 0xC0, 0xC0, 0xC0, 0xC0, 0xFC, 0xFE, 0xC6, 0xC3, 0xC3,
  0xC3, 0xC6, 0xFE, 0xFC, 0x3E, 0x7E, 0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7E,
  0x3F, 0x02, 0x04, 0x08, 0x13, 0xEF, 0xF1, 0xE1, 0x83, 0x87, 0x0B, 0xF3,
  0xE0, 0x3C, 0x7E, 0xC3, 0xFF, 0x80, 0xC0, 0xE0, 0x7E, 0x3E, 0x1F, 0x3F,
  0x30, 0x30, 0xFE, 0xFE, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x30, 0x3E,
  0xFF, 0x0E, 0x18, 0x30, 0x70, 0xBF, 0x3E, 0x0F, 0xFF, 0xE0, 0xC1, 0x83,
  0x06, 0x0F, 0xDF, 0xF1, 0xE1, 0xC3, 0x87, 0x0E, 0x1C, 0x20, 0x30, 0x30,
  0x00, 0xF0, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1E, 0x1E, 0x0C, 0x30,
  0x1F, 0x7C, 0x10, 0x41, 0x04, 0x10, 0x41, 0x0D, 0xF7, 0x80, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC6, 0xCC, 0xD8, 0xF0, 0xF0, 0xD8, 0xCC, 0xC6, 0xC3, 0xF0,
  0xF0, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x10, 0x1E, 0x0E,
  0xFE, 0xFF, 0x93, 0x9B, 0x9B, 0x9B, 0x83, 0x83, 0x83, 0xFD, 0xFF, 0x1E,
  0x1C, 0x38, 0x70, 0xE1, 0xC2, 0x3C, 0x7E, 0xC6, 0xC3, 0x83, 0xC3, 0xC6,
  0x7E, 0x3C, 0xFC, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC6, 0xFE, 0xFC, 0xC0,
  0xC0, 0xC0, 0x3E, 0xFF, 0x0E, 0x18, 0x38, 0x70, 0xBF, 0x3E, 0x04, 0x08,
  0x10, 0x7F, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC0, 0x3E, 0xFF, 0x03, 0x87,
  0xC1, 0xE0, 0xFF, 0x7C, 0x30, 0x30, 0x30, 0xFE, 0xFE, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x3E, 0x1E, 0xC3, 0x87, 0x0E, 0x1C, 0x38, 0x70, 0xBF, 0x3E,
  0x83, 0xC2, 0xC2, 0x46, 0x64, 0x6C, 0x2C, 0x38, 0x18, 0xC0, 0xA0, 0x53,
  0x69, 0xB5, 0xDA, 0xA9, 0xCC, 0xE6, 0x23, 0x00, 0xC2, 0x66, 0x2C, 0x38,
  0x18, 0x3C, 0x64, 0xC6, 0x83, 0xC3, 0xC2, 0x46, 0x66, 0x64, 0x24, 0x3C,
  0x18, 0x18, 0x18, 0xF0, 0xE0, 0x7E, 0xFC, 0x30, 0x41, 0x04, 0x18, 0x7F,
  0xFE, 0x0E, 0x20, 0x40, 0x81, 0x02, 0x04, 0x18, 0xE0, 0x60, 0x40, 0x81,
  0x02, 0x04, 0x0F, 0xFF, 0xFF, 0xF0, 0x30, 0x60, 0xC1, 0x83, 0x02, 0x04,
  0x06, 0x10, 0x60, 0xC1, 0x83, 0x06, 0x78, 0x73, 0xFE, 0x8E,
};

const GFXglyph UbuntuMono_Regular19pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 3, 12, 10, 3, -12 },
  { 6, 5, 5, 10, 2, -13 },
  { 10, 8, 12, 10, 1, -12 },
  { 22, 8, 15, 10, 1, -13 },
  { 37, 9, 12, 10, 0, -12 },
  { 51, 8, 12, 10, 1, -12 },
  { 63, 2, 5, 10, 4, -13 },
  { 65, 5, 15, 10, 2, -12 },
  { 75, 5, 15, 10, 2, -12 },
  { 85, 7, 7, 10, 1, -12 },
  { 92, 8, 9, 10, 1, -9 },
  { 101, 4, 6, 10, 3, -3 },
  { 104, 4, 1, 10, 3, -5 },
  { 105, 3, 3, 10, 3, -3 },
  { 107, 7, 16, 10, 1, -13 },
  { 121, 8, 12, 10, 1, -12 },
  { 133, 7, 12, 10, 1, -12 },
  { 144, 7, 12, 10, 1, -12 },
  { 155, 7, 12, 10, 1, -12 },
  { 166, 8, 12, 10, 1, -12 },
  { 178, 7, 12, 10, 1, -12 },
  { 189, 8, 12, 10, 1, -12 },
  { 201, 8, 12, 10, 1, -12 },
  { 213, 8, 12, 10, 1, -12 },
  { 225, 8, 12, 10, 1, -12 },
  { 237, 3, 9, 10, 3, -9 },
  { 241, 4, 12, 10, 2, -9 },
  { 247, 8, 7, 10, 1, -8 },
  { 254, 8, 4, 10, 1, -7 },
  { 258, 8, 7, 10, 1, -8 },
  { 265, 6, 12, 10, 2, -12 },
  { 274, 8, 15, 10, 1, -12 },
  { 289, 9, 12, 10, 0, -12 },
  { 303, 8, 12, 10, 1, -12 },
  { 315, 8, 12, 10, 1, -12 },
  { 327, 8, 12, 10, 1, -12 },
  { 339, 7, 12, 10, 2, -12 },
  { 350, 6, 12, 10, 2, -12 },
  { 359, 8, 12, 10, 1, -12 },
  { 371, 8, 12, 10, 1, -12 },
  { 383, 6, 12, 10, 2, -12 },
  { 392, 7, 12, 10, 1, -12 },
  { 403, 8, 12, 10, 1, -12 },
  { 415, 7, 12, 10, 2, -12 },
  { 426, 8, 12, 10, 1, -12 },
  { 438, 7, 12, 10, 1, -12 },
  { 449, 8, 12, 10, 1, -12 },
  { 461, 8, 12, 10, 1, -12 },
  { 473, 8, 15, 10, 1, -12 },
  { 488, 8, 12, 10, 1, -12 },
  { 500, 7, 12, 10, 1, -12 },
  { 511, 8, 12, 10, 1, -12 },
  { 523, 8, 12, 10, 1, -12 },
  { 535, 9, 12, 10, 0, -12 },
  { 549, 8, 12, 10, 1, -12 },
  { 561, 9, 12, 10, 0, -12 },
  { 575, 9, 12, 10, 0, -12 },
  { 589, 8, 12, 10, 1, -12 },
  { 601, 4, 15, 10, 3, -12 },
  { 609, 7, 16, 10, 1, -13 },
  { 623, 5, 15, 10, 2, -12 },
  { 633, 8, 6, 10, 1, -12 },
  { 639, 9, 1, 10, 0, 2 },
  { 641, 3, 3, 10, 3, -13 },
  { 643, 7, 9, 10, 1, -9 },
  { 651, 8, 13, 10, 1, -13 },
  { 664, 8, 9, 10, 1, -9 },
  { 673, 7, 13, 10, 1, -13 },
  { 685, 8, 9, 10, 1, -9 },
  { 694, 8, 13, 10, 1, -13 },
  { 707, 7, 12, 10, 1, -9 },
  { 718, 7, 13, 10, 1, -13 },
  { 730, 8, 12, 10, 1, -12 },
  { 742, 6, 15, 10, 1, -12 },
  { 754, 8, 13, 10, 1, -13 },
  { 767, 8, 13, 10, 1, -13 },
  { 780, 8, 9, 10, 1, -9 },
  { 789, 7, 9, 10, 1, -9 },
  { 797, 8, 9, 10, 1, -9 },
  { 806, 8, 12, 10, 1, -9 },
  { 818, 7, 12, 10, 1, -9 },
  { 829, 6, 9, 10, 2, -9 },
  { 836, 7, 9, 10, 1, -9 },
  { 844, 8, 12, 10, 1, -12 },
  { 856, 7, 9, 10, 1, -9 },
  { 864, 8, 9, 10, 1, -9 },
  { 873, 9, 9, 10, 0, -9 },
  { 884, 8, 9, 10, 1, -9 },
  { 893, 8, 12, 10, 1, -9 },
  { 905, 7, 9, 10, 1, -9 },
  { 913, 7, 16, 10, 1, -13 },
  { 927, 1, 16, 10, 4, -13 },
  { 929, 7, 16, 10, 1, -13 },
  { 943, 8, 3, 10, 1, -7 },
};

const GFXfont UbuntuMono_Regular19pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular19pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular19pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _UBUNTUMONO_REGULAR19PT7B_H_
