#ifndef _UBUNTUMONO_REGULAR20PT7B_H_
#define _UBUNTUMONO_REGULAR20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular20pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFC, 0x3F, 0x99, 0x99, 0x90, 0x33, 0x32, 0x32, 0xFF, 0xFF,
  0x26, 0x66, 0x64, 0xFF, 0xFF, 0x4C, 0xCC, 0x18, 0x18, 0x3E, 0x7E, 0xC0,
  0xC0, 0xE0, 0x7C, 0x1E, 0x07, 0x03, 0x83, 0xFE, 0x7C, 0x18, 0x18, 0x70,
  0x96, 0x6D, 0xB3, 0x68, 0x5E, 0x1D, 0x00, 0xB8, 0x7A, 0x16, 0xC9, 0xB6,
  0x69, 0x0E, 0x38, 0x7C, 0xC4, 0x4C, 0x78, 0x73, 0xDB, 0x8E, 0x86, 0xCE,
  0xFF, 0x79, 0xFF, 0xC0, 0x08, 0x73, 0x18, 0x61, 0x0C, 0x30, 0xC1, 0x06,
  0x18, 0x30, 0x60, 0x80, 0x41, 0x83, 0x06, 0x18, 0x20, 0xC3, 0x0C, 0x21,
  0x86, 0x33, 0x84, 0x00, 0x18, 0x18, 0x5A, 0xFF, 0x18, 0x3C, 0x24, 0x18,
  0x18, 0x18, 0x18, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x77, 0x73, 0x6C, 0xFF,
  0xFC, 0x02, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x10,
  0x30, 0x30, 0x20, 0x60, 0x60, 0x40, 0x3C, 0x7E, 0xE7, 0xC3, 0xDB, 0xDB,
  0xDB, 0xC3, 0xC3, 0xE7, 0x7E, 0x3C, 0x08, 0x18, 0x78, 0x48, 0x08, 0x08,
  0x08, 0x08, 0x08, 0x08, 0x7F, 0x7F, 0x3C, 0xFE, 0x46, 0x02, 0x02, 0x04,
  0x08, 0x10, 0x20, 0x40, 0x7F, 0xFF, 0x3C, 0xFE, 0x46, 0x02, 0x06, 0x3C,
  0x3E, 0x07, 0x03, 0x83, 0xFE, 0x7C, 0x06, 0x0E, 0x1E, 0x3E, 0x66, 0x46,
  0xC6, 0xFF, 0xFF, 0x06, 0x06, 0x06, 0x3F, 0x7F, 0x60, 0x60, 0x78, 0x7E,
  0x07, 0x03, 0x03, 0x87, 0xFE, 0x7C, 0x0E, 0x3E, 0x70, 0x40, 0xFC, 0xFE,
  0xC3, 0xC3, 0xC3, 0xE3, 0x7E, 0x3C, 0xFF, 0xFF, 0x03, 0x06, 0x04, 0x0C,
  0x08, 0x18, 0x18, 0x10, 0x30, 0x30, 0x3C, 0x7E, 0xC3, 0xC3, 0xE6, 0x7C,
  0x3E, 0x43, 0xC3, 0xC3, 0xFE, 0x3C, 0x3C, 0x7E, 0xC7, 0xC3, 0xC3, 0xC3,
  0x7F, 0x3F, 0x02, 0x0E, 0x7C, 0x70, 0xFC, 0x0F, 0xC0, 0x31, 0x8C, 0x00,
  0x00, 0xC7, 0x30, 0x8C, 0x80, 0x03, 0x0E, 0x70, 0xC0, 0x70, 0x18, 0x06,
  0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x78, 0x0E, 0x03, 0x07, 0x1C, 0x60,
  0x80, 0x7B, 0xF8, 0xC3, 0x08, 0xC2, 0x00, 0x00, 0xC7, 0x0C, 0x1E, 0x7F,
  0x63, 0xC1, 0xC1, 0xCF, 0x9F, 0x91, 0x91, 0xDF, 0xCF, 0x60, 0x70, 0x3E,
  0x1E, 0x0C, 0x07, 0x81, 0xE0, 0x48, 0x33, 0x0C, 0xC2, 0x11, 0x86, 0x7F,
  0x9F, 0xE4, 0x0B, 0x03, 0xFC, 0xFE, 0xC6, 0xC2, 0xC6, 0xFC, 0xFE, 0xC3,
  0xC3, 0xC3, 0xFE, 0xFC, 0x1E, 0x7F, 0x61, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x61, 0x7F, 0x1E, 0xF8, 0xFE, 0xC6, 0xC3, 0xC3, 0xC1, 0xC1, 0xC3,
  0xC3, 0xC6, 0xFE, 0xF8, 0xFF, 0xFE, 0x04, 0x08, 0x1F, 0xBF, 0x40, 0x81,
  0x03, 0xFF, 0xF0, 0xFF, 0xFE, 0x04, 0x08, 0x1F, 0xBF, 0x40, 0x81, 0x02,
  0x04, 0x00, 0x1E, 0x7F, 0x61, 0xC0, 0xC0, 0xC0, 0xC3, 0xC3, 0xC3, 0x63,
  0x7F, 0x1F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFF, 0xFF, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0xFF, 0xF3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xCF, 0xFF, 0x3E,
  0x7C, 0x08, 0x10, 0x20, 0x40, 0x81, 0x02, 0x8F, 0xFB, 0xE0, 0xC3, 0x63,
  0x33, 0x99, 0x8D, 0x87, 0x83, 0xE1, 0x98, 0xC6, 0x63, 0x30, 0xD8, 0x30,
  0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40, 0x81, 0x03, 0xFF, 0xF0, 0xC3,
  0xE7, 0xA5, 0xA5, 0xBD, 0x99, 0x99, 0x81, 0x81, 0x81, 0x81, 0x81, 0xC3,
  0xE3, 0xE3, 0xF3, 0xD3, 0xDB, 0xCB, 0xCF, 0xC7, 0xC7, 0xC3, 0xC3, 0x3C,
  0x7E, 0xC3, 0xC3, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xC3, 0x7E, 0x3C, 0xFC,
  0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0xC0, 0x3C,
  0x7E, 0xC3, 0xC3, 0x81, 0x81, 0x81, 0x81, 0xC3, 0xC3, 0x7E, 0x3C, 0x18,
  0x0F, 0x03, 0xFC, 0xFE, 0xC6, 0xC3, 0xC3, 0xC6, 0xFE, 0xFC, 0xCC, 0xC6,
  0xC2, 0xC3, 0x3E, 0x7E, 0xC2, 0xC0, 0x60, 0x7C, 0x1E, 0x07, 0x03, 0x83,
  0xFE, 0x7C, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x7E, 0x3C, 0xC0, 0xD0, 0x26, 0x19, 0x86, 0x21, 0x88, 0x43, 0x30, 0xCC,
  0x12, 0x07, 0x81, 0xE0, 0x30, 0x81, 0x81, 0x81, 0x81, 0x81, 0x99, 0x99,
  0xBD, 0xA5, 0xA5, 0xE7, 0xC3, 0x61, 0x88, 0x43, 0x30, 0x78, 0x1E, 0x03,
  0x00, 0xC0, 0x78, 0x33, 0x0C, 0xC6, 0x19, 0x86, 0xC0, 0xD8, 0x66, 0x18,
  0xCC, 0x33, 0x07, 0x80, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF,
  0xFF, 0x02, 0x06, 0x0C, 0x18, 0x10, 0x30, 0x60, 0x40, 0xFF, 0xFF, 0xFC,
  0x21, 0x08, 0x42, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x40, 0x60, 0x60,
  0x20, 0x30, 0x30, 0x10, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x0C, 0x04, 0x06,
  0x06, 0x02, 0xF8, 0x42, 0x10, 0x84, 0x21, 0x08, 0x42, 0x10, 0x87, 0xE0,
  0x18, 0x3C, 0x3C, 0x66, 0x42, 0xC3, 0x81, 0xFF, 0xC0, 0x44, 0x62, 0x7C,
  0x7E, 0x03, 0x3F, 0x43, 0xC3, 0xC3, 0x7F, 0x3F, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFC, 0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0xFC, 0x3F, 0x7F,
  0xE0, 0xC0, 0xC0, 0xC0, 0xE0, 0x7F, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x3F, 0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x3F, 0x3E, 0x7F, 0xC3,
  0xFF, 0xC0, 0xC0, 0xE0, 0x7E, 0x3E, 0x0F, 0x0F, 0xCC, 0x26, 0x03, 0x07,
  0xFB, 0xFC, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x3F, 0x7F,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x3F, 0x02, 0xFE, 0xFC, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFC, 0xFE, 0xC6, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0x30, 0x30, 0x00, 0xF0, 0xF0, 0x10, 0x10, 0x10, 0x10, 0x18, 0x1F, 0x0F,
  0x0C, 0x18, 0x03, 0xF7, 0xE0, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x6F,
  0x9E, 0x00, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x1B, 0x19, 0x98, 0xF8,
  0x78, 0x36, 0x19, 0x8C, 0x66, 0x18, 0xF0, 0xF0, 0x10, 0x10, 0x10, 0x10,
  0x10, 0x10, 0x10, 0x10, 0x10, 0x18, 0x1F, 0x0F, 0xFE, 0xFF, 0x99, 0x99,
  0x99, 0x81, 0x81, 0x81, 0x81, 0xFC, 0xFE, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x3C, 0x7E, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7E, 0x3C, 0xFC,
  0xFE, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xFE, 0xFC, 0xC0, 0xC0, 0xC0, 0x3F,
  0x7F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x7F, 0x3F, 0x03, 0x03, 0x03, 0x7F,
  0xFF, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC0, 0x3E, 0x7E, 0x40, 0x70, 0x3E,
  0x0F, 0x43, 0xFE, 0x7C, 0x30, 0x30, 0x30, 0xFF, 0xFF, 0x30, 0x30, 0x30,
  0x30, 0x30, 0x3F, 0x1F, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x63, 0x7F,
  0x3F, 0xC1, 0xC3, 0xC3, 0x66, 0x66, 0x24, 0x3C, 0x38, 0x18, 0xC0, 0xD0,
  0x24, 0xC9, 0x32, 0x4C, 0x9C, 0xE7, 0x38, 0xCC, 0x21, 0x00, 0xC3, 0x66,
  0x2C, 0x38, 0x18, 0x3C, 0x66, 0x42, 0xC3, 0xC3, 0xC3, 0x63, 0x62, 0x26,
  0x36, 0x34, 0x1C, 0x18, 0x18, 0xF0, 0xE0, 0x7E, 0x7E, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0xFF, 0xFF, 0x1E, 0x60, 0x81, 0x02, 0x04, 0x08, 0x30, 0xC0,
  0xC0, 0x81, 0x02, 0x04, 0x08, 0x18, 0x1E, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x30, 0x20, 0x40, 0x81, 0x02, 0x06, 0x06, 0x18, 0x20, 0x40, 0x81,
  0x02, 0x0C, 0xF0, 0x71, 0xF9, 0x9F, 0x8E,
};

const GFXglyph UbuntuMono_Regular20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 2, 12, 10, 4, -12 },
  { 4, 4, 5, 10, 3, -14 },
  { 7, 8, 12, 10, 1, -12 },
  { 19, 8, 16, 10, 1, -14 },
  { 35, 10, 12, 10, 0, -12 },
  { 50, 8, 12, 10, 1, -12 },
  { 62, 2, 5, 10, 4, -14 },
  { 64, 6, 15, 10, 2, -12 },
  { 76, 6, 15, 10, 2, -12 },
  { 88, 8, 7, 10, 1, -12 },
  { 95, 8, 9, 10, 1, -10 },
  { 104, 4, 6, 10, 3, -3 },
  { 107, 4, 2, 10, 3, -6 },
  { 108, 2, 3, 10, 4, -3 },
  { 109, 8, 17, 10, 1, -14 },
  { 126, 8, 12, 10, 1, -12 },
  { 138, 8, 12, 10, 1, -12 },
  { 150, 8, 12, 10, 1, -12 },
  { 162, 8, 12, 10, 1, -12 },
  { 174, 8, 12, 10, 1, -12 },
  { 186, 8, 12, 10, 1, -12 },
  { 198, 8, 12, 10, 1, -12 },
  { 210, 8, 12, 10, 1, -12 },
  { 222, 8, 12, 10, 1, -12 },
  { 234, 8, 12, 10, 1, -12 },
  { 246, 2, 9, 10, 4, -9 },
  { 249, 5, 12, 10, 2, -9 },
  { 257, 8, 8, 10, 1, -9 },
  { 265, 8, 4, 10, 1, -7 },
  { 269, 8, 8, 10, 1, -9 },
  { 277, 6, 12, 10, 2, -12 },
  { 286, 8, 15, 10, 1, -12 },
  { 301, 10, 12, 10, 0, -12 },
  { 316, 8, 12, 10, 1, -12 },
  { 328, 8, 12, 10, 1, -12 },
  { 340, 8, 12, 10, 1, -12 },
  { 352, 7, 12, 10, 2, -12 },
  { 363, 7, 12, 10, 2, -12 },
  { 374, 8, 12, 10, 1, -12 },
  { 386, 8, 12, 10, 1, -12 },
  { 398, 6, 12, 10, 2, -12 },
  { 407, 7, 12, 10, 1, -12 },
  { 418, 9, 12, 10, 1, -12 },
  { 432, 7, 12, 10, 2, -12 },
  { 443, 8, 12, 10, 1, -12 },
  { 455, 8, 12, 10, 1, -12 },
  { 467, 8, 12, 10, 1, -12 },
  { 479, 8, 12, 10, 1, -12 },
  { 491, 8, 15, 10, 1, -12 },
  { 506, 8, 12, 10, 1, -12 },
  { 518, 8, 12, 10, 1, -12 },
  { 530, 8, 12, 10, 1, -12 },
  { 542, 8, 12, 10, 1, -12 },
  { 554, 10, 12, 10, 0, -12 },
  { 569, 8, 12, 10, 1, -12 },
  { 581, 10, 12, 10, 0, -12 },
  { 596, 10, 12, 10, 0, -12 },
  { 611, 8, 12, 10, 1, -12 },
  { 623, 5, 15, 10, 3, -12 },
  { 633, 8, 17, 10, 1, -14 },
  { 650, 5, 15, 10, 2, -12 },
  { 660, 8, 7, 10, 1, -12 },
  { 667, 10, 1, 10, 0, 2 },
  { 669, 4, 4, 10, 3, -14 },
  { 671, 8, 9, 10, 1, -9 },
  { 680, 8, 14, 10, 1, -14 },
  { 694, 8, 9, 10, 1, -9 },
  { 703, 8, 14, 10, 1, -14 },
  { 717, 8, 9, 10, 1, -9 },
  { 726, 9, 14, 10, 1, -14 },
  { 742, 8, 12, 10, 1, -9 },
  { 754, 8, 14, 10, 1, -14 },
  { 768, 8, 12, 10, 1, -12 },
  { 780, 7, 15, 10, 1, -12 },
  { 794, 9, 14, 10, 1, -14 },
  { 810, 8, 14, 10, 1, -14 },
  { 824, 8, 9, 10, 1, -9 },
  { 833, 8, 9, 10, 1, -9 },
  { 842, 8, 9, 10, 1, -9 },
  { 851, 8, 12, 10, 1, -9 },
  { 863, 8, 12, 10, 1, -9 },
  { 875, 7, 9, 10, 2, -9 },
  { 883, 8, 9, 10, 1, -9 },
  { 892, 8, 12, 10, 1, -12 },
  { 904, 8, 9, 10, 1, -9 },
  { 913, 8, 9, 10, 1, -9 },
  { 922, 10, 9, 10, 0, -9 },
  { 934, 8, 9, 10, 1, -9 },
  { 943, 8, 12, 10, 1, -9 },
  { 955, 8, 9, 10, 1, -9 },
  { 964, 7, 17, 10, 2, -14 },
  { 979, 2, 17, 10, 4, -14 },
  { 984, 7, 17, 10, 1, -14 },
  { 999, 8, 4, 10, 1, -8 },
};

const GFXfont UbuntuMono_Regular20pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular20pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular20pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _UBUNTUMONO_REGULAR20PT7B_H_
