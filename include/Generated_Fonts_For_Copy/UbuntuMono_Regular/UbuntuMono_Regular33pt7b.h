#ifndef _UBUNTUMONO_REGULAR33PT7B_H_
#define _UBUNTUMONO_REGULAR33PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 33pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular33pt7bBitmaps[] PROGMEM = {
  0x00, 0x77, 0x77, 0x77, 0x77, 0x77, 0x66, 0x60, 0x00, 0x7F, 0xF7, 0xE3,
  0xE3, 0xE3, 0xE3, 0xE3, 0xE3, 0x43, 0x43, 0x06, 0x18, 0x0C, 0x30, 0x38,
  0xE0, 0x71, 0xC0, 0xC3, 0x9F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x70,
  0x38, 0xE0, 0x61, 0xC0, 0xC3, 0x01, 0x86, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x30, 0xC0, 0x61, 0x81, 0xC7, 0x03, 0x8E, 0x00, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x3F, 0x83, 0xFF, 0x3F, 0xF3, 0xC0, 0x9C, 0x00, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0xFF, 0x01, 0xFE, 0x03, 0xF8, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x01, 0xF0, 0x1D, 0xFF, 0xEF, 0xFE, 0x1F, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x00, 0x78, 0x0D, 0xF8, 0x3B, 0x30, 0x66, 0x31, 0x8C,
  0x63, 0x18, 0xCC, 0x31, 0xB8, 0x66, 0x60, 0xFD, 0x80, 0xF7, 0x00, 0x0C,
  0xE0, 0x33, 0xE0, 0x6C, 0xE1, 0x98, 0xC7, 0x31, 0x8C, 0x63, 0x30, 0xC6,
  0xE1, 0x9D, 0x81, 0xF6, 0x01, 0xC0, 0x0F, 0x80, 0x3F, 0x80, 0xFF, 0x81,
  0xC7, 0x07, 0x0E, 0x06, 0x1C, 0x0C, 0x30, 0x1D, 0xC0, 0x1F, 0x00, 0x3C,
  0x30, 0xFC, 0x63, 0x9C, 0xCE, 0x1F, 0x9C, 0x1E, 0x38, 0x1C, 0x70, 0x38,
  0xF1, 0xF8, 0xFF, 0xB9, 0xFE, 0x70, 0xF8, 0x60, 0xFF, 0xFF, 0xB6, 0xC0,
  0x01, 0x03, 0xC3, 0xC1, 0xC1, 0xC1, 0xC0, 0xE0, 0xE0, 0x70, 0x70, 0x38,
  0x1C, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x38, 0x1C, 0x07, 0x03,
  0x80, 0xE0, 0x70, 0x1C, 0x07, 0x03, 0xC0, 0xE0, 0x10, 0x40, 0x70, 0x3C,
  0x0F, 0x03, 0xC0, 0xE0, 0x38, 0x1C, 0x07, 0x03, 0x80, 0xC0, 0x60, 0x38,
  0x1C, 0x0E, 0x07, 0x03, 0x81, 0x80, 0xC0, 0xE0, 0x70, 0x70, 0x38, 0x38,
  0x3C, 0x3C, 0x3C, 0x1C, 0x04, 0x00, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x8C,
  0x2F, 0x6F, 0x7F, 0xF8, 0xFF, 0x81, 0xE0, 0x1D, 0x81, 0xCE, 0x1E, 0x38,
  0x21, 0x80, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03, 0x03,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x03,
  0x00, 0x1C, 0x78, 0xF9, 0xE1, 0xC7, 0x3C, 0x70, 0xFF, 0xFF, 0xF8, 0x77,
  0xFE, 0xE0, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x1C, 0x01, 0x80, 0x38, 0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x07,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x00, 0x0F, 0x81, 0xFE, 0x1F,
  0xF8, 0xE1, 0xEF, 0x07, 0x70, 0x1B, 0x80, 0xF8, 0xC7, 0xCF, 0x3E, 0x79,
  0xF1, 0xCF, 0x80, 0x7C, 0x03, 0xF0, 0x1F, 0x80, 0xDC, 0x0E, 0x70, 0xF3,
  0xFF, 0x0F, 0xF0, 0x1F, 0x00, 0x03, 0x80, 0x78, 0x0F, 0x83, 0xF8, 0x7B,
  0x86, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x87, 0xFF, 0x7F, 0xF7, 0xFF, 0x1F,
  0x83, 0xFE, 0x3F, 0xF9, 0xC1, 0xE4, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06,
  0x00, 0x60, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F, 0x83, 0xFE, 0x1F,
  0xF8, 0xC1, 0xC0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x3C, 0x0F, 0xC0, 0x7E,
  0x03, 0xF8, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0xC0, 0xF7,
  0xFF, 0xBF, 0xF8, 0x7F, 0x00, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xFC,
  0x07, 0x70, 0x39, 0xC0, 0xC7, 0x07, 0x1C, 0x38, 0x70, 0xC1, 0xC7, 0x07,
  0x18, 0x1C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x07, 0x00, 0x1C, 0x3F, 0xF1, 0xFF, 0x8F, 0xFC, 0x70, 0x03, 0x00,
  0x18, 0x00, 0xC0, 0x07, 0xE0, 0x3F, 0xC3, 0xFF, 0x00, 0x7C, 0x00, 0xE0,
  0x03, 0x00, 0x1C, 0x00, 0xE0, 0x0E, 0x40, 0xF7, 0xFF, 0xBF, 0xF8, 0x7F,
  0x00, 0x00, 0xE0, 0x3F, 0x83, 0xFC, 0x7E, 0x03, 0x80, 0x38, 0x01, 0x80,
  0x1D, 0xF0, 0xFF, 0xE7, 0xFF, 0xB8, 0x1D, 0xC0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x0F, 0x70, 0xF3, 0xFF, 0x8F, 0xF8, 0x1F, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x0F, 0x81, 0xFF, 0x1F, 0xFD,
  0xE1, 0xEE, 0x07, 0x70, 0x1B, 0x81, 0xDE, 0x0C, 0x7F, 0xE1, 0xFE, 0x0F,
  0xF8, 0xE3, 0xEE, 0x07, 0xF0, 0x1F, 0x00, 0xFC, 0x07, 0xF0, 0x77, 0xFF,
  0x9F, 0xF8, 0x3F, 0x80, 0x1F, 0x81, 0xFE, 0x1F, 0xF9, 0xE1, 0xEE, 0x07,
  0x70, 0x1B, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x83, 0xDF, 0xFE, 0xFF, 0xE1,
  0xFB, 0x00, 0x38, 0x01, 0xC0, 0x3C, 0x07, 0xC3, 0xFC, 0x1F, 0xC0, 0xF0,
  0x00, 0x77, 0xFE, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xEF, 0xFD, 0xC0, 0x1C,
  0x7C, 0xF8, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE3, 0xE7, 0xCF,
  0x86, 0x3D, 0xF3, 0x80, 0x00, 0x18, 0x03, 0xC0, 0xFC, 0x1F, 0x83, 0xE0,
  0x7C, 0x03, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xF0,
  0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7C, 0x00, 0xE0, 0x1F, 0x07, 0xE0, 0xFC, 0x1F, 0x01, 0xE0, 0x0C, 0x00,
  0x00, 0x3F, 0x1F, 0xF3, 0xFF, 0x20, 0xE0, 0x0E, 0x01, 0x80, 0x70, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1C,
  0x07, 0xC0, 0xF8, 0x0E, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x8F, 0x0F,
  0x38, 0x1D, 0xC0, 0x37, 0x00, 0xD8, 0x3F, 0x63, 0xFF, 0x8F, 0xFE, 0x78,
  0xF9, 0xC3, 0xE7, 0x0F, 0x9E, 0x3E, 0x3F, 0xD8, 0xFF, 0x70, 0xFD, 0xC0,
  0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x7C, 0x03,
  0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0x60, 0x06, 0x70, 0x06, 0x70, 0x0E,
  0x30, 0x0C, 0x38, 0x0C, 0x38, 0x1C, 0x18, 0x1C, 0x1C, 0x18, 0x1C, 0x38,
  0x1C, 0x3F, 0xFC, 0x3F, 0xFE, 0x7F, 0xFE, 0x70, 0x0E, 0x70, 0x07, 0x70,
  0x07, 0xE0, 0x07, 0xFF, 0x87, 0xFE, 0x3F, 0xF9, 0x81, 0xEC, 0x07, 0x60,
  0x3B, 0x01, 0xD8, 0x1C, 0xFF, 0xC7, 0xFE, 0x3F, 0xF9, 0x81, 0xEC, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0xF7, 0xFF, 0xBF, 0xF9, 0xFF, 0x00,
  0x07, 0xE0, 0xFF, 0xCF, 0xFE, 0xF8, 0x27, 0x00, 0x70, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x0E, 0x00, 0x7C, 0x19, 0xFF, 0xC7, 0xFE, 0x0F, 0xC0, 0xFE, 0x07, 0xFE,
  0x3F, 0xF9, 0x83, 0xEC, 0x07, 0x60, 0x3F, 0x00, 0xF8, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0E, 0xC1,
  0xF7, 0xFF, 0x3F, 0xF1, 0xFE, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0xCE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xFF, 0xEF, 0xFE, 0xFF, 0xEE, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x07, 0xE0, 0xFF, 0xCF, 0xFE, 0xF8,
  0x27, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xC0, 0x06, 0x00, 0x30, 0x0F,
  0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x80, 0xEE, 0x07, 0x7C, 0x39, 0xFF, 0xC7,
  0xFE, 0x0F, 0xE0, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x3F, 0xF3, 0xFF, 0x3F, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x74, 0x07, 0xE1, 0xEF, 0xFE, 0xFF, 0xC3, 0xF0,
  0xE0, 0x3B, 0x81, 0xCE, 0x0F, 0x38, 0x38, 0xE1, 0xC3, 0x8E, 0x0E, 0x70,
  0x3B, 0xC0, 0xFE, 0x03, 0xF0, 0x0F, 0xE0, 0x3B, 0xC0, 0xE7, 0x83, 0x8F,
  0x0E, 0x1E, 0x38, 0x3C, 0xE0, 0x73, 0x80, 0xEE, 0x03, 0xB8, 0x07, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x70, 0x39, 0xE0, 0xE7, 0x83, 0x9E, 0x1E,
  0x7C, 0x7D, 0xB1, 0xF6, 0xCC, 0xD9, 0xB3, 0x66, 0xCD, 0x9E, 0x36, 0x38,
  0xF8, 0xE3, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x3F, 0x01, 0xFC, 0x0F, 0xF0, 0x7F, 0x83,
  0xEE, 0x1F, 0x30, 0xF9, 0xC7, 0xC6, 0x3E, 0x39, 0xF0, 0xCF, 0x87, 0x7C,
  0x1B, 0xE0, 0xDF, 0x07, 0xF8, 0x1F, 0xC0, 0xFE, 0x03, 0xF0, 0x1F, 0x80,
  0x70, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0xDE, 0x03,
  0xB8, 0x07, 0x70, 0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xDC, 0x03, 0xB8, 0x07, 0x38, 0x1E, 0x78, 0x78, 0x7F, 0xF0, 0x7F,
  0xC0, 0x3E, 0x00, 0xFF, 0x87, 0xFF, 0x3F, 0xFD, 0xC0, 0xEE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x07, 0xBF, 0xFD, 0xFF, 0xCF, 0xF8,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x00,
  0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xE3, 0xC3, 0xC7, 0x03, 0xDE, 0x03, 0xB8,
  0x07, 0x70, 0x06, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xDC, 0x03, 0xB8, 0x07, 0x38, 0x1E, 0x78, 0x78, 0x7F, 0xF0, 0x7F, 0xC0,
  0x7E, 0x00, 0x38, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x18, 0xFF,
  0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E,
  0xE0, 0x77, 0x07, 0xBF, 0xF9, 0xFF, 0x8F, 0xF8, 0x71, 0xC3, 0x87, 0x1C,
  0x1C, 0xE0, 0xE7, 0x03, 0xB8, 0x0D, 0xC0, 0x70, 0x0F, 0xC1, 0xFF, 0x9F,
  0xFC, 0xE0, 0x4E, 0x00, 0x70, 0x03, 0x80, 0x0F, 0x00, 0x7E, 0x01, 0xFE,
  0x03, 0xF8, 0x03, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xE0, 0x07, 0xC0, 0x77,
  0xFF, 0xBF, 0xF8, 0x7F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xF0, 0xF3, 0xFF, 0x8F, 0xF8, 0x3F,
  0x00, 0x60, 0x07, 0x70, 0x07, 0x70, 0x07, 0x70, 0x0E, 0x30, 0x0E, 0x38,
  0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x18, 0x1C, 0x38, 0x0C,
  0x38, 0x0E, 0x38, 0x0E, 0x70, 0x06, 0x70, 0x07, 0x70, 0x07, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0x8D, 0x9E, 0x36, 0x78,
  0xD9, 0xB3, 0x6E, 0xCD, 0xB3, 0x76, 0xC7, 0xDF, 0x1E, 0x78, 0x79, 0xE0,
  0xE7, 0x83, 0x9C, 0x0E, 0xE0, 0x1C, 0xE0, 0x38, 0xE0, 0xE1, 0xC3, 0x81,
  0xC7, 0x03, 0x9C, 0x03, 0xB8, 0x07, 0xE0, 0x07, 0x80, 0x07, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0xFE, 0x03, 0x9C, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0x38,
  0xE0, 0x71, 0xC0, 0x77, 0x00, 0xE0, 0x70, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x38, 0x0E, 0x38, 0x1C, 0x1C, 0x1C, 0x1C, 0x38, 0x0E, 0x38, 0x0F, 0x70,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF, 0xFF, 0xE0,
  0x07, 0x00, 0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C,
  0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00,
  0xE0, 0x06, 0x00, 0x70, 0x07, 0xFF, 0xFF, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07,
  0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0x07, 0xFF, 0xFF, 0x03, 0x80, 0x1E,
  0x00, 0x7C, 0x03, 0xB8, 0x1C, 0xE0, 0x71, 0xC3, 0x87, 0x0E, 0x0E, 0x70,
  0x19, 0x80, 0x76, 0x00, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x21, 0x87, 0x0E,
  0x1C, 0x20, 0x1F, 0x83, 0xFE, 0x3F, 0xF2, 0x0F, 0x00, 0x70, 0x03, 0x1F,
  0xF7, 0xFF, 0xF0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xFF, 0xF7, 0xFF, 0x1F,
  0xF0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x00, 0xEF, 0x87, 0xFF, 0x3F, 0xFD, 0xE1, 0xEE, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1F, 0xC1, 0xEF, 0xFF, 0x7F,
  0xF1, 0xFE, 0x00, 0x07, 0xF0, 0xFF, 0xDF, 0xFC, 0xF0, 0x2F, 0x00, 0x70,
  0x03, 0x80, 0x18, 0x00, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xF0, 0x37, 0xFF,
  0x9F, 0xFC, 0x3F, 0xC0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1C, 0x00, 0xE0, 0x07, 0x0F, 0xF8, 0xFF, 0xCF, 0xFE, 0xF0, 0xF7,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x0E, 0xF0,
  0x73, 0xFF, 0x8F, 0xFC, 0x1F, 0xC0, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E,
  0x0E, 0x70, 0x1D, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x07,
  0x00, 0x1F, 0x02, 0x3F, 0xF8, 0x7F, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x1F,
  0xF0, 0xFF, 0xC3, 0x83, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0xFF,
  0xF3, 0xFF, 0xCF, 0xFF, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01,
  0xC0, 0x00, 0x0F, 0xF0, 0xFF, 0xCF, 0xFE, 0xF0, 0x77, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0xDE, 0x0E, 0xFF, 0xF3, 0xFF, 0x87,
  0xFC, 0x00, 0xE0, 0x07, 0x20, 0x7B, 0xFF, 0x9F, 0xF8, 0x7F, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF,
  0x8F, 0xFE, 0xFF, 0xEE, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0,
  0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0x1C, 0x00,
  0xF0, 0x07, 0x80, 0x38, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0xFE,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x78, 0x41, 0xFE, 0x0F, 0xF0, 0x3F, 0x00, 0x01, 0xC0, 0x78,
  0x0F, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0xF9, 0xFF, 0x3F, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xD0, 0x73, 0xFE, 0xFF, 0x87, 0xE0, 0xE0, 0x03, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x3B, 0x81, 0xCE, 0x1E, 0x38, 0xF0, 0xE7, 0x83, 0xBC, 0x0F, 0xC0, 0x3F,
  0x00, 0xEF, 0x03, 0x9E, 0x0E, 0x1C, 0x38, 0x38, 0xE0, 0x73, 0x81, 0xEE,
  0x03, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07,
  0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x10, 0x7F,
  0x83, 0xFC, 0x07, 0xC0, 0x7C, 0xF3, 0xFF, 0xEF, 0xFF, 0xF8, 0xE7, 0xE3,
  0x8F, 0x8E, 0x3E, 0x38, 0xF8, 0xE3, 0xE3, 0x8F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xC0, 0x7F, 0x8F, 0xFE, 0xFF, 0xEE,
  0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x30, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x9E,
  0x1E, 0x70, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77,
  0x03, 0xDE, 0x1E, 0x3F, 0xF8, 0x7F, 0xC0, 0xFC, 0x00, 0x7F, 0x87, 0xFF,
  0x3F, 0xFD, 0xC1, 0xEE, 0x07, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F,
  0x01, 0xF8, 0x0F, 0xE1, 0xEF, 0xFF, 0x7F, 0xF3, 0xBE, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xF0,
  0x77, 0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x0E,
  0xF0, 0x73, 0xFF, 0x8F, 0xFC, 0x3F, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0,
  0x0E, 0x00, 0x70, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x00, 0x1F, 0xE3,
  0xFE, 0x7F, 0xE7, 0x02, 0xE0, 0x07, 0x80, 0x7F, 0x03, 0xFC, 0x07, 0xF0,
  0x0F, 0x00, 0x74, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x1C, 0x00, 0xE0,
  0x07, 0x00, 0x38, 0x01, 0xC0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFE, 0x1C, 0x00,
  0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E,
  0x08, 0x7F, 0xC3, 0xFE, 0x07, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xF0, 0x77, 0x87,
  0x7F, 0xF3, 0xFF, 0x1F, 0xE0, 0xE0, 0x0D, 0xC0, 0x39, 0xC0, 0x73, 0x80,
  0xC7, 0x03, 0x87, 0x07, 0x0E, 0x1C, 0x0C, 0x38, 0x1C, 0x60, 0x39, 0xC0,
  0x3B, 0x80, 0x7E, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xE0, 0x00, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3F, 0x00, 0x6E, 0x38, 0xDC, 0x71, 0xB9, 0xE3, 0x33,
  0xEE, 0x67, 0xDC, 0xDD, 0xB9, 0xB3, 0xE3, 0xE3, 0xC7, 0x87, 0x87, 0x07,
  0x0C, 0x0C, 0x00, 0x70, 0x1C, 0xE0, 0x70, 0xE1, 0xC0, 0xE3, 0x00, 0xEE,
  0x01, 0xF8, 0x01, 0xE0, 0x01, 0xC0, 0x07, 0xC0, 0x1D, 0xC0, 0x71, 0x81,
  0xC3, 0x83, 0x03, 0x8E, 0x03, 0xB8, 0x07, 0x00, 0x70, 0x1D, 0xC0, 0x77,
  0x01, 0xCE, 0x0E, 0x38, 0x38, 0xE0, 0xE1, 0xC3, 0x07, 0x1C, 0x0C, 0x70,
  0x39, 0x80, 0xEE, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0x00, 0x18, 0x00, 0xE0,
  0x07, 0x01, 0xFC, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0xF7, 0xFF, 0x7F, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE1, 0xFC, 0x38, 0x0E, 0x01,
  0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x03, 0x81,
  0xE0, 0x3C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38,
  0x07, 0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x3F, 0x83, 0xF0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x0F, 0xE0, 0x07,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03,
  0x00, 0x38, 0x03, 0x80, 0x1F, 0x01, 0xF0, 0x38, 0x03, 0x80, 0x30, 0x03,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x70, 0xFE,
  0x0F, 0xC0, 0x1C, 0x0C, 0xFC, 0x37, 0xF9, 0xD8, 0xFF, 0xE1, 0xF9, 0x03,
  0xC0,
};

const GFXglyph UbuntuMono_Regular33pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 17, 0, -1 },
  { 1, 4, 20, 17, 6, -20 },
  { 11, 8, 8, 17, 4, -22 },
  { 19, 15, 20, 17, 1, -20 },
  { 57, 13, 26, 17, 2, -23 },
  { 100, 15, 20, 17, 1, -20 },
  { 138, 15, 20, 17, 1, -20 },
  { 176, 3, 9, 17, 7, -22 },
  { 180, 9, 29, 17, 4, -23 },
  { 213, 9, 29, 17, 4, -23 },
  { 246, 13, 12, 17, 2, -20 },
  { 266, 13, 14, 17, 2, -16 },
  { 289, 7, 8, 17, 5, -4 },
  { 296, 7, 3, 17, 5, -10 },
  { 299, 5, 4, 17, 6, -4 },
  { 302, 12, 28, 17, 2, -23 },
  { 344, 13, 20, 17, 2, -20 },
  { 377, 12, 20, 17, 2, -20 },
  { 407, 13, 20, 17, 2, -20 },
  { 440, 13, 20, 17, 2, -20 },
  { 473, 14, 20, 17, 1, -20 },
  { 508, 13, 20, 17, 2, -20 },
  { 541, 13, 20, 17, 2, -20 },
  { 574, 13, 20, 17, 2, -20 },
  { 607, 13, 20, 17, 2, -20 },
  { 640, 13, 20, 17, 2, -20 },
  { 673, 5, 15, 17, 6, -15 },
  { 683, 7, 19, 17, 4, -15 },
  { 700, 13, 13, 17, 2, -15 },
  { 722, 13, 8, 17, 2, -13 },
  { 735, 13, 13, 17, 2, -15 },
  { 757, 11, 20, 17, 3, -20 },
  { 785, 14, 24, 17, 1, -20 },
  { 827, 16, 20, 17, 0, -20 },
  { 867, 13, 20, 17, 2, -20 },
  { 900, 13, 20, 17, 2, -20 },
  { 933, 13, 20, 17, 2, -20 },
  { 966, 12, 20, 17, 3, -20 },
  { 996, 12, 20, 17, 3, -20 },
  { 1026, 13, 20, 17, 2, -20 },
  { 1059, 14, 20, 17, 1, -20 },
  { 1094, 11, 20, 17, 3, -20 },
  { 1122, 12, 20, 17, 2, -20 },
  { 1152, 14, 20, 17, 2, -20 },
  { 1187, 12, 20, 17, 3, -20 },
  { 1217, 14, 20, 17, 1, -20 },
  { 1252, 13, 20, 17, 2, -20 },
  { 1285, 15, 20, 17, 1, -20 },
  { 1323, 13, 20, 17, 2, -20 },
  { 1356, 15, 25, 17, 1, -20 },
  { 1403, 13, 20, 17, 2, -20 },
  { 1436, 13, 20, 17, 2, -20 },
  { 1469, 14, 20, 17, 1, -20 },
  { 1504, 13, 20, 17, 2, -20 },
  { 1537, 16, 20, 17, 0, -20 },
  { 1577, 14, 20, 17, 1, -20 },
  { 1612, 15, 20, 17, 1, -20 },
  { 1650, 16, 20, 17, 0, -20 },
  { 1690, 13, 20, 17, 2, -20 },
  { 1723, 8, 28, 17, 5, -23 },
  { 1751, 12, 28, 17, 2, -23 },
  { 1793, 8, 28, 17, 4, -23 },
  { 1821, 14, 11, 17, 1, -20 },
  { 1841, 16, 2, 17, 0, 3 },
  { 1845, 6, 6, 17, 5, -23 },
  { 1850, 12, 15, 17, 2, -15 },
  { 1873, 13, 23, 17, 2, -23 },
  { 1911, 13, 15, 17, 2, -15 },
  { 1936, 13, 23, 17, 1, -23 },
  { 1974, 14, 15, 17, 1, -15 },
  { 2001, 14, 23, 17, 2, -23 },
  { 2042, 13, 20, 17, 1, -15 },
  { 2075, 12, 23, 17, 2, -23 },
  { 2110, 13, 21, 17, 2, -21 },
  { 2145, 11, 26, 17, 2, -21 },
  { 2181, 14, 23, 17, 2, -23 },
  { 2222, 13, 23, 17, 2, -23 },
  { 2260, 14, 15, 17, 1, -15 },
  { 2287, 12, 15, 17, 2, -15 },
  { 2310, 14, 15, 17, 1, -15 },
  { 2337, 13, 20, 17, 2, -15 },
  { 2370, 13, 20, 17, 1, -15 },
  { 2403, 10, 15, 17, 4, -15 },
  { 2422, 12, 15, 17, 2, -15 },
  { 2445, 13, 20, 17, 2, -20 },
  { 2478, 12, 15, 17, 2, -15 },
  { 2501, 15, 15, 17, 1, -15 },
  { 2530, 15, 15, 17, 1, -15 },
  { 2559, 15, 15, 17, 1, -15 },
  { 2588, 14, 20, 17, 1, -15 },
  { 2623, 12, 15, 17, 2, -15 },
  { 2646, 11, 28, 17, 3, -23 },
  { 2685, 3, 28, 17, 7, -23 },
  { 2696, 12, 28, 17, 2, -23 },
  { 2738, 14, 6, 17, 1, -12 },
};

const GFXfont UbuntuMono_Regular33pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular33pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular33pt7bGlyphs,
  0x20, 0x7E, 33
};

#endif // _UBUNTUMONO_REGULAR33PT7B_H_
