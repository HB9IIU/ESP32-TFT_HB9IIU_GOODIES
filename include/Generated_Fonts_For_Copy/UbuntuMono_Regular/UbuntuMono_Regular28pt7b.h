#ifndef _UBUNTUMONO_REGULAR28PT7B_H_
#define _UBUNTUMONO_REGULAR28PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 28pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular28pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x06, 0xFF, 0x60, 0xCF, 0x3C,
  0xF3, 0xCE, 0x18, 0x40, 0x0C, 0x60, 0xC6, 0x1C, 0x61, 0x8E, 0xFF, 0xFF,
  0xFF, 0x18, 0xC3, 0x8C, 0x30, 0xC3, 0x18, 0x31, 0x8F, 0xFF, 0xFF, 0xF7,
  0x18, 0x63, 0x86, 0x30, 0x63, 0x00, 0x0C, 0x01, 0x80, 0x30, 0x1F, 0xC7,
  0xF9, 0xC1, 0x30, 0x06, 0x00, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0xC0, 0x3C,
  0x03, 0x80, 0x38, 0x06, 0x81, 0xDF, 0xF1, 0xFC, 0x06, 0x00, 0xC0, 0x18,
  0x00, 0x38, 0x19, 0xB0, 0xC4, 0x43, 0x11, 0x98, 0xC6, 0xC1, 0x1B, 0x04,
  0x58, 0x1B, 0x60, 0x3B, 0x70, 0x1B, 0x60, 0x68, 0x83, 0x62, 0x19, 0x8C,
  0x66, 0x23, 0x08, 0x8C, 0x36, 0x60, 0x70, 0x1E, 0x03, 0xF8, 0x71, 0x86,
  0x18, 0x61, 0x87, 0x38, 0x37, 0x03, 0xE0, 0x3C, 0x67, 0xE6, 0xE7, 0x6C,
  0x3E, 0xC1, 0xCC, 0x1C, 0xE3, 0xE7, 0xF7, 0x3E, 0x30, 0xFF, 0xFC, 0x02,
  0x07, 0x0E, 0x1C, 0x38, 0x70, 0x60, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xE0,
  0xE0, 0x60, 0x60, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x02, 0x40, 0xE0, 0x70,
  0x38, 0x1C, 0x0C, 0x06, 0x06, 0x07, 0x07, 0x03, 0x03, 0x07, 0x07, 0x06,
  0x06, 0x0E, 0x1C, 0x38, 0x70, 0xE0, 0x40, 0x0C, 0x03, 0x0C, 0xCF, 0xFF,
  0x7F, 0x87, 0x83, 0xF0, 0xCC, 0x73, 0x88, 0x40, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x38, 0xF3, 0xCF, 0x18, 0xEF, 0x30, 0xFF, 0xF0, 0x6F, 0xF6,
  0x00, 0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x0E, 0x03, 0x00,
  0xC0, 0x70, 0x18, 0x06, 0x03, 0x80, 0xC0, 0x00, 0x0F, 0x03, 0xFC, 0x30,
  0xC7, 0x0E, 0x60, 0x66, 0x06, 0xE6, 0x7E, 0xF7, 0xEF, 0x7E, 0x67, 0xE0,
  0x76, 0x06, 0x60, 0x67, 0x0E, 0x30, 0xC3, 0xFC, 0x0F, 0x00, 0x06, 0x07,
  0x87, 0xE3, 0xD8, 0x46, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x18, 0x06, 0x01, 0x80, 0x61, 0xFF, 0x7F, 0xC0, 0x3E, 0x3F, 0xEE, 0x3A,
  0x07, 0x01, 0xC0, 0x70, 0x18, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x18, 0x0E, 0x03, 0xFF, 0xFF, 0xC0, 0x3E, 0x3F, 0xE4, 0x38, 0x07, 0x01,
  0xC0, 0x60, 0x38, 0x7C, 0x1F, 0x80, 0xF0, 0x0C, 0x03, 0x00, 0xC0, 0x38,
  0x1F, 0xFE, 0x7E, 0x00, 0x01, 0xC0, 0x3C, 0x03, 0xC0, 0x6C, 0x0C, 0xC1,
  0xCC, 0x18, 0xC3, 0x0C, 0x70, 0xC6, 0x0C, 0xC0, 0xCF, 0xFF, 0xFF, 0xF0,
  0x0C, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x3F, 0xDF, 0xF7, 0x01, 0x80, 0x60,
  0x18, 0x07, 0xE1, 0xFC, 0x07, 0x80, 0x70, 0x0C, 0x03, 0x00, 0xC0, 0x38,
  0x1F, 0xFE, 0x7E, 0x00, 0x03, 0x81, 0xF8, 0xF0, 0x38, 0x06, 0x01, 0xC0,
  0x37, 0xC7, 0xFC, 0xC1, 0xD8, 0x1B, 0x03, 0xE0, 0x7C, 0x0D, 0xC1, 0xB8,
  0x73, 0xFC, 0x1F, 0x00, 0xFF, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x06,
  0x01, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x30, 0x06,
  0x01, 0xC0, 0x38, 0x00, 0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0x60, 0x66,
  0x06, 0x70, 0xC3, 0xDC, 0x1F, 0x83, 0x3E, 0x60, 0xE6, 0x07, 0xE0, 0x76,
  0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x1F, 0x03, 0xFC, 0x70, 0xC6, 0x0E,
  0xE0, 0x6E, 0x06, 0xE0, 0x66, 0x07, 0x70, 0x63, 0xFE, 0x1F, 0xE0, 0x06,
  0x00, 0xC0, 0x1C, 0x07, 0x87, 0xF0, 0x78, 0x00, 0x6F, 0xF6, 0x00, 0x00,
  0x06, 0xFF, 0x60, 0x18, 0xF3, 0xC6, 0x00, 0x00, 0x00, 0x00, 0x63, 0xCF,
  0x1C, 0x73, 0x9C, 0x60, 0x00, 0x20, 0x0F, 0x07, 0xE1, 0xF0, 0xFC, 0x0E,
  0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x40, 0x07, 0x80, 0x3E,
  0x00, 0xF8, 0x01, 0xF0, 0x07, 0x01, 0xF0, 0xF8, 0x3E, 0x07, 0x80, 0x40,
  0x00, 0x7C, 0xFF, 0x87, 0x03, 0x03, 0x03, 0x06, 0x0C, 0x18, 0x38, 0x30,
  0x00, 0x00, 0x38, 0x38, 0x38, 0x38, 0x07, 0x81, 0xFE, 0x38, 0x67, 0x07,
  0x60, 0x36, 0x03, 0xE1, 0xFE, 0x7F, 0xC6, 0x3C, 0xE3, 0xCC, 0x3C, 0xC3,
  0xEE, 0x3E, 0x63, 0x67, 0xF6, 0x1F, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0x70, 0x0C, 0xC0, 0x33,
  0x01, 0x8E, 0x06, 0x18, 0x18, 0x60, 0xE1, 0xC3, 0x03, 0x0F, 0xFC, 0x7F,
  0xF9, 0x80, 0xE6, 0x01, 0x98, 0x06, 0xE0, 0x1C, 0xFE, 0x1F, 0xF3, 0x0E,
  0x60, 0xEC, 0x0D, 0x83, 0xB0, 0xE7, 0xF8, 0xFF, 0x98, 0x3B, 0x03, 0x60,
  0x7C, 0x0F, 0x81, 0xB0, 0x77, 0xFC, 0xFF, 0x00, 0x07, 0xC1, 0xFF, 0x38,
  0x27, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x06, 0x00, 0x60, 0x07, 0x00, 0x38, 0x21, 0xFF, 0x07, 0xE0, 0xFC, 0x1F,
  0xE3, 0x0E, 0x60, 0xEC, 0x0D, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0D, 0x83, 0xB0, 0xE7, 0xF8, 0xFC, 0x00, 0xFF, 0xBF,
  0xEC, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFC, 0xFF, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x0C, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x18,
  0x0C, 0x06, 0x03, 0x01, 0xFE, 0xFF, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x00, 0x07, 0xC1, 0xFF, 0x3C, 0x27, 0x00, 0x70, 0x06,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x07, 0xE0, 0x76, 0x07, 0x60, 0x77,
  0x07, 0x38, 0x71, 0xFF, 0x07, 0xE0, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x70, 0xFF, 0xFF, 0xF0, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC3, 0xFF, 0xFF, 0xC0, 0x3F, 0xCF, 0xF0, 0x1C, 0x07, 0x01,
  0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78,
  0x3B, 0xFC, 0x7E, 0x00, 0xC0, 0xEC, 0x1C, 0xC3, 0x8C, 0x38, 0xC7, 0x0C,
  0xE0, 0xDC, 0x0F, 0x80, 0xF8, 0x0D, 0xC0, 0xCE, 0x0C, 0x70, 0xC3, 0x8C,
  0x1C, 0xC0, 0xCC, 0x0E, 0xC0, 0x70, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x03, 0xFF, 0xFF, 0xC0, 0x60, 0x67, 0x0E, 0x70, 0xE5, 0x8A, 0x59, 0xA5,
  0x9A, 0xCF, 0x3C, 0xF3, 0xCF, 0x3C, 0x63, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0xC0, 0xF8, 0x3E, 0x0F, 0xC3, 0xF0,
  0xF6, 0x3D, 0x8F, 0x33, 0xCC, 0xF1, 0xBC, 0x6F, 0x0F, 0xC3, 0xF0, 0x7C,
  0x1F, 0x07, 0xC0, 0xC0, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x7C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xE0, 0x76,
  0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0xFF, 0x1F, 0xF3, 0x07, 0x60, 0x6C,
  0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC1, 0xDF, 0xF3, 0xF8, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x06, 0x00, 0xC0, 0x00, 0x1F, 0x83, 0xFC, 0x70, 0xE6, 0x06,
  0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xE0, 0x76, 0x06, 0x70, 0xE3, 0xFC, 0x1F, 0x80, 0x60, 0x07, 0x80, 0x3E,
  0x00, 0x60, 0xFE, 0x1F, 0xF3, 0x0E, 0x60, 0xEC, 0x0D, 0x81, 0xB0, 0x36,
  0x0E, 0xC3, 0x9F, 0xE3, 0xF8, 0x63, 0x8C, 0x31, 0x83, 0x30, 0x76, 0x06,
  0xC0, 0xE0, 0x1F, 0x1F, 0xFE, 0x0B, 0x00, 0xC0, 0x38, 0x0F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x1C, 0x03, 0x00, 0xC0, 0x3C, 0x1F, 0xFE, 0x7F, 0x00,
  0xFF, 0xFF, 0xFF, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60,
  0x06, 0x00, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x76, 0x06, 0x70,
  0xE3, 0xFC, 0x1F, 0x80, 0xE0, 0x1D, 0x80, 0x66, 0x01, 0x9C, 0x0E, 0x30,
  0x38, 0xC0, 0xC3, 0x83, 0x0E, 0x1C, 0x18, 0x60, 0x61, 0x81, 0xCE, 0x03,
  0x30, 0x0C, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0xC0, 0x3C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x63, 0xCF, 0x3C,
  0xF3, 0xCF, 0x25, 0x9A, 0x59, 0xA5, 0x1A, 0x70, 0xE7, 0x0E, 0x60, 0x60,
  0xE0, 0x76, 0x06, 0x70, 0xE3, 0x8C, 0x19, 0x81, 0xF8, 0x0F, 0x00, 0xF0,
  0x06, 0x00, 0xF0, 0x1F, 0x81, 0x98, 0x39, 0xC3, 0x0E, 0x60, 0xEE, 0x07,
  0xC0, 0x30, 0x60, 0x19, 0xC0, 0x67, 0x03, 0x8C, 0x0C, 0x38, 0x70, 0x71,
  0x81, 0xCE, 0x03, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x30, 0x00, 0xC0, 0x03,
  0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0xFF, 0xFF, 0xFC, 0x07,
  0x00, 0xC0, 0x38, 0x0E, 0x01, 0x80, 0x70, 0x1C, 0x03, 0x00, 0xE0, 0x18,
  0x07, 0x00, 0xC0, 0x30, 0x07, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x06, 0x0C,
  0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x06, 0x0F, 0xFF, 0xC0, 0xC0, 0x38, 0x06, 0x01, 0x80, 0x70, 0x0C, 0x03,
  0x00, 0xE0, 0x18, 0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xE0, 0x18,
  0x06, 0x01, 0xC0, 0x30, 0x0C, 0x03, 0x80, 0x60, 0x18, 0x07, 0x00, 0xC0,
  0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x3F, 0xFF, 0xC0, 0x06, 0x00, 0xF0, 0x1F,
  0x81, 0x98, 0x39, 0xC3, 0x0C, 0x70, 0xEE, 0x07, 0x40, 0x20, 0xFF, 0xFF,
  0xFF, 0xF0, 0x8C, 0x63, 0x10, 0x7F, 0x1F, 0xE0, 0x1C, 0x03, 0x00, 0xCF,
  0xF7, 0xFF, 0x83, 0xC0, 0xF0, 0x3E, 0x0F, 0xFF, 0x3F, 0xC0, 0xC0, 0x18,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x37, 0xC7, 0xFC, 0xE1, 0xD8, 0x1B,
  0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x06, 0xC1, 0xDF, 0xF3, 0xF8,
  0x00, 0x0F, 0xE1, 0xFE, 0x38, 0x27, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0x60, 0x07, 0x00, 0x38, 0x23, 0xFF, 0x0F, 0xE0, 0x00, 0x60, 0x0C,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC7, 0xD9, 0xFF, 0x70, 0xEC, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1B, 0x03, 0x70, 0x67, 0xFC, 0x3F, 0x00,
  0x0F, 0x83, 0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0xE0, 0x06, 0x00, 0x78, 0x23, 0xFE, 0x0F, 0xC0, 0x07, 0xE0, 0xFE, 0x1C,
  0x21, 0x80, 0x18, 0x01, 0x80, 0xFF, 0xCF, 0xFC, 0x18, 0x01, 0x80, 0x18,
  0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18, 0x01, 0x80, 0x18,
  0x00, 0x0F, 0xC7, 0xFD, 0xC1, 0xB0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03,
  0xE0, 0x6C, 0x0D, 0xC3, 0x9F, 0xF1, 0xF6, 0x00, 0xC0, 0x3A, 0x0E, 0x7F,
  0xCF, 0xE0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0F, 0xF3, 0xFE,
  0xC1, 0xF0, 0x7C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0C, 0x38, 0x07, 0x80, 0x60, 0x00, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0x62,
  0x0F, 0xC0, 0xF8, 0x07, 0x03, 0x81, 0xC0, 0x00, 0x03, 0xFD, 0xFE, 0x07,
  0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0,
  0xE0, 0x70, 0x37, 0xF9, 0xF8, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01,
  0x80, 0x30, 0x36, 0x0E, 0xC3, 0x98, 0xC3, 0x70, 0x7C, 0x0F, 0x81, 0xB8,
  0x31, 0x86, 0x1C, 0xC1, 0x98, 0x1B, 0x03, 0x80, 0xFC, 0x1F, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x0C, 0x41, 0xF8, 0x1F, 0x00, 0x79,
  0xCF, 0xFE, 0xC6, 0x7C, 0x63, 0xC6, 0x3C, 0x63, 0xC6, 0x3C, 0x63, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x30, 0x7F, 0x3F, 0xEC, 0x1F, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xC0,
  0x0F, 0x03, 0xFC, 0x70, 0xE6, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x76, 0x06, 0x70, 0xE3, 0xFC, 0x0F, 0x00, 0x7E, 0x1F, 0xF3, 0x07,
  0x60, 0x6C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1B, 0x87, 0x7F,
  0xCD, 0xF1, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x0F, 0xC7, 0xFD,
  0xC1, 0xB0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x6C, 0x0D, 0xC3,
  0x9F, 0xF1, 0xF6, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x3F, 0xFF,
  0xF0, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C,
  0x00, 0x3F, 0x9F, 0xEE, 0x0B, 0x00, 0xE0, 0x1F, 0x03, 0xF0, 0x1E, 0x01,
  0xC0, 0x3C, 0x1F, 0xFE, 0x7F, 0x00, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x0F,
  0xFD, 0xFF, 0x86, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x10, 0xFE, 0x07, 0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF8, 0x3E, 0x0D, 0xFF, 0x3F, 0xC0, 0xC0,
  0x3E, 0x07, 0x60, 0x66, 0x06, 0x70, 0xE3, 0x0C, 0x30, 0xC3, 0x98, 0x19,
  0x81, 0xF8, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0xC0, 0x3C, 0x03, 0xC0, 0x3C,
  0x63, 0xC6, 0x3C, 0xF3, 0xCF, 0x36, 0x96, 0x79, 0xE7, 0x9E, 0x70, 0xE7,
  0x0E, 0x70, 0xC0, 0xE0, 0x67, 0x0E, 0x31, 0xC1, 0x98, 0x1F, 0x00, 0xF0,
  0x06, 0x00, 0xF0, 0x19, 0x83, 0x9C, 0x70, 0xE6, 0x06, 0xE0, 0x70, 0xE0,
  0x76, 0x07, 0x70, 0x67, 0x06, 0x30, 0xE3, 0x0C, 0x38, 0xC1, 0x8C, 0x1D,
  0x80, 0xD8, 0x0D, 0x80, 0x70, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0xFC,
  0x0F, 0x00, 0xFF, 0xFF, 0xF0, 0x38, 0x0C, 0x07, 0x03, 0x81, 0xC0, 0x60,
  0x30, 0x1C, 0x06, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xC3, 0xF1, 0xC0, 0x70,
  0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0xE0, 0xF0, 0x3C,
  0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0xC0,
  0x3F, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF8, 0x3F,
  0x00, 0xE0, 0x38, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60,
  0x1C, 0x03, 0xC0, 0xF0, 0x60, 0x18, 0x06, 0x01, 0x80, 0x60, 0x18, 0x06,
  0x03, 0x80, 0xE3, 0xF0, 0xF8, 0x00, 0x38, 0x37, 0xE3, 0xC7, 0xEC, 0x1C,
};

const GFXglyph UbuntuMono_Regular28pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 4, 17, 14, 5, -17 },
  { 10, 6, 7, 14, 4, -19 },
  { 16, 12, 17, 14, 1, -17 },
  { 42, 11, 22, 14, 2, -19 },
  { 73, 14, 17, 14, 0, -17 },
  { 103, 12, 17, 14, 1, -17 },
  { 129, 2, 7, 14, 6, -19 },
  { 131, 8, 22, 14, 3, -17 },
  { 153, 8, 22, 14, 3, -17 },
  { 175, 10, 10, 14, 2, -17 },
  { 188, 12, 12, 14, 1, -13 },
  { 206, 6, 8, 14, 4, -4 },
  { 212, 6, 2, 14, 4, -8 },
  { 214, 4, 4, 14, 5, -4 },
  { 216, 10, 25, 14, 2, -20 },
  { 248, 12, 17, 14, 1, -17 },
  { 274, 10, 17, 14, 2, -17 },
  { 296, 10, 17, 14, 2, -17 },
  { 318, 10, 17, 14, 2, -17 },
  { 340, 12, 17, 14, 1, -17 },
  { 366, 10, 17, 14, 2, -17 },
  { 388, 11, 17, 14, 2, -17 },
  { 412, 11, 17, 14, 2, -17 },
  { 436, 12, 17, 14, 1, -17 },
  { 462, 12, 17, 14, 1, -17 },
  { 488, 4, 13, 14, 5, -13 },
  { 495, 6, 17, 14, 3, -13 },
  { 508, 12, 11, 14, 1, -13 },
  { 525, 12, 7, 14, 1, -11 },
  { 536, 12, 11, 14, 1, -13 },
  { 553, 8, 17, 14, 3, -17 },
  { 570, 12, 21, 14, 1, -17 },
  { 602, 14, 17, 14, 0, -17 },
  { 632, 11, 17, 14, 2, -17 },
  { 656, 12, 17, 14, 1, -17 },
  { 682, 11, 17, 14, 2, -17 },
  { 706, 10, 17, 14, 3, -17 },
  { 728, 9, 17, 14, 3, -17 },
  { 748, 12, 17, 14, 1, -17 },
  { 774, 12, 17, 14, 1, -17 },
  { 800, 10, 17, 14, 2, -17 },
  { 822, 10, 17, 14, 2, -17 },
  { 844, 12, 17, 14, 2, -17 },
  { 870, 10, 17, 14, 3, -17 },
  { 892, 12, 17, 14, 1, -17 },
  { 918, 10, 17, 14, 2, -17 },
  { 940, 12, 17, 14, 1, -17 },
  { 966, 11, 17, 14, 2, -17 },
  { 990, 12, 21, 14, 1, -17 },
  { 1022, 11, 17, 14, 2, -17 },
  { 1046, 10, 17, 14, 2, -17 },
  { 1068, 12, 17, 14, 1, -17 },
  { 1094, 12, 17, 14, 1, -17 },
  { 1120, 14, 17, 14, 0, -17 },
  { 1150, 12, 17, 14, 1, -17 },
  { 1176, 12, 17, 14, 1, -17 },
  { 1202, 14, 17, 14, 0, -17 },
  { 1232, 11, 17, 14, 2, -17 },
  { 1256, 7, 22, 14, 4, -17 },
  { 1276, 10, 25, 14, 2, -20 },
  { 1308, 7, 22, 14, 3, -17 },
  { 1328, 12, 9, 14, 1, -17 },
  { 1342, 14, 2, 14, 0, 3 },
  { 1346, 4, 5, 14, 5, -20 },
  { 1349, 10, 13, 14, 2, -13 },
  { 1366, 11, 19, 14, 2, -19 },
  { 1393, 12, 13, 14, 1, -13 },
  { 1413, 11, 19, 14, 1, -19 },
  { 1440, 12, 13, 14, 1, -13 },
  { 1460, 12, 19, 14, 2, -19 },
  { 1489, 11, 18, 14, 1, -13 },
  { 1514, 10, 19, 14, 2, -19 },
  { 1538, 11, 18, 14, 2, -18 },
  { 1563, 9, 23, 14, 2, -18 },
  { 1589, 11, 19, 14, 2, -19 },
  { 1616, 11, 19, 14, 2, -19 },
  { 1643, 12, 13, 14, 1, -13 },
  { 1663, 10, 13, 14, 2, -13 },
  { 1680, 12, 13, 14, 1, -13 },
  { 1700, 11, 18, 14, 2, -13 },
  { 1725, 11, 18, 14, 1, -13 },
  { 1750, 9, 13, 14, 3, -13 },
  { 1765, 10, 13, 14, 2, -13 },
  { 1782, 11, 17, 14, 2, -17 },
  { 1806, 10, 13, 14, 2, -13 },
  { 1823, 12, 13, 14, 1, -13 },
  { 1843, 12, 13, 14, 1, -13 },
  { 1863, 12, 13, 14, 1, -13 },
  { 1883, 12, 18, 14, 1, -13 },
  { 1910, 10, 13, 14, 2, -13 },
  { 1927, 10, 25, 14, 2, -20 },
  { 1959, 2, 25, 14, 6, -20 },
  { 1966, 10, 25, 14, 2, -20 },
  { 1998, 12, 4, 14, 1, -9 },
};

const GFXfont UbuntuMono_Regular28pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular28pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular28pt7bGlyphs,
  0x20, 0x7E, 28
};

#endif // _UBUNTUMONO_REGULAR28PT7B_H_
