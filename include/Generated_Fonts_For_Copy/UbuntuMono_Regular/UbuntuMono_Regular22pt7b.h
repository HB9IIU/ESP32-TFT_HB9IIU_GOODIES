#ifndef _UBUNTUMONO_REGULAR22PT7B_H_
#define _UBUNTUMONO_REGULAR22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular22pt7bBitmaps[] PROGMEM = {
  0x00, 0xDB, 0x6C, 0x92, 0x40, 0x7F, 0xC0, 0xDE, 0xE3, 0x18, 0x80, 0x19,
  0x88, 0x84, 0x46, 0x6F, 0xFF, 0xFC, 0xCC, 0x44, 0x66, 0x7F, 0xFF, 0xEC,
  0xC4, 0x46, 0x20, 0x08, 0x04, 0x0F, 0xCF, 0xE6, 0x16, 0x01, 0x80, 0xF0,
  0x3E, 0x03, 0x80, 0xE0, 0x34, 0x3F, 0xF9, 0xF8, 0x10, 0x08, 0x00, 0x70,
  0x4B, 0x1B, 0x26, 0x64, 0x8C, 0xB0, 0xB4, 0x1D, 0x80, 0x6E, 0x0B, 0x43,
  0x4C, 0x49, 0x99, 0x36, 0x34, 0x83, 0x80, 0x3C, 0x3F, 0x19, 0x88, 0xC6,
  0x41, 0xC1, 0xC6, 0xB2, 0xCD, 0x63, 0xB0, 0xD8, 0xEF, 0xDB, 0xCC, 0xFC,
  0x04, 0x31, 0x8C, 0x21, 0x86, 0x10, 0xC3, 0x04, 0x18, 0x60, 0xC3, 0x06,
  0x0C, 0x10, 0x41, 0x83, 0x06, 0x18, 0x30, 0xC1, 0x04, 0x10, 0x43, 0x0C,
  0x21, 0x8C, 0x61, 0x00, 0x08, 0x04, 0x12, 0x5F, 0xF1, 0xC0, 0xA0, 0xD8,
  0x44, 0x08, 0x04, 0x02, 0x01, 0x0F, 0xFF, 0xFC, 0x20, 0x10, 0x08, 0x04,
  0x00, 0x33, 0xCE, 0x23, 0x60, 0xFF, 0xC0, 0xFF, 0x80, 0x06, 0x0C, 0x18,
  0x20, 0xC1, 0x82, 0x0C, 0x18, 0x20, 0xC1, 0x82, 0x0C, 0x18, 0x30, 0xC1,
  0x83, 0x00, 0x1C, 0x3F, 0x98, 0xD8, 0x3C, 0x1E, 0x4F, 0x77, 0x93, 0xC1,
  0xE0, 0xF0, 0x6C, 0x67, 0xF0, 0xE0, 0x18, 0x38, 0x78, 0xD8, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3E, 0x7F, 0x90, 0xC0,
  0x60, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x08, 0x0C, 0x07, 0xFB, 0xFC,
  0x3C, 0x3F, 0x90, 0xC0, 0x60, 0x30, 0x38, 0x78, 0x3C, 0x03, 0x00, 0xC0,
  0x68, 0x6F, 0xF3, 0xF0, 0x07, 0x03, 0x83, 0xC3, 0xE3, 0xB1, 0x99, 0x8C,
  0x86, 0xC3, 0x7F, 0xFF, 0xE0, 0x60, 0x30, 0x18, 0x3F, 0x1F, 0x88, 0x04,
  0x02, 0x03, 0xE1, 0xFC, 0x0E, 0x01, 0x80, 0xC0, 0x68, 0x67, 0xF3, 0xE0,
  0x07, 0x0F, 0x8E, 0x0C, 0x06, 0x07, 0xF3, 0xFD, 0x87, 0xC1, 0xE0, 0xF0,
  0x6C, 0x67, 0xF1, 0xF0, 0xFF, 0xFF, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30,
  0x18, 0x08, 0x0C, 0x06, 0x03, 0x01, 0x01, 0x80, 0x3E, 0x3F, 0x98, 0xD8,
  0x3C, 0x13, 0x19, 0xF8, 0x7E, 0x63, 0xE0, 0xF0, 0x7C, 0x77, 0xF1, 0xF0,
  0x3C, 0x3F, 0x98, 0xD8, 0x3C, 0x1E, 0x0F, 0x86, 0xFF, 0x3F, 0x81, 0x80,
  0xC1, 0xC7, 0xC3, 0x80, 0xFF, 0x80, 0x07, 0xFC, 0x77, 0x70, 0x00, 0x07,
  0x77, 0x36, 0xC0, 0x01, 0x83, 0xC7, 0xCF, 0x0C, 0x03, 0xC0, 0x7C, 0x0F,
  0x01, 0x80, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0xC0, 0x78,
  0x1F, 0x01, 0xF0, 0x18, 0x7D, 0xF1, 0xE0, 0xC0, 0x00, 0x7D, 0xFE, 0x18,
  0x30, 0x61, 0x86, 0x18, 0x30, 0x00, 0x01, 0x83, 0x06, 0x00, 0x1E, 0x1F,
  0x9C, 0x6C, 0x3C, 0x0E, 0x3F, 0x3F, 0xB1, 0xD8, 0xEC, 0x76, 0x39, 0xFC,
  0x7B, 0x01, 0xC0, 0x7E, 0x0F, 0x00, 0x0E, 0x01, 0xC0, 0x2C, 0x0D, 0x81,
  0xB0, 0x22, 0x0C, 0x61, 0x8C, 0x20, 0x8F, 0xF9, 0xFF, 0x30, 0x64, 0x0D,
  0x80, 0xC0, 0xFC, 0x7F, 0xB0, 0xD8, 0x6C, 0x36, 0x1B, 0xF9, 0xFE, 0xC3,
  0xE0, 0xF0, 0x78, 0x7F, 0xF7, 0xF0, 0x1F, 0x1F, 0xDC, 0x2C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x0E, 0x13, 0xF8, 0xF8, 0xFC, 0x7F,
  0x31, 0xD8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0xF8, 0xEF,
  0xE7, 0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE, 0xC0, 0xC0,
  0xC0, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0xFE, 0xFE,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x1F, 0x1F, 0xDC, 0x2C, 0x0C, 0x06,
  0x03, 0x01, 0x83, 0xC1, 0xE0, 0xD8, 0x6E, 0x33, 0xF8, 0xFC, 0xC1, 0xE0,
  0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0xFF, 0xFF, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0C, 0xFF, 0xFC, 0x40, 0x81, 0x02, 0x04, 0x08, 0x10, 0x20, 0x40,
  0x8F, 0xFF, 0xC0, 0x3F, 0x3F, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x43, 0xFE, 0x7C, 0xC1, 0xB0, 0xCC, 0x73, 0x18, 0xCC, 0x36,
  0x0F, 0x03, 0x60, 0xCC, 0x31, 0x8C, 0x33, 0x0C, 0xC1, 0xB0, 0x70, 0xC0,
  0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xFF,
  0xFF, 0x63, 0x31, 0xF8, 0xFC, 0x7F, 0x7E, 0xAF, 0x57, 0xBB, 0xC9, 0xE0,
  0xF0, 0x78, 0x38, 0x0C, 0x04, 0xC1, 0xF0, 0xF8, 0x7E, 0x3D, 0x1E, 0xCF,
  0x27, 0x9B, 0xC5, 0xE3, 0xF0, 0xF8, 0x7C, 0x3E, 0x0C, 0x3E, 0x3F, 0x98,
  0xF8, 0x3C, 0x1E, 0x0E, 0x03, 0x01, 0xC1, 0xE0, 0xF0, 0x7C, 0x77, 0xF1,
  0xF0, 0xFC, 0xFE, 0x87, 0x83, 0x83, 0x83, 0x87, 0xFE, 0xFC, 0x80, 0x80,
  0x80, 0x80, 0x80, 0x3E, 0x3F, 0x98, 0xF8, 0x3C, 0x1E, 0x0E, 0x03, 0x01,
  0xC1, 0xE0, 0xF0, 0x7C, 0x77, 0xF1, 0xF0, 0x30, 0x1F, 0x03, 0x80, 0xFC,
  0x7F, 0xB0, 0xD8, 0x6C, 0x16, 0x0B, 0x0D, 0xFC, 0xFC, 0x63, 0x31, 0x98,
  0x6C, 0x16, 0x0C, 0x3E, 0x3F, 0x98, 0x48, 0x06, 0x03, 0x80, 0xF0, 0x3E,
  0x03, 0x00, 0xC0, 0x68, 0x7F, 0xF3, 0xF0, 0xFF, 0xFF, 0xC2, 0x01, 0x00,
  0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x02, 0x01, 0x00, 0x80, 0x40, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x7C,
  0x77, 0xF1, 0xF0, 0xC0, 0x6C, 0x09, 0x83, 0x30, 0x66, 0x0C, 0x63, 0x0C,
  0x61, 0x8C, 0x11, 0x03, 0x60, 0x6C, 0x05, 0x00, 0xE0, 0x1C, 0x00, 0x80,
  0xC0, 0x70, 0x78, 0x3C, 0x1E, 0x4F, 0x77, 0xAB, 0xD5, 0xFB, 0xF8, 0xFC,
  0x7E, 0x33, 0x18, 0xC1, 0xB1, 0x98, 0xC6, 0xC3, 0x60, 0xE0, 0x70, 0x38,
  0x3E, 0x1B, 0x18, 0xCC, 0x6C, 0x1E, 0x0C, 0xC0, 0x6C, 0x19, 0x83, 0x18,
  0xC3, 0x18, 0x36, 0x06, 0xC0, 0x70, 0x0E, 0x00, 0x80, 0x10, 0x02, 0x00,
  0x40, 0x08, 0x00, 0x7F, 0xBF, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x30, 0x30,
  0x30, 0x18, 0x18, 0x0C, 0x0F, 0xFF, 0xFC, 0xFE, 0x31, 0x8C, 0x63, 0x18,
  0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC7, 0xC0, 0xC1, 0x83, 0x02, 0x06, 0x0C,
  0x08, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x81, 0x83, 0x06, 0x06, 0x0C, 0x18,
  0xF8, 0xC6, 0x31, 0x8C, 0x63, 0x18, 0xC6, 0x31, 0x8C, 0x63, 0x1F, 0xC0,
  0x1C, 0x0E, 0x0D, 0x86, 0xC6, 0x36, 0x0F, 0x06, 0xFF, 0xFF, 0xFC, 0x99,
  0x90, 0x7E, 0x3F, 0x80, 0xC0, 0x23, 0xFB, 0x0F, 0x07, 0xC3, 0x7F, 0x9F,
  0xC0, 0x80, 0x80, 0x80, 0x80, 0x80, 0xBC, 0xFE, 0xC7, 0x83, 0x83, 0x83,
  0x83, 0x87, 0xFE, 0xFC, 0x1F, 0xBF, 0x98, 0x18, 0x0C, 0x06, 0x03, 0x00,
  0xC0, 0x7F, 0x8F, 0xC0, 0x01, 0x01, 0x01, 0x01, 0x01, 0x3D, 0x7F, 0xE3,
  0xC1, 0xC1, 0xC1, 0xC1, 0xE1, 0x7F, 0x3F, 0x3E, 0x3F, 0xB8, 0xF8, 0x3F,
  0xFE, 0x03, 0x01, 0xC0, 0x7F, 0x0F, 0x80, 0x0F, 0x87, 0xF1, 0x88, 0x40,
  0x10, 0x3F, 0xCF, 0xF0, 0x40, 0x10, 0x04, 0x01, 0x00, 0x40, 0x10, 0x04,
  0x01, 0x00, 0x3F, 0x7F, 0xE1, 0xC1, 0xC1, 0xC1, 0xC1, 0xE3, 0x7F, 0x3D,
  0x01, 0x43, 0x7F, 0x7C, 0x80, 0x80, 0x80, 0x80, 0x80, 0xFC, 0xFE, 0x86,
  0x82, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x18, 0x1C, 0x06, 0x00, 0x00,
  0x07, 0xC3, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xFC, 0x3E,
  0x0C, 0x70, 0xC0, 0x01, 0xF7, 0xC1, 0x04, 0x10, 0x41, 0x04, 0x10, 0x41,
  0x0F, 0xFF, 0x80, 0x80, 0x40, 0x20, 0x10, 0x08, 0x04, 0x1A, 0x19, 0x38,
  0xB8, 0x70, 0x2C, 0x13, 0x08, 0xC4, 0x32, 0x0C, 0xF8, 0x7C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0x7C,
  0x3E, 0xF7, 0x7F, 0xF2, 0x79, 0x1C, 0x8E, 0x47, 0x03, 0x81, 0xC0, 0xE0,
  0x40, 0xFC, 0xFE, 0x86, 0x82, 0x83, 0x83, 0x83, 0x83, 0x83, 0x83, 0x3E,
  0x3F, 0xB8, 0xF8, 0x3C, 0x1E, 0x0F, 0x07, 0xC7, 0x7F, 0x1F, 0x00, 0xFC,
  0xFE, 0x87, 0x83, 0x83, 0x83, 0x83, 0xC7, 0xFE, 0xBC, 0x80, 0x80, 0x80,
  0x80, 0x3F, 0x7F, 0xE1, 0xC1, 0xC1, 0xC1, 0xC1, 0xE3, 0x7F, 0x3D, 0x01,
  0x01, 0x01, 0x01, 0x7F, 0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0x3F, 0x3F, 0x98, 0x4C, 0x07, 0xC0, 0xF8, 0x0C, 0x83, 0x7F, 0x3F,
  0x00, 0x10, 0x08, 0x04, 0x1F, 0xFF, 0xF8, 0x80, 0x40, 0x20, 0x10, 0x08,
  0x06, 0x03, 0xF0, 0xF8, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0xC1, 0x41, 0x61,
  0x7F, 0x3F, 0xC1, 0xE0, 0xF0, 0x6C, 0x66, 0x31, 0x10, 0xD8, 0x68, 0x1C,
  0x0E, 0x00, 0xC0, 0x68, 0x09, 0x11, 0x27, 0x26, 0xEC, 0xD5, 0x9A, 0xB1,
  0x9C, 0x31, 0x86, 0x30, 0xC1, 0xB1, 0x8D, 0x86, 0x81, 0xC0, 0xE0, 0xD8,
  0xC6, 0x63, 0x60, 0xC0, 0xC1, 0xE0, 0xD8, 0x4C, 0x62, 0x31, 0x98, 0xC8,
  0x3C, 0x1E, 0x06, 0x03, 0x03, 0x0F, 0x87, 0x80, 0xFF, 0xFC, 0x38, 0xE1,
  0x86, 0x18, 0x60, 0xFF, 0xFC, 0x1E, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x21, 0x80, 0x81, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0x78, 0xFF, 0xFF,
  0xE0, 0xF0, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x08, 0x0C, 0x20, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x33, 0xC0, 0x70, 0xFC, 0xF3, 0xF0, 0xE0,
};

const GFXglyph UbuntuMono_Regular22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 3, 14, 11, 4, -14 },
  { 7, 5, 5, 11, 3, -15 },
  { 11, 9, 14, 11, 1, -14 },
  { 27, 9, 17, 11, 1, -15 },
  { 47, 11, 14, 11, 0, -14 },
  { 67, 9, 14, 11, 1, -14 },
  { 83, 1, 6, 11, 5, -15 },
  { 84, 6, 18, 11, 2, -14 },
  { 98, 6, 18, 11, 2, -14 },
  { 112, 9, 8, 11, 1, -14 },
  { 121, 9, 10, 11, 1, -11 },
  { 133, 5, 6, 11, 3, -3 },
  { 137, 5, 2, 11, 3, -7 },
  { 139, 3, 3, 11, 4, -3 },
  { 141, 7, 19, 11, 2, -15 },
  { 158, 9, 14, 11, 1, -14 },
  { 174, 8, 14, 11, 2, -14 },
  { 188, 9, 14, 11, 1, -14 },
  { 204, 9, 14, 11, 1, -14 },
  { 220, 9, 14, 11, 1, -14 },
  { 236, 9, 14, 11, 1, -14 },
  { 252, 9, 14, 11, 1, -14 },
  { 268, 9, 14, 11, 1, -14 },
  { 284, 9, 14, 11, 1, -14 },
  { 300, 9, 14, 11, 1, -14 },
  { 316, 3, 10, 11, 4, -10 },
  { 320, 4, 13, 11, 3, -10 },
  { 327, 9, 9, 11, 1, -10 },
  { 338, 9, 7, 11, 1, -9 },
  { 346, 9, 9, 11, 1, -10 },
  { 357, 7, 14, 11, 2, -14 },
  { 370, 9, 17, 11, 1, -14 },
  { 390, 11, 14, 11, 0, -14 },
  { 410, 9, 14, 11, 1, -14 },
  { 426, 9, 14, 11, 1, -14 },
  { 442, 9, 14, 11, 1, -14 },
  { 458, 8, 14, 11, 2, -14 },
  { 472, 8, 14, 11, 2, -14 },
  { 486, 9, 14, 11, 1, -14 },
  { 502, 9, 14, 11, 1, -14 },
  { 518, 7, 14, 11, 2, -14 },
  { 531, 8, 14, 11, 1, -14 },
  { 545, 10, 14, 11, 1, -14 },
  { 563, 8, 14, 11, 2, -14 },
  { 577, 9, 14, 11, 1, -14 },
  { 593, 9, 14, 11, 1, -14 },
  { 609, 9, 14, 11, 1, -14 },
  { 625, 8, 14, 11, 2, -14 },
  { 639, 9, 17, 11, 1, -14 },
  { 659, 9, 14, 11, 1, -14 },
  { 675, 9, 14, 11, 1, -14 },
  { 691, 9, 14, 11, 1, -14 },
  { 707, 9, 14, 11, 1, -14 },
  { 723, 11, 14, 11, 0, -14 },
  { 743, 9, 14, 11, 1, -14 },
  { 759, 9, 14, 11, 1, -14 },
  { 775, 11, 14, 11, 0, -14 },
  { 795, 9, 14, 11, 1, -14 },
  { 811, 5, 18, 11, 3, -14 },
  { 823, 7, 19, 11, 2, -15 },
  { 840, 5, 18, 11, 3, -14 },
  { 852, 9, 7, 11, 1, -14 },
  { 860, 11, 2, 11, 0, 2 },
  { 863, 3, 4, 11, 4, -15 },
  { 865, 9, 10, 11, 1, -10 },
  { 877, 8, 15, 11, 2, -15 },
  { 892, 9, 10, 11, 1, -10 },
  { 904, 8, 15, 11, 1, -15 },
  { 919, 9, 10, 11, 1, -10 },
  { 931, 10, 15, 11, 1, -15 },
  { 950, 8, 14, 11, 1, -10 },
  { 964, 8, 15, 11, 2, -15 },
  { 979, 9, 15, 11, 1, -15 },
  { 996, 6, 19, 11, 2, -15 },
  { 1011, 9, 15, 11, 2, -15 },
  { 1028, 9, 15, 11, 1, -15 },
  { 1045, 9, 10, 11, 1, -10 },
  { 1057, 8, 10, 11, 2, -10 },
  { 1067, 9, 10, 11, 1, -10 },
  { 1079, 8, 14, 11, 2, -10 },
  { 1093, 8, 14, 11, 1, -10 },
  { 1107, 8, 10, 11, 2, -10 },
  { 1117, 9, 10, 11, 1, -10 },
  { 1129, 9, 13, 11, 1, -13 },
  { 1144, 8, 10, 11, 1, -10 },
  { 1154, 9, 10, 11, 1, -10 },
  { 1166, 11, 10, 11, 0, -10 },
  { 1180, 9, 10, 11, 1, -10 },
  { 1192, 9, 14, 11, 1, -10 },
  { 1208, 7, 10, 11, 2, -10 },
  { 1217, 7, 19, 11, 2, -15 },
  { 1234, 1, 19, 11, 5, -15 },
  { 1237, 7, 19, 11, 2, -15 },
  { 1254, 9, 4, 11, 1, -8 },
};

const GFXfont UbuntuMono_Regular22pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular22pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular22pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _UBUNTUMONO_REGULAR22PT7B_H_
