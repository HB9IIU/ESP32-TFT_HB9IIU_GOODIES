#ifndef _UBUNTUMONO_REGULAR47PT7B_H_
#define _UBUNTUMONO_REGULAR47PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 47pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular47pt7bBitmaps[] PROGMEM = {
  0x00, 0x3C, 0x78, 0xF1, 0xE3, 0xC7, 0x8F, 0x1E, 0x3C, 0x78, 0xF1, 0xE3,
  0xC7, 0x8E, 0x1C, 0x38, 0x70, 0xE0, 0x00, 0x00, 0x00, 0x1C, 0x7C, 0xFD,
  0xFB, 0xE3, 0x80, 0xF0, 0xFE, 0x1F, 0xC3, 0xF8, 0x7F, 0x0F, 0xE1, 0xF8,
  0x3F, 0x07, 0xE0, 0xEC, 0x1D, 0x83, 0xB0, 0x30, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x00, 0x70, 0x38, 0x03, 0x83, 0xC0, 0x1C, 0x1E, 0x01, 0xE0, 0xF0,
  0x0F, 0x07, 0x00, 0x78, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0x81, 0xC0, 0x1C, 0x1E, 0x01,
  0xE0, 0xF0, 0x0F, 0x07, 0x00, 0x78, 0x38, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0x07, 0x00, 0x78, 0x38, 0x03, 0x81, 0xC0, 0x1C,
  0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80, 0x78, 0x38, 0x03, 0x81, 0xC0,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x01, 0xFF, 0x01, 0xFF, 0xF0, 0xFF, 0xFC, 0x7E, 0x03, 0x1E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF,
  0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0xC0, 0x07, 0xBC, 0x07, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x1F, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x38, 0xFC, 0x01, 0xC7, 0x38, 0x0F, 0x38,
  0x70, 0x38, 0xE1, 0xC1, 0xE3, 0x87, 0x07, 0x0E, 0x1C, 0x38, 0x38, 0x71,
  0xE0, 0xE1, 0xC7, 0x03, 0x87, 0x38, 0x0E, 0x1C, 0xE0, 0x38, 0x77, 0x00,
  0x73, 0xBC, 0x00, 0xFC, 0xE0, 0x01, 0xE7, 0x3E, 0x00, 0x3D, 0xFC, 0x00,
  0xEF, 0x38, 0x07, 0xB8, 0xE0, 0x1C, 0xE3, 0x80, 0xE3, 0x07, 0x07, 0x9C,
  0x1C, 0x1C, 0x70, 0x70, 0xE1, 0xC1, 0xC3, 0x83, 0x07, 0x1C, 0x0E, 0x38,
  0xF0, 0x38, 0xE3, 0x80, 0xE3, 0x9C, 0x01, 0xFC, 0xF0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x3F, 0xE0, 0x03, 0xFF, 0x80, 0x3E, 0x3E, 0x01, 0xE0, 0xF0,
  0x0E, 0x07, 0x80, 0x70, 0x1C, 0x03, 0x81, 0xE0, 0x1C, 0x0F, 0x00, 0xF0,
  0xF0, 0x07, 0x87, 0x80, 0x1E, 0x78, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xC3, 0xFC, 0x1C, 0x3F, 0xF0, 0xE1, 0xE7, 0xC7, 0x1E, 0x1F,
  0x78, 0xF0, 0x7F, 0xC7, 0x01, 0xFC, 0x78, 0x07, 0xE3, 0xE0, 0x1E, 0x0F,
  0x00, 0xF8, 0x78, 0x0F, 0xE3, 0xF1, 0xFF, 0x0F, 0xFF, 0xBC, 0x3F, 0xF1,
  0xF0, 0x7E, 0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xEE, 0xEE, 0xE0, 0x00,
  0x20, 0x03, 0x80, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x1E, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00,
  0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0E, 0x00, 0x20, 0x20, 0x03, 0x80, 0x1E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x03, 0xC0, 0x1F, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xC0,
  0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x7C, 0x03, 0xC0,
  0x3C, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x0E, 0x00, 0x20,
  0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x41, 0xC1,
  0xBC, 0x71, 0xEF, 0xCD, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x1D, 0xE0, 0x0F, 0x3C, 0x07, 0x8F, 0x83, 0xE1, 0xE0, 0x70,
  0x78, 0x0C, 0x08, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x0F, 0x07, 0xE1, 0xF8, 0x7E, 0x1F,
  0x83, 0xE0, 0x78, 0x3C, 0x3F, 0x3F, 0x8F, 0x81, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x3C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0x87, 0xC3, 0xE0, 0x78,
  0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0F, 0x78, 0x01, 0xEE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x70, 0xFF, 0x1F, 0x1F, 0xE3, 0xE3, 0xFC, 0x7C, 0x7F,
  0x8F, 0x8F, 0xF0, 0xE1, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xF7,
  0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0xF1, 0xE0, 0x1E, 0x3C, 0x07, 0x83,
  0xE1, 0xF0, 0x3F, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x03, 0xFF, 0x03, 0xF7, 0x81,
  0xE3, 0xC0, 0x41, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x1F, 0xFF, 0xEF, 0xFF, 0xF7, 0xFF, 0xF8, 0x07,
  0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE3, 0xE0, 0xFC, 0x60, 0x0F, 0x10, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x0F, 0xFF, 0x07, 0xFF, 0xE1,
  0xE0, 0xFC, 0x20, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xFC, 0x01, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0xB0, 0x0F, 0xCF, 0xFF, 0xE3, 0xFF, 0xF0, 0x3F, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0x70, 0x01, 0xE7, 0x00, 0x1C, 0x70, 0x03, 0xC7, 0x00, 0x78, 0x70,
  0x07, 0x07, 0x00, 0xF0, 0x70, 0x1E, 0x07, 0x01, 0xC0, 0x70, 0x3C, 0x07,
  0x03, 0x80, 0x70, 0x78, 0x07, 0x07, 0x00, 0x70, 0xF0, 0x07, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x1F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xF8, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x98, 0x0F, 0xCF, 0xFF,
  0xE3, 0xFF, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x3F,
  0xF0, 0x1F, 0xC0, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xCF, 0xE0, 0xFF, 0xFE, 0x3F,
  0xFF, 0xCF, 0x81, 0xFB, 0xC0, 0x1E, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x1E,
  0x78, 0x07, 0x8F, 0x87, 0xC3, 0xFF, 0xF0, 0x3F, 0xF0, 0x03, 0xF0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F,
  0xFE, 0x1F, 0x07, 0xC3, 0xC0, 0x3C, 0xF0, 0x07, 0x9E, 0x00, 0x73, 0xC0,
  0x0E, 0x78, 0x01, 0xCF, 0x00, 0x78, 0xF0, 0x0F, 0x1F, 0x03, 0xC1, 0xF8,
  0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xF8, 0x3C, 0x0F, 0x8F, 0x00,
  0xF9, 0xE0, 0x0F, 0xB8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xC7, 0xC0, 0xF8, 0xFF, 0xFE, 0x07, 0xFF,
  0x80, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0x07,
  0xC3, 0xC0, 0x78, 0xF0, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF8, 0x03,
  0xCF, 0x81, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0xFF, 0xE0, 0x1F, 0xE0, 0x03, 0xE0, 0x00,
  0x3C, 0xFF, 0xFF, 0xF7, 0xE7, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1E, 0x7F, 0xFF, 0xFB, 0xF3, 0xC0, 0x0F, 0x0F, 0xCF, 0xE7, 0xF1,
  0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x1F, 0x9F, 0xCF, 0xE3, 0xF0, 0xF8, 0x3C, 0x3C, 0x7E, 0xFE, 0x7C,
  0x38, 0x00, 0x00, 0x00, 0x60, 0x00, 0x1E, 0x00, 0x07, 0xE0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x0F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x60, 0x00, 0x07, 0x80, 0x00,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xF0, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0x80, 0x00, 0x60, 0x00, 0x00, 0x1F, 0xE1, 0xFF, 0xF1, 0xFF,
  0xF3, 0x03, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x80, 0xF8, 0x3C,
  0x1E, 0x01, 0xE3, 0xC0, 0x0E, 0x3C, 0x00, 0xF7, 0x80, 0x0F, 0x78, 0x00,
  0xF7, 0x80, 0xFF, 0x70, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xF8, 0xFF, 0x1F,
  0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1C, 0x0F, 0xF1,
  0xC0, 0xFF, 0x1E, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF1, 0xF0, 0xF7,
  0x0F, 0x8F, 0x78, 0x7F, 0xF7, 0x83, 0xFF, 0x78, 0x0F, 0xE3, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x79, 0xE0, 0x00, 0xE3, 0xC0, 0x03, 0xC3, 0x80, 0x07, 0x87, 0x80, 0x0E,
  0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x1C, 0x00, 0xE0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x70, 0x0E, 0x00, 0xF0, 0x1C, 0x01, 0xE0, 0x7F, 0xFF,
  0xC0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x87, 0x80, 0x0F, 0x0F, 0x00, 0x0E,
  0x1E, 0x00, 0x1E, 0x38, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0, 0x00, 0xF3,
  0xC0, 0x00, 0xF7, 0x00, 0x01, 0xE0, 0xFF, 0xE0, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE3, 0x80, 0xFC, 0xE0, 0x0F, 0x38, 0x01, 0xEE, 0x00, 0x7B, 0x80, 0x1E,
  0xE0, 0x07, 0xB8, 0x01, 0xCE, 0x00, 0xF3, 0x80, 0xF8, 0xFF, 0xFC, 0x3F,
  0xFF, 0x0F, 0xFF, 0xE3, 0x80, 0x7C, 0xE0, 0x07, 0xB8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x07, 0xB8, 0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF0, 0x7F, 0xE0, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFE, 0x07, 0xFF, 0xE0, 0xFC, 0x1E, 0x1F, 0x00,
  0x43, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x20, 0xFC, 0x0E, 0x07, 0xFF, 0xE0, 0x3F, 0xFE, 0x00, 0xFF,
  0x00, 0xFF, 0xC0, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x70, 0x3F, 0x0E, 0x01,
  0xF1, 0xC0, 0x1F, 0x38, 0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x03, 0xDC, 0x00,
  0x7B, 0x80, 0x0F, 0x70, 0x01, 0xEE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x7B, 0x80, 0x0F, 0x70, 0x01,
  0xEE, 0x00, 0x3D, 0xC0, 0x0F, 0xB8, 0x01, 0xE7, 0x00, 0x7C, 0xE0, 0x1F,
  0x1C, 0x0F, 0xC3, 0xFF, 0xF0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x8F, 0xFF, 0xE3, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xE7, 0xFF, 0xF3, 0xFF, 0xF9,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFC, 0x1F,
  0xFF, 0x87, 0xE0, 0xF1, 0xF0, 0x04, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x03, 0xBC, 0x00, 0x77, 0x80, 0x0E, 0xF0, 0x01, 0xCF, 0x00,
  0x39, 0xF0, 0x07, 0x1F, 0x00, 0xE1, 0xF8, 0x3C, 0x1F, 0xFF, 0x81, 0xFF,
  0xF0, 0x0F, 0xF8, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0E,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x83, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0x8F, 0xFF, 0xC7,
  0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x40, 0x1F,
  0x78, 0x1F, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0xF0, 0x03, 0xEF,
  0x00, 0x3C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x03, 0xE0,
  0xF0, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF8, 0x0F, 0x1F, 0x00, 0xF3, 0xE0,
  0x0F, 0x7C, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF0,
  0x3E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0xCF,
  0x00, 0x3C, 0xF0, 0x03, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xF0, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x01, 0xE1, 0xF0, 0x0F, 0x0F, 0x80, 0x78,
  0x7C, 0x07, 0xC3, 0xF0, 0x3E, 0x1F, 0x81, 0xF8, 0xFC, 0x1D, 0xC7, 0x70,
  0xEE, 0x3B, 0x87, 0x71, 0xDC, 0x73, 0x8E, 0x73, 0x9C, 0xF3, 0x9C, 0xE7,
  0x9D, 0xC7, 0x3C, 0x7E, 0x39, 0xE3, 0xF1, 0xCF, 0x1F, 0x0E, 0x78, 0x78,
  0x73, 0xC3, 0xC3, 0x9C, 0x00, 0x1C, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8,
  0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03,
  0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0x80, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xFC, 0x03, 0xFF, 0x80, 0xFF, 0xE0,
  0x3F, 0xBC, 0x0F, 0xEF, 0x03, 0xF9, 0xE0, 0xFE, 0x38, 0x3F, 0x8F, 0x0F,
  0xE1, 0xC3, 0xF8, 0x78, 0xFE, 0x0E, 0x3F, 0x83, 0xCF, 0xE0, 0xF3, 0xF8,
  0x1C, 0xFE, 0x07, 0xBF, 0x80, 0xEF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E,
  0x0F, 0x81, 0xE0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xCF, 0x00, 0x1E,
  0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0x80, 0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3C, 0x1E, 0x03, 0xE0, 0xF8, 0x3E, 0x03,
  0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF0, 0x3F, 0xFF,
  0x8F, 0xFF, 0xF3, 0xC0, 0x7E, 0xF0, 0x07, 0xBC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xEF, 0x01, 0xFB, 0xFF, 0xFC, 0xFF, 0xFC, 0x3F, 0xFC,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0xE0, 0x3E, 0x0F,
  0x81, 0xE0, 0x3E, 0x1E, 0x00, 0xF0, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xDE, 0x00, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x79,
  0xF0, 0x03, 0xC7, 0x80, 0x3E, 0x3E, 0x03, 0xE0, 0xF8, 0x3E, 0x03, 0xFF,
  0xF0, 0x0F, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x00, 0x00,
  0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF8, 0x70, 0x1F, 0x8E, 0x00,
  0xF1, 0xC0, 0x1F, 0x38, 0x01, 0xE7, 0x00, 0x3C, 0xE0, 0x07, 0x9C, 0x00,
  0xF3, 0x80, 0x1E, 0x70, 0x03, 0xCE, 0x00, 0x79, 0xC0, 0x1E, 0x38, 0x0F,
  0x87, 0xFF, 0xF0, 0xFF, 0xF8, 0x1F, 0xFE, 0x03, 0x81, 0xE0, 0x70, 0x3E,
  0x0E, 0x03, 0xC1, 0xC0, 0x3C, 0x38, 0x07, 0x87, 0x00, 0x78, 0xE0, 0x0F,
  0x1C, 0x00, 0xF3, 0x80, 0x1F, 0x70, 0x01, 0xEE, 0x00, 0x3E, 0x03, 0xFC,
  0x07, 0xFF, 0xC3, 0xFF, 0xF9, 0xF8, 0x3C, 0x78, 0x01, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0F, 0x40, 0x07, 0xBC, 0x07, 0xEF, 0xFF, 0xF3, 0xFF,
  0xF8, 0x1F, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xDE, 0x00, 0x7B,
  0xC0, 0x1F, 0x7C, 0x03, 0xC7, 0xC1, 0xF8, 0x7F, 0xFE, 0x07, 0xFF, 0x80,
  0x3F, 0xC0, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xBE, 0x00,
  0x1E, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x0F, 0x00, 0x3C,
  0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x83, 0xC0, 0x1E, 0x07, 0x80, 0x78, 0x1E,
  0x01, 0xE0, 0x78, 0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0xF0, 0x0F, 0x07,
  0x80, 0x1C, 0x1E, 0x00, 0x78, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0x8F, 0x00,
  0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x70, 0x00,
  0x7B, 0x80, 0x03, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xF7, 0x00, 0x07, 0xB8,
  0x00, 0x3D, 0xC0, 0x01, 0xEE, 0x00, 0x0F, 0x70, 0x00, 0x7B, 0x80, 0x03,
  0xDC, 0x00, 0x1C, 0xF0, 0xF0, 0xE7, 0x87, 0x87, 0x3C, 0x7C, 0x39, 0xE3,
  0xF1, 0xCF, 0x1B, 0x8E, 0x79, 0xDC, 0x73, 0xCE, 0x73, 0x9E, 0x63, 0x9C,
  0x77, 0x1C, 0xE3, 0xB8, 0x67, 0x1D, 0xC3, 0xB8, 0xFC, 0x1D, 0xC7, 0xE0,
  0x6C, 0x3F, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xC3,
  0xC0, 0x1E, 0x00, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x3C,
  0x03, 0xC1, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3E, 0x1E, 0x00, 0xF1, 0xF0,
  0x07, 0xCF, 0x00, 0x1E, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xF7, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0x78, 0x07, 0x83,
  0xC0, 0x3C, 0x0F, 0x03, 0xC0, 0x7C, 0x3E, 0x01, 0xE1, 0xE0, 0x0F, 0x9F,
  0x00, 0x3C, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0x80, 0xF0, 0x00, 0x7F, 0xC0,
  0x01, 0xE7, 0x80, 0x07, 0x9E, 0x00, 0x3C, 0x7C, 0x00, 0xF0, 0xF0, 0x07,
  0xC3, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1F, 0x03, 0xC0, 0x3C, 0x1F, 0x00,
  0xF8, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80,
  0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0E,
  0x01, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xC0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0,
  0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07,
  0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x79, 0xE0, 0x0F,
  0x1E, 0x00, 0xF0, 0xF0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x3C, 0x07, 0x87,
  0xC0, 0x3C, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x00, 0xE2, 0x00, 0x08,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x20, 0x60, 0xF0,
  0x78, 0x3C, 0x1E, 0x0E, 0x04, 0x1F, 0xF0, 0x1F, 0xFF, 0x0F, 0xFF, 0xC6,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x83, 0xFF, 0xC7, 0xFF, 0xEF, 0xFF, 0xFF, 0xC0, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFF, 0x01, 0xEF, 0xFF, 0xF3,
  0xFF, 0xF8, 0x3F, 0xF0, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x79, 0xF8, 0x0F, 0xFF, 0xC1, 0xFF,
  0xFE, 0x3F, 0x07, 0xC7, 0x80, 0x3C, 0xF0, 0x07, 0xDE, 0x00, 0x7B, 0xC0,
  0x0F, 0x78, 0x01, 0xEF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x0F, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00,
  0xF9, 0xE0, 0x3E, 0x3F, 0xFF, 0x87, 0xFF, 0xE0, 0x1F, 0xF0, 0x00, 0x00,
  0xFF, 0x80, 0x7F, 0xFC, 0x3F, 0xFF, 0x0F, 0xC0, 0x23, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x01, 0x87, 0xFF, 0xF0, 0x7F,
  0xFE, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x0F, 0xCF, 0x0F, 0xFF, 0xC7, 0xFF, 0xF3,
  0xE0, 0xFD, 0xF0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0xC0, 0xF1,
  0xFF, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xE0,
  0x7F, 0xFE, 0x1F, 0x87, 0xE3, 0xC0, 0x3C, 0xF0, 0x03, 0xDE, 0x00, 0x7F,
  0x80, 0x0F, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0xFC, 0x02, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x01, 0xFF, 0xE0, 0x3E, 0x06, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0x70,
  0x00, 0x07, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x07,
  0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00,
  0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00,
  0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0x01,
  0xFE, 0x03, 0xFF, 0xF1, 0xFF, 0xFC, 0xF8, 0x0F, 0x7C, 0x03, 0xDE, 0x00,
  0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x7C,
  0x03, 0xCF, 0x83, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFB, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE3, 0x01, 0xF9,
  0xFF, 0xFC, 0x7F, 0xFE, 0x07, 0xFC, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0xFE, 0x0F, 0xFF, 0xC7, 0xFF,
  0xF3, 0xE0, 0x7D, 0xE0, 0x1E, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07,
  0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0x80, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x83, 0x01, 0xFF, 0xC0,
  0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x07, 0xC0, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0xFF,
  0xF9, 0xFF, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0xF3, 0x83, 0xE7,
  0xFF, 0x9F, 0xFE, 0x07, 0xF8, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x01, 0xEF, 0x00,
  0x79, 0xE0, 0x1E, 0x3C, 0x07, 0x87, 0x81, 0xF0, 0xF0, 0xF8, 0x1E, 0x3E,
  0x03, 0xCF, 0x80, 0x7B, 0xE0, 0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF0,
  0x07, 0x9F, 0x00, 0xF1, 0xF0, 0x1E, 0x1F, 0x03, 0xC1, 0xF0, 0x78, 0x1F,
  0x0F, 0x01, 0xF1, 0xE0, 0x1F, 0x3C, 0x01, 0xF7, 0x80, 0x1E, 0xF0, 0x01,
  0xE0, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x30, 0x1F, 0xFC, 0x03,
  0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x0F, 0x0F, 0xFF, 0xFC, 0xFF, 0xFF, 0xEE,
  0x1F, 0x1E, 0xE0, 0xE0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F,
  0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0, 0xFE, 0x0F, 0x0F, 0xE0, 0xF0,
  0xFE, 0x0F, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0x1F,
  0xF0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x03, 0xEF, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3C, 0x01, 0xF8,
  0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0xF8, 0x3C, 0x07, 0xC7, 0x80,
  0x3C, 0x78, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xE7,
  0x80, 0x1E, 0x78, 0x03, 0xC3, 0xC0, 0x7C, 0x3E, 0x0F, 0x81, 0xFF, 0xF0,
  0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xF8,
  0x78, 0x0F, 0x8F, 0x00, 0xF9, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0x80, 0x1E,
  0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x07, 0xDE, 0x00, 0xF3,
  0xF0, 0x7C, 0x7F, 0xFF, 0x8F, 0xFF, 0xC1, 0xE7, 0xE0, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xF1, 0xFF, 0xFC,
  0xFC, 0x0F, 0x3C, 0x03, 0xDE, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xDF, 0x00, 0xF3, 0xE0, 0xFC,
  0x7F, 0xFF, 0x0F, 0xFF, 0xC0, 0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x0F, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xF8, 0x06, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x07, 0xFE, 0x0F,
  0xFF, 0x8F, 0xFF, 0xCF, 0x80, 0x67, 0x80, 0x03, 0x80, 0x01, 0xC0, 0x00,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xA0, 0x03, 0xDE,
  0x03, 0xFF, 0xFF, 0xEF, 0xFF, 0xE0, 0xFF, 0x80, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x30, 0x3F, 0xFC, 0x07, 0xFF, 0x00,
  0x7F, 0x00, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC,
  0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F,
  0x78, 0x07, 0xBC, 0x03, 0xCF, 0x81, 0xE7, 0xFF, 0xF1, 0xFF, 0xF8, 0x3F,
  0xF0, 0x78, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xF8, 0x01, 0xE3,
  0xC0, 0x0F, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03,
  0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC7, 0x80, 0x1E, 0x3C, 0x00, 0x79, 0xC0, 0x03, 0xDE, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x00,
  0x3B, 0xC1, 0xC0, 0xE7, 0x07, 0x87, 0x9C, 0x1E, 0x1E, 0x70, 0xF8, 0x79,
  0xE3, 0xF1, 0xC7, 0x8F, 0xC7, 0x1E, 0x77, 0x1C, 0x79, 0xCC, 0x70, 0xE7,
  0x39, 0xC3, 0xB8, 0xEF, 0x0E, 0xE1, 0xB8, 0x3B, 0x07, 0xE0, 0xFC, 0x1F,
  0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x07, 0x00,
  0x78, 0x00, 0xF1, 0xE0, 0x0F, 0x07, 0x80, 0x78, 0x3E, 0x07, 0x80, 0xF0,
  0x78, 0x03, 0xC7, 0x80, 0x1F, 0x3C, 0x00, 0x7F, 0xC0, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFF,
  0x00, 0x0F, 0x3C, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0xC0, 0xF0, 0x1E, 0x07,
  0x80, 0x78, 0x78, 0x03, 0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x3C, 0xF8, 0x01,
  0xF7, 0x80, 0x1E, 0x78, 0x01, 0xE7, 0x80, 0x1E, 0x3C, 0x01, 0xE3, 0xC0,
  0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x0F,
  0x07, 0x80, 0xF0, 0x70, 0x0F, 0x0F, 0x00, 0x78, 0xF0, 0x07, 0x8E, 0x00,
  0x3D, 0xE0, 0x03, 0xDE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xC0,
  0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0x01, 0xFF, 0x03, 0xFF, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0xFE, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x80,
  0x07, 0x80, 0x07, 0xC0, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x00, 0x7F, 0xE0, 0x3F,
  0xF8, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00,
  0x07, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0E, 0x00, 0x0F, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0x1F,
  0x00, 0x63, 0xF8, 0x07, 0x7F, 0xE0, 0xE7, 0x1F, 0x0E, 0xE0, 0x7F, 0xCE,
  0x03, 0xFC, 0x60, 0x0F, 0x00,
};

const GFXglyph UbuntuMono_Regular47pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 24, 0, -1 },
  { 1, 7, 29, 24, 8, -29 },
  { 27, 11, 12, 24, 6, -32 },
  { 44, 21, 29, 24, 1, -29 },
  { 121, 18, 38, 24, 3, -33 },
  { 207, 22, 29, 24, 1, -29 },
  { 287, 21, 29, 24, 1, -29 },
  { 364, 4, 13, 24, 10, -32 },
  { 371, 13, 41, 24, 5, -33 },
  { 438, 13, 41, 24, 5, -33 },
  { 505, 18, 17, 24, 3, -29 },
  { 544, 19, 21, 24, 2, -23 },
  { 594, 10, 12, 24, 7, -6 },
  { 609, 10, 4, 24, 7, -14 },
  { 614, 7, 6, 24, 8, -6 },
  { 620, 17, 41, 24, 3, -33 },
  { 708, 19, 29, 24, 2, -29 },
  { 777, 17, 29, 24, 4, -29 },
  { 839, 18, 29, 24, 3, -29 },
  { 905, 18, 29, 24, 3, -29 },
  { 971, 20, 29, 24, 2, -29 },
  { 1044, 18, 29, 24, 3, -29 },
  { 1110, 18, 29, 24, 3, -29 },
  { 1176, 18, 29, 24, 3, -29 },
  { 1242, 19, 29, 24, 2, -29 },
  { 1311, 19, 29, 24, 2, -29 },
  { 1380, 7, 21, 24, 8, -21 },
  { 1399, 9, 27, 24, 6, -21 },
  { 1430, 20, 19, 24, 2, -21 },
  { 1478, 19, 12, 24, 2, -19 },
  { 1507, 20, 19, 24, 2, -21 },
  { 1555, 15, 29, 24, 4, -29 },
  { 1610, 20, 35, 24, 2, -29 },
  { 1698, 23, 29, 24, 0, -29 },
  { 1782, 18, 29, 24, 3, -29 },
  { 1848, 20, 29, 24, 2, -29 },
  { 1921, 19, 29, 24, 3, -29 },
  { 1990, 18, 29, 24, 4, -29 },
  { 2056, 17, 29, 24, 4, -29 },
  { 2118, 19, 29, 24, 2, -29 },
  { 2187, 19, 29, 24, 2, -29 },
  { 2256, 15, 29, 24, 4, -29 },
  { 2311, 17, 29, 24, 3, -29 },
  { 2373, 20, 29, 24, 3, -29 },
  { 2446, 18, 29, 24, 4, -29 },
  { 2512, 21, 29, 24, 1, -29 },
  { 2589, 18, 29, 24, 3, -29 },
  { 2655, 21, 29, 24, 1, -29 },
  { 2732, 18, 29, 24, 3, -29 },
  { 2798, 21, 36, 24, 1, -29 },
  { 2893, 19, 29, 24, 3, -29 },
  { 2962, 18, 29, 24, 3, -29 },
  { 3028, 20, 29, 24, 2, -29 },
  { 3101, 19, 29, 24, 2, -29 },
  { 3170, 22, 29, 24, 1, -29 },
  { 3250, 21, 29, 24, 1, -29 },
  { 3327, 21, 29, 24, 1, -29 },
  { 3404, 22, 29, 24, 1, -29 },
  { 3484, 18, 29, 24, 3, -29 },
  { 3550, 11, 41, 24, 7, -33 },
  { 3607, 17, 41, 24, 3, -33 },
  { 3695, 11, 41, 24, 6, -33 },
  { 3752, 20, 16, 24, 2, -29 },
  { 3792, 23, 3, 24, 0, 4 },
  { 3801, 8, 8, 24, 8, -32 },
  { 3809, 17, 22, 24, 3, -22 },
  { 3856, 19, 33, 24, 3, -33 },
  { 3935, 19, 22, 24, 2, -22 },
  { 3988, 18, 33, 24, 2, -33 },
  { 4063, 19, 22, 24, 2, -22 },
  { 4116, 20, 33, 24, 3, -33 },
  { 4199, 18, 30, 24, 2, -22 },
  { 4267, 17, 33, 24, 3, -33 },
  { 4338, 18, 31, 24, 3, -31 },
  { 4408, 15, 39, 24, 3, -31 },
  { 4482, 19, 33, 24, 3, -33 },
  { 4561, 18, 33, 24, 3, -33 },
  { 4636, 20, 22, 24, 2, -22 },
  { 4691, 17, 22, 24, 3, -22 },
  { 4738, 20, 22, 24, 2, -22 },
  { 4793, 19, 30, 24, 3, -22 },
  { 4865, 18, 30, 24, 2, -22 },
  { 4933, 16, 22, 24, 5, -22 },
  { 4977, 17, 22, 24, 3, -22 },
  { 5024, 18, 29, 24, 3, -29 },
  { 5090, 17, 22, 24, 3, -22 },
  { 5137, 21, 22, 24, 1, -22 },
  { 5195, 22, 22, 24, 1, -22 },
  { 5256, 21, 22, 24, 1, -22 },
  { 5314, 20, 30, 24, 2, -22 },
  { 5389, 17, 22, 24, 3, -22 },
  { 5436, 16, 41, 24, 4, -33 },
  { 5518, 4, 41, 24, 10, -33 },
  { 5539, 17, 41, 24, 3, -33 },
  { 5627, 20, 7, 24, 2, -16 },
};

const GFXfont UbuntuMono_Regular47pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular47pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular47pt7bGlyphs,
  0x20, 0x7E, 47
};

#endif // _UBUNTUMONO_REGULAR47PT7B_H_
