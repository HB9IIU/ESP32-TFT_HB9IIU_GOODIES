#ifndef _UBUNTUMONO_REGULAR40PT7B_H_
#define _UBUNTUMONO_REGULAR40PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular40pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xC3,
  0x0C, 0x30, 0x00, 0x00, 0x7B, 0xEF, 0xFE, 0x78, 0xE1, 0xF8, 0x7E, 0x1F,
  0x87, 0xE1, 0xF8, 0x7E, 0x1D, 0x86, 0x61, 0x98, 0x60, 0x03, 0x87, 0x00,
  0xE1, 0xC0, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x07, 0x01, 0xC1, 0xC0, 0x70,
  0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xE0, 0xE0, 0x38, 0x78,
  0x0E, 0x1C, 0x03, 0x87, 0x01, 0xC1, 0xC0, 0x70, 0x70, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x70, 0xE0, 0x38, 0x38, 0x0E, 0x0E, 0x03, 0x87,
  0x00, 0xE1, 0xC0, 0x38, 0x70, 0x00, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0,
  0x01, 0xC0, 0x07, 0xF8, 0x1F, 0xFC, 0x3F, 0xFC, 0x7C, 0x0C, 0x78, 0x00,
  0x70, 0x00, 0x70, 0x00, 0x70, 0x00, 0x78, 0x00, 0x7E, 0x00, 0x3F, 0xC0,
  0x1F, 0xF0, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x60, 0x1E, 0x7F, 0xFE, 0xFF, 0xF8,
  0x1F, 0xE0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x01, 0xC0, 0x3C, 0x01,
  0xDF, 0x80, 0xEE, 0x70, 0x33, 0x8C, 0x1C, 0xC3, 0x0E, 0x30, 0xC3, 0x8C,
  0x31, 0xC3, 0x0C, 0x60, 0xE3, 0x38, 0x39, 0xDC, 0x07, 0xE7, 0x00, 0xF3,
  0x80, 0x00, 0xC0, 0x00, 0x73, 0xC0, 0x39, 0xF8, 0x0E, 0xE7, 0x07, 0x31,
  0xC1, 0x8C, 0x30, 0xE3, 0x0C, 0x70, 0xC3, 0x1C, 0x30, 0xCE, 0x0C, 0x77,
  0x03, 0x9D, 0xC0, 0x7E, 0xE0, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x01,
  0xFF, 0x80, 0xF0, 0xE0, 0x38, 0x3C, 0x0E, 0x0E, 0x03, 0x83, 0x80, 0xE0,
  0xE0, 0x1C, 0x70, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x3E, 0x0C, 0x1F, 0x83,
  0x0E, 0xF1, 0xC7, 0x9E, 0x71, 0xC3, 0xDC, 0xF0, 0x7F, 0x3C, 0x0F, 0x8F,
  0x01, 0xE3, 0xC0, 0x78, 0x70, 0x3F, 0x1F, 0x1F, 0xC7, 0xFF, 0x78, 0xFF,
  0x8E, 0x0F, 0x83, 0xC0, 0xFF, 0xFF, 0xFF, 0xE6, 0x66, 0x60, 0x00, 0x80,
  0x70, 0x3C, 0x1E, 0x0F, 0x07, 0x81, 0xC0, 0xF0, 0x78, 0x1C, 0x07, 0x03,
  0xC0, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xE0,
  0x38, 0x0E, 0x03, 0xC0, 0x70, 0x1E, 0x07, 0x80, 0xF0, 0x1C, 0x07, 0x80,
  0xF0, 0x1E, 0x03, 0xC0, 0x70, 0x08, 0x40, 0x38, 0x0F, 0x01, 0xE0, 0x3C,
  0x07, 0x81, 0xE0, 0x3C, 0x07, 0x01, 0xE0, 0x38, 0x0F, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0F,
  0x03, 0x81, 0xE0, 0x70, 0x3C, 0x0E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x38,
  0x04, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x01, 0xC0, 0x61, 0x82,
  0x79, 0x9E, 0xFF, 0xFF, 0x3F, 0xFC, 0x03, 0xC0, 0x07, 0xE0, 0x0E, 0x70,
  0x1E, 0x78, 0x1E, 0x7C, 0x1C, 0x38, 0x08, 0x10, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x1E, 0x3F, 0x3F, 0x3F, 0x1F, 0x0F,
  0x3E, 0xFC, 0xF8, 0xE0, 0xFF, 0xFF, 0xFF, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x38, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x70, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x1F, 0xF8, 0x3C, 0x3C, 0x78, 0x1E, 0x70,
  0x0E, 0x70, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xE1, 0x87, 0xE3, 0xC7, 0xE3,
  0xC7, 0xE3, 0xC7, 0xE1, 0x87, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0,
  0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1E, 0x3C, 0x3C, 0x1F, 0xFC, 0x1F,
  0xF0, 0x07, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x7E, 0x01, 0xFC,
  0x0F, 0xB8, 0x3C, 0x70, 0x20, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x1F, 0xFF, 0xBF, 0xFF,
  0x7F, 0xFE, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xFC, 0x78, 0x7C, 0x20, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x70, 0x00, 0x7F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x0F, 0xE0, 0x3F, 0xF8, 0x7F, 0xF8, 0x70, 0x7C,
  0x20, 0x1C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x78,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF8, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x60, 0x3E,
  0x7F, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07,
  0xE0, 0x03, 0xF8, 0x00, 0xEE, 0x00, 0x73, 0x80, 0x38, 0xE0, 0x0E, 0x38,
  0x07, 0x0E, 0x03, 0x83, 0x80, 0xE0, 0xE0, 0x70, 0x38, 0x38, 0x0E, 0x0E,
  0x03, 0x87, 0x00, 0xE1, 0xC0, 0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0xFF, 0xF1, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xFE, 0x01, 0xFF, 0x83,
  0xFF, 0x80, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xE0, 0x03, 0xD8, 0x0F, 0xBF, 0xFE, 0x7F, 0xF8,
  0x3F, 0x80, 0x00, 0x3C, 0x01, 0xFC, 0x03, 0xFC, 0x0F, 0xC0, 0x1F, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x77, 0xF0, 0x7F, 0xF8,
  0xFF, 0xFC, 0xF8, 0x3E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x07,
  0xF0, 0x07, 0x70, 0x0F, 0x70, 0x0F, 0x78, 0x1E, 0x3C, 0x3E, 0x3F, 0xFC,
  0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0,
  0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x80, 0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0x3C, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F,
  0x00, 0x1E, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x70,
  0x1E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E, 0x78, 0x1C, 0x3E,
  0x3C, 0x1F, 0xF8, 0x0F, 0xF8, 0x3F, 0xFC, 0x38, 0x3E, 0x70, 0x0E, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0x78, 0x1E, 0x7F,
  0xFE, 0x3F, 0xFC, 0x0F, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C,
  0x3C, 0x70, 0x1E, 0xF0, 0x0E, 0xF0, 0x0E, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x0F, 0x78, 0x1F, 0x7F, 0xFF, 0x3F, 0xFF, 0x0F, 0xEF, 0x00,
  0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xF0, 0x7F, 0xE0, 0x7F, 0x80, 0x7C, 0x00, 0x7B, 0xFF, 0xFF, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xEF, 0xFF, 0xFD, 0xE0, 0x1E, 0x3F, 0x3F,
  0x3F, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x3F,
  0x3F, 0x3F, 0x1F, 0x0F, 0x1E, 0xFC, 0xF8, 0xE0, 0x00, 0x03, 0x00, 0x0F,
  0x00, 0x7F, 0x01, 0xFE, 0x0F, 0xF0, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F,
  0x00, 0x0F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x40, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x00, 0x07, 0x00, 0x3F, 0x00, 0xFE, 0x03, 0xF8,
  0x1F, 0xE0, 0x7F, 0x80, 0xFC, 0x00, 0xF0, 0x00, 0x40, 0x00, 0x3F, 0x8F,
  0xFE, 0xFF, 0xEC, 0x1F, 0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0xF0,
  0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x3F, 0x01, 0xF0, 0x1E, 0x00,
  0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0xC3, 0xE3, 0xC0, 0x73, 0xC0,
  0x39, 0xC0, 0x1E, 0xE0, 0x07, 0xF0, 0x7F, 0xF0, 0x7F, 0xF8, 0x7F, 0xFC,
  0x78, 0x7E, 0x38, 0x3F, 0x1C, 0x1F, 0x9E, 0x0F, 0xCF, 0x07, 0xE7, 0x83,
  0xF1, 0xC1, 0xF8, 0xE0, 0xFC, 0x78, 0x7F, 0x1F, 0xFB, 0x87, 0xFD, 0xC1,
  0xFC, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x81, 0xFF, 0xC0,
  0x7F, 0xE0, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x03, 0x9C, 0x00, 0x39, 0xC0, 0x03, 0x9C, 0x00, 0x70, 0xE0,
  0x07, 0x0E, 0x00, 0x70, 0xE0, 0x0F, 0x0F, 0x00, 0xE0, 0x70, 0x0E, 0x07,
  0x01, 0xE0, 0x78, 0x1C, 0x03, 0x81, 0xC0, 0x38, 0x1F, 0xFF, 0x83, 0xFF,
  0xFC, 0x3F, 0xFF, 0xC3, 0x80, 0x1C, 0x38, 0x01, 0xC7, 0x80, 0x1E, 0x70,
  0x00, 0xE7, 0x00, 0x0E, 0xF0, 0x00, 0xF0, 0x7F, 0xC0, 0xFF, 0xF0, 0xFF,
  0xFC, 0xE0, 0x7C, 0xE0, 0x1E, 0xE0, 0x1E, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0,
  0x1E, 0xE0, 0x1C, 0xE0, 0x78, 0xFF, 0xF0, 0xFF, 0xF0, 0xFF, 0xFC, 0xE0,
  0x3E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0F, 0xE0, 0x3E, 0xFF, 0xFC, 0xFF, 0xF8, 0xFF, 0xE0, 0x01, 0xF8, 0x07,
  0xFF, 0x0F, 0xFF, 0x1F, 0x07, 0x3C, 0x02, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3F, 0x03, 0x1F, 0xFF, 0x07, 0xFF, 0x01, 0xFC, 0x7F,
  0x80, 0xFF, 0xE0, 0xFF, 0xF8, 0xE0, 0xFC, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0,
  0x0E, 0xE0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0,
  0x0E, 0xE0, 0x1E, 0xE0, 0x3E, 0xE0, 0x7C, 0xFF, 0xF8, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0x3F, 0xFC, 0xFF, 0xF3,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3F, 0xFC, 0xFF, 0xF3, 0xFF, 0xCE, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F,
  0x07, 0x3C, 0x02, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07, 0x78, 0x07, 0x3C, 0x07, 0x3F,
  0x07, 0x1F, 0xFF, 0x0F, 0xFF, 0x01, 0xFC, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFE, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xE4, 0x03, 0xCE, 0x0F, 0xBF, 0xFE, 0x3F, 0xF8, 0x1F, 0xC0, 0xE0, 0x0E,
  0x70, 0x0F, 0x38, 0x0F, 0x1C, 0x0F, 0x0E, 0x07, 0x87, 0x07, 0x83, 0x87,
  0x81, 0xC7, 0x80, 0xE7, 0x80, 0x77, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x0F,
  0xF0, 0x07, 0x7C, 0x03, 0x9F, 0x01, 0xC7, 0x80, 0xE1, 0xE0, 0x70, 0x78,
  0x38, 0x1E, 0x1C, 0x07, 0x8E, 0x03, 0xC7, 0x00, 0xF3, 0x80, 0x79, 0xC0,
  0x1E, 0xE0, 0x07, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x38, 0x07, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3E, 0x0F, 0x1F,
  0x87, 0xE7, 0x61, 0xB9, 0xD8, 0x6E, 0x77, 0x3B, 0x9C, 0xCC, 0xE7, 0x33,
  0x39, 0xCF, 0xCE, 0x71, 0xF3, 0x9C, 0x78, 0xE7, 0x1E, 0x39, 0xC7, 0x8E,
  0x70, 0x03, 0x9C, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xC0, 0xF0, 0x07, 0xF0,
  0x07, 0xF8, 0x07, 0xF8, 0x07, 0xFC, 0x07, 0xFE, 0x07, 0xEE, 0x07, 0xEF,
  0x07, 0xE7, 0x07, 0xE3, 0x87, 0xE3, 0x87, 0xE3, 0x87, 0xE1, 0xC7, 0xE1,
  0xC7, 0xE0, 0xE7, 0xE0, 0xE7, 0xE0, 0x77, 0xE0, 0x77, 0xE0, 0x37, 0xE0,
  0x3F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0x03,
  0xF0, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x1E, 0x01,
  0xE7, 0x00, 0x39, 0xC0, 0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xE0, 0x1E, 0x38, 0x0F, 0x0F, 0x87,
  0xC1, 0xFF, 0xE0, 0x3F, 0xF0, 0x03, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0xE3,
  0xFF, 0xE7, 0x03, 0xEE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x07, 0xDF, 0xFF, 0x3F, 0xFC,
  0x7F, 0xE0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0xF8, 0x7C, 0x3C, 0x0F, 0x1E, 0x01, 0xE7, 0x00, 0x39, 0xC0,
  0x0E, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xE7,
  0x00, 0x39, 0xE0, 0x1E, 0x38, 0x0F, 0x0F, 0x87, 0xC1, 0xFF, 0xE0, 0x3F,
  0xF0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xF0, 0x00, 0x7F,
  0x80, 0x07, 0xE0, 0x00, 0x30, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFE, 0x1E,
  0x0F, 0x8F, 0x01, 0xE7, 0x80, 0xF3, 0xC0, 0x39, 0xE0, 0x1C, 0xF0, 0x0E,
  0x78, 0x07, 0x3C, 0x07, 0x9E, 0x03, 0xCF, 0x07, 0xC7, 0xFF, 0xC3, 0xFF,
  0xC1, 0xFF, 0xC0, 0xF0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x1E, 0x07, 0x8F,
  0x01, 0xC7, 0x80, 0xF3, 0xC0, 0x39, 0xE0, 0x1E, 0xF0, 0x07, 0x00, 0x07,
  0xF8, 0x1F, 0xFE, 0x3F, 0xFC, 0x7C, 0x0C, 0x78, 0x00, 0x70, 0x00, 0x70,
  0x00, 0x70, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x40, 0x0F, 0x70, 0x3E, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x7C, 0x3E, 0x3F,
  0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xE0, 0x01, 0xDC, 0x00, 0x3B, 0xC0, 0x07,
  0x78, 0x01, 0xE7, 0x00, 0x38, 0xE0, 0x07, 0x1E, 0x00, 0xE3, 0xC0, 0x3C,
  0x38, 0x07, 0x07, 0x00, 0xE0, 0xF0, 0x3C, 0x0E, 0x07, 0x01, 0xC0, 0xE0,
  0x3C, 0x3C, 0x07, 0x87, 0x80, 0x70, 0xE0, 0x0F, 0x1C, 0x01, 0xE7, 0x80,
  0x1C, 0xE0, 0x03, 0x9C, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x00, 0x39, 0xC0, 0x0E, 0x70,
  0x03, 0x9C, 0x78, 0xE7, 0x1E, 0x39, 0xC7, 0x8E, 0x73, 0xE3, 0x9C, 0xFC,
  0xE7, 0x33, 0x39, 0xCC, 0xCE, 0x77, 0x3B, 0x9D, 0x86, 0xE7, 0x61, 0xB9,
  0xF8, 0x7C, 0x3C, 0x1F, 0x0F, 0x03, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x38,
  0x07, 0x00, 0x70, 0x03, 0x9E, 0x01, 0xE3, 0x80, 0x70, 0xF0, 0x3C, 0x1E,
  0x0E, 0x07, 0x87, 0x80, 0xF3, 0xC0, 0x1C, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x1F, 0xE0, 0x0F, 0x3C, 0x03, 0xCF, 0x01, 0xE1, 0xE0, 0x70, 0x38, 0x3C,
  0x0F, 0x0E, 0x01, 0xC7, 0x80, 0x79, 0xC0, 0x0E, 0xF0, 0x03, 0xC0, 0xE0,
  0x01, 0xDE, 0x00, 0x7B, 0xC0, 0x0E, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x78,
  0x0E, 0x0F, 0x03, 0xC0, 0xF0, 0x70, 0x1E, 0x1E, 0x01, 0xE3, 0x80, 0x3C,
  0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7F,
  0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0,
  0x07, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x70,
  0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E,
  0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0x03, 0x81,
  0xC0, 0xE0, 0x70, 0x38, 0x1C, 0x0E, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x0E, 0x70, 0x1E, 0x78, 0x1C,
  0x38, 0x3C, 0x3C, 0x38, 0x1C, 0x78, 0x1E, 0x70, 0x0E, 0xF0, 0x0F, 0xE0,
  0x07, 0x60, 0x06, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x43,
  0x8F, 0x1E, 0x38, 0x70, 0x80, 0x1F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF0, 0x81,
  0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0xFF, 0x1F, 0xFE, 0xFF, 0xFD,
  0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xBC, 0x07, 0x7F,
  0xFE, 0x7F, 0xFC, 0x3F, 0xF0, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xCF, 0x83,
  0xFF, 0xC7, 0xFF, 0xCF, 0x87, 0xDC, 0x03, 0xB8, 0x07, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xF0, 0x1E, 0xE0, 0x7D, 0xFF, 0xF3, 0xFF, 0xC1, 0xFE, 0x00, 0x01, 0xFC,
  0x0F, 0xFF, 0x1F, 0xFE, 0x3E, 0x02, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0x70, 0x00, 0x78, 0x00, 0x3E, 0x03, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC,
  0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0,
  0x03, 0x80, 0x07, 0x00, 0x0E, 0x0F, 0xDC, 0x7F, 0xF9, 0xFF, 0xF7, 0xC3,
  0xEE, 0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x03, 0xBC, 0x07, 0x7C, 0x0E, 0x7F,
  0xFC, 0x7F, 0xF8, 0x3F, 0xC0, 0x07, 0xE0, 0x1F, 0xF8, 0x3F, 0xFC, 0x7C,
  0x3E, 0x78, 0x0E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C,
  0x06, 0x3F, 0xFE, 0x1F, 0xFE, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xFF, 0x07,
  0xFF, 0x0F, 0x83, 0x0E, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xFC, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xE0, 0x77, 0x80,
  0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xDF, 0x0F, 0x9F, 0xFF, 0x1F, 0xFE, 0x1F,
  0xDC, 0x00, 0x38, 0x00, 0x70, 0x01, 0xE0, 0x03, 0xD8, 0x1F, 0x3F, 0xFE,
  0x7F, 0xF0, 0x7F, 0x80, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xBF, 0x0F, 0xFF, 0x3F,
  0xFE, 0xF0, 0x7B, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0x07, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x07, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0xFF,
  0x80, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03,
  0x80, 0x03, 0x80, 0x03, 0xC3, 0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x00,
  0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xF3, 0xFF, 0x3F, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x60, 0xFF, 0xFE, 0xFF,
  0xC3, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00,
  0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x1E, 0xE0, 0x3C,
  0xE0, 0x78, 0xE0, 0xF0, 0xE1, 0xE0, 0xE3, 0xC0, 0xE7, 0x80, 0xEF, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xEF, 0x00, 0xE7, 0xC0, 0xE3, 0xE0, 0xE0, 0xF0,
  0xE0, 0x78, 0xE0, 0x78, 0xE0, 0x3C, 0xE0, 0x1E, 0xE0, 0x0F, 0xFF, 0x80,
  0xFF, 0x80, 0xFF, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80,
  0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0x80, 0x03, 0xC3,
  0x03, 0xFF, 0x01, 0xFF, 0x00, 0x7E, 0x7E, 0x3C, 0x7F, 0xFF, 0x3F, 0xFF,
  0xDC, 0x78, 0xEE, 0x38, 0x77, 0x0E, 0x1F, 0x87, 0x0F, 0xC3, 0x87, 0xE1,
  0xC3, 0xF0, 0xE1, 0xF8, 0x70, 0xFC, 0x38, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xE0, 0x3F,
  0xC3, 0xFF, 0xCF, 0xFF, 0xB8, 0x1E, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xC0, 0x07, 0xE0, 0x1F,
  0xF8, 0x3F, 0xFC, 0x7C, 0x3E, 0x78, 0x1E, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0x78, 0x1E, 0x7C, 0x3E, 0x3F, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x3F,
  0xC1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xEE, 0x03, 0xDC, 0x03, 0xF8, 0x07,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0x7C, 0x3E, 0xFF, 0xF9, 0xFF, 0xE3, 0xBF, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x00,
  0x07, 0xF8, 0x3F, 0xFC, 0xFF, 0xFB, 0xE0, 0x77, 0x80, 0xFE, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x01, 0xDC, 0x03, 0xBE, 0x1F, 0x3F, 0xFE, 0x3F, 0xFC, 0x1F, 0x38,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x0F, 0xFB, 0xFF, 0xEF, 0xFF, 0xBC, 0x02, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x0F,
  0xF0, 0xFF, 0xE7, 0xFF, 0xBC, 0x06, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1F,
  0x00, 0x3F, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x3F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0xE0, 0xC3, 0xFF, 0x83, 0xFF, 0x01, 0xF8, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xDE, 0x07,
  0x7F, 0xFC, 0xFF, 0xF0, 0xFF, 0x00, 0xF0, 0x03, 0xDC, 0x00, 0xE7, 0x00,
  0x39, 0xE0, 0x1E, 0x38, 0x07, 0x0E, 0x01, 0xC3, 0xC0, 0xF0, 0x70, 0x38,
  0x1C, 0x0E, 0x07, 0x87, 0x80, 0xE1, 0xC0, 0x38, 0xF0, 0x0F, 0x38, 0x01,
  0xCE, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xC1,
  0xF8, 0x78, 0x7E, 0x1E, 0x19, 0xC7, 0x8E, 0x71, 0xF3, 0x9C, 0xFC, 0xE7,
  0x33, 0x39, 0xCC, 0xEE, 0x77, 0x3B, 0x0D, 0x86, 0xC3, 0x61, 0xF0, 0xF8,
  0x7C, 0x3C, 0x0F, 0x0F, 0x03, 0xC1, 0x80, 0x60, 0x78, 0x07, 0x8E, 0x01,
  0xC3, 0xC0, 0xE0, 0x78, 0x78, 0x0E, 0x1C, 0x03, 0xCE, 0x00, 0x7F, 0x80,
  0x0F, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3F, 0x00, 0x1F, 0xE0, 0x07,
  0x38, 0x03, 0x87, 0x01, 0xE1, 0xE0, 0xF0, 0x3C, 0x38, 0x07, 0x1E, 0x01,
  0xEF, 0x00, 0x3C, 0x78, 0x03, 0xBC, 0x01, 0xCE, 0x01, 0xE7, 0x00, 0xF3,
  0xC0, 0x70, 0xE0, 0x38, 0x70, 0x3C, 0x3C, 0x1C, 0x0E, 0x0E, 0x07, 0x07,
  0x03, 0xC7, 0x80, 0xE3, 0x80, 0x71, 0xC0, 0x1D, 0xE0, 0x0E, 0xE0, 0x07,
  0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1C, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0F, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0xFC, 0x0F,
  0xF0, 0x7F, 0xC1, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07,
  0x80, 0xFC, 0x03, 0xE0, 0x0F, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x70, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00,
  0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0xFC, 0x0F, 0xF0, 0x1F, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFC, 0x03, 0xFC, 0x0F, 0xF8, 0x01, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xFC, 0x01,
  0xF0, 0x0F, 0xC0, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01,
  0xE0, 0xFF, 0x83, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0x01, 0x8F, 0xE0, 0x67,
  0xFE, 0x39, 0xC7, 0xFE, 0x60, 0x7F, 0x18, 0x0F, 0x80,
};

const GFXglyph UbuntuMono_Regular40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 20, 0, -1 },
  { 1, 6, 25, 20, 7, -25 },
  { 20, 10, 10, 20, 5, -27 },
  { 33, 18, 25, 20, 1, -25 },
  { 90, 16, 32, 20, 2, -28 },
  { 154, 18, 25, 20, 1, -25 },
  { 211, 18, 25, 20, 1, -25 },
  { 268, 4, 11, 20, 8, -27 },
  { 274, 10, 35, 20, 5, -28 },
  { 318, 10, 35, 20, 5, -28 },
  { 362, 16, 15, 20, 2, -25 },
  { 392, 16, 17, 20, 2, -19 },
  { 426, 8, 10, 20, 6, -5 },
  { 436, 8, 3, 20, 6, -12 },
  { 439, 6, 5, 20, 7, -5 },
  { 443, 14, 35, 20, 3, -28 },
  { 505, 16, 25, 20, 2, -25 },
  { 555, 15, 25, 20, 3, -25 },
  { 602, 16, 25, 20, 2, -25 },
  { 652, 16, 25, 20, 2, -25 },
  { 702, 18, 25, 20, 1, -25 },
  { 759, 15, 25, 20, 3, -25 },
  { 806, 16, 25, 20, 2, -25 },
  { 856, 15, 25, 20, 3, -25 },
  { 903, 16, 25, 20, 2, -25 },
  { 953, 16, 25, 20, 2, -25 },
  { 1003, 6, 18, 20, 7, -18 },
  { 1017, 8, 23, 20, 5, -18 },
  { 1040, 16, 16, 20, 2, -18 },
  { 1072, 16, 11, 20, 2, -16 },
  { 1094, 16, 16, 20, 2, -18 },
  { 1126, 12, 25, 20, 4, -25 },
  { 1164, 17, 30, 20, 2, -25 },
  { 1228, 20, 25, 20, 0, -25 },
  { 1291, 16, 25, 20, 2, -25 },
  { 1341, 16, 25, 20, 2, -25 },
  { 1391, 16, 25, 20, 2, -25 },
  { 1441, 14, 25, 20, 4, -25 },
  { 1485, 14, 25, 20, 4, -25 },
  { 1529, 16, 25, 20, 2, -25 },
  { 1579, 16, 25, 20, 2, -25 },
  { 1629, 12, 25, 20, 4, -25 },
  { 1667, 15, 25, 20, 2, -25 },
  { 1714, 17, 25, 20, 3, -25 },
  { 1768, 14, 25, 20, 4, -25 },
  { 1812, 18, 25, 20, 1, -25 },
  { 1869, 16, 25, 20, 2, -25 },
  { 1919, 18, 25, 20, 1, -25 },
  { 1976, 15, 25, 20, 3, -25 },
  { 2023, 18, 31, 20, 1, -25 },
  { 2093, 17, 25, 20, 2, -25 },
  { 2147, 16, 25, 20, 2, -25 },
  { 2197, 16, 25, 20, 2, -25 },
  { 2247, 16, 25, 20, 2, -25 },
  { 2297, 19, 25, 20, 1, -25 },
  { 2357, 18, 25, 20, 1, -25 },
  { 2414, 18, 25, 20, 1, -25 },
  { 2471, 19, 25, 20, 1, -25 },
  { 2531, 16, 25, 20, 2, -25 },
  { 2581, 9, 35, 20, 6, -28 },
  { 2621, 14, 35, 20, 3, -28 },
  { 2683, 9, 35, 20, 5, -28 },
  { 2723, 16, 14, 20, 2, -25 },
  { 2751, 20, 3, 20, 0, 4 },
  { 2759, 6, 7, 20, 7, -28 },
  { 2765, 15, 19, 20, 2, -19 },
  { 2801, 15, 28, 20, 3, -28 },
  { 2854, 16, 19, 20, 2, -19 },
  { 2892, 15, 28, 20, 2, -28 },
  { 2945, 16, 19, 20, 2, -19 },
  { 2983, 16, 28, 20, 3, -28 },
  { 3039, 15, 26, 20, 2, -19 },
  { 3088, 14, 28, 20, 3, -28 },
  { 3137, 16, 27, 20, 2, -27 },
  { 3191, 12, 34, 20, 3, -27 },
  { 3242, 16, 28, 20, 3, -28 },
  { 3298, 16, 28, 20, 2, -28 },
  { 3354, 17, 19, 20, 2, -19 },
  { 3395, 14, 19, 20, 3, -19 },
  { 3429, 16, 19, 20, 2, -19 },
  { 3467, 15, 26, 20, 3, -19 },
  { 3516, 15, 26, 20, 2, -19 },
  { 3565, 14, 19, 20, 4, -19 },
  { 3599, 14, 19, 20, 3, -19 },
  { 3633, 15, 25, 20, 3, -25 },
  { 3680, 14, 19, 20, 3, -19 },
  { 3714, 18, 19, 20, 1, -19 },
  { 3757, 18, 19, 20, 1, -19 },
  { 3800, 18, 19, 20, 1, -19 },
  { 3843, 17, 26, 20, 1, -19 },
  { 3899, 14, 19, 20, 3, -19 },
  { 3933, 14, 35, 20, 3, -28 },
  { 3995, 4, 35, 20, 8, -28 },
  { 4013, 14, 35, 20, 3, -28 },
  { 4075, 18, 6, 20, 1, -14 },
};

const GFXfont UbuntuMono_Regular40pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular40pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular40pt7bGlyphs,
  0x20, 0x7E, 40
};

#endif // _UBUNTUMONO_REGULAR40PT7B_H_
