#ifndef _UBUNTUMONO_REGULAR11PT7B_H_
#define _UBUNTUMONO_REGULAR11PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular11pt7bBitmaps[] PROGMEM = {
  0x00, 0xFA, 0xB6, 0x80, 0x29, 0x7E, 0xAF, 0xA9, 0x40, 0x4F, 0x88, 0x61,
  0x1E, 0x40, 0xCD, 0xB4, 0x43, 0xAE, 0x60, 0x72, 0x98, 0xD9, 0xCD, 0xA0,
  0xE0, 0x29, 0x49, 0x12, 0x20, 0x88, 0x92, 0x4A, 0x80, 0x4F, 0x4A, 0x21,
  0x3E, 0x42, 0x00, 0xE0, 0xC0, 0xC0, 0x12, 0x22, 0x44, 0x48, 0x88, 0x72,
  0x53, 0x54, 0xA5, 0xC0, 0x6A, 0x22, 0x22, 0xF0, 0xE9, 0x12, 0x48, 0xF0,
  0xE1, 0x26, 0x11, 0xE0, 0x11, 0x94, 0xAF, 0x88, 0x40, 0xF8, 0x8E, 0x11,
  0xE0, 0x7C, 0x8E, 0x99, 0xE0, 0xF1, 0x22, 0x44, 0x40, 0xE9, 0x96, 0x99,
  0xE0, 0xE9, 0x9F, 0x12, 0xC0, 0xC0, 0xC0, 0x60, 0x07, 0x80, 0x16, 0x86,
  0x10, 0xF8, 0x3E, 0x86, 0x16, 0x80, 0xE3, 0x22, 0x40, 0x40, 0x32, 0x57,
  0x5A, 0xAD, 0x07, 0x31, 0x94, 0x97, 0xC6, 0x20, 0xE9, 0x9E, 0x99, 0xE0,
  0x3A, 0x11, 0x04, 0x20, 0xE0, 0xE9, 0x99, 0x99, 0xE0, 0xF8, 0x8E, 0x88,
  0xF0, 0xF8, 0x8F, 0x88, 0x80, 0x3A, 0x11, 0x04, 0xA4, 0xE0, 0x8C, 0x63,
  0xF8, 0xC6, 0x20, 0xF4, 0x44, 0x44, 0xF0, 0xF1, 0x11, 0x1B, 0xE0, 0x9A,
  0xEC, 0xEA, 0x90, 0x88, 0x88, 0x88, 0xF0, 0x4A, 0xEF, 0x58, 0xC6, 0x20,
  0x99, 0xDD, 0xBB, 0x90, 0x72, 0x63, 0x18, 0xA5, 0xC0, 0xE9, 0x99, 0xE8,
  0x80, 0x72, 0x63, 0x18, 0xA5, 0xC4, 0x18, 0xE9, 0x9E, 0xAA, 0x90, 0xF8,
  0x86, 0x11, 0xE0, 0xF9, 0x08, 0x42, 0x10, 0x80, 0x99, 0x99, 0x99, 0xE0,
  0x8C, 0x52, 0xA5, 0x18, 0x80, 0x8C, 0x63, 0x5B, 0xAD, 0x20, 0x4A, 0x8C,
  0x43, 0x29, 0x20, 0x8A, 0x54, 0x62, 0x10, 0x80, 0xF2, 0x24, 0x48, 0xF0,
  0xEA, 0xAA, 0xC0, 0x88, 0x84, 0x44, 0x22, 0x21, 0xE4, 0x92, 0x49, 0xE0,
  0x22, 0x93, 0x10, 0xF8, 0x90, 0xE1, 0xF9, 0xF0, 0x88, 0x8E, 0x99, 0x9E,
  0x78, 0x88, 0xF0, 0x08, 0x42, 0xF4, 0xC5, 0x2F, 0x72, 0x7E, 0x87, 0x80,
  0x74, 0x4F, 0x44, 0x44, 0x7A, 0x62, 0x97, 0x85, 0xC0, 0x88, 0x8E, 0x99,
  0x99, 0x40, 0xC4, 0x44, 0x70, 0x23, 0x92, 0x49, 0xE0, 0x88, 0x89, 0xEC,
  0xA9, 0xC4, 0x44, 0x44, 0x47, 0xFD, 0x6B, 0x18, 0x80, 0xE9, 0x99, 0x90,
  0x72, 0x62, 0x97, 0x00, 0xE9, 0x99, 0xE8, 0x80, 0x7A, 0x62, 0x97, 0x84,
  0x20, 0xF8, 0x88, 0x80, 0xE8, 0xE1, 0xE0, 0x44, 0xF4, 0x44, 0x70, 0x99,
  0x99, 0xF0, 0x8A, 0x54, 0x62, 0x00, 0x8D, 0x6E, 0xB4, 0x80, 0x49, 0x88,
  0xA4, 0x80, 0x4A, 0x54, 0x63, 0x13, 0x80, 0xF2, 0x48, 0xF0, 0x74, 0x44,
  0x84, 0x44, 0x47, 0xFF, 0xC0, 0xC4, 0x22, 0x32, 0x22, 0x4C, 0x6C, 0xC0,
};

const GFXglyph UbuntuMono_Regular11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 1, 7, 6, 2, -7 },
  { 2, 3, 3, 6, 1, -7 },
  { 4, 5, 7, 6, 0, -7 },
  { 9, 4, 9, 6, 1, -8 },
  { 14, 5, 7, 6, 0, -7 },
  { 19, 5, 7, 6, 0, -7 },
  { 24, 1, 3, 6, 2, -7 },
  { 25, 3, 9, 6, 1, -7 },
  { 29, 3, 9, 6, 1, -7 },
  { 33, 4, 4, 6, 1, -7 },
  { 35, 5, 5, 6, 0, -6 },
  { 39, 2, 2, 6, 2, -1 },
  { 40, 2, 1, 6, 2, -3 },
  { 41, 2, 1, 6, 2, -1 },
  { 42, 4, 10, 6, 1, -8 },
  { 47, 5, 7, 6, 0, -7 },
  { 52, 4, 7, 6, 1, -7 },
  { 56, 4, 7, 6, 1, -7 },
  { 60, 4, 7, 6, 1, -7 },
  { 64, 5, 7, 6, 0, -7 },
  { 69, 4, 7, 6, 1, -7 },
  { 73, 4, 7, 6, 1, -7 },
  { 77, 4, 7, 6, 1, -7 },
  { 81, 4, 7, 6, 1, -7 },
  { 85, 4, 7, 6, 1, -7 },
  { 89, 2, 5, 6, 2, -5 },
  { 91, 3, 6, 6, 1, -5 },
  { 94, 4, 5, 6, 1, -5 },
  { 97, 5, 3, 6, 0, -4 },
  { 99, 4, 5, 6, 1, -5 },
  { 102, 4, 7, 6, 1, -7 },
  { 106, 5, 8, 6, 0, -7 },
  { 111, 5, 7, 6, 0, -7 },
  { 116, 4, 7, 6, 1, -7 },
  { 120, 5, 7, 6, 0, -7 },
  { 125, 4, 7, 6, 1, -7 },
  { 129, 4, 7, 6, 1, -7 },
  { 133, 4, 7, 6, 1, -7 },
  { 137, 5, 7, 6, 0, -7 },
  { 142, 5, 7, 6, 0, -7 },
  { 147, 4, 7, 6, 1, -7 },
  { 151, 4, 7, 6, 1, -7 },
  { 155, 4, 7, 6, 1, -7 },
  { 159, 4, 7, 6, 1, -7 },
  { 163, 5, 7, 6, 0, -7 },
  { 168, 4, 7, 6, 1, -7 },
  { 172, 5, 7, 6, 0, -7 },
  { 177, 4, 7, 6, 1, -7 },
  { 181, 5, 9, 6, 0, -7 },
  { 187, 4, 7, 6, 1, -7 },
  { 191, 4, 7, 6, 1, -7 },
  { 195, 5, 7, 6, 0, -7 },
  { 200, 4, 7, 6, 1, -7 },
  { 204, 5, 7, 6, 0, -7 },
  { 209, 5, 7, 6, 0, -7 },
  { 214, 5, 7, 6, 0, -7 },
  { 219, 5, 7, 6, 0, -7 },
  { 224, 4, 7, 6, 1, -7 },
  { 228, 2, 9, 6, 2, -7 },
  { 231, 4, 10, 6, 1, -8 },
  { 236, 3, 9, 6, 1, -7 },
  { 240, 5, 4, 6, 0, -7 },
  { 243, 5, 1, 6, 0, 1 },
  { 244, 2, 2, 6, 2, -8 },
  { 245, 4, 5, 6, 1, -5 },
  { 248, 4, 8, 6, 1, -8 },
  { 252, 4, 5, 6, 1, -5 },
  { 255, 5, 8, 6, 0, -8 },
  { 260, 5, 5, 6, 0, -5 },
  { 264, 4, 8, 6, 1, -8 },
  { 268, 5, 7, 6, 0, -5 },
  { 273, 4, 8, 6, 1, -8 },
  { 277, 4, 7, 6, 1, -7 },
  { 281, 3, 9, 6, 1, -7 },
  { 285, 4, 8, 6, 1, -8 },
  { 289, 4, 8, 6, 1, -8 },
  { 293, 5, 5, 6, 0, -5 },
  { 297, 4, 5, 6, 1, -5 },
  { 300, 5, 5, 6, 0, -5 },
  { 304, 4, 7, 6, 1, -5 },
  { 308, 5, 7, 6, 0, -5 },
  { 313, 4, 5, 6, 1, -5 },
  { 316, 4, 5, 6, 1, -5 },
  { 319, 4, 7, 6, 1, -7 },
  { 323, 4, 5, 6, 1, -5 },
  { 326, 5, 5, 6, 0, -5 },
  { 330, 5, 5, 6, 0, -5 },
  { 334, 5, 5, 6, 0, -5 },
  { 338, 5, 7, 6, 0, -5 },
  { 343, 4, 5, 6, 1, -5 },
  { 346, 4, 10, 6, 1, -8 },
  { 351, 1, 10, 6, 2, -8 },
  { 353, 4, 10, 6, 1, -8 },
  { 358, 5, 2, 6, 0, -4 },
};

const GFXfont UbuntuMono_Regular11pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular11pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular11pt7bGlyphs,
  0x20, 0x7E, 11
};

#endif // _UBUNTUMONO_REGULAR11PT7B_H_
