#ifndef _UBUNTUMONO_REGULAR68PT7B_H_
#define _UBUNTUMONO_REGULAR68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular68pt7bBitmaps[] PROGMEM = {
  0x00, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F,
  0x8F, 0xC7, 0xE3, 0xF1, 0xF8, 0xFC, 0x7E, 0x3F, 0x1F, 0x8F, 0xC7, 0xE3,
  0xF1, 0xF8, 0xF8, 0x7C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x07, 0x8F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xBF,
  0x87, 0x80, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F, 0xF8, 0x1F,
  0xF8, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0x70, 0x0E, 0x70, 0x0E, 0x70, 0x0E,
  0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0,
  0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x01, 0xF0, 0x0F, 0x80, 0x07, 0xC0, 0x7E, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0xFC, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x3E,
  0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x07, 0xC0, 0x3E, 0x00, 0x1F, 0x00,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xE0, 0x1F, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x01, 0xF8, 0x0F, 0x80, 0x07,
  0xC0, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0,
  0x1F, 0x80, 0x07, 0xC0, 0x7C, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xC0, 0x1E, 0x1F, 0xC0, 0x00, 0x87,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0x01,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFD, 0x80, 0x00, 0x7F,
  0x7C, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xF0, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3E, 0x3F, 0xF8, 0x00, 0x3C, 0x3F, 0xFC,
  0x00, 0x7C, 0x7C, 0x7C, 0x00, 0xF8, 0x78, 0x3C, 0x00, 0xF0, 0x78, 0x3E,
  0x01, 0xF0, 0xF8, 0x1E, 0x03, 0xE0, 0xF0, 0x1E, 0x03, 0xE0, 0xF0, 0x1E,
  0x07, 0xC0, 0xF0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x0F, 0x80, 0xF0, 0x1E,
  0x1F, 0x00, 0xF8, 0x1E, 0x1F, 0x00, 0x78, 0x3E, 0x3E, 0x00, 0x78, 0x3C,
  0x3C, 0x00, 0x7C, 0x7C, 0x7C, 0x00, 0x3F, 0xFC, 0xF8, 0x00, 0x3F, 0xF8,
  0xF8, 0x00, 0x1F, 0xF1, 0xF0, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x07, 0x83, 0xE0, 0x00, 0x0F,
  0x8F, 0xF8, 0x00, 0x1F, 0x1F, 0xFC, 0x00, 0x1F, 0x3F, 0xFC, 0x00, 0x3E,
  0x3E, 0x3E, 0x00, 0x3C, 0x3C, 0x1E, 0x00, 0x7C, 0x7C, 0x1E, 0x00, 0xF8,
  0x78, 0x1F, 0x00, 0xF8, 0x78, 0x1F, 0x01, 0xF0, 0x78, 0x0F, 0x01, 0xE0,
  0x78, 0x0F, 0x03, 0xE0, 0x78, 0x0F, 0x07, 0xC0, 0x78, 0x1F, 0x07, 0x80,
  0x78, 0x1F, 0x0F, 0x80, 0x7C, 0x1E, 0x1F, 0x00, 0x3C, 0x1E, 0x1F, 0x00,
  0x3E, 0x3E, 0x3E, 0x00, 0x3F, 0xFC, 0x3C, 0x00, 0x1F, 0xFC, 0x7C, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x1F, 0x80, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x07, 0xC0, 0x07,
  0xE0, 0x1F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0xFC,
  0x1F, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x78, 0x07, 0xFE, 0x01,
  0xF0, 0x3F, 0xFC, 0x07, 0x81, 0xFB, 0xF8, 0x1E, 0x07, 0xC7, 0xF0, 0xF8,
  0x3F, 0x0F, 0xE3, 0xE1, 0xF8, 0x1F, 0xCF, 0x87, 0xE0, 0x3F, 0xBC, 0x1F,
  0x00, 0x7F, 0xF0, 0xFC, 0x00, 0xFF, 0xC3, 0xF0, 0x03, 0xFE, 0x0F, 0xC0,
  0x07, 0xF8, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0xFF, 0x07, 0xE0, 0x07, 0xFC, 0x1F, 0xC0, 0x3F, 0xF8, 0x7F, 0xC7, 0xFF,
  0xF0, 0xFF, 0xFF, 0xEF, 0xC1, 0xFF, 0xFF, 0x1F, 0x83, 0xFF, 0xF8, 0x7E,
  0x07, 0xFF, 0x80, 0xFC, 0x07, 0xF8, 0x03, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x79, 0xE7, 0x9E, 0x79, 0xE0, 0x00, 0x01,
  0x00, 0x01, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00,
  0x0F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0x80, 0x01, 0xC0, 0x00, 0x10, 0x20,
  0x00, 0x0E, 0x00, 0x07, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x0E, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x02, 0x01, 0xE0, 0x11, 0xE0,
  0x78, 0x1E, 0x7E, 0x1E, 0x1F, 0x9F, 0xE7, 0x9F, 0xEF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x0F, 0xE1, 0xFC, 0x07, 0xF0, 0x3F, 0x80,
  0xFC, 0x0F, 0xC0, 0x0E, 0x01, 0xC0, 0x01, 0x00, 0x20, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x03,
  0xE0, 0x1F, 0xC0, 0xFF, 0x83, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0xFF, 0xC1,
  0xFF, 0x03, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0xFF, 0x8F,
  0xFC, 0x3F, 0xC0, 0x7E, 0x01, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x1E, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFD, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0x0F, 0xF0, 0x1F, 0xC0,
  0x3F, 0x81, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0xF0, 0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC1, 0xFC, 0x3F, 0xFC,
  0x3F, 0xC3, 0xFF, 0xC3, 0xFC, 0x3F, 0xFC, 0x3F, 0xC3, 0xFF, 0xC1, 0xFC,
  0x3F, 0xFC, 0x1F, 0x83, 0xFF, 0xC0, 0xF0, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7E, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x81, 0xFC,
  0x03, 0xF8, 0x0F, 0xF0, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xDF, 0x80, 0x7F, 0xCF, 0xC0, 0x1F, 0x87, 0xE0, 0x0F, 0x83, 0xF0,
  0x02, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xFE, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x01, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xFE, 0x3F, 0xC0, 0x7F, 0x87, 0xC0, 0x0F, 0xF0, 0xE0, 0x01,
  0xFC, 0x20, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xC0, 0xFF, 0x83, 0x80, 0x0F, 0xE0, 0x40, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x90, 0x00, 0x1F, 0xE7, 0xC0,
  0x1F, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xF7, 0xE0,
  0x00, 0x0F, 0xDF, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x03, 0xF1, 0xF8, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F,
  0x81, 0xF8, 0x00, 0x7C, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80,
  0x7E, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x80, 0x7C, 0x00, 0x7E, 0x01, 0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xE0,
  0x3E, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x7E, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFF, 0xFF, 0x81,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x83, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x60, 0x00, 0x7F, 0x9F, 0x00, 0x7F, 0xC7,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x7F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF1, 0xFF, 0x01, 0xFF, 0x3F, 0x00, 0x0F, 0xE7, 0xC0, 0x00,
  0xFE, 0xF8, 0x00, 0x0F, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9, 0xF8,
  0x00, 0x3F, 0x3F, 0x80, 0x0F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0xC1, 0xFE,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x00, 0x3F,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFE, 0x07,
  0xF8, 0x1F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0xC3,
  0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xC7, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x07, 0xC3, 0xF0, 0x00, 0xFC,
  0x3F, 0x80, 0x1F, 0x81, 0xFC, 0x03, 0xF0, 0x1F, 0xF0, 0x7F, 0x00, 0xFF,
  0xEF, 0xE0, 0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xC1, 0xFF, 0x81, 0xF8, 0x07, 0xFC, 0x3F,
  0x00, 0x1F, 0xC3, 0xE0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x00,
  0x3E, 0x7C, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xE7, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0xF0,
  0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x3F, 0xC1, 0xFE, 0x0F, 0xE0,
  0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF9,
  0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7F, 0xF8, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x7D, 0xF8, 0x00, 0x0F, 0xBF, 0x80, 0x01, 0xF3, 0xF8, 0x00,
  0x7E, 0x7F, 0xC0, 0x7F, 0xC7, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFD, 0xFE, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE1, 0xFE, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFF, 0x7F, 0xDF, 0xE1, 0xF0, 0x01, 0xE0, 0x1F, 0xE0, 0x7F,
  0xC3, 0xFF, 0x0F, 0xFC, 0x3F, 0xF0, 0x7F, 0xC1, 0xFE, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x01,
  0xFE, 0x07, 0xF8, 0x3F, 0xF0, 0xFF, 0xC3, 0xFF, 0x0F, 0xFC, 0x1F, 0xF0,
  0x3F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x7F, 0x07, 0xF8, 0x7F, 0xC1,
  0xFE, 0x07, 0xE0, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x00,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0xFE, 0x0F,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF0, 0x1F, 0xE2, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0x3F, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xFC, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0x7E,
  0x1F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0xFF, 0xEF, 0x80, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x3F, 0xC3, 0xFF, 0x81, 0xF8, 0x1F, 0xFC,
  0x1F, 0x80, 0xFF, 0xE0, 0xFC, 0x07, 0xFF, 0x07, 0xC0, 0x3F, 0xF8, 0x3E,
  0x01, 0xFF, 0xC1, 0xF0, 0x0F, 0xFE, 0x0F, 0x80, 0x7F, 0xF0, 0x7C, 0x03,
  0xFF, 0x83, 0xE0, 0x1F, 0xFC, 0x1F, 0x00, 0xFF, 0xF0, 0xFC, 0x07, 0xFF,
  0x87, 0xE0, 0x3F, 0xFC, 0x1F, 0x81, 0xFF, 0xE0, 0xFE, 0x0F, 0xDF, 0x03,
  0xFF, 0xFE, 0xFC, 0x1F, 0xFF, 0xF7, 0xE0, 0x7F, 0xFF, 0x9F, 0x00, 0xFF,
  0xFC, 0xFC, 0x01, 0xFF, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x01, 0xFF, 0x80, 0x40, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xFC, 0x3F, 0x00,
  0x00, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0,
  0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x07, 0xC0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0, 0x03, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x3E, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F,
  0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xE1, 0xF0, 0x07, 0xFC, 0x3E, 0x00, 0x3F, 0xC7,
  0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x7E, 0x7C, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF9, 0xF0, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0xFE, 0x1F, 0x00, 0x7F,
  0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xC0, 0x0F, 0xF8, 0xF8, 0x00, 0x3F,
  0x9F, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x3F, 0x7C, 0x00, 0x03, 0xEF, 0x80,
  0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0x7C, 0x00,
  0x1F, 0xCF, 0x80, 0x1F, 0xF9, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0x87,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xC0, 0x7E, 0x0F, 0xF0, 0x00, 0xE0, 0xFE,
  0x00, 0x02, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x02, 0x07, 0xFE, 0x01, 0xE0, 0x3F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F,
  0xC0, 0x3F, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC1, 0xF0, 0x0F, 0xF8, 0x3E, 0x00, 0x7F,
  0x87, 0xC0, 0x03, 0xF8, 0xF8, 0x00, 0x3F, 0x9F, 0x00, 0x03, 0xF3, 0xE0,
  0x00, 0x7E, 0x7C, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x0F,
  0xBE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0xFE, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xF3, 0xE0, 0x01, 0xFC, 0x7C,
  0x00, 0x7F, 0x0F, 0x80, 0x7F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xF7, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0x8F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF1, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x7F,
  0xE0, 0x7E, 0x0F, 0xF0, 0x00, 0xE0, 0xFE, 0x00, 0x04, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0x7C, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x80, 0x03,
  0xF1, 0xFC, 0x00, 0x3F, 0x1F, 0xE0, 0x03, 0xF0, 0xFF, 0x00, 0x3F, 0x07,
  0xFC, 0x03, 0xF0, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x88, 0x00, 0x1F, 0xCE, 0x00, 0x1F, 0xC7,
  0xE0, 0x3F, 0xE7, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF7, 0xE0,
  0x00, 0x7F, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0x80,
  0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x01, 0xFC, 0x01, 0xF8,
  0x1F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0xFE,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFE, 0x00, 0x03, 0xF7, 0xF8, 0x00, 0x1F, 0x9F, 0xE0, 0x00, 0xFC, 0x7F,
  0x80, 0x07, 0xE0, 0xFE, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xE0,
  0x0F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x1F,
  0x80, 0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00,
  0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0x07,
  0xF3, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x7F,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0x0F, 0x78, 0x07, 0xBC, 0x3D, 0xE0,
  0x1E, 0xF0, 0xF7, 0x80, 0x7B, 0xC3, 0xCF, 0x03, 0xEF, 0x0F, 0x3C, 0x0F,
  0x3C, 0x3C, 0xF0, 0x3C, 0xF0, 0xF1, 0xE1, 0xF3, 0xC3, 0xC7, 0x87, 0x8F,
  0x0F, 0x1E, 0x1E, 0x3C, 0x3C, 0x7C, 0xF8, 0xF9, 0xF0, 0xF3, 0xC3, 0xE7,
  0xC3, 0xCF, 0x0F, 0x9F, 0x0F, 0xFC, 0x3E, 0x7C, 0x1F, 0xE0, 0xF9, 0xF0,
  0x7F, 0x83, 0xE7, 0xC1, 0xFE, 0x0F, 0x9F, 0x03, 0xF0, 0x3E, 0x7C, 0x0F,
  0xC0, 0xF9, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F,
  0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xEF,
  0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0x07, 0xFF,
  0xF8, 0x01, 0xFF, 0xBE, 0x00, 0x7F, 0xEF, 0xC0, 0x1F, 0xF9, 0xF0, 0x07,
  0xFE, 0x7E, 0x01, 0xFF, 0x8F, 0x80, 0x7F, 0xE3, 0xF0, 0x1F, 0xF8, 0x7C,
  0x07, 0xFE, 0x0F, 0x81, 0xFF, 0x83, 0xE0, 0x7F, 0xE0, 0xFC, 0x1F, 0xF8,
  0x1F, 0x07, 0xFE, 0x07, 0xE1, 0xFF, 0x80, 0xF8, 0x7F, 0xE0, 0x3E, 0x1F,
  0xF8, 0x07, 0xC7, 0xFE, 0x01, 0xF1, 0xFF, 0x80, 0x3E, 0x7F, 0xE0, 0x0F,
  0x9F, 0xF8, 0x01, 0xF7, 0xFE, 0x00, 0x7D, 0xFF, 0x80, 0x0F, 0x7F, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x80, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00,
  0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xF0,
  0x03, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xCF, 0xC0, 0x07, 0xF3,
  0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xEF,
  0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x3F, 0x00, 0x7F,
  0xCF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0x80, 0x3F, 0xC0, 0xFF, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x3F,
  0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x38, 0x3F, 0xFE, 0x00,
  0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xE1, 0xF0, 0x07, 0xFC, 0x3E, 0x00, 0x1F, 0xC7, 0xC0, 0x01, 0xF8,
  0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x7C, 0x00,
  0x07, 0xCF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07, 0xE7,
  0xC0, 0x00, 0xFC, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0xFC, 0x7C, 0x00, 0x3F, 0x8F, 0x80, 0x3F, 0xE1, 0xFF, 0xFF, 0xF8, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8,
  0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0x3F, 0x01, 0xF0,
  0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E,
  0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x8F, 0x80,
  0x01, 0xF9, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F,
  0xF8, 0x0F, 0xC3, 0xF0, 0x00, 0x21, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFE, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF4, 0x00, 0x00,
  0xFD, 0xC0, 0x00, 0xFE, 0x7E, 0x00, 0xFF, 0xBF, 0xFF, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x7E, 0x7F, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x3F, 0xE0, 0x7F,
  0xC1, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00,
  0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x00,
  0x00, 0x7C, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x03, 0xF0,
  0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0xFC,
  0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x0F, 0x9F,
  0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x03, 0xE7, 0xC0,
  0x00, 0x0F, 0x9F, 0x00, 0x00, 0x3E, 0x7C, 0x0F, 0xC0, 0xF9, 0xF0, 0x3F,
  0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x9F, 0x07, 0xF8, 0x3E, 0x7C, 0x1F, 0xE0,
  0xF9, 0xF0, 0x7F, 0x83, 0xE7, 0xC3, 0xFF, 0x0F, 0x9F, 0x0F, 0x3C, 0x3E,
  0x7C, 0x3C, 0xF0, 0xF1, 0xF1, 0xF3, 0xE3, 0xC3, 0xC7, 0x87, 0x8F, 0x0F,
  0x1E, 0x1E, 0x3C, 0x3C, 0xF8, 0x78, 0xF0, 0xF3, 0xC0, 0xF3, 0xC3, 0xCF,
  0x03, 0xCF, 0x0F, 0x7C, 0x0F, 0x3C, 0x3D, 0xE0, 0x1E, 0xF0, 0xF7, 0x80,
  0x7B, 0xC3, 0xDE, 0x01, 0xEF, 0x0F, 0xF0, 0x07, 0xF8, 0x3F, 0xC0, 0x0F,
  0xE0, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x83,
  0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x80, 0x07, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x3F, 0x9F, 0x80,
  0x00, 0x7E, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80,
  0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0,
  0x0F, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E,
  0x7E, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xF7, 0x80, 0x00, 0x1E, 0x18, 0x00, 0x00, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x07, 0x01, 0xF0, 0x7F, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7C, 0x07, 0x00, 0x40, 0x03,
  0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF0, 0x60, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0x7C, 0x1F, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xF0, 0x07, 0xFF, 0xC0,
  0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xDF, 0xE0, 0x03, 0xEF,
  0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xE0, 0x18, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE1, 0xFE, 0x00, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0xFF, 0x81, 0xFE, 0x3F,
  0x80, 0x1F, 0xCF, 0x80, 0x03, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x1F,
  0xBE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xFB, 0xE0, 0x00,
  0xFC, 0xF8, 0x00, 0xFF, 0x3F, 0x00, 0xFF, 0x8F, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x0C, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x60, 0x7F,
  0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x7C, 0x01, 0xFE, 0x1F, 0x01, 0xFF, 0xF7, 0xC1,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x1F, 0xE0, 0x7F,
  0xCF, 0xE0, 0x07, 0xF7, 0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x1F, 0x7E, 0x00,
  0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xDF, 0x80, 0x01, 0xF7, 0xF0, 0x00, 0x7C, 0xFC,
  0x00, 0x1F, 0x3F, 0xC0, 0x07, 0xC7, 0xFC, 0x03, 0xF0, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xFC, 0x3F, 0x80,
  0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x3E,
  0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x08, 0x1F, 0xF0, 0x07, 0x80,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00,
  0x7F, 0x80, 0x78, 0x03, 0xF8, 0x00, 0x40, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xF8, 0x03, 0xF3, 0xF8, 0x00, 0x7D, 0xFC, 0x00, 0x1F, 0x7E, 0x00,
  0x07, 0xDF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xFC,
  0x00, 0x1F, 0x3F, 0x80, 0x0F, 0xCF, 0xF8, 0x1F, 0xF1, 0xFF, 0xFF, 0xFC,
  0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xC0, 0x7F, 0xFD, 0xF0, 0x07, 0xF8,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x30, 0x00, 0x3F, 0x8F, 0x80, 0x3F, 0xC3,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x18, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xF8, 0xFF, 0xFF, 0xFC, 0xFE, 0x03, 0xFE, 0xF8, 0x00, 0xFE, 0xF8, 0x00,
  0x7E, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x00, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x10, 0x01, 0xFC, 0x0E, 0x00, 0x3F, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x7F, 0xFF,
  0xE3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFB, 0x00, 0x1F, 0x9F, 0x03, 0xFC, 0xFF,
  0xFF, 0xCF, 0xFF, 0xFE, 0x7F, 0xFF, 0xE1, 0xFF, 0xFC, 0x00, 0xFF, 0x80,
  0x18, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0xF8, 0x00, 0x3F, 0x8F,
  0x80, 0x07, 0xF0, 0xF8, 0x00, 0xFE, 0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x03,
  0xF8, 0x0F, 0x80, 0x7F, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x81, 0xFC, 0x00,
  0xF8, 0x3F, 0x80, 0x0F, 0x87, 0xF0, 0x00, 0xF8, 0xFE, 0x00, 0x0F, 0xBF,
  0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0xF9, 0xFC, 0x00, 0x0F, 0x8F, 0xE0, 0x00, 0xF8,
  0x7F, 0x80, 0x0F, 0x83, 0xFC, 0x00, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x7F,
  0x00, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x1F, 0xC0, 0xF8, 0x00, 0xFC, 0x0F,
  0x80, 0x07, 0xE0, 0xF8, 0x00, 0x3F, 0x0F, 0x80, 0x03, 0xF8, 0xF8, 0x00,
  0x1F, 0xCF, 0x80, 0x00, 0xFE, 0xF8, 0x00, 0x07, 0xE0, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x40, 0x07, 0xF0, 0x38, 0x00, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x7E, 0x07, 0xFF, 0xCF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7C, 0x1F, 0xE3, 0xFB, 0xE0, 0x7E,
  0x07, 0xDF, 0x03, 0xE0, 0x3E, 0xF8, 0x0F, 0x81, 0xF7, 0xC0, 0x7C, 0x0F,
  0xFE, 0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0x03, 0xFF, 0x80, 0xF8, 0x1F, 0xFC,
  0x07, 0xC0, 0xFF, 0xE0, 0x3E, 0x07, 0xFF, 0x01, 0xF0, 0x3F, 0xF8, 0x0F,
  0x81, 0xFF, 0xC0, 0x7C, 0x0F, 0xFE, 0x03, 0xE0, 0x7F, 0xF0, 0x1F, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0x07, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0xFC,
  0x01, 0xFE, 0xF8, 0x00, 0xFE, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x01, 0xFE, 0x07, 0xF8, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC,
  0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC3,
  0xF8, 0x01, 0xFC, 0x1F, 0xE0, 0x7F, 0x80, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0x00, 0xFF, 0x8F, 0x80, 0x0F, 0xF3, 0xE0,
  0x01, 0xFC, 0xF8, 0x00, 0x3F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF,
  0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0xBF, 0x80, 0x1F,
  0xCF, 0xF8, 0x1F, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF,
  0xFE, 0x0F, 0xBF, 0xFE, 0x03, 0xE1, 0xFE, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xC7, 0xFC, 0x03, 0xF3, 0xFC, 0x00, 0x7C, 0xFE, 0x00, 0x1F, 0x7F, 0x00,
  0x07, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF8,
  0x00, 0x1F, 0x7F, 0x00, 0x07, 0xCF, 0xE0, 0x07, 0xF1, 0xFE, 0x07, 0xFC,
  0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0x7C, 0x00, 0xFE, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xDF, 0xF0, 0x01, 0xBF, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xE0, 0x07, 0x87, 0xF0, 0x00, 0x21, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x60, 0x00, 0x0F, 0x9E, 0x00, 0x07,
  0xE7, 0xF0, 0x07, 0xF9, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xF0, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x20, 0x0F, 0xF0,
  0x1C, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7F, 0x00, 0x1F,
  0x7F, 0xC0, 0x3F, 0x3F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xE0, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E, 0x7E, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3E, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8, 0x7E,
  0x00, 0x03, 0xE1, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x3E, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x03,
  0xC0, 0x3E, 0x7C, 0x03, 0xE0, 0x3E, 0x7C, 0x07, 0xE0, 0x3E, 0x7E, 0x07,
  0xE0, 0x3C, 0x3E, 0x07, 0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x0F,
  0xF0, 0x7C, 0x3E, 0x0F, 0xF0, 0x7C, 0x3E, 0x1F, 0xF8, 0x7C, 0x3E, 0x1E,
  0x78, 0x7C, 0x3F, 0x1E, 0x78, 0x78, 0x1F, 0x3E, 0x7C, 0xF8, 0x1F, 0x3C,
  0x3C, 0xF8, 0x1F, 0x3C, 0x3C, 0xF8, 0x1F, 0x7C, 0x3E, 0xF8, 0x1F, 0x78,
  0x1E, 0xF8, 0x0F, 0x78, 0x1E, 0xF0, 0x0F, 0xF8, 0x1F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00,
  0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x7E,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE1, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x3F, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x7E, 0x7E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x7E,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3E, 0x00, 0x7E, 0x01, 0xF0,
  0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xF8, 0x00, 0x3E, 0x07, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x20, 0x3F, 0x80, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0x00,
  0x7F, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0xC1, 0xFF, 0x80, 0x0F,
  0x3F, 0xFE, 0x00, 0xF3, 0xFF, 0xF0, 0x1F, 0x7F, 0xFF, 0xC3, 0xFF, 0xC3,
  0xFF, 0xFE, 0xF8, 0x0F, 0xFF, 0xCF, 0x00, 0x7F, 0xFC, 0xF0, 0x01, 0xFF,
  0x83, 0x00, 0x07, 0xE0,
};

const GFXglyph UbuntuMono_Regular68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 34, 0, -1 },
  { 1, 9, 43, 34, 12, -42 },
  { 50, 16, 17, 34, 9, -46 },
  { 84, 30, 42, 34, 2, -42 },
  { 242, 26, 54, 34, 4, -47 },
  { 418, 32, 44, 34, 1, -43 },
  { 594, 30, 42, 34, 2, -42 },
  { 752, 6, 18, 34, 14, -46 },
  { 766, 18, 59, 34, 8, -48 },
  { 899, 18, 59, 34, 8, -48 },
  { 1032, 26, 25, 34, 4, -42 },
  { 1114, 28, 31, 34, 3, -34 },
  { 1223, 14, 18, 34, 10, -8 },
  { 1255, 14, 5, 34, 10, -20 },
  { 1264, 10, 9, 34, 12, -8 },
  { 1276, 24, 59, 34, 5, -48 },
  { 1453, 28, 44, 34, 3, -43 },
  { 1607, 25, 42, 34, 5, -42 },
  { 1739, 26, 43, 34, 4, -43 },
  { 1879, 26, 44, 34, 4, -43 },
  { 2022, 30, 42, 34, 2, -42 },
  { 2180, 26, 43, 34, 4, -42 },
  { 2320, 27, 43, 34, 4, -42 },
  { 2466, 27, 42, 34, 4, -42 },
  { 2608, 28, 44, 34, 3, -43 },
  { 2762, 27, 43, 34, 3, -43 },
  { 2908, 10, 31, 34, 12, -30 },
  { 2947, 14, 40, 34, 8, -30 },
  { 3017, 28, 27, 34, 3, -31 },
  { 3112, 28, 18, 34, 3, -27 },
  { 3175, 28, 27, 34, 3, -31 },
  { 3270, 22, 44, 34, 6, -43 },
  { 3391, 29, 51, 34, 3, -42 },
  { 3576, 32, 42, 34, 1, -42 },
  { 3744, 27, 42, 34, 4, -42 },
  { 3886, 28, 42, 34, 3, -42 },
  { 4033, 27, 42, 34, 4, -42 },
  { 4175, 25, 42, 34, 6, -42 },
  { 4307, 24, 42, 34, 6, -42 },
  { 4433, 28, 42, 34, 3, -42 },
  { 4580, 28, 42, 34, 3, -42 },
  { 4727, 22, 42, 34, 6, -42 },
  { 4843, 25, 42, 34, 4, -42 },
  { 4975, 29, 42, 34, 4, -42 },
  { 5128, 25, 42, 34, 6, -42 },
  { 5260, 30, 42, 34, 2, -42 },
  { 5418, 26, 42, 34, 4, -42 },
  { 5555, 30, 42, 34, 2, -42 },
  { 5713, 26, 42, 34, 5, -42 },
  { 5850, 30, 52, 34, 2, -42 },
  { 6045, 27, 42, 34, 4, -42 },
  { 6187, 26, 42, 34, 4, -42 },
  { 6324, 28, 42, 34, 3, -42 },
  { 6471, 28, 42, 34, 3, -42 },
  { 6618, 32, 42, 34, 1, -42 },
  { 6786, 30, 42, 34, 2, -42 },
  { 6944, 30, 42, 34, 2, -42 },
  { 7102, 32, 42, 34, 1, -42 },
  { 7270, 27, 42, 34, 4, -42 },
  { 7412, 16, 59, 34, 10, -48 },
  { 7530, 24, 59, 34, 5, -48 },
  { 7707, 16, 59, 34, 8, -48 },
  { 7825, 28, 23, 34, 3, -42 },
  { 7906, 32, 5, 34, 1, 6 },
  { 7926, 11, 12, 34, 11, -47 },
  { 7943, 25, 32, 34, 4, -32 },
  { 8043, 26, 47, 34, 5, -47 },
  { 8196, 28, 32, 34, 3, -32 },
  { 8308, 26, 47, 34, 3, -47 },
  { 8461, 28, 32, 34, 3, -32 },
  { 8573, 29, 47, 34, 4, -47 },
  { 8744, 26, 43, 34, 3, -32 },
  { 8884, 24, 47, 34, 5, -47 },
  { 9025, 27, 45, 34, 4, -45 },
  { 9177, 21, 56, 34, 5, -45 },
  { 9324, 28, 47, 34, 5, -47 },
  { 9489, 27, 47, 34, 4, -47 },
  { 9648, 29, 32, 34, 3, -32 },
  { 9764, 24, 32, 34, 5, -32 },
  { 9860, 28, 32, 34, 3, -32 },
  { 9972, 26, 43, 34, 5, -32 },
  { 10112, 26, 43, 34, 3, -32 },
  { 10252, 23, 32, 34, 7, -32 },
  { 10344, 26, 32, 34, 4, -32 },
  { 10448, 27, 42, 34, 4, -42 },
  { 10590, 24, 32, 34, 5, -32 },
  { 10686, 30, 32, 34, 2, -32 },
  { 10806, 32, 32, 34, 1, -32 },
  { 10934, 30, 32, 34, 2, -32 },
  { 11054, 29, 43, 34, 2, -32 },
  { 11210, 24, 32, 34, 5, -32 },
  { 11306, 24, 59, 34, 5, -48 },
  { 11483, 6, 59, 34, 14, -48 },
  { 11528, 24, 59, 34, 5, -48 },
  { 11705, 28, 10, 34, 3, -23 },
};

const GFXfont UbuntuMono_Regular68pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular68pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular68pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _UBUNTUMONO_REGULAR68PT7B_H_
