#ifndef _UBUNTUMONO_REGULAR32PT7B_H_
#define _UBUNTUMONO_REGULAR32PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 32pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular32pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x66, 0x60, 0x00, 0x6F, 0xFE, 0xE7,
  0xE7, 0xE7, 0xE7, 0xC3, 0xC3, 0xC3, 0x42, 0x06, 0x18, 0x38, 0xE0, 0xE3,
  0x83, 0x0C, 0x0C, 0x33, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x70, 0x61,
  0x81, 0x86, 0x06, 0x18, 0x38, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x30,
  0xC0, 0xC7, 0x07, 0x1C, 0x18, 0x60, 0x06, 0x00, 0x60, 0x06, 0x01, 0xFC,
  0x3F, 0xE7, 0xFE, 0xF0, 0x6E, 0x00, 0xE0, 0x0F, 0x00, 0x7E, 0x03, 0xF8,
  0x1F, 0xE0, 0x3F, 0x00, 0xF0, 0x07, 0x00, 0x7C, 0x07, 0xFF, 0xFF, 0xFE,
  0x3F, 0x80, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x78, 0x0F, 0xF0, 0x6C,
  0xC3, 0xB3, 0x0C, 0xC6, 0x63, 0x19, 0x8C, 0xCC, 0x33, 0x70, 0xFD, 0x81,
  0xEC, 0x00, 0x37, 0x81, 0xBF, 0x0E, 0xCC, 0x33, 0x31, 0x98, 0xC6, 0x63,
  0x30, 0xCD, 0xC3, 0x36, 0x0F, 0xF0, 0x1E, 0x0F, 0x80, 0xFF, 0x03, 0xFC,
  0x1E, 0x38, 0x70, 0xE1, 0xC3, 0x03, 0x1C, 0x0E, 0xE0, 0x1F, 0x00, 0x78,
  0x63, 0x71, 0x9D, 0xEE, 0xE3, 0xF3, 0x87, 0xCE, 0x0F, 0x38, 0x3C, 0xF1,
  0xF9, 0xFF, 0xE7, 0xF9, 0xC7, 0x87, 0xFF, 0xFF, 0xC0, 0x02, 0x07, 0x0F,
  0x1C, 0x38, 0x30, 0x70, 0x60, 0xE0, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xE0, 0xE0, 0x60, 0x70, 0x38, 0x38, 0x1C, 0x0F, 0x07, 0x02, 0x40, 0xE0,
  0xF0, 0x78, 0x3C, 0x1C, 0x0E, 0x06, 0x07, 0x07, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x07, 0x06, 0x0E, 0x1C, 0x1C, 0x38, 0xF0, 0xE0, 0x40, 0x06,
  0x00, 0x60, 0x06, 0x04, 0x62, 0xF6, 0xFF, 0xFF, 0x3F, 0xC0, 0xF0, 0x1F,
  0x83, 0x9C, 0x79, 0xE1, 0x08, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0x03, 0x00, 0x0C, 0x0F, 0xFF, 0xFF, 0xFF, 0x03, 0x00, 0x0C, 0x00, 0x30,
  0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x38, 0xF7, 0xCF, 0x1C, 0xEF, 0x30,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0E, 0x00,
  0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x01, 0xC0, 0x1C, 0x01, 0x80, 0x38,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x00, 0x07, 0x80,
  0x7F, 0x83, 0xFF, 0x0E, 0x1C, 0x70, 0x39, 0xC0, 0xE7, 0x03, 0x98, 0xC6,
  0xE7, 0x9B, 0x9E, 0x7E, 0x31, 0xD8, 0x06, 0x60, 0x19, 0x80, 0xE7, 0x03,
  0x9C, 0x0E, 0x38, 0x70, 0xFF, 0xC1, 0xFE, 0x03, 0xE0, 0x03, 0x00, 0x70,
  0x1F, 0x03, 0xF0, 0x7B, 0x06, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x00, 0x30, 0x03, 0x07, 0xFF,
  0x7F, 0xF7, 0xFF, 0x1F, 0x87, 0xFC, 0xFF, 0xEE, 0x1E, 0x40, 0xE0, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0,
  0x38, 0x07, 0x00, 0x60, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0x07, 0xFC,
  0x7F, 0xE4, 0x1E, 0x00, 0xE0, 0x06, 0x00, 0xE0, 0x1E, 0x1F, 0xC1, 0xF8,
  0x1F, 0xE0, 0x1E, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0xC0, 0xFF, 0xFE,
  0xFF, 0xC3, 0xF0, 0x00, 0x70, 0x03, 0xC0, 0x1F, 0x00, 0xFC, 0x07, 0x70,
  0x39, 0xC0, 0xC7, 0x06, 0x1C, 0x38, 0x70, 0xC1, 0xC7, 0x07, 0x18, 0x1C,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x3F, 0xF3, 0xFF, 0x3F, 0xF3, 0x00, 0x30, 0x03, 0x00, 0x30,
  0x03, 0xE0, 0x7F, 0xC7, 0xFE, 0x03, 0xE0, 0x0F, 0x00, 0x70, 0x07, 0x00,
  0x70, 0x07, 0x40, 0xFF, 0xFE, 0xFF, 0xC3, 0xF0, 0x01, 0xE0, 0x7E, 0x1F,
  0xE3, 0xE0, 0x38, 0x07, 0x00, 0x60, 0x0F, 0xF8, 0xFF, 0xEF, 0xFE, 0xE0,
  0xFC, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x07, 0x70, 0xF7, 0xFE, 0x3F,
  0xC0, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0x70,
  0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00, 0x60, 0x07,
  0x00, 0x38, 0x01, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x00, 0x1F,
  0x83, 0xFC, 0x7F, 0xEF, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x7F, 0x0E, 0x7D,
  0xC3, 0xF8, 0x3F, 0xE7, 0x3F, 0xE0, 0x7C, 0x03, 0xC0, 0x3C, 0x07, 0xF0,
  0xFF, 0xFF, 0x7F, 0xE1, 0xF8, 0x1F, 0x03, 0xFC, 0x7F, 0xEF, 0x0E, 0xE0,
  0x7C, 0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3F, 0x07, 0x7F, 0xF7, 0xFF, 0x1F,
  0xF0, 0x07, 0x00, 0xE0, 0x1E, 0x07, 0xC7, 0xF8, 0x7E, 0x07, 0x80, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3C, 0xF3, 0xCF, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xCF, 0x3C, 0xF1, 0xCE, 0xF3, 0x80, 0x00, 0x10, 0x07, 0x80,
  0xFC, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x00, 0xFC, 0x01, 0xE0, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xE0, 0x3F, 0x07, 0xE0, 0xF8,
  0x1F, 0x01, 0xE0, 0x08, 0x00, 0x00, 0x3E, 0x3F, 0xEF, 0xFD, 0x0F, 0x01,
  0xC0, 0x70, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0x70, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x1C, 0x0F, 0x03, 0xC0, 0x70, 0x07, 0xE0, 0x3F, 0xC1, 0xFF,
  0x8F, 0x0E, 0x38, 0x1D, 0xC0, 0x77, 0x01, 0xD8, 0x3F, 0xE3, 0xFF, 0x8F,
  0xFE, 0x71, 0xF9, 0xC7, 0xE6, 0x1F, 0x9C, 0x7E, 0x71, 0xD8, 0xFF, 0x73,
  0xFD, 0xC3, 0xF7, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x7F, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x06, 0x60, 0x0E,
  0x70, 0x0E, 0x70, 0x0C, 0x30, 0x1C, 0x38, 0x1C, 0x38, 0x18, 0x38, 0x18,
  0x18, 0x38, 0x1C, 0x3F, 0xFC, 0x3F, 0xFC, 0x7F, 0xFE, 0x70, 0x0E, 0x70,
  0x0E, 0x60, 0x0E, 0xE0, 0x07, 0xFF, 0x0F, 0xFC, 0xFF, 0xEC, 0x1E, 0xC0,
  0x6C, 0x06, 0xC0, 0x6C, 0x1E, 0xFF, 0xCF, 0xF8, 0xFF, 0xEC, 0x0F, 0xC0,
  0x7C, 0x03, 0xC0, 0x3C, 0x07, 0xC0, 0xFF, 0xFE, 0xFF, 0xEF, 0xF0, 0x03,
  0xF0, 0x3F, 0xF1, 0xFF, 0x8F, 0x02, 0x38, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0x60, 0x03, 0x80, 0x0E, 0x00, 0x18, 0x00, 0x60, 0x01, 0xC0, 0x07,
  0x00, 0x1E, 0x00, 0x3C, 0x08, 0x7F, 0xE0, 0xFF, 0xC0, 0xFC, 0xFE, 0x07,
  0xFC, 0x3F, 0xF1, 0x83, 0xCC, 0x0F, 0x60, 0x3B, 0x01, 0xD8, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x3B, 0x01, 0xD8, 0x1E,
  0xC1, 0xE7, 0xFE, 0x3F, 0xE1, 0xFC, 0x00, 0xFF, 0xEF, 0xFE, 0xFF, 0xEE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xFF, 0xCF, 0xFC, 0xFF, 0xCE,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00,
  0xFF, 0xDF, 0xFB, 0xFF, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0,
  0x1C, 0x03, 0x80, 0x70, 0x00, 0x03, 0xF0, 0x3F, 0xE1, 0xFF, 0x8F, 0x82,
  0x38, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0x60, 0x03, 0x80, 0x0E, 0x01,
  0xD8, 0x07, 0x60, 0x1D, 0xC0, 0x77, 0x01, 0xDE, 0x07, 0x3C, 0x1C, 0x7F,
  0xF0, 0xFF, 0xC1, 0xFC, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0,
  0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C,
  0x3F, 0xFF, 0xFF, 0xFF, 0x3F, 0xE7, 0xFC, 0xFF, 0x80, 0x30, 0x06, 0x00,
  0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x00, 0xC0,
  0x18, 0x07, 0x41, 0xFF, 0xFB, 0xFF, 0x1F, 0x80, 0xE0, 0x3B, 0x81, 0xCE,
  0x0E, 0x38, 0x78, 0xE1, 0xC3, 0x8E, 0x0E, 0x70, 0x3B, 0x80, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x3B, 0xC0, 0xE7, 0x83, 0x8F, 0x0E, 0x1C, 0x38, 0x38,
  0xE0, 0x73, 0x81, 0xCE, 0x03, 0xB8, 0x0E, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0x70, 0x39, 0xC0, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0x79, 0xB3, 0x66,
  0xCD, 0x9B, 0x36, 0x67, 0x99, 0x9E, 0x6E, 0x79, 0xF8, 0xC7, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF8, 0x3D, 0x83, 0xDC, 0x3C, 0xC3,
  0xCE, 0x3C, 0x63, 0xC7, 0x3C, 0x33, 0xC3, 0xBC, 0x1B, 0xC1, 0xBC, 0x0F,
  0xC0, 0xFC, 0x07, 0xC0, 0x7C, 0x07, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E,
  0x1E, 0x70, 0x3B, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E,
  0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x78, 0x78,
  0xFF, 0xC1, 0xFE, 0x03, 0xF0, 0xFF, 0x87, 0xFF, 0x3F, 0xF9, 0xC1, 0xEE,
  0x07, 0x70, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0x77, 0x07, 0xBF, 0xF9, 0xFF,
  0x8F, 0xF8, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xDC, 0x0E, 0x78, 0x78, 0xFF, 0xC1, 0xFE, 0x03,
  0xF0, 0x03, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x00, 0x18, 0xFF, 0x07,
  0xFE, 0x3F, 0xF9, 0x83, 0xCC, 0x07, 0x60, 0x3B, 0x01, 0xD8, 0x0E, 0xC0,
  0x76, 0x0F, 0x3F, 0xF9, 0xFF, 0x8F, 0xF0, 0x61, 0xC3, 0x07, 0x18, 0x18,
  0xC0, 0xE6, 0x03, 0x30, 0x1D, 0x80, 0x70, 0x1F, 0xC3, 0xFE, 0x7F, 0xE7,
  0x06, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x80, 0x7E, 0x03, 0xF8, 0x0F, 0xE0,
  0x3E, 0x00, 0xF0, 0x07, 0x00, 0x30, 0x07, 0xC0, 0xFF, 0xFE, 0xFF, 0xE3,
  0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x03, 0x00, 0x0C, 0x00,
  0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00,
  0x0C, 0x00, 0x30, 0x00, 0xC0, 0x03, 0x00, 0x0C, 0x00, 0x30, 0x00, 0xC0,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3E, 0x07,
  0xF0, 0xF7, 0xFE, 0x7F, 0xE1, 0xF8, 0x60, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x70, 0x0E, 0x30, 0x0E, 0x38, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x18, 0x18,
  0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0x60,
  0x07, 0x60, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xE3, 0x1F, 0x9E, 0x66, 0x79, 0x99, 0xE6, 0x6C, 0xD9, 0xB3, 0x66, 0xCD,
  0x9E, 0x1E, 0x78, 0x79, 0xE1, 0xE7, 0x03, 0x9C, 0x0E, 0xE0, 0x1D, 0xC0,
  0xE3, 0x03, 0x8E, 0x1C, 0x1C, 0x60, 0x73, 0x80, 0xFC, 0x03, 0xF0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x03, 0xF0, 0x0F, 0xC0, 0x73, 0x81, 0xCE, 0x0E,
  0x1C, 0x30, 0x39, 0xC0, 0xE6, 0x01, 0xF8, 0x07, 0x70, 0x06, 0x70, 0x0E,
  0x70, 0x0E, 0x38, 0x1C, 0x38, 0x1C, 0x1C, 0x38, 0x1C, 0x38, 0x0E, 0x70,
  0x0E, 0x70, 0x07, 0xE0, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0x80, 0x01, 0x80,
  0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80, 0x01, 0x80,
  0xFF, 0xF7, 0xFF, 0xBF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0x06,
  0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1,
  0x83, 0x06, 0x0C, 0x18, 0x30, 0x7F, 0xFE, 0xE0, 0x06, 0x00, 0x70, 0x07,
  0x00, 0x30, 0x03, 0x80, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0C, 0x00,
  0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x03, 0x80,
  0x18, 0x01, 0xC0, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x70,
  0xFF, 0xFC, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60,
  0xC1, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0xFF, 0xFE, 0x03, 0x00,
  0x1E, 0x00, 0xFC, 0x03, 0xF0, 0x1C, 0xE0, 0x61, 0x83, 0x87, 0x0C, 0x0C,
  0x70, 0x3B, 0x80, 0x76, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0x43, 0x87,
  0x0E, 0x18, 0x20, 0x3F, 0x87, 0xFE, 0x3F, 0xE2, 0x0F, 0x00, 0x70, 0x07,
  0x1F, 0xF7, 0xFF, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xFF, 0xF7, 0xFF,
  0x1F, 0xE0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03,
  0x80, 0x1D, 0xF0, 0xFF, 0xC7, 0xFF, 0x3C, 0x3D, 0xC0, 0xEE, 0x03, 0xF0,
  0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x03, 0xB8, 0x3D, 0xFF, 0xCF, 0xFC,
  0x3F, 0x80, 0x0F, 0xE3, 0xFF, 0x7F, 0xF7, 0x81, 0xE0, 0x0E, 0x00, 0xE0,
  0x0C, 0x00, 0xC0, 0x0E, 0x00, 0xE0, 0x0F, 0x81, 0x7F, 0xF3, 0xFF, 0x0F,
  0xE0, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00,
  0xE1, 0xF7, 0x1F, 0xF9, 0xFF, 0xDE, 0x1E, 0xE0, 0x7E, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0xDE, 0x0E, 0x7F, 0xF1, 0xFF, 0x87,
  0xF8, 0x07, 0xC0, 0x7F, 0xC3, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0x80, 0x6F,
  0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x04, 0x3F, 0xF0,
  0x7F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0xC3, 0xFE, 0x3C, 0x11, 0xC0,
  0x0E, 0x00, 0x70, 0x1F, 0xFE, 0xFF, 0xF7, 0xFF, 0x87, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38,
  0x01, 0xC0, 0x0E, 0x00, 0x0F, 0xF0, 0xFF, 0xCF, 0xFE, 0xF0, 0x77, 0x03,
  0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3B, 0x81, 0xDE, 0x1E, 0xFF, 0xF3,
  0xFF, 0x87, 0xDC, 0x00, 0xE0, 0x07, 0x60, 0x73, 0xFF, 0x9F, 0xF8, 0x7F,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0xF8, 0xFF, 0xCF, 0xFE, 0xE0, 0xEE, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0x1C, 0x01,
  0xE0, 0x1E, 0x01, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0xFE, 0x00,
  0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00,
  0xE1, 0x0F, 0xF0, 0x7F, 0x03, 0xE0, 0x03, 0x80, 0xF0, 0x3C, 0x0E, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x3F, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x74, 0x1D, 0xFF,
  0xFF, 0x8F, 0xC0, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x80, 0x1C, 0x0E, 0xE0, 0xE7, 0x0F, 0x38, 0xF1, 0xCE, 0x0E, 0xE0,
  0x7E, 0x03, 0xF0, 0x1D, 0xC0, 0xE7, 0x07, 0x1E, 0x38, 0x71, 0xC1, 0xCE,
  0x07, 0x70, 0x1C, 0xFE, 0x0F, 0xE0, 0xFE, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x10, 0xFF, 0x07, 0xF0, 0x3E,
  0x7C, 0xF3, 0xFF, 0xEF, 0xFF, 0xB9, 0xC7, 0xE3, 0x1F, 0x8C, 0x7E, 0x31,
  0xF8, 0xC7, 0xE3, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xC0, 0x7F, 0x8F, 0xFC, 0xFF, 0xEE, 0x0E, 0xE0, 0x7E, 0x07,
  0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07,
  0xE0, 0x70, 0x0F, 0xC0, 0x7F, 0x83, 0xFF, 0x1E, 0x1E, 0x70, 0x3B, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x77, 0x03, 0x9E, 0x1E, 0x3F,
  0xF0, 0x7F, 0x80, 0xFC, 0x00, 0x7F, 0x07, 0xFE, 0x3F, 0xF9, 0xC1, 0xEE,
  0x07, 0x70, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x1D, 0xE1,
  0xEF, 0xFE, 0x7F, 0xE3, 0xBE, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x00, 0x07, 0xF0, 0xFF, 0xCF, 0xFE, 0xF0, 0x77, 0x03, 0xF0, 0x1F,
  0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xDC, 0x0E, 0xF0, 0xF3, 0xFF, 0x8F,
  0xFC, 0x3E, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C,
  0x03, 0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x00, 0x1F, 0xC3, 0xFE, 0x7F,
  0xEF, 0x02, 0xE0, 0x07, 0x80, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x0F, 0x00,
  0x74, 0x07, 0xFF, 0xFF, 0xFE, 0x3F, 0x80, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x01, 0xC0, 0x1C, 0x01,
  0xC0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x1E, 0x10, 0xFF, 0x0F, 0xF0,
  0x3E, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x77, 0x07, 0x7F, 0xF3, 0xFF, 0x1F, 0xE0,
  0xE0, 0x1F, 0x80, 0x77, 0x01, 0x9C, 0x0E, 0x70, 0x38, 0xE1, 0xC3, 0x87,
  0x0E, 0x18, 0x1C, 0xE0, 0x73, 0x80, 0xCC, 0x03, 0xF0, 0x07, 0x80, 0x1E,
  0x00, 0x70, 0x00, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0xC3, 0xE3, 0x0F,
  0x9E, 0x7E, 0x79, 0xD9, 0xE6, 0x6C, 0xD9, 0xB3, 0x66, 0xCD, 0x9E, 0x1E,
  0x78, 0x70, 0xE1, 0xC3, 0x03, 0x00, 0x60, 0x39, 0xC0, 0xE3, 0x87, 0x07,
  0x38, 0x1C, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x3B, 0x01,
  0xCE, 0x0E, 0x1C, 0x70, 0x39, 0xC0, 0xEE, 0x01, 0xC0, 0x70, 0x1D, 0xC0,
  0x67, 0x03, 0x8C, 0x0E, 0x38, 0x38, 0xE0, 0xC1, 0x87, 0x07, 0x1C, 0x1C,
  0x60, 0x3B, 0x80, 0xEE, 0x01, 0xB0, 0x07, 0xC0, 0x0E, 0x00, 0x38, 0x00,
  0xE0, 0x07, 0x03, 0xF8, 0x0F, 0xE0, 0x3E, 0x00, 0x7F, 0xE7, 0xFE, 0x7F,
  0xE0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x38,
  0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xE1, 0xFC, 0x70, 0x0E,
  0x01, 0x80, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x03,
  0x81, 0xE0, 0x3C, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80,
  0x30, 0x07, 0x00, 0xE0, 0x1C, 0x01, 0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0xFC, 0x1F, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06,
  0x00, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x38, 0x03, 0xC0,
  0x78, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0,
  0x38, 0x07, 0x1F, 0xC3, 0xF0, 0x00, 0x3C, 0x0D, 0xFC, 0x77, 0xFF, 0xB8,
  0xFE, 0xC0, 0xF0,
};

const GFXglyph UbuntuMono_Regular32pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 4, 20, 16, 6, -20 },
  { 11, 8, 8, 16, 4, -22 },
  { 19, 14, 20, 16, 1, -20 },
  { 54, 12, 25, 16, 2, -22 },
  { 92, 14, 20, 16, 1, -20 },
  { 127, 14, 20, 16, 1, -20 },
  { 162, 2, 9, 16, 7, -22 },
  { 165, 8, 25, 16, 4, -20 },
  { 190, 8, 25, 16, 4, -20 },
  { 215, 12, 12, 16, 2, -20 },
  { 233, 14, 14, 16, 1, -15 },
  { 258, 6, 8, 16, 5, -4 },
  { 264, 8, 3, 16, 4, -10 },
  { 267, 4, 4, 16, 6, -4 },
  { 269, 12, 27, 16, 2, -22 },
  { 310, 14, 20, 16, 1, -20 },
  { 345, 12, 20, 16, 2, -20 },
  { 375, 12, 20, 16, 2, -20 },
  { 405, 12, 20, 16, 2, -20 },
  { 435, 14, 20, 16, 1, -20 },
  { 470, 12, 20, 16, 2, -20 },
  { 500, 12, 20, 16, 2, -20 },
  { 530, 13, 20, 16, 2, -20 },
  { 563, 12, 20, 16, 2, -20 },
  { 593, 12, 20, 16, 2, -20 },
  { 623, 4, 14, 16, 6, -14 },
  { 630, 6, 18, 16, 4, -14 },
  { 644, 13, 13, 16, 2, -15 },
  { 666, 14, 8, 16, 1, -13 },
  { 680, 13, 13, 16, 2, -15 },
  { 702, 10, 20, 16, 3, -20 },
  { 727, 14, 24, 16, 1, -20 },
  { 769, 16, 20, 16, 0, -20 },
  { 809, 12, 20, 16, 2, -20 },
  { 839, 14, 20, 16, 1, -20 },
  { 874, 13, 20, 16, 2, -20 },
  { 907, 12, 20, 16, 3, -20 },
  { 937, 11, 20, 16, 3, -20 },
  { 965, 14, 20, 16, 1, -20 },
  { 1000, 14, 20, 16, 1, -20 },
  { 1035, 10, 20, 16, 3, -20 },
  { 1060, 11, 20, 16, 2, -20 },
  { 1088, 14, 20, 16, 2, -20 },
  { 1123, 12, 20, 16, 3, -20 },
  { 1153, 14, 20, 16, 1, -20 },
  { 1188, 12, 20, 16, 2, -20 },
  { 1218, 14, 20, 16, 1, -20 },
  { 1253, 13, 20, 16, 2, -20 },
  { 1286, 14, 25, 16, 1, -20 },
  { 1330, 13, 20, 16, 2, -20 },
  { 1363, 12, 20, 16, 2, -20 },
  { 1393, 14, 20, 16, 1, -20 },
  { 1428, 12, 20, 16, 2, -20 },
  { 1458, 16, 20, 16, 0, -20 },
  { 1498, 14, 20, 16, 1, -20 },
  { 1533, 14, 20, 16, 1, -20 },
  { 1568, 16, 20, 16, 0, -20 },
  { 1608, 13, 20, 16, 2, -20 },
  { 1641, 7, 25, 16, 5, -20 },
  { 1663, 12, 27, 16, 2, -22 },
  { 1704, 7, 25, 16, 4, -20 },
  { 1726, 14, 11, 16, 1, -20 },
  { 1746, 16, 2, 16, 0, 3 },
  { 1750, 6, 6, 16, 5, -23 },
  { 1755, 12, 15, 16, 2, -15 },
  { 1778, 13, 22, 16, 2, -22 },
  { 1814, 12, 15, 16, 2, -15 },
  { 1837, 13, 22, 16, 1, -22 },
  { 1873, 14, 15, 16, 1, -15 },
  { 1900, 13, 22, 16, 2, -22 },
  { 1936, 13, 20, 16, 1, -15 },
  { 1969, 12, 22, 16, 2, -22 },
  { 2002, 12, 21, 16, 2, -21 },
  { 2034, 10, 26, 16, 2, -21 },
  { 2067, 13, 22, 16, 2, -22 },
  { 2103, 12, 22, 16, 2, -22 },
  { 2136, 14, 15, 16, 1, -15 },
  { 2163, 12, 15, 16, 2, -15 },
  { 2186, 14, 15, 16, 1, -15 },
  { 2213, 13, 20, 16, 2, -15 },
  { 2246, 13, 20, 16, 1, -15 },
  { 2279, 11, 15, 16, 3, -15 },
  { 2300, 12, 15, 16, 2, -15 },
  { 2323, 12, 20, 16, 2, -20 },
  { 2353, 12, 15, 16, 2, -15 },
  { 2376, 14, 15, 16, 1, -15 },
  { 2403, 14, 15, 16, 1, -15 },
  { 2430, 14, 15, 16, 1, -15 },
  { 2457, 14, 20, 16, 1, -15 },
  { 2492, 12, 15, 16, 2, -15 },
  { 2515, 11, 27, 16, 3, -22 },
  { 2553, 2, 27, 16, 7, -22 },
  { 2560, 11, 27, 16, 2, -22 },
  { 2598, 14, 5, 16, 1, -11 },
};

const GFXfont UbuntuMono_Regular32pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular32pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular32pt7bGlyphs,
  0x20, 0x7E, 32
};

#endif // _UBUNTUMONO_REGULAR32PT7B_H_
