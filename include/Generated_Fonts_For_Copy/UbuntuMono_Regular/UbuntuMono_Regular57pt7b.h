#ifndef _UBUNTUMONO_REGULAR57PT7B_H_
#define _UBUNTUMONO_REGULAR57PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular57pt7bBitmaps[] PROGMEM = {
  0x00, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E, 0x3E,
  0x3E, 0x3E, 0x3E, 0x3E, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0x7F, 0xFF, 0xFF, 0x7F, 0x7E, 0x3C,
  0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xF7, 0x83,
  0xDE, 0x0F, 0x70, 0x3D, 0xC0, 0xF7, 0x03, 0xDC, 0x0F, 0x70, 0x19, 0xC0,
  0x60, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x3E,
  0x07, 0x80, 0x1F, 0x03, 0xC0, 0x0F, 0x01, 0xE0, 0x07, 0x81, 0xF0, 0x03,
  0xC0, 0xF8, 0x01, 0xE0, 0x78, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x1E, 0x07, 0x80, 0x1F, 0x03, 0xC0,
  0x0F, 0x01, 0xE0, 0x07, 0x80, 0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7C,
  0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1E, 0x00, 0x78, 0x0F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0x80,
  0xF0, 0x03, 0xC0, 0xF8, 0x01, 0xE0, 0x7C, 0x01, 0xF0, 0x3C, 0x00, 0xF8,
  0x1E, 0x00, 0x78, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x07, 0xC0, 0x0F,
  0x03, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xFF,
  0xFE, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xF8, 0x07, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF6, 0x00, 0x0F, 0xDF, 0x00, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80,
  0x03, 0xCF, 0xF0, 0x01, 0xE3, 0xFE, 0x00, 0xF1, 0xE7, 0x80, 0x3C, 0x70,
  0xF0, 0x1E, 0x3C, 0x1C, 0x07, 0x8F, 0x07, 0x03, 0xC3, 0xC1, 0xC1, 0xE0,
  0xF0, 0x70, 0x78, 0x3C, 0x1C, 0x3C, 0x0F, 0x07, 0x0F, 0x03, 0xC1, 0xC7,
  0x80, 0xF0, 0xF3, 0xC0, 0x1C, 0x3C, 0xF0, 0x07, 0x9E, 0x78, 0x00, 0xFF,
  0xBC, 0x00, 0x3F, 0xCF, 0x00, 0x03, 0xE7, 0x8F, 0x80, 0x01, 0xEF, 0xF0,
  0x00, 0xF3, 0xFE, 0x00, 0x79, 0xE7, 0xC0, 0x1E, 0x70, 0xF0, 0x0F, 0x3C,
  0x1C, 0x03, 0xCF, 0x07, 0x01, 0xE3, 0xC1, 0xC0, 0xF0, 0xF0, 0x70, 0x3C,
  0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x0F, 0x03, 0xC1, 0xC3, 0xC0, 0xF0, 0x71,
  0xE0, 0x1C, 0x3C, 0x78, 0x07, 0x9E, 0x3C, 0x00, 0xFF, 0x9E, 0x00, 0x3F,
  0xC7, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x1F, 0x01, 0xE0, 0x07,
  0x81, 0xF0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7D, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x1E, 0x07, 0xF8, 0x0F,
  0x07, 0xFE, 0x07, 0x87, 0xDF, 0x83, 0x87, 0xC7, 0xE3, 0xC3, 0xE1, 0xF9,
  0xE3, 0xE0, 0x7E, 0xF1, 0xF0, 0x1F, 0xF0, 0xF8, 0x07, 0xF8, 0x7C, 0x01,
  0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0xC7, 0xE0,
  0x3F, 0xE1, 0xFC, 0x7F, 0xF8, 0xFF, 0xFF, 0x7C, 0x3F, 0xFF, 0x1F, 0x07,
  0xFF, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xF7,
  0xBD, 0xEF, 0x39, 0xC0, 0x00, 0x04, 0x00, 0x0E, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3E, 0x00, 0x0E, 0x00, 0x04, 0x10, 0x00, 0x38, 0x00,
  0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0,
  0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x38, 0x00, 0x10, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x81, 0xE0, 0x27, 0x83, 0x87, 0x9F, 0x8E, 0x7E, 0x7F, 0xBF,
  0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x3E, 0xF0, 0x01, 0xF3, 0xE0, 0x0F, 0xC7, 0xC0, 0x7E,
  0x1F, 0x81, 0xF8, 0x3E, 0x01, 0xC0, 0xF0, 0x02, 0x01, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0,
  0xFE, 0x0F, 0xE0, 0xFF, 0x0F, 0xF0, 0xFF, 0x0F, 0xF0, 0x7F, 0x01, 0xE0,
  0x3E, 0x07, 0xC1, 0xFC, 0x7F, 0x87, 0xF0, 0x7C, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x3C, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0x7D,
  0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFF,
  0x07, 0x07, 0xFE, 0x1F, 0x0F, 0xF8, 0x7E, 0x1F, 0xF0, 0xFE, 0x3F, 0xE1,
  0xF8, 0x7F, 0xC1, 0xF0, 0xFF, 0x81, 0xC1, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1E, 0xF8, 0x00, 0x7D, 0xF0, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xE0, 0x3E,
  0x07, 0xE0, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xF7, 0x80,
  0x7E, 0x3C, 0x03, 0xC1, 0xE0, 0x08, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x07, 0xFF, 0xFF, 0x3F, 0xFF, 0xF9, 0xFF, 0xFF, 0xCF, 0xFF, 0xFE, 0x03,
  0xFC, 0x00, 0x3F, 0xFE, 0x03, 0xFF, 0xFC, 0x1F, 0xFF, 0xF8, 0x7E, 0x07,
  0xF1, 0xE0, 0x0F, 0xC2, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xC0,
  0x03, 0xFC, 0x00, 0x7F, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3C,
  0x07, 0xF0, 0x40, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFD, 0x00, 0x07, 0xE7, 0x80,
  0x7F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE1, 0xFF, 0xFE, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xFB, 0xC0, 0x00,
  0xF9, 0xE0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00,
  0x7C, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x3E, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x0F, 0x00, 0x3C,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x83, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x3C, 0x00, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xFC, 0x3F,
  0xFF, 0xE1, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0,
  0x03, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xA0, 0x01, 0xFB, 0xC0, 0x3F,
  0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xC7, 0xFF, 0xF8, 0x03, 0xFE, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x3F,
  0xF0, 0x00, 0xFE, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x9F, 0xE0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xF1,
  0xFC, 0x07, 0xF3, 0xE0, 0x03, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3E, 0xF0,
  0x00, 0x79, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xE0, 0x0F, 0xC7, 0xE0,
  0x1F, 0x0F, 0xE0, 0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x07, 0xFF,
  0x80, 0x03, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x80, 0xFF, 0xFF, 0x83, 0xF0, 0x3F, 0x8F, 0xC0, 0x1F, 0x1F, 0x00,
  0x3E, 0x3C, 0x00, 0x3E, 0x78, 0x00, 0x7C, 0xF0, 0x00, 0xF9, 0xE0, 0x01,
  0xF3, 0xE0, 0x03, 0xC7, 0xE0, 0x0F, 0x87, 0xE0, 0x3E, 0x0F, 0xE0, 0xFC,
  0x0F, 0xFB, 0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0xF8, 0x7F, 0x83, 0xE0, 0x3F, 0x8F, 0x80, 0x1F, 0x9E, 0x00, 0x1F, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0,
  0x01, 0xEF, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0xC0, 0xFE, 0x1F, 0xFF,
  0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xF8, 0x3F, 0x07, 0xF1,
  0xF8, 0x07, 0xE7, 0xC0, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xFC, 0x07, 0xF3,
  0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xF9, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF8, 0x0F,
  0xFF, 0x80, 0x3F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x3C,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F,
  0x3C, 0x07, 0x80, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xE1, 0xFE, 0x0F, 0xE0,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0x80, 0xFE, 0x1F, 0xE1, 0xFE, 0x1F, 0xF1,
  0xFF, 0x0F, 0xF0, 0x7E, 0x03, 0xE0, 0x3E, 0x07, 0xC3, 0xF8, 0xFF, 0x0F,
  0xE0, 0x7C, 0x06, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x78, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x7F, 0xE0,
  0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x01, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x40, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xC0,
  0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x0F, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x78,
  0x1F, 0xD0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7E, 0x07,
  0xE0, 0x7E, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x00, 0x03, 0xEF, 0x80, 0x01, 0xF7, 0xC0,
  0x1F, 0xFB, 0xE0, 0x3F, 0xFD, 0xE0, 0x7F, 0xFE, 0xF0, 0x7F, 0xFF, 0x78,
  0x3F, 0x0F, 0xFC, 0x3F, 0x07, 0xFE, 0x1F, 0x03, 0xFF, 0x0F, 0x81, 0xFF,
  0x87, 0x80, 0xFF, 0xC3, 0xC0, 0x7F, 0xE1, 0xE0, 0x3F, 0xF0, 0xF0, 0x1F,
  0xF8, 0x78, 0x0F, 0xFC, 0x3C, 0x07, 0xDE, 0x1F, 0x03, 0xEF, 0x0F, 0x81,
  0xF7, 0xC3, 0xF0, 0xFB, 0xE1, 0xFF, 0xFD, 0xF0, 0x7F, 0xFE, 0x7C, 0x1F,
  0xFF, 0x3E, 0x01, 0xFC, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x10, 0x03,
  0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xF7, 0x80, 0x00, 0x3C, 0xF8, 0x00,
  0x07, 0x9F, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3E, 0x00, 0x07, 0x87,
  0xC0, 0x01, 0xF0, 0x78, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0x81, 0xF0, 0x01,
  0xF0, 0x1E, 0x00, 0x3C, 0x03, 0xE0, 0x07, 0x80, 0x7C, 0x01, 0xF0, 0x07,
  0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E,
  0x00, 0x3C, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0xE0, 0xF0, 0x00, 0x3E, 0x3E, 0x00, 0x07, 0xC7, 0xC0,
  0x00, 0xF8, 0xF8, 0x00, 0x0F, 0x9E, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0x80, 0x3F,
  0xFC, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80,
  0xFF, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00,
  0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F,
  0x1F, 0x00, 0x7E, 0x3E, 0x03, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xC7, 0xC0, 0x3F, 0xCF, 0x80, 0x0F, 0xDF,
  0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x7C, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0xDF, 0x00,
  0x1F, 0xBE, 0x01, 0xFE, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x3F, 0xFF, 0xF0, 0xFE, 0x03, 0xC3, 0xF0, 0x00, 0x8F, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x83, 0xF8, 0x0F, 0x07, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x01,
  0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0x81, 0xFE, 0x1F,
  0x00, 0x7E, 0x3E, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0x7D, 0xF0,
  0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xFB,
  0xE0, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00, 0x7E, 0x3E,
  0x07, 0xF8, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xBF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xEF, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xF8, 0xFF, 0xFF, 0xC7, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF1, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0xFF, 0xFF, 0xCF, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x3F,
  0xFF, 0xE0, 0xFE, 0x03, 0xC3, 0xF8, 0x01, 0x8F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFC,
  0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xF0,
  0x03, 0xE3, 0xF0, 0x07, 0xC3, 0xF8, 0x0F, 0x87, 0xFF, 0xFF, 0x03, 0xFF,
  0xFE, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x7F, 0xFF,
  0xC3, 0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE2, 0x00, 0x1F, 0x38,
  0x01, 0xF9, 0xF0, 0x3F, 0x9F, 0xFF, 0xFC, 0x7F, 0xFF, 0xC1, 0xFF, 0xF8,
  0x01, 0xFF, 0x00, 0xF0, 0x00, 0x7C, 0xF0, 0x00, 0xFC, 0xF0, 0x00, 0xF8,
  0xF0, 0x01, 0xF0, 0xF0, 0x03, 0xF0, 0xF0, 0x07, 0xE0, 0xF0, 0x0F, 0xC0,
  0xF0, 0x0F, 0x80, 0xF0, 0x1F, 0x00, 0xF0, 0x3F, 0x00, 0xF0, 0x7E, 0x00,
  0xF0, 0xFC, 0x00, 0xF1, 0xF8, 0x00, 0xF3, 0xF0, 0x00, 0xF3, 0xE0, 0x00,
  0xF7, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00,
  0xF3, 0xF8, 0x00, 0xF1, 0xFC, 0x00, 0xF0, 0xFE, 0x00, 0xF0, 0x7F, 0x00,
  0xF0, 0x3F, 0x80, 0xF0, 0x1F, 0x80, 0xF0, 0x0F, 0xC0, 0xF0, 0x07, 0xE0,
  0xF0, 0x03, 0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xF8, 0xF0, 0x00, 0xFC,
  0xF0, 0x00, 0x7C, 0xF0, 0x00, 0x7E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3F,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x3E, 0x00, 0x3C, 0x1F,
  0x00, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xE1,
  0xFC, 0x07, 0xF0, 0xFE, 0x03, 0xF8, 0x77, 0x03, 0xDC, 0x7B, 0x81, 0xEE,
  0x3D, 0xE0, 0xE7, 0x1E, 0x70, 0x73, 0x8F, 0x38, 0x79, 0xC7, 0x9E, 0x38,
  0xE3, 0xC7, 0x1C, 0x79, 0xE3, 0x9E, 0x3C, 0xF1, 0xEE, 0x1E, 0x78, 0xF7,
  0x0F, 0x3C, 0x3F, 0x87, 0x9E, 0x1F, 0x83, 0xCF, 0x0F, 0xC1, 0xE7, 0x83,
  0xE0, 0xF7, 0xC1, 0xF0, 0x7B, 0xE0, 0x00, 0x3D, 0xF0, 0x00, 0x1E, 0xF8,
  0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF,
  0x80, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3D, 0xE0, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF8, 0x03, 0xFD, 0xE0, 0x0F, 0xF7, 0xC0, 0x3F, 0xCF,
  0x00, 0xFF, 0x3E, 0x03, 0xFC, 0x78, 0x0F, 0xF1, 0xF0, 0x3F, 0xC3, 0xC0,
  0xFF, 0x0F, 0x83, 0xFC, 0x1E, 0x0F, 0xF0, 0x7C, 0x3F, 0xC0, 0xF0, 0xFF,
  0x03, 0xE3, 0xFC, 0x07, 0x8F, 0xF0, 0x1E, 0x3F, 0xC0, 0x3C, 0xFF, 0x00,
  0xF3, 0xFC, 0x01, 0xEF, 0xF0, 0x07, 0xBF, 0xC0, 0x1F, 0xFF, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00,
  0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x01,
  0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0x7C,
  0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x01,
  0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0,
  0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF,
  0x80, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x7E, 0x07, 0xF0,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x3F, 0xFC, 0x03, 0xFF, 0xFE, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8,
  0xF8, 0x07, 0xF3, 0xE0, 0x07, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xFB,
  0xE0, 0x1F, 0xCF, 0xFF, 0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xFF,
  0xF0, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x01, 0xF8, 0x1F, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x01, 0xF8,
  0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3C, 0x00, 0x0F, 0xBE, 0x00, 0x07,
  0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F,
  0x00, 0x07, 0xCF, 0x80, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE0,
  0x7E, 0x07, 0xF0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x3F, 0xFC, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x0F, 0x80, 0x7F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00,
  0xF3, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xEF, 0x80, 0x07, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x01, 0xF1, 0xF0, 0x1F, 0xE3,
  0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xE0,
  0x0F, 0x87, 0xC0, 0x0F, 0x0F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0, 0x00, 0x7F, 0xE0, 0x00,
  0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x87, 0xFF, 0xFE,
  0x3F, 0x80, 0xF0, 0xF8, 0x00, 0x47, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7D, 0x80, 0x03, 0xF7,
  0xC0, 0x3F, 0x9F, 0xFF, 0xFC, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x00, 0x7F,
  0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0xC0,
  0x1F, 0x0F, 0xC0, 0xFE, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7B, 0xE0,
  0x00, 0x1F, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8, 0x00, 0x0F,
  0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87, 0xC0,
  0x01, 0xE0, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xE0,
  0x3E, 0x00, 0x7C, 0x03, 0xC0, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x0F, 0x80,
  0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3C, 0x00,
  0x7C, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x1F, 0x0F,
  0x80, 0x01, 0xF1, 0xF0, 0x00, 0x3E, 0x3C, 0x00, 0x07, 0xCF, 0x80, 0x00,
  0x7D, 0xF0, 0x00, 0x0F, 0xBC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xF7, 0xC0, 0x00, 0x7B, 0xE0, 0x00,
  0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0x7C, 0x00, 0x07, 0xBE, 0x00,
  0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0xC1, 0xE0, 0x7B, 0xE0,
  0xF8, 0x3C, 0xF0, 0xFC, 0x1E, 0x78, 0x7E, 0x0F, 0x3C, 0x3F, 0x87, 0x9E,
  0x3D, 0xC3, 0xCF, 0x1E, 0xE1, 0xE7, 0x8E, 0x78, 0xF3, 0xCF, 0x3C, 0x71,
  0xE7, 0x8E, 0x38, 0xF3, 0x87, 0x9C, 0x7B, 0xC3, 0xCE, 0x3D, 0xE0, 0xE7,
  0x1E, 0xE0, 0x7B, 0x8F, 0x70, 0x3D, 0xC3, 0xF8, 0x0F, 0xE1, 0xF8, 0x07,
  0xF0, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x1F, 0x00,
  0x3E, 0x0F, 0x80, 0x0F, 0x00, 0x7C, 0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE3,
  0xF0, 0x01, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3E, 0x03, 0xE0, 0x1F,
  0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xFC,
  0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFF, 0xC0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xC7, 0xC0, 0x03,
  0xE1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0,
  0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x7C, 0xF8,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x07,
  0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xC0, 0xF8,
  0x01, 0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x01, 0xF0,
  0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F, 0xFF,
  0xFC, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E,
  0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0x80, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x3E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF,
  0x80, 0x01, 0xF7, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC1, 0xF0, 0x0F, 0x81, 0xF0, 0x1F, 0x00, 0xF8, 0x1F, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x1F, 0x78, 0x00, 0x0E, 0x10, 0x00, 0x08, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x10, 0x0E, 0x07,
  0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1E, 0x03, 0x80, 0x40, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0C, 0x03, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x1F, 0xF7, 0xC3, 0xFF, 0xFF, 0x1F, 0xFF, 0xFC, 0xFF, 0xFF,
  0xF7, 0xF0, 0x07, 0xDF, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xFC, 0x01, 0xF3, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x38, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x9F, 0xC0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x8F,
  0xF0, 0x7F, 0x3E, 0x00, 0x7E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07,
  0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x07, 0xEF, 0x80, 0x3F, 0x3E, 0x03,
  0xFC, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE1,
  0xFE, 0x01, 0x87, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFC, 0x01, 0x83, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFE,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xE3, 0xC0, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF1, 0xF8, 0x1F, 0xCF, 0xC0, 0x1F, 0x7E, 0x00,
  0x3D, 0xF0, 0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xF7, 0xC0, 0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x3C, 0xF8, 0x00,
  0xF3, 0xF0, 0x03, 0xC7, 0xF0, 0x0F, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xFF, 0xE0, 0x07,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0x7C, 0x3E,
  0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x78, 0x00, 0x1F, 0xF8,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x0C, 0x0F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F,
  0x81, 0xE0, 0x7E, 0x00, 0x40, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF9,
  0xFF, 0xFF, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xC0, 0x7C, 0xFC, 0x00, 0xF3, 0xE0,
  0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0xE0, 0x03, 0xCF, 0xC0,
  0x1F, 0x3F, 0x81, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF,
  0x00, 0xFE, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE3, 0x80, 0x3F, 0x8F, 0xFF, 0xFC, 0x3F, 0xFF,
  0xE0, 0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xEF, 0xF0, 0x1F, 0xFF,
  0xE0, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0x3F, 0x01, 0xF9, 0xF0, 0x07, 0xEF,
  0x80, 0x1F, 0x7C, 0x00, 0xFB, 0xE0, 0x03, 0xDF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07,
  0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFE, 0x0C, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x40, 0x0F, 0x9E,
  0x07, 0xE7, 0xFF, 0xF3, 0xFF, 0xF8, 0x7F, 0xFC, 0x03, 0xFC, 0x00, 0x38,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x3F, 0x7C, 0x00, 0xFC, 0xF8, 0x03, 0xF1,
  0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x07, 0xC0, 0xFC, 0x0F, 0x83, 0xF0, 0x1F,
  0x0F, 0xC0, 0x3E, 0x3F, 0x00, 0x7D, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0x80, 0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xBF, 0x80, 0x1F, 0x1F,
  0x80, 0x3E, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0xF8, 0x1F, 0x81, 0xF0, 0x1F,
  0x83, 0xE0, 0x1F, 0x87, 0xC0, 0x1F, 0x8F, 0x80, 0x1F, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x78, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x60, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x03,
  0xF8, 0x1F, 0xC1, 0xF0, 0xFF, 0xF7, 0xFC, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFE, 0xF8, 0x7E, 0x1F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3C, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E, 0x0F, 0xF8, 0x3E,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0x0F, 0xFC, 0x07, 0xFF, 0xF8,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0x80, 0x7E, 0x7C, 0x01, 0xFB, 0xE0,
  0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x00, 0xF7, 0xC0, 0x07, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00,
  0x1F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x1F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF8, 0x1F, 0xC1, 0xFC, 0x3F, 0x00, 0x7C, 0x3E, 0x00,
  0x7E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00,
  0x3E, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7C, 0x1F, 0xC1, 0xFC, 0x0F, 0xFF,
  0xF8, 0x07, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xFC,
  0x03, 0xFF, 0xFC, 0x0F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xF8, 0x0F, 0xF3,
  0xE0, 0x0F, 0xCF, 0x80, 0x1F, 0xBE, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xFF,
  0x80, 0x0F, 0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xFB, 0xF8, 0x1F, 0xCF, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x83, 0xE7, 0xF8, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0x1F, 0xC0,
  0x3C, 0xFC, 0x00, 0xF3, 0xE0, 0x03, 0xDF, 0x00, 0x0F, 0x7C, 0x00, 0x3D,
  0xF0, 0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x0F, 0x7C, 0x00, 0x3D, 0xF0, 0x00,
  0xF7, 0xC0, 0x03, 0xCF, 0x80, 0x0F, 0x3F, 0x00, 0x7C, 0x7E, 0x07, 0xF1,
  0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0x03, 0xFF, 0xBC, 0x03, 0xF8, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x03, 0xFF, 0xCF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xE0, 0x0D,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFF, 0xFF,
  0xC7, 0xE0, 0x06, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF4, 0x00, 0x1F, 0xFC, 0x01, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x01,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFE, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x60, 0x3F, 0xFF,
  0x80, 0x7F, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0x7C,
  0x00, 0xF7, 0xF0, 0x0F, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0,
  0x3F, 0xF8, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xCF,
  0x80, 0x03, 0xE7, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0xF8, 0x3F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x07,
  0xC0, 0x0F, 0x87, 0xC0, 0x03, 0xC3, 0xE0, 0x01, 0xF1, 0xE0, 0x00, 0xF9,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xDE, 0x00, 0x00, 0xF7, 0x81, 0xE0, 0x3D, 0xE0,
  0x7C, 0x1F, 0x78, 0x1F, 0x07, 0x9E, 0x07, 0xC1, 0xE7, 0xC3, 0xF0, 0x79,
  0xF0, 0xFE, 0x1E, 0x3C, 0x3F, 0x87, 0x8F, 0x1E, 0xE1, 0xE3, 0xC7, 0x3C,
  0xF0, 0xF1, 0xCF, 0x3C, 0x3C, 0xF1, 0xCF, 0x07, 0xB8, 0x7B, 0xC1, 0xFE,
  0x0E, 0xF0, 0x7F, 0x83, 0xB8, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x1F, 0x80,
  0xF8, 0x07, 0xE0, 0x3E, 0x01, 0xF8, 0x0F, 0x00, 0x3C, 0x03, 0xC0, 0x0F,
  0x00, 0xFC, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x07,
  0xCF, 0x80, 0x03, 0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xEF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xF1, 0xF0, 0x01, 0xF0, 0x7C,
  0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0xF8, 0x03, 0xE0, 0xF8, 0x00,
  0xF8, 0xF8, 0x00, 0x7C, 0x78, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x7C, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x78, 0x07, 0x80, 0xF8, 0x07,
  0xC0, 0xF8, 0x07, 0xC0, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE1, 0xF0, 0x01,
  0xE1, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF3, 0xE0, 0x00, 0xFB, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xE0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xF7, 0xFF,
  0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xFF, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x00, 0x1F, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0xFF, 0xF0,
  0x0F, 0xFF, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F,
  0xF0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xFF, 0x80,
  0xFF, 0xF0, 0x0F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x06, 0x1F,
  0xF0, 0x07, 0x3F, 0xFC, 0x0F, 0x7F, 0xFE, 0x1F, 0x78, 0x7F, 0xFE, 0xF0,
  0x1F, 0xFE, 0xF0, 0x07, 0xFC, 0x70, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Regular57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 29, 0, -1 },
  { 1, 8, 35, 29, 10, -35 },
  { 36, 14, 14, 29, 7, -39 },
  { 61, 25, 35, 29, 2, -35 },
  { 171, 22, 46, 29, 3, -40 },
  { 298, 26, 35, 29, 1, -35 },
  { 412, 25, 35, 29, 2, -35 },
  { 522, 5, 15, 29, 12, -39 },
  { 532, 16, 50, 29, 6, -40 },
  { 632, 16, 50, 29, 6, -40 },
  { 732, 22, 21, 29, 3, -35 },
  { 790, 23, 25, 29, 3, -27 },
  { 862, 12, 16, 29, 8, -8 },
  { 886, 13, 4, 29, 8, -16 },
  { 893, 8, 8, 29, 10, -8 },
  { 901, 21, 49, 29, 4, -40 },
  { 1030, 23, 35, 29, 3, -35 },
  { 1131, 21, 35, 29, 4, -35 },
  { 1223, 22, 35, 29, 3, -35 },
  { 1320, 22, 35, 29, 3, -35 },
  { 1417, 25, 35, 29, 2, -35 },
  { 1527, 21, 35, 29, 4, -35 },
  { 1619, 23, 35, 29, 3, -35 },
  { 1720, 22, 35, 29, 4, -35 },
  { 1817, 23, 35, 29, 3, -35 },
  { 1918, 22, 35, 29, 3, -35 },
  { 2015, 8, 26, 29, 10, -26 },
  { 2041, 12, 34, 29, 7, -26 },
  { 2092, 23, 23, 29, 3, -26 },
  { 2159, 23, 15, 29, 3, -23 },
  { 2203, 23, 23, 29, 3, -26 },
  { 2270, 18, 35, 29, 5, -35 },
  { 2349, 25, 43, 29, 2, -35 },
  { 2484, 27, 35, 29, 1, -35 },
  { 2603, 23, 35, 29, 3, -35 },
  { 2704, 23, 35, 29, 3, -35 },
  { 2805, 23, 35, 29, 3, -35 },
  { 2906, 21, 35, 29, 5, -35 },
  { 2998, 20, 35, 29, 5, -35 },
  { 3086, 23, 35, 29, 3, -35 },
  { 3187, 23, 35, 29, 3, -35 },
  { 3288, 18, 35, 29, 5, -35 },
  { 3367, 21, 35, 29, 3, -35 },
  { 3459, 24, 35, 29, 4, -35 },
  { 3564, 21, 35, 29, 5, -35 },
  { 3656, 25, 35, 29, 2, -35 },
  { 3766, 22, 35, 29, 3, -35 },
  { 3863, 25, 35, 29, 2, -35 },
  { 3973, 22, 35, 29, 4, -35 },
  { 4070, 25, 44, 29, 2, -35 },
  { 4208, 23, 35, 29, 3, -35 },
  { 4309, 22, 35, 29, 3, -35 },
  { 4406, 24, 35, 29, 2, -35 },
  { 4511, 23, 35, 29, 3, -35 },
  { 4612, 27, 35, 29, 1, -35 },
  { 4731, 25, 35, 29, 2, -35 },
  { 4841, 26, 35, 29, 1, -35 },
  { 4955, 27, 35, 29, 1, -35 },
  { 5074, 23, 35, 29, 3, -35 },
  { 5175, 14, 49, 29, 8, -40 },
  { 5261, 21, 49, 29, 4, -40 },
  { 5390, 13, 49, 29, 7, -40 },
  { 5470, 24, 19, 29, 2, -35 },
  { 5527, 28, 4, 29, 0, 5 },
  { 5541, 10, 10, 29, 9, -40 },
  { 5554, 22, 26, 29, 3, -26 },
  { 5626, 22, 40, 29, 4, -40 },
  { 5736, 23, 26, 29, 3, -26 },
  { 5811, 22, 40, 29, 2, -40 },
  { 5921, 24, 26, 29, 2, -26 },
  { 5999, 23, 40, 29, 4, -40 },
  { 6114, 22, 35, 29, 2, -26 },
  { 6211, 21, 40, 29, 4, -40 },
  { 6316, 23, 37, 29, 3, -37 },
  { 6423, 18, 46, 29, 4, -37 },
  { 6527, 23, 40, 29, 4, -40 },
  { 6642, 23, 40, 29, 3, -40 },
  { 6757, 24, 26, 29, 2, -26 },
  { 6835, 21, 26, 29, 4, -26 },
  { 6904, 24, 26, 29, 2, -26 },
  { 6982, 22, 35, 29, 4, -26 },
  { 7079, 22, 35, 29, 2, -26 },
  { 7176, 19, 26, 29, 6, -26 },
  { 7238, 21, 26, 29, 4, -26 },
  { 7307, 22, 34, 29, 4, -34 },
  { 7401, 20, 26, 29, 4, -26 },
  { 7466, 25, 26, 29, 2, -26 },
  { 7548, 26, 26, 29, 1, -26 },
  { 7633, 25, 26, 29, 2, -26 },
  { 7715, 24, 35, 29, 2, -26 },
  { 7820, 20, 26, 29, 4, -26 },
  { 7885, 20, 49, 29, 4, -40 },
  { 8008, 4, 49, 29, 12, -40 },
  { 8033, 20, 49, 29, 4, -40 },
  { 8156, 24, 8, 29, 2, -19 },
};

const GFXfont UbuntuMono_Regular57pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular57pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular57pt7bGlyphs,
  0x20, 0x7E, 57
};

#endif // _UBUNTUMONO_REGULAR57PT7B_H_
