#ifndef _UBUNTUMONO_REGULAR15PT7B_H_
#define _UBUNTUMONO_REGULAR15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular15pt7bBitmaps[] PROGMEM = {
  0x00, 0xAA, 0xA8, 0xC0, 0xBB, 0xAA, 0x14, 0x4B, 0xF9, 0x22, 0x45, 0xBF,
  0xA4, 0x48, 0x20, 0x87, 0xA0, 0xC1, 0xE0, 0xE3, 0xF8, 0x82, 0x00, 0x63,
  0x4A, 0x75, 0x47, 0x63, 0x4A, 0xA5, 0x46, 0x38, 0x91, 0x21, 0xC7, 0x6B,
  0xB3, 0x26, 0x7A, 0xF0, 0x36, 0x48, 0x88, 0x88, 0x84, 0x62, 0x8C, 0x62,
  0x31, 0x13, 0x26, 0xC8, 0x22, 0xA7, 0x0C, 0x59, 0x20, 0x20, 0x82, 0x3F,
  0x20, 0x82, 0x00, 0x67, 0x00, 0xE0, 0xC0, 0x08, 0x46, 0x21, 0x18, 0x84,
  0x62, 0x11, 0x00, 0x73, 0x28, 0xEF, 0xB6, 0x38, 0xF2, 0x70, 0x31, 0xCD,
  0x04, 0x10, 0x41, 0x04, 0x7C, 0x72, 0x20, 0x82, 0x10, 0x84, 0x30, 0xFC,
  0xF0, 0x20, 0x82, 0x30, 0x20, 0xC2, 0xF8, 0x18, 0xE2, 0x92, 0x8A, 0x2F,
  0xC2, 0x08, 0x79, 0x04, 0x1C, 0x18, 0x30, 0xC2, 0xF0, 0x19, 0x8C, 0x3E,
  0x8A, 0x38, 0xF2, 0x78, 0xFC, 0x21, 0x84, 0x30, 0x82, 0x08, 0x60, 0x7A,
  0x28, 0xF2, 0x72, 0x28, 0x63, 0x78, 0x73, 0x28, 0xE3, 0x8D, 0xF0, 0x86,
  0xE0, 0xC0, 0x30, 0x60, 0x00, 0xDE, 0x0D, 0xC8, 0x1C, 0x0C, 0xFC, 0x00,
  0x3F, 0xC1, 0xC0, 0xDE, 0xC0, 0xF0, 0x42, 0x11, 0x10, 0x80, 0x60, 0x79,
  0x38, 0x67, 0xA6, 0x9A, 0x67, 0x81, 0x03, 0x80, 0x18, 0x70, 0xA1, 0x26,
  0x48, 0x9F, 0xA1, 0xC2, 0xF2, 0x28, 0xA2, 0xF2, 0x38, 0x63, 0xF8, 0x39,
  0x18, 0x20, 0x82, 0x08, 0x31, 0x3C, 0xF2, 0x28, 0xE1, 0x86, 0x18, 0xE2,
  0xF0, 0xFF, 0x0C, 0x30, 0xFB, 0x0C, 0x30, 0xFC, 0xFF, 0x0C, 0x30, 0xFB,
  0x0C, 0x30, 0xC0, 0x39, 0x18, 0x20, 0x82, 0x18, 0x71, 0x7C, 0x86, 0x18,
  0x61, 0xFE, 0x18, 0x61, 0x84, 0xF9, 0x08, 0x42, 0x10, 0x84, 0xF8, 0x78,
  0x42, 0x10, 0x84, 0x31, 0xF0, 0x8E, 0x29, 0x2C, 0xE2, 0x89, 0xA2, 0x84,
  0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xFC, 0x64, 0xCD, 0xAA, 0xD5, 0xA8,
  0x50, 0xA1, 0x42, 0x87, 0x1C, 0x69, 0xB6, 0x59, 0x63, 0x8C, 0x3C, 0x89,
  0x0E, 0x1C, 0x38, 0x50, 0xA2, 0x3C, 0xFA, 0x38, 0x61, 0x8B, 0xE8, 0x20,
  0x80, 0x3C, 0x89, 0x0E, 0x1C, 0x38, 0x50, 0xA2, 0x3C, 0x30, 0x38, 0xF2,
  0x28, 0xA2, 0xF2, 0x48, 0xA2, 0x8C, 0x7B, 0x28, 0x30, 0x30, 0x20, 0xE3,
  0xF8, 0xFC, 0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0x86, 0x18, 0x61, 0x86,
  0x18, 0xE2, 0x78, 0xC2, 0x85, 0x1A, 0x26, 0x45, 0x8A, 0x1C, 0x18, 0x42,
  0x85, 0x0A, 0x15, 0x2B, 0x5A, 0xB3, 0x44, 0x46, 0xC8, 0xB0, 0xC1, 0x87,
  0x0B, 0x32, 0x42, 0xC2, 0x8D, 0x91, 0x63, 0x82, 0x04, 0x08, 0x10, 0xFC,
  0x21, 0x84, 0x21, 0x84, 0x20, 0xFC, 0xF8, 0x88, 0x88, 0x88, 0x88, 0xF0,
  0x82, 0x10, 0xC2, 0x10, 0xC2, 0x10, 0xC2, 0x10, 0xE4, 0x92, 0x49, 0x27,
  0x80, 0x31, 0xC5, 0xA2, 0x84, 0xFE, 0x48, 0x80, 0x78, 0x42, 0xF8, 0xC5,
  0xE0, 0x82, 0x08, 0x3E, 0x8A, 0x18, 0x61, 0x8B, 0xC0, 0x7F, 0x08, 0x20,
  0x83, 0x07, 0xC0, 0x08, 0x42, 0xF8, 0xC6, 0x31, 0xCB, 0xC0, 0x7B, 0x28,
  0x7F, 0x83, 0x07, 0x80, 0x3C, 0x86, 0x3E, 0x61, 0x86, 0x18, 0x61, 0x80,
  0x7E, 0x63, 0x18, 0xC5, 0xE1, 0xF0, 0x84, 0x21, 0xF8, 0xC6, 0x31, 0x8C,
  0x40, 0x60, 0x0E, 0x08, 0x20, 0x82, 0x08, 0x3C, 0x18, 0x1E, 0x10, 0x84,
  0x21, 0x08, 0xFC, 0x82, 0x08, 0x22, 0x9A, 0x8E, 0x2C, 0x8A, 0x30, 0xE0,
  0x82, 0x08, 0x20, 0x82, 0x08, 0x20, 0xF0, 0xFA, 0x9A, 0x69, 0x86, 0x18,
  0x40, 0xFC, 0x63, 0x18, 0xC6, 0x20, 0x73, 0x28, 0x61, 0x87, 0x27, 0x00,
  0xF2, 0x28, 0xE1, 0x86, 0x2F, 0xA0, 0x80, 0x7E, 0x63, 0x18, 0xC5, 0xE1,
  0x08, 0xF4, 0x21, 0x08, 0x42, 0x00, 0x7A, 0x0C, 0x1C, 0x0A, 0x2F, 0x80,
  0x61, 0x8F, 0xD8, 0x61, 0x86, 0x08, 0x3C, 0x8C, 0x63, 0x18, 0xE5, 0xE0,
  0x42, 0x8D, 0x91, 0x22, 0x87, 0x06, 0x00, 0x83, 0x85, 0x4A, 0xD7, 0xAD,
  0x99, 0x00, 0x44, 0x58, 0xE0, 0xC3, 0x8C, 0x91, 0x80, 0x8F, 0x34, 0x92,
  0x78, 0xC3, 0x08, 0xC0, 0xF8, 0xC4, 0x46, 0x63, 0xE0, 0x39, 0x08, 0x42,
  0x60, 0x84, 0x21, 0x08, 0x70, 0xFF, 0xF0, 0xE1, 0x84, 0x21, 0x04, 0x42,
  0x10, 0x8D, 0xC0, 0xE6, 0x60,
};

const GFXglyph UbuntuMono_Regular15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 9, 8, 3, -9 },
  { 4, 4, 4, 8, 2, -10 },
  { 6, 7, 9, 8, 0, -9 },
  { 14, 6, 11, 8, 1, -10 },
  { 23, 7, 9, 8, 0, -9 },
  { 31, 7, 9, 8, 0, -9 },
  { 39, 1, 4, 8, 3, -10 },
  { 40, 4, 12, 8, 2, -9 },
  { 46, 4, 12, 8, 2, -9 },
  { 52, 6, 6, 8, 1, -9 },
  { 57, 6, 7, 8, 1, -7 },
  { 63, 3, 3, 8, 2, -1 },
  { 65, 3, 1, 8, 2, -4 },
  { 66, 2, 1, 8, 3, -1 },
  { 67, 5, 12, 8, 1, -10 },
  { 75, 6, 9, 8, 1, -9 },
  { 82, 6, 9, 8, 1, -9 },
  { 89, 6, 9, 8, 1, -9 },
  { 96, 6, 9, 8, 1, -9 },
  { 103, 6, 9, 8, 1, -9 },
  { 110, 6, 9, 8, 1, -9 },
  { 117, 6, 9, 8, 1, -9 },
  { 124, 6, 9, 8, 1, -9 },
  { 131, 6, 9, 8, 1, -9 },
  { 138, 6, 9, 8, 1, -9 },
  { 145, 2, 6, 8, 3, -6 },
  { 147, 3, 8, 8, 2, -6 },
  { 150, 6, 5, 8, 1, -6 },
  { 154, 6, 4, 8, 1, -6 },
  { 157, 6, 5, 8, 1, -6 },
  { 161, 5, 9, 8, 1, -9 },
  { 167, 6, 11, 8, 1, -9 },
  { 176, 7, 9, 8, 0, -9 },
  { 184, 6, 9, 8, 1, -9 },
  { 191, 6, 9, 8, 1, -9 },
  { 198, 6, 9, 8, 1, -9 },
  { 205, 6, 9, 8, 1, -9 },
  { 212, 6, 9, 8, 1, -9 },
  { 219, 6, 9, 8, 1, -9 },
  { 226, 6, 9, 8, 1, -9 },
  { 233, 5, 9, 8, 1, -9 },
  { 239, 5, 9, 8, 1, -9 },
  { 245, 6, 9, 8, 1, -9 },
  { 252, 6, 9, 8, 1, -9 },
  { 259, 7, 9, 8, 0, -9 },
  { 267, 6, 9, 8, 1, -9 },
  { 274, 7, 9, 8, 0, -9 },
  { 282, 6, 9, 8, 1, -9 },
  { 289, 7, 11, 8, 0, -9 },
  { 299, 6, 9, 8, 1, -9 },
  { 306, 6, 9, 8, 1, -9 },
  { 313, 6, 9, 8, 1, -9 },
  { 320, 6, 9, 8, 1, -9 },
  { 327, 7, 9, 8, 0, -9 },
  { 335, 7, 9, 8, 0, -9 },
  { 343, 7, 9, 8, 0, -9 },
  { 351, 7, 9, 8, 0, -9 },
  { 359, 6, 9, 8, 1, -9 },
  { 366, 4, 11, 8, 2, -9 },
  { 372, 5, 12, 8, 1, -10 },
  { 380, 3, 11, 8, 2, -9 },
  { 385, 6, 5, 8, 1, -9 },
  { 389, 7, 1, 8, 0, 1 },
  { 390, 3, 3, 8, 2, -11 },
  { 392, 5, 7, 8, 1, -7 },
  { 397, 6, 10, 8, 1, -10 },
  { 405, 6, 7, 8, 1, -7 },
  { 411, 5, 10, 8, 1, -10 },
  { 418, 6, 7, 8, 1, -7 },
  { 424, 6, 10, 8, 1, -10 },
  { 432, 5, 9, 8, 1, -7 },
  { 438, 5, 10, 8, 1, -10 },
  { 445, 6, 9, 8, 1, -9 },
  { 452, 5, 11, 8, 1, -9 },
  { 459, 6, 10, 8, 1, -10 },
  { 467, 6, 10, 8, 1, -10 },
  { 475, 6, 7, 8, 1, -7 },
  { 481, 5, 7, 8, 1, -7 },
  { 486, 6, 7, 8, 1, -7 },
  { 492, 6, 9, 8, 1, -7 },
  { 499, 5, 9, 8, 1, -7 },
  { 505, 5, 7, 8, 2, -7 },
  { 510, 6, 7, 8, 1, -7 },
  { 516, 6, 9, 8, 1, -9 },
  { 523, 5, 7, 8, 1, -7 },
  { 528, 7, 7, 8, 0, -7 },
  { 535, 7, 7, 8, 0, -7 },
  { 542, 7, 7, 8, 0, -7 },
  { 549, 6, 9, 8, 1, -7 },
  { 556, 5, 7, 8, 1, -7 },
  { 561, 5, 12, 8, 1, -10 },
  { 569, 1, 12, 8, 3, -10 },
  { 571, 5, 12, 8, 1, -10 },
  { 579, 6, 2, 8, 1, -5 },
};

const GFXfont UbuntuMono_Regular15pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular15pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular15pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _UBUNTUMONO_REGULAR15PT7B_H_
