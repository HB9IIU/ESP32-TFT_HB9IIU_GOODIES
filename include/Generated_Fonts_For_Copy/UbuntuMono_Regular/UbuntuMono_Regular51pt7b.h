#ifndef _UBUNTUMONO_REGULAR51PT7B_H_
#define _UBUNTUMONO_REGULAR51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular51pt7bBitmaps[] PROGMEM = {
  0x00, 0x7C, 0xF9, 0xF3, 0xE7, 0xCF, 0x9F, 0x3E, 0x7C, 0xF9, 0xF3, 0xE7,
  0xC7, 0x8F, 0x1E, 0x3C, 0x70, 0xE1, 0xC3, 0x80, 0x00, 0x00, 0x00, 0x71,
  0xFF, 0xFF, 0xFF, 0xDF, 0x9C, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x0F, 0xE0,
  0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0E, 0xE0, 0x6E, 0x06, 0xE0,
  0x60, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0, 0x03, 0x81, 0xE0, 0x0F, 0x03,
  0xC0, 0x1E, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0xE0, 0x78,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x3C, 0x1E, 0x00, 0x70, 0x3C, 0x01, 0xE0, 0x78, 0x03, 0xC0, 0xF0, 0x07,
  0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1C, 0x0F, 0x00, 0x78, 0x1E, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x07,
  0x80, 0x3C, 0x0F, 0x00, 0x78, 0x1C, 0x00, 0xF0, 0x78, 0x01, 0xE0, 0xF0,
  0x03, 0x81, 0xE0, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x3F, 0xE0,
  0x0F, 0xFF, 0xC1, 0xFF, 0xFC, 0x3F, 0xFF, 0xC7, 0xE0, 0x18, 0x7C, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x03, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x40, 0x01, 0xEF, 0x80, 0x7E,
  0xFF, 0xFF, 0xCF, 0xFF, 0xFC, 0x7F, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x1F, 0x00, 0x1E, 0x3F, 0x80, 0x1C, 0x7F, 0xC0, 0x3C, 0x71, 0xC0,
  0x78, 0xF1, 0xE0, 0x70, 0xE0, 0xE0, 0xF0, 0xE0, 0xE0, 0xE0, 0xE0, 0xE1,
  0xE0, 0xE0, 0xE3, 0xC0, 0xE0, 0xE3, 0x80, 0xE0, 0xE7, 0x80, 0xF1, 0xE7,
  0x00, 0x71, 0xCF, 0x00, 0x7F, 0xDE, 0x00, 0x3F, 0x9C, 0x00, 0x1F, 0x3C,
  0x00, 0x00, 0x38, 0xF0, 0x00, 0x7B, 0xFC, 0x00, 0xF3, 0xFC, 0x00, 0xE7,
  0x9E, 0x01, 0xE7, 0x0E, 0x01, 0xC7, 0x0E, 0x03, 0xC7, 0x0F, 0x07, 0x87,
  0x0F, 0x07, 0x07, 0x0F, 0x0F, 0x07, 0x0F, 0x0E, 0x07, 0x0E, 0x1E, 0x07,
  0x0E, 0x3C, 0x07, 0x9E, 0x38, 0x03, 0xFC, 0x78, 0x03, 0xFC, 0x70, 0x00,
  0xF0, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x3F, 0x1F, 0x00, 0xF0, 0x3C, 0x03, 0xC0, 0x78, 0x0F, 0x01, 0xC0, 0x3C,
  0x0F, 0x00, 0xF0, 0x3C, 0x03, 0xC1, 0xE0, 0x07, 0x87, 0x80, 0x1F, 0x7C,
  0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x1C, 0x1F, 0xE0, 0x70,
  0xFF, 0xC3, 0xC7, 0xCF, 0x8F, 0x1E, 0x1F, 0x3C, 0xF0, 0x3E, 0xE3, 0xC0,
  0x7F, 0x8F, 0x00, 0xFE, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x1F,
  0x8F, 0x80, 0xFE, 0x3F, 0x8F, 0xFC, 0x7F, 0xFE, 0xF0, 0xFF, 0xF1, 0xE1,
  0xFF, 0x87, 0x81, 0xF8, 0x1F, 0xFF, 0xFE, 0xF7, 0xBD, 0xEF, 0x7B, 0xDC,
  0xE7, 0x38, 0x00, 0x10, 0x00, 0xE0, 0x0F, 0x80, 0x7F, 0x03, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x00, 0x3C,
  0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF8, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x10, 0x20, 0x01, 0xC0,
  0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xC0, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x01, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x00, 0xF0,
  0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x0F, 0x80,
  0x1C, 0x00, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0x04, 0x78, 0xE1, 0xEF, 0xEE, 0x7E,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC,
  0x00, 0x79, 0xE0, 0x0F, 0x9F, 0x01, 0xF1, 0xF8, 0x3F, 0x0F, 0x80, 0xE0,
  0x70, 0x04, 0x04, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x78, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x80, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78,
  0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x3C, 0x00, 0x0F, 0x07, 0xE3, 0xFC, 0xFF, 0x3F, 0xC7, 0xF0, 0xFC, 0x1E,
  0x07, 0x83, 0xC3, 0xE3, 0xF0, 0xF8, 0x38, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x03, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0x81, 0xF8,
  0x7E, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0xF3,
  0xC0, 0x07, 0xDE, 0x00, 0x3E, 0xF0, 0x00, 0xFF, 0x87, 0x07, 0xFC, 0x7C,
  0x3F, 0xE3, 0xF1, 0xFF, 0x1F, 0x8F, 0xF8, 0xFC, 0x7F, 0xC7, 0xC3, 0xFE,
  0x1C, 0x1F, 0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x7D, 0xE0, 0x03,
  0xEF, 0x80, 0x1E, 0x7C, 0x00, 0xF1, 0xF0, 0x0F, 0x8F, 0x80, 0xF8, 0x3F,
  0x0F, 0xC1, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x70, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07,
  0xFC, 0x07, 0xEF, 0x03, 0xF3, 0xC0, 0xF0, 0xF0, 0x10, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x7F, 0xFF, 0xDF, 0xFF, 0xF7, 0xFF, 0xFD, 0xFF, 0xFF,
  0x07, 0xF8, 0x01, 0xFF, 0xE0, 0x7F, 0xFF, 0x0F, 0xFF, 0xF8, 0xFC, 0x1F,
  0xC7, 0x00, 0x7C, 0x20, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x7F, 0xFF,
  0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x07, 0xF8, 0x01, 0xFF,
  0xE0, 0x7F, 0xFF, 0x07, 0xFF, 0xF8, 0x38, 0x1F, 0x82, 0x00, 0x7C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x3F, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x40, 0x03, 0xE7, 0x00, 0xFC, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xBC, 0x00,
  0x3C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x0F, 0x00, 0x38, 0x3C, 0x01, 0xE0,
  0xF0, 0x0F, 0x03, 0xC0, 0x38, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x00, 0xF0,
  0x3C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0xFF, 0xE1, 0xFF,
  0xFE, 0x1F, 0xFF, 0xE1, 0xFF, 0xFE, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xC0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x00, 0x7F, 0xC0, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x40, 0x03, 0xE7, 0x00, 0xFC, 0x7F, 0xFF, 0xCF, 0xFF, 0xF8, 0x7F,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0xC0,
  0x3F, 0xFC, 0x07, 0xF8, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF9, 0xFC,
  0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0xFC, 0x07, 0xEF, 0x00,
  0x3E, 0xF0, 0x01, 0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x7C, 0x03, 0xE3,
  0xF0, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x1F, 0xC0,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xF8, 0x00, 0xFF,
  0xF0, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0x3E, 0xF8,
  0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xEF, 0x80, 0x1E, 0xF8, 0x01, 0xE7,
  0xC0, 0x3C, 0x7E, 0x07, 0xC3, 0xF8, 0xF8, 0x1F, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x81, 0xF7, 0xFC, 0x3C, 0x0F, 0xE7, 0x80, 0x3E, 0xF0, 0x01,
  0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x1F, 0xF8, 0x03, 0xEF, 0xE0, 0x7E, 0x7F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0xE0, 0x1F, 0xFF, 0x03,
  0xFF, 0xF8, 0x7E, 0x0F, 0xC7, 0xC0, 0x7C, 0xF8, 0x03, 0xEF, 0x00, 0x1E,
  0xF0, 0x01, 0xEF, 0x00, 0x1E, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF8, 0x01, 0xF7, 0xE0, 0x7F, 0x7F, 0xFF, 0xF3, 0xFF,
  0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0x9E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0x00,
  0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x7E, 0xFE, 0xFF, 0xFE, 0x7E, 0x3C, 0x07,
  0x81, 0xF8, 0x7F, 0x0F, 0xF1, 0xFC, 0x1F, 0x81, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0x81, 0xF8,
  0x7F, 0x0F, 0xF1, 0xFE, 0x1F, 0xC3, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0xFC,
  0x7F, 0x07, 0xC0, 0xE0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x03, 0xC0, 0x00,
  0x7E, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x01, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x00, 0x01,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x20, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x0F, 0xFC, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0x80, 0x3F, 0xF0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0, 0x03, 0xFE,
  0x00, 0x1F, 0x80, 0x00, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x7F, 0xF8, 0xFF, 0xFC, 0xFF, 0xFE, 0xF0, 0x7E, 0x40, 0x1F, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C,
  0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0x80,
  0x07, 0x00, 0x00, 0x7F, 0x00, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xFF,
  0xFC, 0x0F, 0xC1, 0xF0, 0x7C, 0x03, 0xE1, 0xE0, 0x07, 0x8F, 0x00, 0x1F,
  0x3C, 0x00, 0x3D, 0xF0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x01, 0xFF, 0x78,
  0x1F, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0xFF, 0xFC, 0x3F, 0x0F, 0xF0, 0xF8,
  0x3F, 0xC3, 0xC0, 0xFF, 0x1F, 0x03, 0xFC, 0x7C, 0x0F, 0xF1, 0xF0, 0x3F,
  0xC3, 0xC0, 0xFF, 0x0F, 0x03, 0xFC, 0x3C, 0x0F, 0xF8, 0xFC, 0x3D, 0xE1,
  0xFF, 0xF7, 0x83, 0xFF, 0xDE, 0x07, 0xFF, 0x7C, 0x07, 0xF0, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7F, 0x02, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0x78, 0x00, 0x07, 0xBC, 0x00, 0x03, 0xCF, 0x00,
  0x01, 0xC7, 0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF0, 0xF0, 0x00, 0x70, 0x78,
  0x00, 0x78, 0x3C, 0x00, 0x3C, 0x0F, 0x00, 0x1C, 0x07, 0x80, 0x1E, 0x03,
  0xC0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x07, 0x80, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x07, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x3C, 0x00, 0x1E, 0x1E, 0x00, 0x0F, 0x0F,
  0x00, 0x07, 0xC7, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF3, 0xC0, 0x00, 0x79,
  0xE0, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0x7F, 0xF0, 0x0F, 0xFF, 0xE0, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF8, 0xF0, 0x1F, 0xCF, 0x00, 0x7C, 0xF0, 0x03, 0xCF,
  0x00, 0x3E, 0xF0, 0x03, 0xEF, 0x00, 0x3C, 0xF0, 0x03, 0xCF, 0x00, 0x78,
  0xF0, 0x1F, 0x8F, 0xFF, 0xF0, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x8F, 0x00, 0xFC, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0xF0,
  0x03, 0xEF, 0x00, 0xFE, 0xFF, 0xFF, 0xCF, 0xFF, 0xF8, 0xFF, 0xFE, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0xFE, 0x07, 0x0F, 0xC0, 0x08, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x04, 0x1F, 0xC0, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x07, 0xFF, 0xC0,
  0x0F, 0xF8, 0x7F, 0xE0, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0,
  0xF0, 0x3F, 0x8F, 0x00, 0xFC, 0xF0, 0x07, 0xCF, 0x00, 0x3E, 0xF0, 0x01,
  0xEF, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x01, 0xFF,
  0x00, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x7C, 0xF0, 0x0F, 0xCF, 0x03, 0xF8,
  0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0xFF,
  0xBF, 0xFF, 0xEF, 0xFF, 0xFB, 0xFF, 0xFE, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xFF, 0xFF,
  0x3F, 0xFF, 0xCF, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xFF, 0x80, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFE, 0x07, 0x0F,
  0xC0, 0x08, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1E,
  0xF0, 0x00, 0xF7, 0x80, 0x07, 0xBC, 0x00, 0x3D, 0xF0, 0x01, 0xEF, 0x80,
  0x0F, 0x3E, 0x00, 0x79, 0xF8, 0x03, 0xC7, 0xE0, 0x1E, 0x1F, 0xC0, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x0F, 0xF8, 0xF0, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03,
  0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF1, 0xFF, 0xFC, 0x7F, 0xFF, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01,
  0xF4, 0x00, 0xFD, 0xE0, 0x7E, 0xFF, 0xFF, 0xBF, 0xFF, 0xC7, 0xFF, 0xC0,
  0x3F, 0xC0, 0xF0, 0x00, 0xFB, 0xC0, 0x07, 0xCF, 0x00, 0x3E, 0x3C, 0x01,
  0xF0, 0xF0, 0x07, 0xC3, 0xC0, 0x3E, 0x0F, 0x01, 0xF0, 0x3C, 0x0F, 0x80,
  0xF0, 0x7C, 0x03, 0xC3, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x7C, 0x00, 0xF3,
  0xE0, 0x03, 0xDF, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0xF7, 0xE0,
  0x03, 0xCF, 0xC0, 0x0F, 0x1F, 0x80, 0x3C, 0x3F, 0x00, 0xF0, 0x7E, 0x03,
  0xC0, 0xFC, 0x0F, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0xF0, 0x07, 0xC3, 0xC0,
  0x1F, 0x8F, 0x00, 0x3E, 0x3C, 0x00, 0x7C, 0xF0, 0x01, 0xF3, 0xC0, 0x03,
  0xEF, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x3C, 0x00, 0xF0, 0xF0, 0x07, 0xC3,
  0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x7E, 0x03, 0xF1, 0xFC, 0x0F, 0xC7, 0x70,
  0x3F, 0x1D, 0xC1, 0xFC, 0x77, 0x07, 0x79, 0xCE, 0x1D, 0xE7, 0x38, 0xF7,
  0x9C, 0xE3, 0x9E, 0x71, 0xCE, 0x79, 0xC7, 0x39, 0xE7, 0x1D, 0xC7, 0xBC,
  0x3F, 0x1E, 0xF0, 0xFC, 0x7B, 0xC3, 0xE1, 0xEF, 0x0F, 0x83, 0xBC, 0x1E,
  0x0E, 0xF0, 0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xF7, 0x80, 0xFF, 0x78, 0x0F, 0xF3,
  0xC0, 0xFF, 0x3C, 0x0F, 0xF1, 0xE0, 0xFF, 0x1E, 0x0F, 0xF0, 0xF0, 0xFF,
  0x0F, 0x0F, 0xF0, 0x70, 0xFF, 0x07, 0x8F, 0xF0, 0x38, 0xFF, 0x03, 0xCF,
  0xF0, 0x3C, 0xFF, 0x01, 0xEF, 0xF0, 0x1E, 0xFF, 0x00, 0xEF, 0xF0, 0x0F,
  0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFF, 0x00,
  0x3F, 0xF0, 0x01, 0xFF, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x1F, 0x0F,
  0x80, 0x1E, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F,
  0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0x7C, 0x03, 0xE0,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x7F, 0x00, 0x7F, 0xF0, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF,
  0x01, 0xFD, 0xE0, 0x0F, 0xBC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFC,
  0x00, 0xFF, 0x80, 0x3E, 0xF0, 0x1F, 0xDF, 0xFF, 0xF3, 0xFF, 0xFC, 0x7F,
  0xFF, 0x0F, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x81, 0xF8, 0x3F, 0x03, 0xE0, 0x1F, 0x0F,
  0x80, 0x1E, 0x1E, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF0, 0x00, 0x79, 0xE0,
  0x00, 0xFB, 0xC0, 0x01, 0xF7, 0x80, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x3D, 0xE0, 0x00,
  0x7B, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0xDE, 0x00, 0x0F,
  0x3E, 0x00, 0x1E, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0xFC, 0x03, 0xE0,
  0xFC, 0x1F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x7F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1C, 0x7F, 0xF0, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF, 0x0F,
  0x01, 0xFC, 0x78, 0x03, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x7C, 0xF0, 0x01,
  0xE7, 0x80, 0x0F, 0x3C, 0x00, 0x79, 0xE0, 0x03, 0xCF, 0x00, 0x3E, 0x78,
  0x01, 0xE3, 0xC0, 0x1F, 0x1E, 0x03, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF8,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x0F, 0x03, 0xC0, 0x78, 0x1F, 0x03, 0xC0,
  0x78, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x87, 0x80, 0x3C, 0x3C, 0x01, 0xF1,
  0xE0, 0x07, 0x8F, 0x00, 0x3E, 0x78, 0x00, 0xF3, 0xC0, 0x07, 0xDE, 0x00,
  0x1E, 0x01, 0xFE, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0xC3, 0xFF, 0xFC, 0x7F,
  0x03, 0xC7, 0xC0, 0x08, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x03, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x40, 0x03, 0xE7, 0x80, 0x7E, 0xFF,
  0xFF, 0xCF, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF,
  0x80, 0x07, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x03,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x3D, 0xE0,
  0x01, 0xEF, 0x00, 0x1F, 0x78, 0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x80, 0x7C,
  0x7E, 0x07, 0xE3, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x3F,
  0xC0, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0xF8, 0x00,
  0x1E, 0x78, 0x00, 0x3E, 0x78, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0x3C, 0x00,
  0x3C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x78, 0x1E, 0x00,
  0x78, 0x1E, 0x00, 0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x0F, 0x01, 0xE0, 0x0F, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x07, 0x83,
  0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC7, 0xC0, 0x03, 0xE7,
  0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x80, 0x01, 0xFF, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x3B, 0xC0, 0x00, 0xEF, 0x00, 0x03, 0xBC, 0x00, 0x0E, 0xF0, 0x78,
  0x3B, 0xC3, 0xE1, 0xEF, 0x0F, 0x87, 0xBC, 0x3F, 0x1E, 0xF1, 0xFC, 0x7B,
  0xC7, 0x71, 0xE7, 0x1C, 0xE7, 0x9C, 0x73, 0x9E, 0x73, 0x8E, 0x79, 0xCE,
  0x3D, 0xE7, 0x38, 0x77, 0x9D, 0xC1, 0xDC, 0x77, 0x07, 0xF1, 0xDC, 0x0F,
  0xC7, 0xE0, 0x3F, 0x1F, 0x80, 0xFC, 0x7E, 0x01, 0xF0, 0xF8, 0x07, 0xC3,
  0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x7C, 0x00, 0x3C, 0x78, 0x00, 0xF8, 0xF8,
  0x01, 0xE0, 0xF0, 0x07, 0xC1, 0xF0, 0x0F, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x78, 0x03, 0xE1, 0xF0, 0x03, 0xC7, 0xC0, 0x07, 0xCF, 0x00, 0x07, 0xBE,
  0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7C, 0xF8, 0x01, 0xF0, 0xF0, 0x03,
  0xC1, 0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x03, 0xE0, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0xC3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00, 0x0F, 0xBC, 0x00,
  0x1F, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1E, 0x78, 0x00, 0x3E, 0x7C, 0x00,
  0x3C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x1F, 0x00,
  0xF8, 0x1F, 0x00, 0xF0, 0x0F, 0x81, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0xC3,
  0xE0, 0x07, 0xC3, 0xC0, 0x03, 0xE7, 0xC0, 0x03, 0xEF, 0x80, 0x01, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x3F,
  0xE0, 0x01, 0xEF, 0x80, 0x1F, 0x3C, 0x00, 0xF0, 0xF0, 0x0F, 0x07, 0xC0,
  0xF8, 0x1E, 0x07, 0x80, 0xF8, 0x7C, 0x03, 0xC3, 0xC0, 0x1F, 0x3C, 0x00,
  0x7B, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0x30, 0x00, 0x20, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x20, 0x18,
  0x1E, 0x0F, 0x83, 0xE0, 0xF8, 0x3C, 0x0E, 0x02, 0x00, 0x0F, 0xF8, 0x07,
  0xFF, 0xE0, 0x7F, 0xFE, 0x0F, 0xFF, 0xE1, 0x80, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x7F, 0xFC, 0x7F, 0xFF, 0x9F,
  0xFF, 0xF7, 0xE0, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFF, 0x00, 0xF7, 0xFF, 0xFE, 0x7F,
  0xFF, 0xC7, 0xFF, 0xF8, 0x1F, 0xF8, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x79, 0xFC, 0x0F, 0xFF,
  0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE7, 0xE0, 0xFE, 0xF0, 0x07, 0xDE, 0x00,
  0x7F, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x01,
  0xFF, 0x00, 0x3D, 0xE0, 0x0F, 0xBC, 0x07, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x1F, 0xFF, 0x80, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x1F, 0xFF, 0xE1, 0xFC, 0x03, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x20, 0xFF,
  0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x0F, 0xF8, 0x00, 0x00, 0x70,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x1F, 0xCF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF, 0x1F, 0xFF, 0xF3, 0xF0,
  0x7F, 0x7E, 0x01, 0xF7, 0xC0, 0x0F, 0x78, 0x00, 0xFF, 0x80, 0x0F, 0xF8,
  0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x00, 0xF7, 0x80, 0x0F, 0x7C, 0x00, 0xF3, 0xE0, 0x0F,
  0x3F, 0x80, 0xF1, 0xFF, 0xFF, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x00, 0xFF,
  0x80, 0x00, 0xFE, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0xC3,
  0xF8, 0x3F, 0x1F, 0x00, 0xF9, 0xF0, 0x03, 0xEF, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x7F, 0x00, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x03, 0xF0, 0x18, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x3F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x8F, 0xFF, 0xFE, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xFF,
  0xF1, 0xFF, 0xFF, 0x3F, 0x01, 0xF7, 0xE0, 0x0F, 0x7C, 0x00, 0xF7, 0x80,
  0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0x7C, 0x00, 0xF7,
  0xC0, 0x0F, 0x3F, 0x03, 0xF3, 0xFF, 0xFF, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF,
  0x01, 0xFC, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE3, 0x00, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x7F, 0xFF, 0x00, 0xFF,
  0x80, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xDF, 0xC0, 0xFF, 0xFC, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xE0,
  0x7E, 0xF0, 0x0F, 0xBC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x0F, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x0F,
  0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x82, 0x00,
  0xFF, 0xF0, 0x0F, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x00, 0x3C, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3C, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x3F,
  0xFF, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x60,
  0x7E, 0xFF, 0xFC, 0xFF, 0xFC, 0xFF, 0xF8, 0x1F, 0xE0, 0x70, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x3E, 0xF0, 0x07, 0xCF, 0x00, 0xF8, 0xF0, 0x1F, 0x0F, 0x03,
  0xE0, 0xF0, 0x7C, 0x0F, 0x0F, 0x80, 0xF1, 0xF0, 0x0F, 0x3E, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0xF7, 0xE0, 0x0F,
  0x1F, 0x00, 0xF0, 0xF8, 0x0F, 0x07, 0xC0, 0xF0, 0x3E, 0x0F, 0x01, 0xF0,
  0xF0, 0x0F, 0x8F, 0x00, 0x7C, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x01,
  0xF0, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x20, 0x0F, 0xFF, 0x00, 0xFF, 0xF0,
  0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0x87, 0xC3, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFE, 0xF0, 0xF8, 0x7B, 0xC1, 0xE1, 0xFF, 0x07, 0x83,
  0xFC, 0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC,
  0x1E, 0x0F, 0xF0, 0x78, 0x3F, 0xC1, 0xE0, 0xFF, 0x07, 0x83, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0x1F,
  0xF0, 0x3F, 0xFF, 0x0F, 0xFF, 0xF3, 0xFF, 0xFC, 0xF0, 0x1F, 0xBC, 0x03,
  0xEF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0x01, 0xFC, 0x00, 0x3F, 0xF8, 0x03, 0xFF,
  0xF0, 0x3F, 0xFF, 0xC3, 0xF0, 0x7E, 0x3F, 0x00, 0xF9, 0xF0, 0x03, 0xCF,
  0x00, 0x1F, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0x78,
  0x00, 0xFB, 0xE0, 0x07, 0x9F, 0x80, 0x7C, 0x7E, 0x0F, 0xC1, 0xFF, 0xFE,
  0x07, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xFF,
  0x83, 0xFF, 0xFC, 0x7F, 0xFF, 0xCF, 0x01, 0xF9, 0xE0, 0x0F, 0xBC, 0x01,
  0xF7, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x03,
  0xFE, 0x00, 0x7F, 0xC0, 0x1F, 0x7E, 0x0F, 0xEF, 0xFF, 0xF9, 0xFF, 0xFE,
  0x3F, 0xFF, 0x87, 0x9F, 0xC0, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0x0F, 0xFF, 0xF1, 0xFF, 0xFF, 0x3F, 0x80,
  0xF3, 0xE0, 0x0F, 0x7C, 0x00, 0xF7, 0x80, 0x0F, 0xF8, 0x00, 0xFF, 0x80,
  0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0x80, 0x0F, 0x78, 0x00, 0xF7, 0xC0, 0x0F, 0x7E, 0x01, 0xF3,
  0xF0, 0x3F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x1F, 0x8F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x07, 0xFF, 0x3F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x03,
  0xFF, 0x01, 0xFF, 0xF8, 0xFF, 0xFF, 0x1F, 0xFF, 0xE7, 0xE0, 0x18, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0xFF,
  0xC0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x01, 0xE0, 0x00, 0x3D, 0x00, 0x07, 0xBC, 0x03, 0xF7, 0xFF,
  0xFD, 0xFF, 0xFF, 0x9F, 0xFF, 0xC0, 0x7F, 0xE0, 0x03, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x20, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x0F, 0xFF, 0x00,
  0x3F, 0xC0, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFE,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x80, 0x3D, 0xF0, 0x07, 0x9F,
  0x80, 0xF3, 0xFF, 0xFE, 0x3F, 0xFF, 0xC3, 0xFF, 0xF8, 0x1F, 0xF8, 0xF0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x07, 0x9E, 0x00, 0x1E, 0x78, 0x00,
  0xF9, 0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3E, 0x01, 0xE0,
  0x78, 0x0F, 0x81, 0xE0, 0x3C, 0x07, 0xC0, 0xF0, 0x0F, 0x07, 0xC0, 0x3C,
  0x1E, 0x00, 0xF8, 0x78, 0x01, 0xE3, 0xC0, 0x07, 0xCF, 0x00, 0x0F, 0x7C,
  0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0xF0, 0x00, 0x0E, 0xF0, 0x00, 0x0E, 0xF0,
  0x00, 0x1E, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E, 0x70, 0x3C, 0x1E, 0x78,
  0x3C, 0x1E, 0x78, 0x3C, 0x1E, 0x78, 0x7C, 0x1E, 0x78, 0x7E, 0x1C, 0x78,
  0x7E, 0x1C, 0x78, 0xFE, 0x3C, 0x38, 0xEF, 0x3C, 0x38, 0xE7, 0x3C, 0x3D,
  0xE7, 0x3C, 0x3D, 0xC7, 0xB8, 0x3D, 0xC3, 0xB8, 0x3F, 0x83, 0xB8, 0x1F,
  0x83, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x00, 0xF0, 0x0E, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF0, 0x78,
  0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF8, 0x1E, 0x00, 0xF8, 0x78, 0x00, 0xF1,
  0xF0, 0x01, 0xF7, 0xC0, 0x01, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0,
  0x01, 0xF3, 0xC0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0xC0, 0x3E, 0x07, 0x80,
  0xF8, 0x07, 0x81, 0xE0, 0x0F, 0x87, 0x80, 0x0F, 0x9F, 0x00, 0x1F, 0x3C,
  0x00, 0x1F, 0x78, 0x00, 0x79, 0xE0, 0x01, 0xE7, 0xC0, 0x0F, 0x9F, 0x00,
  0x3E, 0x3C, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xE0, 0x1F, 0x07, 0x80, 0x78,
  0x1F, 0x01, 0xE0, 0x7C, 0x07, 0x80, 0xF0, 0x3E, 0x03, 0xE0, 0xF0, 0x07,
  0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x7C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xE7,
  0x80, 0x07, 0xBC, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x38, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFE, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xC0, 0x3F, 0xF0, 0x1F, 0xFC, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3F,
  0xC0, 0x0F, 0xC0, 0x03, 0xFC, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x00, 0x0F,
  0x80, 0x10, 0xFF, 0x00, 0xF3, 0xFF, 0x03, 0x9F, 0xFF, 0x1E, 0x78, 0xFF,
  0xFB, 0xC1, 0xFF, 0xCE, 0x01, 0xFE, 0x18, 0x01, 0xF0,
};

const GFXglyph UbuntuMono_Regular51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 26, 0, -1 },
  { 1, 7, 32, 26, 9, -32 },
  { 29, 12, 13, 26, 7, -35 },
  { 49, 23, 32, 26, 1, -32 },
  { 141, 20, 40, 26, 3, -35 },
  { 241, 24, 32, 26, 1, -32 },
  { 337, 22, 32, 26, 2, -32 },
  { 425, 5, 14, 26, 10, -35 },
  { 434, 14, 45, 26, 6, -36 },
  { 513, 14, 45, 26, 6, -36 },
  { 592, 20, 19, 26, 3, -32 },
  { 640, 21, 22, 26, 2, -25 },
  { 698, 10, 14, 26, 8, -7 },
  { 716, 11, 4, 26, 7, -15 },
  { 722, 8, 7, 26, 9, -7 },
  { 729, 18, 44, 26, 4, -36 },
  { 828, 21, 32, 26, 2, -32 },
  { 912, 18, 32, 26, 4, -32 },
  { 984, 20, 32, 26, 3, -32 },
  { 1064, 20, 32, 26, 3, -32 },
  { 1144, 22, 32, 26, 2, -32 },
  { 1232, 20, 32, 26, 3, -32 },
  { 1312, 20, 32, 26, 3, -32 },
  { 1392, 20, 32, 26, 3, -32 },
  { 1472, 20, 32, 26, 3, -32 },
  { 1552, 20, 32, 26, 3, -32 },
  { 1632, 8, 23, 26, 9, -23 },
  { 1655, 11, 30, 26, 6, -23 },
  { 1697, 21, 21, 26, 2, -24 },
  { 1753, 21, 14, 26, 2, -20 },
  { 1790, 21, 21, 26, 2, -24 },
  { 1846, 16, 32, 26, 5, -32 },
  { 1910, 22, 39, 26, 2, -32 },
  { 2018, 25, 32, 26, 0, -32 },
  { 2118, 20, 32, 26, 3, -32 },
  { 2198, 21, 32, 26, 2, -32 },
  { 2282, 20, 32, 26, 3, -32 },
  { 2362, 18, 32, 26, 5, -32 },
  { 2434, 18, 32, 26, 5, -32 },
  { 2506, 21, 32, 26, 2, -32 },
  { 2590, 21, 32, 26, 2, -32 },
  { 2674, 16, 32, 26, 5, -32 },
  { 2738, 18, 32, 26, 3, -32 },
  { 2810, 22, 32, 26, 3, -32 },
  { 2898, 18, 32, 26, 5, -32 },
  { 2970, 22, 32, 26, 2, -32 },
  { 3058, 20, 32, 26, 3, -32 },
  { 3138, 23, 32, 26, 1, -32 },
  { 3230, 19, 32, 26, 4, -32 },
  { 3306, 23, 40, 26, 1, -32 },
  { 3421, 21, 32, 26, 3, -32 },
  { 3505, 20, 32, 26, 3, -32 },
  { 3585, 22, 32, 26, 2, -32 },
  { 3673, 21, 32, 26, 2, -32 },
  { 3757, 24, 32, 26, 1, -32 },
  { 3853, 22, 32, 26, 2, -32 },
  { 3941, 23, 32, 26, 1, -32 },
  { 4033, 24, 32, 26, 1, -32 },
  { 4129, 20, 32, 26, 3, -32 },
  { 4209, 12, 44, 26, 7, -36 },
  { 4275, 18, 44, 26, 4, -36 },
  { 4374, 12, 44, 26, 6, -36 },
  { 4440, 21, 17, 26, 2, -32 },
  { 4485, 25, 4, 26, 0, 5 },
  { 4498, 9, 9, 26, 8, -35 },
  { 4509, 19, 24, 26, 3, -24 },
  { 4566, 19, 35, 26, 4, -35 },
  { 4650, 21, 24, 26, 2, -24 },
  { 4713, 20, 35, 26, 2, -35 },
  { 4801, 21, 24, 26, 2, -24 },
  { 4864, 22, 35, 26, 3, -35 },
  { 4961, 20, 32, 26, 2, -24 },
  { 5041, 18, 35, 26, 4, -35 },
  { 5120, 20, 34, 26, 3, -34 },
  { 5205, 16, 42, 26, 4, -34 },
  { 5289, 20, 35, 26, 4, -35 },
  { 5377, 20, 35, 26, 3, -35 },
  { 5465, 22, 24, 26, 2, -24 },
  { 5531, 18, 24, 26, 4, -24 },
  { 5585, 21, 24, 26, 2, -24 },
  { 5648, 19, 32, 26, 4, -24 },
  { 5724, 20, 32, 26, 2, -24 },
  { 5804, 17, 24, 26, 5, -24 },
  { 5855, 19, 24, 26, 3, -24 },
  { 5912, 20, 31, 26, 3, -31 },
  { 5990, 19, 24, 26, 3, -24 },
  { 6047, 22, 24, 26, 2, -24 },
  { 6113, 24, 24, 26, 1, -24 },
  { 6185, 23, 24, 26, 1, -24 },
  { 6254, 22, 32, 26, 2, -24 },
  { 6342, 18, 24, 26, 4, -24 },
  { 6396, 18, 44, 26, 4, -36 },
  { 6495, 4, 44, 26, 11, -36 },
  { 6517, 17, 44, 26, 4, -36 },
  { 6611, 22, 8, 26, 2, -18 },
};

const GFXfont UbuntuMono_Regular51pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular51pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular51pt7bGlyphs,
  0x20, 0x7E, 51
};

#endif // _UBUNTUMONO_REGULAR51PT7B_H_
