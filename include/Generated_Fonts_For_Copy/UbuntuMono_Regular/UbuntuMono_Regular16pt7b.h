#ifndef _UBUNTUMONO_REGULAR16PT7B_H_
#define _UBUNTUMONO_REGULAR16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular16pt7bBitmaps[] PROGMEM = {
  0x00, 0xFF, 0xFE, 0x30, 0x99, 0x99, 0x12, 0x12, 0x36, 0xFF, 0x24, 0x24,
  0xFF, 0x6C, 0x48, 0x48, 0x30, 0xC7, 0xF0, 0x83, 0x03, 0x83, 0x06, 0x3F,
  0x8C, 0x30, 0x62, 0x92, 0x94, 0x98, 0x68, 0x16, 0x19, 0x29, 0x49, 0x46,
  0x38, 0x6C, 0x44, 0x68, 0x38, 0x72, 0x5A, 0x4C, 0x4E, 0x7A, 0xFE, 0x12,
  0x4C, 0x88, 0x88, 0x8C, 0x63, 0x10, 0x8C, 0x63, 0x11, 0x11, 0x13, 0x24,
  0x80, 0x33, 0x73, 0x0C, 0x49, 0x20, 0x30, 0xC3, 0x3F, 0x30, 0xC3, 0x00,
  0x62, 0xC0, 0xF0, 0xC0, 0x0C, 0x20, 0x86, 0x10, 0x43, 0x0C, 0x20, 0x86,
  0x10, 0x43, 0x00, 0x7B, 0x38, 0x61, 0xB6, 0xD8, 0x61, 0xCD, 0xE0, 0x11,
  0xCD, 0x04, 0x10, 0x41, 0x04, 0x11, 0xF0, 0x7A, 0x30, 0xC3, 0x18, 0x42,
  0x10, 0xC3, 0xF0, 0xF8, 0x20, 0xC2, 0x30, 0x30, 0x41, 0x0F, 0xE0, 0x08,
  0x62, 0x92, 0xCA, 0x2F, 0xC2, 0x08, 0x20, 0x7D, 0x04, 0x10, 0x70, 0x30,
  0x41, 0x0F, 0xE0, 0x1D, 0x84, 0x30, 0xFA, 0x38, 0x61, 0xCD, 0xE0, 0xFC,
  0x30, 0x86, 0x10, 0xC3, 0x08, 0x20, 0x80, 0x7B, 0x38, 0x73, 0x79, 0x68,
  0x61, 0xCD, 0xE0, 0x7B, 0x38, 0x61, 0xC5, 0xF0, 0xC2, 0x1B, 0x80, 0xC0,
  0x30, 0x60, 0x00, 0xDE, 0x04, 0x66, 0x20, 0x60, 0x60, 0x40, 0xFC, 0x00,
  0x3F, 0x81, 0x81, 0x81, 0x19, 0x88, 0x00, 0x78, 0x20, 0xC2, 0x18, 0x43,
  0x08, 0x00, 0xC0, 0x39, 0x18, 0x67, 0xB6, 0x9A, 0x6D, 0x9F, 0x06, 0x0F,
  0x18, 0x18, 0x3C, 0x24, 0x24, 0x66, 0x7E, 0x42, 0x42, 0xC3, 0xFA, 0x38,
  0xE2, 0xFA, 0x38, 0x61, 0x8F, 0xE0, 0x3D, 0x1C, 0x20, 0x82, 0x08, 0x30,
  0x44, 0xF0, 0xF2, 0x28, 0x61, 0x86, 0x18, 0x61, 0x8B, 0xC0, 0xFF, 0x0C,
  0x30, 0xFB, 0x0C, 0x30, 0xC3, 0xF0, 0xFF, 0x0C, 0x30, 0xFF, 0x0C, 0x30,
  0xC3, 0x00, 0x3D, 0x1C, 0x20, 0x82, 0x18, 0x71, 0x44, 0xF0, 0x86, 0x18,
  0x61, 0xFE, 0x18, 0x61, 0x86, 0x10, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x33, 0xF0, 0x7C, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x8B, 0xC0, 0x85, 0x12,
  0x65, 0x8E, 0x16, 0x26, 0x44, 0x85, 0x0C, 0xC3, 0x0C, 0x30, 0xC3, 0x0C,
  0x30, 0xC3, 0xF0, 0xCF, 0x3C, 0xED, 0xB6, 0xD8, 0x61, 0x86, 0x10, 0x87,
  0x1E, 0x69, 0xB6, 0x59, 0x63, 0x8E, 0x10, 0x3C, 0x66, 0x42, 0x42, 0xC3,
  0xC3, 0x42, 0x42, 0x66, 0x3C, 0xFA, 0x38, 0x61, 0x8F, 0xE8, 0x20, 0x82,
  0x00, 0x3C, 0x66, 0x42, 0x42, 0xC3, 0xC3, 0x42, 0x42, 0x66, 0x3C, 0x18,
  0x06, 0xFA, 0x38, 0x61, 0x8F, 0xE9, 0xA2, 0x8E, 0x10, 0x7B, 0x18, 0x30,
  0x70, 0x60, 0x41, 0x8F, 0xE0, 0xFC, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC0, 0x86, 0x18, 0x61, 0x86, 0x18, 0x61, 0xCD, 0xE0, 0xC3, 0x42, 0x42,
  0x42, 0x66, 0x24, 0x24, 0x3C, 0x18, 0x18, 0x86, 0x18, 0x61, 0xB6, 0xDB,
  0x73, 0xCF, 0x30, 0x42, 0x66, 0x24, 0x18, 0x18, 0x18, 0x3C, 0x24, 0x66,
  0x42, 0xC3, 0x42, 0x66, 0x24, 0x3C, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFC,
  0x30, 0x84, 0x30, 0x86, 0x10, 0xC3, 0xF0, 0xFC, 0xCC, 0xCC, 0xCC, 0xCC,
  0xCC, 0xF0, 0xC1, 0x04, 0x18, 0x20, 0x83, 0x0C, 0x10, 0x41, 0x82, 0x08,
  0x30, 0xF3, 0x33, 0x33, 0x33, 0x33, 0x33, 0xF0, 0x31, 0xE4, 0xB3, 0x84,
  0xFF, 0xB4, 0x78, 0x30, 0x5F, 0x86, 0x17, 0xC0, 0x82, 0x08, 0x20, 0xFB,
  0x38, 0x61, 0x86, 0x3F, 0x80, 0x3F, 0x08, 0x20, 0x83, 0x03, 0xC0, 0x04,
  0x10, 0x41, 0x7F, 0x38, 0x61, 0x87, 0x17, 0xC0, 0x7B, 0x38, 0x7F, 0x83,
  0x07, 0xC0, 0x1E, 0x40, 0x81, 0x0F, 0xC4, 0x08, 0x10, 0x20, 0x40, 0x80,
  0x7F, 0x18, 0x61, 0x87, 0x17, 0xC3, 0x0F, 0xE0, 0x82, 0x08, 0x20, 0xFA,
  0x38, 0x61, 0x86, 0x18, 0x40, 0x60, 0x0E, 0x08, 0x20, 0x82, 0x0C, 0x1C,
  0x18, 0x1E, 0x10, 0x84, 0x21, 0x08, 0x43, 0xE0, 0x81, 0x02, 0x04, 0x08,
  0xD3, 0x2C, 0x70, 0x91, 0x12, 0x10, 0xE0, 0x82, 0x08, 0x20, 0x82, 0x08,
  0x20, 0xC1, 0xC0, 0xFE, 0xDB, 0x6D, 0x86, 0x18, 0x40, 0xFA, 0x38, 0x61,
  0x86, 0x18, 0x40, 0x7B, 0x38, 0x61, 0x87, 0x37, 0x80, 0xFA, 0x38, 0x61,
  0x86, 0x3F, 0xA0, 0x82, 0x00, 0x7F, 0x18, 0x61, 0x87, 0x17, 0xC1, 0x04,
  0x10, 0xFC, 0x21, 0x08, 0x42, 0x00, 0x7B, 0x0C, 0x1E, 0x0E, 0x1F, 0x80,
  0x20, 0x8F, 0xC8, 0x20, 0x82, 0x08, 0x3C, 0x86, 0x18, 0x61, 0x87, 0x17,
  0xC0, 0x42, 0x42, 0x66, 0x24, 0x3C, 0x18, 0x18, 0xC3, 0xC3, 0x5A, 0x5A,
  0x7E, 0x66, 0x66, 0x42, 0x24, 0x18, 0x18, 0x3C, 0x26, 0x42, 0x87, 0x14,
  0xD2, 0x68, 0xE3, 0x04, 0x23, 0x80, 0xFC, 0x21, 0x0C, 0x61, 0x0F, 0xC0,
  0x1C, 0x82, 0x08, 0x20, 0x82, 0x30, 0x20, 0x82, 0x08, 0x20, 0x70, 0xFF,
  0xFF, 0xFF, 0xF0, 0xE0, 0x41, 0x04, 0x10, 0x41, 0x03, 0x10, 0x41, 0x04,
  0x13, 0x80, 0xE6, 0x70,
};

const GFXglyph UbuntuMono_Regular16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 8, 0, -1 },
  { 1, 2, 10, 8, 3, -10 },
  { 4, 4, 4, 8, 2, -11 },
  { 6, 8, 10, 8, 0, -10 },
  { 16, 6, 13, 8, 1, -11 },
  { 26, 8, 10, 8, 0, -10 },
  { 36, 8, 10, 8, 0, -10 },
  { 46, 2, 4, 8, 3, -11 },
  { 47, 4, 13, 8, 2, -10 },
  { 54, 4, 13, 8, 2, -10 },
  { 61, 6, 6, 8, 1, -10 },
  { 66, 6, 7, 8, 1, -8 },
  { 72, 4, 3, 8, 2, -1 },
  { 74, 4, 1, 8, 2, -4 },
  { 75, 2, 1, 8, 3, -1 },
  { 76, 6, 14, 8, 1, -11 },
  { 87, 6, 10, 8, 1, -10 },
  { 95, 6, 10, 8, 1, -10 },
  { 103, 6, 10, 8, 1, -10 },
  { 111, 6, 10, 8, 1, -10 },
  { 119, 6, 10, 8, 1, -10 },
  { 127, 6, 10, 8, 1, -10 },
  { 135, 6, 10, 8, 1, -10 },
  { 143, 6, 10, 8, 1, -10 },
  { 151, 6, 10, 8, 1, -10 },
  { 159, 6, 10, 8, 1, -10 },
  { 167, 2, 6, 8, 3, -6 },
  { 169, 3, 8, 8, 2, -6 },
  { 172, 6, 7, 8, 1, -8 },
  { 178, 6, 4, 8, 1, -6 },
  { 181, 6, 7, 8, 1, -8 },
  { 187, 6, 10, 8, 1, -10 },
  { 195, 6, 12, 8, 1, -10 },
  { 204, 8, 10, 8, 0, -10 },
  { 214, 6, 10, 8, 1, -10 },
  { 222, 6, 10, 8, 1, -10 },
  { 230, 6, 10, 8, 1, -10 },
  { 238, 6, 10, 8, 1, -10 },
  { 246, 6, 10, 8, 1, -10 },
  { 254, 6, 10, 8, 1, -10 },
  { 262, 6, 10, 8, 1, -10 },
  { 270, 6, 10, 8, 1, -10 },
  { 278, 6, 10, 8, 1, -10 },
  { 286, 7, 10, 8, 1, -10 },
  { 295, 6, 10, 8, 1, -10 },
  { 303, 6, 10, 8, 1, -10 },
  { 311, 6, 10, 8, 1, -10 },
  { 319, 8, 10, 8, 0, -10 },
  { 329, 6, 10, 8, 1, -10 },
  { 337, 8, 12, 8, 0, -10 },
  { 349, 6, 10, 8, 1, -10 },
  { 357, 6, 10, 8, 1, -10 },
  { 365, 6, 10, 8, 1, -10 },
  { 373, 6, 10, 8, 1, -10 },
  { 381, 8, 10, 8, 0, -10 },
  { 391, 6, 10, 8, 1, -10 },
  { 399, 8, 10, 8, 0, -10 },
  { 409, 8, 10, 8, 0, -10 },
  { 419, 6, 10, 8, 1, -10 },
  { 427, 4, 13, 8, 2, -10 },
  { 434, 6, 14, 8, 1, -11 },
  { 445, 4, 13, 8, 2, -10 },
  { 452, 6, 5, 8, 1, -10 },
  { 456, 8, 1, 8, 0, 2 },
  { 457, 2, 3, 8, 3, -11 },
  { 458, 6, 7, 8, 1, -7 },
  { 464, 6, 11, 8, 1, -11 },
  { 473, 6, 7, 8, 1, -7 },
  { 479, 6, 11, 8, 1, -11 },
  { 488, 6, 7, 8, 1, -7 },
  { 494, 7, 11, 8, 1, -11 },
  { 504, 6, 10, 8, 1, -7 },
  { 512, 6, 11, 8, 1, -11 },
  { 521, 6, 9, 8, 1, -9 },
  { 528, 5, 12, 8, 1, -9 },
  { 536, 7, 11, 8, 1, -11 },
  { 546, 6, 11, 8, 1, -11 },
  { 555, 6, 7, 8, 1, -7 },
  { 561, 6, 7, 8, 1, -7 },
  { 567, 6, 7, 8, 1, -7 },
  { 573, 6, 10, 8, 1, -7 },
  { 581, 6, 10, 8, 1, -7 },
  { 589, 5, 7, 8, 2, -7 },
  { 594, 6, 7, 8, 1, -7 },
  { 600, 6, 9, 8, 1, -9 },
  { 607, 6, 7, 8, 1, -7 },
  { 613, 8, 7, 8, 0, -7 },
  { 620, 8, 7, 8, 0, -7 },
  { 627, 8, 7, 8, 0, -7 },
  { 634, 6, 10, 8, 1, -7 },
  { 642, 6, 7, 8, 1, -7 },
  { 648, 6, 14, 8, 1, -11 },
  { 659, 2, 14, 8, 3, -11 },
  { 663, 6, 14, 8, 1, -11 },
  { 674, 6, 2, 8, 1, -5 },
};

const GFXfont UbuntuMono_Regular16pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular16pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular16pt7bGlyphs,
  0x20, 0x7E, 16
};

#endif // _UBUNTUMONO_REGULAR16PT7B_H_
