#ifndef _UBUNTUMONO_REGULAR24PT7B_H_
#define _UBUNTUMONO_REGULAR24PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 24pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular24pt7bBitmaps[] PROGMEM = {
  0x00, 0x66, 0x66, 0x66, 0x66, 0x66, 0x00, 0x6F, 0x60, 0xCF, 0x3C, 0xF3,
  0xCF, 0x30, 0x18, 0x86, 0x61, 0x98, 0x46, 0xFF, 0xFF, 0xF3, 0x10, 0xCC,
  0x23, 0x3F, 0xFF, 0xFD, 0x88, 0x66, 0x19, 0x84, 0x60, 0x0C, 0x03, 0x01,
  0xF1, 0xFE, 0x60, 0x98, 0x06, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x38, 0x07,
  0x00, 0xD0, 0x7F, 0xF9, 0xFC, 0x0C, 0x03, 0x00, 0xC0, 0x38, 0x64, 0x84,
  0xCC, 0xCC, 0xC8, 0xCD, 0x84, 0xB0, 0x7A, 0x00, 0x60, 0x05, 0xC0, 0xD2,
  0x1B, 0x21, 0x33, 0x33, 0x26, 0x12, 0x61, 0xC0, 0x3C, 0x1F, 0x86, 0x31,
  0x8C, 0x62, 0x19, 0x83, 0xC0, 0xE2, 0x7C, 0xB3, 0xEC, 0x7B, 0x0E, 0xE7,
  0xBF, 0xB3, 0xCC, 0xFF, 0xF0, 0x0C, 0x73, 0x8C, 0x63, 0x8C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x86, 0x0C, 0x38, 0x70, 0xC0, 0xC3, 0x87, 0x0C, 0x18,
  0x60, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x61, 0x8C, 0x73, 0x8C, 0x00, 0x0C,
  0x03, 0x04, 0xC9, 0xFE, 0x3F, 0x07, 0x83, 0xF0, 0xCC, 0x33, 0x00, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0x77, 0x73, 0xEC, 0xFF, 0xF0, 0x6F, 0x60, 0x03, 0x03, 0x03, 0x06, 0x06,
  0x06, 0x0C, 0x0C, 0x0C, 0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x60, 0x60,
  0x60, 0xE0, 0xC0, 0xC0, 0x1E, 0x0F, 0xC7, 0x39, 0x86, 0xE0, 0xF0, 0x3C,
  0xCF, 0x33, 0xCC, 0xF0, 0x3E, 0x0D, 0x86, 0x73, 0x8F, 0xC1, 0xE0, 0x0C,
  0x0E, 0x0F, 0x0D, 0x88, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01,
  0x80, 0xC3, 0xFD, 0xFE, 0x3E, 0x1F, 0xC4, 0x38, 0x06, 0x01, 0x80, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0x00, 0xC0, 0x60, 0x1F, 0xF7, 0xFC, 0x3E,
  0x1F, 0xC4, 0x38, 0x06, 0x01, 0x80, 0xC1, 0xE0, 0x7C, 0x03, 0x80, 0x60,
  0x0C, 0x07, 0x41, 0x9F, 0xE7, 0xE0, 0x03, 0x01, 0xC0, 0xD0, 0x64, 0x19,
  0x0C, 0x46, 0x11, 0x84, 0xC1, 0x3F, 0xFF, 0xFC, 0x04, 0x01, 0x00, 0x40,
  0x10, 0x7F, 0x3F, 0x98, 0x0C, 0x06, 0x03, 0x01, 0xF0, 0xFC, 0x07, 0x01,
  0x80, 0x60, 0x78, 0x77, 0xF9, 0xF0, 0x03, 0x83, 0xE3, 0xC0, 0xC0, 0x60,
  0x18, 0x0F, 0xF3, 0xFE, 0xE1, 0xB0, 0x3C, 0x0D, 0x83, 0x61, 0x8F, 0xE1,
  0xE0, 0xFF, 0xFF, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x18, 0x18, 0x0C,
  0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x1E, 0x1F, 0xE6, 0x19, 0x86, 0x61,
  0x98, 0x67, 0xB0, 0xFC, 0x77, 0x98, 0x7C, 0x0F, 0x03, 0xE1, 0xDF, 0xE3,
  0xF0, 0x1E, 0x1F, 0xC6, 0x1B, 0x06, 0xC0, 0xF0, 0x36, 0x0D, 0xFF, 0x3F,
  0xC0, 0x60, 0x18, 0x0E, 0x0F, 0x1F, 0x87, 0x80, 0x6F, 0x60, 0x00, 0x00,
  0x6F, 0x60, 0x33, 0xCC, 0x00, 0x00, 0x00, 0x33, 0xCE, 0x6F, 0x60, 0x00,
  0xC0, 0xF1, 0xF1, 0xE0, 0xC0, 0x3E, 0x01, 0xF8, 0x0F, 0x00, 0xC0, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x40, 0x3E, 0x03, 0xE0,
  0x1F, 0x00, 0xC1, 0xF3, 0xE3, 0xE0, 0x40, 0x00, 0x7C, 0xFE, 0x47, 0x03,
  0x03, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x00, 0x00, 0x38, 0x38, 0x38, 0x0F,
  0x0F, 0xE7, 0x1D, 0x83, 0x60, 0xF1, 0xFC, 0xFF, 0x33, 0xD8, 0xF6, 0x3C,
  0xCF, 0x3F, 0xC7, 0xD8, 0x07, 0x00, 0xE0, 0x1F, 0x83, 0xE0, 0x06, 0x00,
  0xF0, 0x0F, 0x00, 0x98, 0x19, 0x81, 0x98, 0x10, 0x83, 0x0C, 0x30, 0xC3,
  0xFC, 0x7F, 0xE6, 0x06, 0x60, 0x66, 0x06, 0xC0, 0x30, 0xFE, 0x3F, 0xCC,
  0x3B, 0x06, 0xC1, 0xB0, 0xEF, 0xE3, 0xFC, 0xC1, 0xB0, 0x3C, 0x0F, 0x03,
  0xC1, 0xBF, 0xEF, 0xE0, 0x0F, 0x8F, 0xF7, 0x0D, 0x80, 0x60, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0E, 0x01, 0x80, 0x70, 0x4F, 0xF0, 0xF8, 0xFC,
  0x3F, 0xCC, 0x3B, 0x06, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x06, 0xC3, 0xBF, 0xCF, 0xC0, 0xFF, 0xFF, 0xF0, 0x18, 0x0C, 0x06,
  0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0xFF, 0xFE, 0xFF,
  0xFF, 0xF0, 0x18, 0x0C, 0x06, 0x03, 0xFD, 0xFE, 0xC0, 0x60, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x0F, 0x8F, 0xF7, 0x09, 0x80, 0xE0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0xF0, 0x3E, 0x0D, 0x83, 0x70, 0xCF, 0xF0, 0xFC, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3F, 0xFF, 0xFF, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0x18, 0xFF, 0xFF, 0x3F, 0x9F, 0xC0,
  0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x34, 0x3F,
  0xF8, 0xF8, 0xC1, 0xB0, 0xCC, 0x63, 0x38, 0xDC, 0x3E, 0x0F, 0x03, 0xC0,
  0xD8, 0x33, 0x0C, 0x63, 0x1C, 0xC3, 0xB0, 0x6C, 0x1C, 0xC0, 0x60, 0x30,
  0x18, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07,
  0xFF, 0xFE, 0x61, 0x98, 0x67, 0x1B, 0xCF, 0xD2, 0xF4, 0xBD, 0xEF, 0x33,
  0xCC, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0C, 0xE0, 0xF8, 0x3F,
  0x0F, 0xC3, 0xD8, 0xF6, 0x3C, 0xCF, 0x33, 0xC6, 0xF1, 0xBC, 0x2F, 0x0F,
  0xC1, 0xF0, 0x7C, 0x1C, 0x1E, 0x1F, 0xE6, 0x1B, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x61, 0x9F, 0xE1, 0xE0, 0xFC,
  0x7F, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x86, 0xFF, 0x7E, 0x30, 0x18,
  0x0C, 0x06, 0x03, 0x00, 0x1E, 0x1F, 0xE6, 0x1B, 0x07, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0x61, 0x9F, 0xE1, 0xE0, 0x30,
  0x0F, 0x01, 0xF0, 0x18, 0xFE, 0x3F, 0xCC, 0x3B, 0x06, 0xC1, 0xB0, 0x6C,
  0x1B, 0x0E, 0xFF, 0x3F, 0x8C, 0x63, 0x0C, 0xC1, 0xB0, 0x6C, 0x0C, 0x1F,
  0x1F, 0xE6, 0x09, 0x80, 0x60, 0x1C, 0x03, 0xC0, 0x7C, 0x07, 0x80, 0x60,
  0x0C, 0x03, 0x41, 0xBF, 0xE3, 0xE0, 0xFF, 0xFF, 0xF0, 0xC0, 0x30, 0x0C,
  0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03, 0x00,
  0xC0, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x0F, 0x87, 0x61, 0x9F, 0xE3, 0xE0, 0xE0, 0x36, 0x06, 0x60,
  0x66, 0x06, 0x70, 0x63, 0x0C, 0x30, 0xC3, 0x0C, 0x19, 0x81, 0x98, 0x19,
  0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x06, 0x00, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0xCF, 0x33, 0xDE, 0xF4, 0xBD, 0x2F, 0xCF, 0x63, 0x98,
  0x66, 0x18, 0xC0, 0xD8, 0x66, 0x18, 0xCC, 0x3B, 0x07, 0x81, 0xE0, 0x30,
  0x1E, 0x07, 0x83, 0x31, 0xCE, 0x61, 0xB0, 0x3C, 0x0C, 0xE0, 0x76, 0x06,
  0x70, 0xE3, 0x0C, 0x38, 0xC1, 0x98, 0x1F, 0x80, 0xF0, 0x0F, 0x00, 0x60,
  0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x7F, 0xDF, 0xF0, 0x18,
  0x0E, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0E, 0x03, 0x01, 0x80, 0x60,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFC, 0x30, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30,
  0xC3, 0x0C, 0x30, 0xC3, 0xFF, 0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x30, 0x18, 0x18, 0x18, 0x0C, 0x0C, 0x0C, 0x06, 0x06, 0x06,
  0x03, 0x03, 0x03, 0xFF, 0xF0, 0xC3, 0x0C, 0x30, 0xC3, 0x0C, 0x30, 0xC3,
  0x0C, 0x30, 0xC3, 0x0F, 0xFF, 0xC0, 0x0C, 0x07, 0x81, 0xE0, 0xCC, 0x73,
  0x98, 0x6C, 0x0D, 0x02, 0xFF, 0xFF, 0xFF, 0x4E, 0x62, 0x3F, 0x1F, 0xC0,
  0x60, 0x33, 0xFB, 0xFF, 0x87, 0x83, 0x61, 0xBF, 0xCF, 0xE0, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x06, 0x03, 0xF1, 0xFE, 0xC3, 0x60, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x0D, 0xFE, 0xFC, 0x00, 0x1F, 0xCF, 0xE7, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x80, 0x70, 0x0F, 0xF1, 0xFC, 0x01, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0C, 0x7E, 0xFF, 0x61, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0D,
  0x86, 0xFF, 0x1F, 0x80, 0x1F, 0x1F, 0xE6, 0x1B, 0x03, 0xFF, 0xFF, 0xFC,
  0x03, 0x00, 0x70, 0x9F, 0xE1, 0xF8, 0x0F, 0x87, 0xE3, 0x88, 0xC0, 0x30,
  0x0C, 0x0F, 0xF3, 0xFC, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0x0C, 0x03,
  0x00, 0xC0, 0x30, 0x00, 0x1F, 0xBF, 0xD8, 0x78, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0x61, 0xBF, 0xCF, 0xE0, 0x34, 0x3B, 0xF9, 0xF8, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0xC0, 0xFC, 0xFF, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3,
  0xC3, 0xC3, 0x18, 0x0F, 0x01, 0x80, 0x00, 0x00, 0x3E, 0x0F, 0x80, 0x20,
  0x08, 0x02, 0x00, 0x80, 0x20, 0x0C, 0x03, 0x10, 0xFC, 0x1E, 0x0E, 0x1C,
  0x38, 0x00, 0x0F, 0xDF, 0x83, 0x06, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83,
  0x07, 0x0F, 0xFF, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x03, 0x0F,
  0x8E, 0xCE, 0x6E, 0x3C, 0x1E, 0x0D, 0x86, 0x63, 0x19, 0x86, 0xC1, 0x80,
  0xF8, 0x3E, 0x00, 0x80, 0x20, 0x08, 0x02, 0x00, 0x80, 0x20, 0x08, 0x02,
  0x00, 0x80, 0x20, 0x08, 0x03, 0x00, 0xC4, 0x3F, 0x07, 0x80, 0xFB, 0xBF,
  0xFC, 0xCF, 0x33, 0xCC, 0xF3, 0x3C, 0xCF, 0x03, 0xC0, 0xF0, 0x3C, 0x0C,
  0xFC, 0xFF, 0xC7, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0x1E,
  0x1F, 0xE6, 0x1B, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0x61, 0x9F, 0xE1,
  0xE0, 0xFC, 0x7F, 0xB0, 0xD8, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x7F,
  0xBF, 0x18, 0x0C, 0x06, 0x03, 0x00, 0x1F, 0xBF, 0xD8, 0x7C, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0x61, 0xBF, 0xC7, 0xE0, 0x30, 0x18, 0x0C, 0x06, 0x7E,
  0xFE, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0x7E, 0xFF,
  0xC1, 0xC0, 0xF8, 0x7E, 0x0F, 0x03, 0x83, 0xFF, 0xFE, 0x30, 0x18, 0x0C,
  0x1F, 0xFF, 0xF9, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x06, 0x13, 0xF8,
  0xF8, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xC3, 0xE3, 0xFF, 0x3F,
  0xC0, 0xF0, 0x3E, 0x1D, 0x86, 0x61, 0x8C, 0xC3, 0x30, 0xDC, 0x1E, 0x07,
  0x80, 0xC0, 0xC0, 0x24, 0x02, 0x60, 0x66, 0x66, 0x66, 0x66, 0xF6, 0x6F,
  0x66, 0x94, 0x39, 0xC3, 0x1C, 0x30, 0xC0, 0xC1, 0xD8, 0x63, 0x30, 0xF8,
  0x1E, 0x03, 0x01, 0xE0, 0xCC, 0x61, 0x98, 0x6C, 0x0C, 0xC0, 0xD8, 0x36,
  0x19, 0x86, 0x31, 0x8C, 0x63, 0x30, 0x6C, 0x1A, 0x03, 0x80, 0xE0, 0x30,
  0x1C, 0x3E, 0x0F, 0x00, 0xFF, 0xFF, 0x06, 0x0E, 0x1C, 0x18, 0x30, 0x60,
  0xC0, 0xFF, 0xFF, 0x0F, 0x1F, 0x18, 0x10, 0x10, 0x10, 0x10, 0x10, 0x30,
  0x30, 0xE0, 0xE0, 0x30, 0x30, 0x10, 0x10, 0x10, 0x10, 0x18, 0x1F, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0xF8, 0x18, 0x0C, 0x0C, 0x0C,
  0x0C, 0x0C, 0x0C, 0x0C, 0x07, 0x0F, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C, 0x0C,
  0x18, 0xF8, 0xF0, 0x70, 0x5F, 0x3C, 0xFA, 0x0E,
};

const GFXglyph UbuntuMono_Regular24pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 4, 15, 12, 4, -15 },
  { 9, 6, 6, 12, 3, -16 },
  { 14, 10, 15, 12, 1, -15 },
  { 33, 10, 19, 12, 1, -17 },
  { 57, 12, 15, 12, 0, -15 },
  { 80, 10, 15, 12, 1, -15 },
  { 99, 2, 6, 12, 5, -16 },
  { 101, 6, 19, 12, 3, -15 },
  { 116, 6, 19, 12, 3, -15 },
  { 131, 10, 9, 12, 1, -15 },
  { 143, 10, 10, 12, 1, -11 },
  { 156, 4, 6, 12, 4, -3 },
  { 159, 6, 2, 12, 3, -7 },
  { 161, 4, 3, 12, 4, -3 },
  { 163, 8, 21, 12, 2, -17 },
  { 184, 10, 15, 12, 1, -15 },
  { 203, 9, 15, 12, 2, -15 },
  { 220, 10, 15, 12, 1, -15 },
  { 239, 10, 15, 12, 1, -15 },
  { 258, 10, 15, 12, 1, -15 },
  { 277, 9, 15, 12, 2, -15 },
  { 294, 10, 15, 12, 1, -15 },
  { 313, 9, 15, 12, 2, -15 },
  { 330, 10, 15, 12, 1, -15 },
  { 349, 10, 15, 12, 1, -15 },
  { 368, 4, 11, 12, 4, -11 },
  { 374, 5, 14, 12, 3, -11 },
  { 383, 10, 9, 12, 1, -11 },
  { 395, 10, 7, 12, 1, -10 },
  { 404, 10, 9, 12, 1, -11 },
  { 416, 8, 15, 12, 2, -15 },
  { 431, 10, 18, 12, 1, -15 },
  { 454, 12, 15, 12, 0, -15 },
  { 477, 10, 15, 12, 1, -15 },
  { 496, 10, 15, 12, 1, -15 },
  { 515, 10, 15, 12, 1, -15 },
  { 534, 9, 15, 12, 2, -15 },
  { 551, 9, 15, 12, 2, -15 },
  { 568, 10, 15, 12, 1, -15 },
  { 587, 10, 15, 12, 1, -15 },
  { 606, 8, 15, 12, 2, -15 },
  { 621, 9, 15, 12, 1, -15 },
  { 638, 10, 15, 12, 2, -15 },
  { 657, 9, 15, 12, 2, -15 },
  { 674, 10, 15, 12, 1, -15 },
  { 693, 10, 15, 12, 1, -15 },
  { 712, 10, 15, 12, 1, -15 },
  { 731, 9, 15, 12, 2, -15 },
  { 748, 10, 19, 12, 1, -15 },
  { 772, 10, 15, 12, 1, -15 },
  { 791, 10, 15, 12, 1, -15 },
  { 810, 10, 15, 12, 1, -15 },
  { 829, 10, 15, 12, 1, -15 },
  { 848, 12, 15, 12, 0, -15 },
  { 871, 10, 15, 12, 1, -15 },
  { 890, 10, 15, 12, 1, -15 },
  { 909, 12, 15, 12, 0, -15 },
  { 932, 10, 15, 12, 1, -15 },
  { 951, 6, 19, 12, 3, -15 },
  { 966, 8, 21, 12, 2, -17 },
  { 987, 6, 19, 12, 3, -15 },
  { 1002, 10, 8, 12, 1, -15 },
  { 1012, 12, 2, 12, 0, 2 },
  { 1015, 4, 4, 12, 4, -16 },
  { 1017, 9, 11, 12, 1, -11 },
  { 1030, 9, 17, 12, 2, -17 },
  { 1050, 10, 11, 12, 1, -11 },
  { 1064, 9, 17, 12, 1, -17 },
  { 1084, 10, 11, 12, 1, -11 },
  { 1098, 10, 17, 12, 2, -17 },
  { 1120, 9, 15, 12, 1, -11 },
  { 1137, 8, 17, 12, 2, -17 },
  { 1154, 10, 16, 12, 1, -16 },
  { 1174, 7, 20, 12, 2, -16 },
  { 1192, 9, 17, 12, 2, -17 },
  { 1212, 10, 17, 12, 1, -17 },
  { 1234, 10, 11, 12, 1, -11 },
  { 1248, 8, 11, 12, 2, -11 },
  { 1259, 10, 11, 12, 1, -11 },
  { 1273, 9, 15, 12, 2, -11 },
  { 1290, 9, 15, 12, 1, -11 },
  { 1307, 8, 11, 12, 3, -11 },
  { 1318, 8, 11, 12, 2, -11 },
  { 1329, 9, 14, 12, 2, -14 },
  { 1345, 8, 11, 12, 2, -11 },
  { 1356, 10, 11, 12, 1, -11 },
  { 1370, 12, 11, 12, 0, -11 },
  { 1387, 10, 11, 12, 1, -11 },
  { 1401, 10, 15, 12, 1, -11 },
  { 1420, 8, 11, 12, 2, -11 },
  { 1431, 8, 21, 12, 2, -17 },
  { 1452, 2, 21, 12, 5, -17 },
  { 1458, 8, 21, 12, 2, -17 },
  { 1479, 10, 4, 12, 1, -9 },
};

const GFXfont UbuntuMono_Regular24pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular24pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular24pt7bGlyphs,
  0x20, 0x7E, 24
};

#endif // _UBUNTUMONO_REGULAR24PT7B_H_
