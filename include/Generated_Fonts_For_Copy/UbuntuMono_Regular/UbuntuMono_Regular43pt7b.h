#ifndef _UBUNTUMONO_REGULAR43PT7B_H_
#define _UBUNTUMONO_REGULAR43PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: UbuntuMono-Regular.ttf
// Size: 43pt @ 72dpi, chars: 0x20-0x7E

const uint8_t UbuntuMono_Regular43pt7bBitmaps[] PROGMEM = {
  0x00, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9E, 0x79, 0xE7, 0x9C, 0x71, 0xC7,
  0x1C, 0x70, 0x00, 0x00, 0x01, 0xCF, 0xBF, 0xFF, 0xE7, 0x00, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xE1, 0xF8, 0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x6C, 0x18,
  0x01, 0xC1, 0xC0, 0x78, 0x78, 0x0E, 0x0E, 0x01, 0xC1, 0xC0, 0x38, 0x38,
  0x07, 0x07, 0x01, 0xE1, 0xE7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1C, 0x1C, 0x07, 0x87, 0x80, 0xF0, 0xF0, 0x1C, 0x1C, 0x03, 0x83, 0x80,
  0x70, 0x70, 0x0E, 0x0E, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF1,
  0xC1, 0xC0, 0x38, 0x38, 0x0F, 0x0F, 0x01, 0xC1, 0xC0, 0x38, 0x38, 0x07,
  0x07, 0x00, 0xE0, 0xE0, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00,
  0x38, 0x00, 0x3F, 0xC0, 0xFF, 0xF8, 0xFF, 0xFC, 0x7C, 0x0C, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x40, 0x07, 0xBC, 0x0F,
  0x9F, 0xFF, 0xCF, 0xFF, 0xC1, 0xFF, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x3E, 0x00, 0xE7, 0xF0, 0x1C, 0xE7,
  0x01, 0xCE, 0x38, 0x38, 0xE3, 0x83, 0x8C, 0x38, 0x70, 0xC3, 0x8E, 0x0C,
  0x38, 0xE0, 0xE3, 0x9C, 0x0E, 0x39, 0xC0, 0x67, 0x38, 0x07, 0xF7, 0x00,
  0x3E, 0x70, 0x00, 0x0E, 0x00, 0x00, 0xE7, 0x80, 0x1C, 0xFC, 0x03, 0x9C,
  0xE0, 0x39, 0x86, 0x07, 0x18, 0x70, 0x73, 0x87, 0x0E, 0x38, 0x71, 0xC3,
  0x87, 0x1C, 0x18, 0x73, 0x81, 0x86, 0x38, 0x1C, 0xE7, 0x00, 0xFC, 0xE0,
  0x07, 0x80, 0x03, 0xE0, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0x1E, 0x03,
  0xC1, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x01, 0xE0, 0xE0, 0x1C, 0x3C, 0x03,
  0xCF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x1C, 0x3F, 0x83, 0x8F,
  0x78, 0x71, 0xC7, 0x9C, 0x78, 0xFB, 0x8E, 0x0F, 0xF3, 0xC0, 0xFE, 0x78,
  0x0F, 0x8F, 0x00, 0xF1, 0xE0, 0x1E, 0x1E, 0x07, 0xE3, 0xE3, 0xFE, 0x3F,
  0xFB, 0xC3, 0xFE, 0x3C, 0x3F, 0x07, 0x80, 0xFF, 0xFF, 0xFE, 0xEE, 0xEE,
  0x60, 0x00, 0x40, 0x0E, 0x01, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E, 0x01,
  0xE0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x70, 0x0F, 0x00, 0xF0, 0x0E,
  0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0x70, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x01, 0xE0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0E, 0x00, 0x40, 0x40, 0x07, 0x00,
  0xF8, 0x07, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0F,
  0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x0E, 0x01, 0xE0, 0x1C,
  0x03, 0xC0, 0x3C, 0x07, 0x80, 0x78, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x07, 0x00, 0x60, 0x00, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x38, 0x06, 0x1C, 0x13, 0xC6, 0x39, 0xFB, 0x7E, 0xFF, 0xFF, 0x3F, 0xFE,
  0x00, 0xF0, 0x00, 0xFC, 0x00, 0xEF, 0x00, 0xF3, 0xC0, 0xF1, 0xF0, 0x78,
  0x70, 0x08, 0x10, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00,
  0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C,
  0x00, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x0F,
  0xC7, 0xE3, 0xF1, 0xF8, 0x7C, 0x1E, 0x1E, 0x3E, 0x7F, 0x1E, 0x0C, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x7B, 0xFF, 0xFF, 0xFD, 0xE0, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x38, 0x00, 0x78, 0x00, 0x70, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x03,
  0xF0, 0x03, 0xFE, 0x01, 0xFF, 0xC0, 0xF8, 0x78, 0x3C, 0x0F, 0x1E, 0x03,
  0xC7, 0x80, 0x79, 0xC0, 0x1E, 0xF0, 0x07, 0xBC, 0x00, 0xEF, 0x1C, 0x3B,
  0xC7, 0x8E, 0xF3, 0xE3, 0xBC, 0xF8, 0xFF, 0x1E, 0x3F, 0xC7, 0x0E, 0xF0,
  0x03, 0xBC, 0x00, 0xEF, 0x00, 0x79, 0xC0, 0x1E, 0x78, 0x07, 0x9E, 0x03,
  0xC3, 0xC0, 0xF0, 0xF8, 0x78, 0x1F, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0x00,
  0x00, 0xE0, 0x01, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0xE0,
  0x79, 0xE0, 0x61, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x3F, 0xFF, 0x3F, 0xFF, 0x3F, 0xFF, 0x07, 0xF0, 0x0F, 0xFE, 0x1F, 0xFF,
  0x8F, 0x87, 0xC7, 0x00, 0xF1, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0xBF,
  0xFF, 0xDF, 0xFF, 0xE0, 0x1F, 0xC0, 0x7F, 0xF0, 0xFF, 0xF8, 0x70, 0x7C,
  0x40, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x1E, 0xC0, 0x7E, 0xFF, 0xFC, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x77, 0x80,
  0x3D, 0xE0, 0x1E, 0x78, 0x07, 0x1E, 0x03, 0x87, 0x81, 0xE1, 0xE0, 0x70,
  0x78, 0x38, 0x1E, 0x0E, 0x07, 0x87, 0x01, 0xE3, 0xC0, 0x78, 0xE0, 0x1E,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x3F,
  0xFE, 0x3F, 0xFE, 0x3F, 0xFE, 0x3C, 0x00, 0x38, 0x00, 0x38, 0x00, 0x38,
  0x00, 0x38, 0x00, 0x38, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x3F,
  0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1E, 0xC0, 0x7E, 0xFF,
  0xFC, 0xFF, 0xF8, 0x3F, 0xC0, 0x00, 0x1F, 0x00, 0x7F, 0x80, 0xFF, 0xC0,
  0xFE, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38, 0x00,
  0x3C, 0x00, 0x1C, 0xFC, 0x0F, 0xFF, 0x87, 0xFF, 0xE7, 0xC0, 0xFB, 0xC0,
  0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xEE, 0x00, 0x77,
  0x80, 0x7B, 0xC0, 0x3C, 0xF0, 0x3C, 0x7C, 0x3E, 0x1F, 0xFE, 0x07, 0xFE,
  0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x38,
  0x00, 0x3C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x70, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x00, 0x03, 0x80,
  0x00, 0x03, 0xF0, 0x07, 0xFE, 0x07, 0xFF, 0x87, 0x83, 0xE7, 0x80, 0xF3,
  0x80, 0x3D, 0xC0, 0x1E, 0xE0, 0x0F, 0x78, 0x07, 0x3C, 0x03, 0x8F, 0x03,
  0xC7, 0xE3, 0xC1, 0xFF, 0xC0, 0x7F, 0xE0, 0x7F, 0xF8, 0x78, 0x3E, 0x78,
  0x0F, 0xB8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x3D,
  0xE0, 0x1E, 0xF8, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF, 0x01, 0xFE, 0x00, 0x07,
  0xF0, 0x07, 0xFC, 0x0F, 0xFF, 0x87, 0x83, 0xC7, 0x80, 0xF3, 0x80, 0x3B,
  0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x77, 0x80, 0x3B, 0xE0, 0x7C, 0xFF, 0xFE, 0x3F, 0xFF, 0x07, 0xF7, 0x80,
  0x03, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0,
  0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xE0, 0x0F, 0x00, 0x00, 0x7B, 0xFF, 0xFF,
  0xFD, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xBF, 0xFF, 0xFF, 0xDE,
  0x0F, 0x0F, 0xC7, 0xE3, 0xF1, 0xF8, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x1F, 0x8F, 0xC7, 0xE1, 0xF0, 0x78,
  0x78, 0xF9, 0xFC, 0x78, 0x30, 0x00, 0x00, 0x00, 0x80, 0x01, 0xE0, 0x01,
  0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x03, 0xF8, 0x00,
  0xF0, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1E, 0x00, 0x00, 0x80, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x40, 0x00,
  0x1E, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xC0, 0x07, 0xF0, 0x07, 0xF8, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x00,
  0x00, 0x3F, 0xC3, 0xFF, 0xCF, 0xFF, 0x90, 0x3E, 0x00, 0x78, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x1C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x38, 0x01, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x00, 0xE0,
  0x00, 0x01, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7C, 0x3E, 0x3C, 0x07,
  0x8E, 0x00, 0xF7, 0x80, 0x3D, 0xC0, 0x07, 0x70, 0x01, 0xFC, 0x0F, 0xFF,
  0x07, 0xFF, 0x83, 0xFF, 0xE1, 0xE1, 0xF8, 0xF0, 0x7E, 0x3C, 0x1F, 0x8F,
  0x07, 0xE3, 0x81, 0xF8, 0xE0, 0x7E, 0x38, 0x1F, 0x8F, 0x07, 0xF3, 0xC1,
  0xFC, 0x78, 0x7F, 0x1F, 0xFD, 0xC3, 0xFF, 0x78, 0x3F, 0x9E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xF0, 0x0F,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF8, 0x00, 0x1D, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0x71,
  0xE0, 0x03, 0x87, 0x00, 0x3C, 0x38, 0x01, 0xC1, 0xE0, 0x0E, 0x0F, 0x00,
  0xF0, 0x38, 0x07, 0x01, 0xC0, 0x38, 0x0F, 0x03, 0xC0, 0x38, 0x1E, 0x01,
  0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x7F, 0xFF, 0xC3, 0x80, 0x0E, 0x1C,
  0x00, 0x78, 0xE0, 0x03, 0xCF, 0x00, 0x0E, 0x78, 0x00, 0x73, 0x80, 0x03,
  0xFC, 0x00, 0x1E, 0x7F, 0xE0, 0x7F, 0xFE, 0x3F, 0xFF, 0x9E, 0x07, 0xCF,
  0x00, 0xF7, 0x80, 0x7B, 0xC0, 0x1D, 0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x07,
  0x3C, 0x0F, 0x9F, 0xFF, 0x8F, 0xFF, 0x87, 0xFF, 0xF3, 0xC0, 0x7D, 0xE0,
  0x1F, 0xF0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x3F, 0xC0, 0x3F, 0xE0, 0x3E, 0xFF, 0xFE, 0x7F, 0xFE, 0x1F, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x0E, 0x3E, 0x00,
  0x8F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00,
  0x0F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x06, 0x0F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1F, 0xE0, 0x7F, 0xC0, 0x3F, 0xFC, 0x0F, 0xFF, 0xC3, 0xC1, 0xF8, 0xF0,
  0x1E, 0x3C, 0x03, 0xCF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x03, 0xBC, 0x00,
  0xEF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xEF, 0x00, 0x3B, 0xC0, 0x1E, 0xF0,
  0x07, 0xBC, 0x03, 0xCF, 0x01, 0xE3, 0xC1, 0xF8, 0xFF, 0xFC, 0x3F, 0xFC,
  0x07, 0xFC, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFE, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xFF, 0xF8, 0xFF, 0xF8, 0xFF, 0xF8, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0xFF, 0xEF, 0xFF, 0xDF, 0xFF, 0xB8,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00,
  0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0x7E, 0x0E, 0x3E, 0x00, 0x8F,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x3F, 0xC0, 0x0F,
  0xF0, 0x03, 0xFC, 0x00, 0xF7, 0x00, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xCF,
  0x00, 0xF3, 0xE0, 0x3C, 0x7C, 0x0F, 0x0F, 0xFF, 0xC1, 0xFF, 0xF0, 0x1F,
  0xE0, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x80, 0x1E,
  0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0x1F, 0xFF, 0x1F, 0xFF, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x40, 0x1E,
  0x70, 0x3E, 0xFF, 0xFC, 0x7F, 0xF8, 0x0F, 0xE0, 0xE0, 0x07, 0xB8, 0x03,
  0xCE, 0x01, 0xE3, 0x80, 0x78, 0xE0, 0x3C, 0x38, 0x1E, 0x0E, 0x0F, 0x03,
  0x87, 0xC0, 0xE3, 0xE0, 0x38, 0xF0, 0x0E, 0x78, 0x03, 0xBC, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x0E, 0xF8, 0x03, 0x9F, 0x00, 0xE3, 0xE0, 0x38, 0x7C,
  0x0E, 0x0F, 0x83, 0x81, 0xF0, 0xE0, 0x3C, 0x38, 0x07, 0x8E, 0x01, 0xF3,
  0x80, 0x3C, 0xE0, 0x07, 0xB8, 0x01, 0xEE, 0x00, 0x3C, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0,
  0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x3C, 0x03, 0x87, 0x80, 0xF0, 0xF0, 0x1F, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x6C, 0x1F, 0x8D, 0xC3, 0xF1, 0xB8, 0x6E, 0x73, 0x1D,
  0xCE, 0x73, 0xB9, 0xCE, 0x67, 0x38, 0xDC, 0xE7, 0x1B, 0x9C, 0xE3, 0xE3,
  0x9C, 0x7C, 0x7B, 0x87, 0x8F, 0x70, 0xF1, 0xEE, 0x00, 0x1D, 0xC0, 0x03,
  0xB8, 0x00, 0x77, 0x00, 0x0E, 0xE0, 0x01, 0xDC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0x80, 0xF0, 0x03, 0xFC, 0x01,
  0xFE, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x0F, 0xEE,
  0x07, 0xF7, 0x03, 0xF9, 0xC1, 0xFC, 0xE0, 0xFE, 0x38, 0x7F, 0x1C, 0x3F,
  0x87, 0x1F, 0xC3, 0x8F, 0xE0, 0xE7, 0xF0, 0x73, 0xF8, 0x3D, 0xFC, 0x0E,
  0xFE, 0x07, 0x7F, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0xF0,
  0x0F, 0xF8, 0x03, 0xFC, 0x01, 0xE0, 0x01, 0xF8, 0x00, 0xFF, 0xC0, 0x3F,
  0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x9E, 0x00, 0x73, 0xC0,
  0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x3D, 0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1C, 0x70, 0x07, 0x8F, 0x01,
  0xE0, 0xF0, 0x7C, 0x1F, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x7F,
  0xE0, 0x7F, 0xFC, 0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x00, 0xF7, 0x80, 0x7B,
  0xC0, 0x1D, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xDE, 0x01,
  0xEF, 0x00, 0xF7, 0x81, 0xF3, 0xFF, 0xF1, 0xFF, 0xF0, 0xFF, 0xE0, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0xFF, 0xC0, 0x3F, 0xFC, 0x0F, 0x07, 0xC3, 0xC0, 0x78, 0x70, 0x07, 0x9E,
  0x00, 0x73, 0xC0, 0x0F, 0x70, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3D, 0xC0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x1C, 0xF0,
  0x07, 0x8F, 0x01, 0xF0, 0xF0, 0x7C, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x0F,
  0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x38, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF,
  0xC3, 0xC0, 0xF8, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00, 0x73, 0xC0, 0x1C,
  0xF0, 0x07, 0xBC, 0x01, 0xCF, 0x00, 0x73, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C,
  0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0xFF, 0xF0, 0x3C, 0x1E, 0x0F, 0x03,
  0x83, 0xC0, 0xF0, 0xF0, 0x1C, 0x3C, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x3C,
  0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0x3C, 0x03, 0xF8, 0x07, 0xFF, 0x87,
  0xFF, 0xC7, 0xC1, 0xE7, 0x80, 0x23, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x3F,
  0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0,
  0x00, 0x70, 0x00, 0x38, 0x00, 0x3D, 0x00, 0x1E, 0xF0, 0x3E, 0x7F, 0xFF,
  0x3F, 0xFE, 0x03, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x7B, 0x80, 0x3D, 0xE0, 0x3E, 0xF8, 0x3E, 0x3F, 0xFE, 0x0F,
  0xFE, 0x01, 0xFC, 0x00, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0xEF,
  0x00, 0x1E, 0x70, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x01, 0xC7, 0x80, 0x3C,
  0x38, 0x03, 0xC3, 0xC0, 0x3C, 0x3C, 0x03, 0x81, 0xC0, 0x78, 0x1E, 0x07,
  0x81, 0xE0, 0x70, 0x1E, 0x0F, 0x00, 0xE0, 0xF0, 0x0F, 0x0E, 0x00, 0xF0,
  0xE0, 0x07, 0x1E, 0x00, 0x79, 0xC0, 0x07, 0x9C, 0x00, 0x3B, 0xC0, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x77, 0x00, 0x0E,
  0xE0, 0x01, 0xDC, 0x00, 0x3B, 0x80, 0x07, 0x70, 0x01, 0xEE, 0x00, 0x3D,
  0xC3, 0x87, 0xB8, 0x78, 0xF7, 0x1F, 0x1C, 0xE3, 0xE3, 0x9C, 0x6E, 0x73,
  0x9D, 0xCE, 0x73, 0x99, 0xCE, 0x63, 0xB9, 0xCC, 0x77, 0x3B, 0x86, 0xE3,
  0x70, 0xFC, 0x6C, 0x1F, 0x8F, 0x81, 0xF1, 0xF0, 0x3E, 0x3C, 0x07, 0x87,
  0x80, 0xF0, 0xF0, 0x0E, 0x00, 0x78, 0x01, 0xEF, 0x00, 0x78, 0xF0, 0x0F,
  0x1E, 0x03, 0xC1, 0xE0, 0x78, 0x1C, 0x1E, 0x03, 0xC3, 0x80, 0x3C, 0xF0,
  0x07, 0xBC, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0xF7, 0x80,
  0x1C, 0x78, 0x07, 0x87, 0x81, 0xE0, 0xF0, 0x3C, 0x0F, 0x0F, 0x01, 0xE1,
  0xE0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x3F, 0xC0, 0x07, 0x80, 0xF0, 0x00,
  0xFF, 0x00, 0x0E, 0x70, 0x01, 0xE7, 0x80, 0x1E, 0x78, 0x03, 0xC3, 0xC0,
  0x3C, 0x3C, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x00, 0xF0, 0xF0, 0x0F,
  0x1E, 0x00, 0x79, 0xE0, 0x07, 0xBC, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0xFF, 0x9F, 0xFF, 0xE7, 0xFF,
  0xF8, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xE0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3C, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0xF0, 0x00, 0xE0, 0x01, 0xC0, 0x03,
  0xC0, 0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0xC0,
  0x07, 0x80, 0x07, 0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x80, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78,
  0x00, 0xF0, 0x00, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x07, 0x01, 0xC0, 0x70,
  0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0,
  0x70, 0x1C, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0x78, 0x03, 0xCE, 0x00, 0xE3, 0xC0, 0x78, 0x70, 0x3C, 0x1E, 0x0F,
  0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x1E, 0xF0, 0x03, 0xB8, 0x00, 0xF2, 0x00,
  0x10, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x20, 0xC3, 0xC3,
  0xC3, 0xC3, 0x83, 0x82, 0x0F, 0xF0, 0x0F, 0xFE, 0x07, 0xFF, 0x83, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x07, 0xFF, 0x8F,
  0xFF, 0xCF, 0xFF, 0xEF, 0x80, 0xF7, 0x80, 0x7F, 0x80, 0x3D, 0xC0, 0x1E,
  0xF0, 0x0F, 0x7C, 0x07, 0x9F, 0xFF, 0xC7, 0xFF, 0xE0, 0xFF, 0xC0, 0x70,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3D, 0xF8, 0x1F, 0xFF,
  0x0F, 0xFF, 0xC7, 0xC1, 0xF3, 0xC0, 0x7D, 0xE0, 0x1E, 0xF0, 0x07, 0x78,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F,
  0xE0, 0x0E, 0xF0, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x9F, 0xFF, 0x8F, 0xFF,
  0x81, 0xFF, 0x00, 0x01, 0xFF, 0x03, 0xFF, 0xC7, 0xFF, 0xE7, 0xE0, 0x23,
  0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3F, 0x01, 0x8F, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07,
  0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x07, 0xE7, 0x1F, 0xFF, 0x3F, 0xFF,
  0x7C, 0x1F, 0x78, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x70, 0x07,
  0x78, 0x07, 0x3E, 0x07, 0x1F, 0xFF, 0x0F, 0xFF, 0x03, 0xFC, 0x03, 0xF0,
  0x03, 0xFF, 0x01, 0xFF, 0xE0, 0xF8, 0x7C, 0x78, 0x07, 0x9C, 0x01, 0xEF,
  0x00, 0x3B, 0x80, 0x0E, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x03,
  0x07, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x7F, 0xF0,
  0x3F, 0xF8, 0x1F, 0x06, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x0F, 0xFF, 0xE3, 0xFF, 0xF8, 0xFF, 0xFE,
  0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00,
  0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38,
  0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x3F, 0xFF, 0x3E, 0x07, 0x78,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0x78, 0x07, 0x7C, 0x1F, 0x3F,
  0xFF, 0x1F, 0xFF, 0x07, 0xE7, 0x00, 0x07, 0x00, 0x07, 0x00, 0x0F, 0x00,
  0x0F, 0x60, 0x3E, 0x7F, 0xFE, 0x7F, 0xF8, 0x1F, 0xE0, 0x70, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0xE0, 0xFF, 0xF8, 0xFF, 0xFC, 0xF0,
  0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0x07, 0x80, 0x07,
  0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x70, 0x03,
  0xE0, 0x1F, 0x80, 0x3E, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0xFF, 0xF3, 0xFF, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38,
  0x00, 0xE0, 0x07, 0x98, 0x3E, 0xFF, 0xF3, 0xFF, 0x81, 0xFC, 0x00, 0x70,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0xF3,
  0xC0, 0x78, 0xF0, 0x3E, 0x3C, 0x1F, 0x0F, 0x0F, 0x83, 0xC7, 0x80, 0xF3,
  0xC0, 0x3D, 0xE0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFF, 0x80, 0x3D, 0xF0,
  0x0F, 0x3E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3C, 0x0F, 0x0F, 0x01, 0xE3,
  0xC0, 0x3C, 0xF0, 0x0F, 0xBC, 0x01, 0xE0, 0xFF, 0xC0, 0x7F, 0xE0, 0x3F,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x20, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xF8, 0x7E,
  0x3E, 0x3F, 0xFF, 0xCF, 0xFF, 0xFB, 0x87, 0x8F, 0xE1, 0xC3, 0xF8, 0x70,
  0x7E, 0x1C, 0x1F, 0x87, 0x07, 0xE1, 0xC1, 0xF8, 0x70, 0x7E, 0x1C, 0x1F,
  0x87, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0x3F, 0xE0, 0xFF, 0xF8,
  0xFF, 0xFC, 0xF0, 0x3E, 0xF0, 0x1E, 0xF0, 0x1E, 0xF0, 0x0E, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF0, 0x0F,
  0x03, 0xF0, 0x03, 0xFF, 0x03, 0xFF, 0xE0, 0xF0, 0x7C, 0x78, 0x0F, 0x1C,
  0x01, 0xEF, 0x00, 0x3B, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00,
  0x3F, 0x80, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x00, 0x79, 0xE0, 0x3C,
  0x3C, 0x1F, 0x0F, 0xFF, 0x80, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x7F,
  0xFC, 0x3F, 0xFF, 0x1E, 0x07, 0xCF, 0x01, 0xE7, 0x80, 0x7B, 0xC0, 0x3D,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x80, 0x3B, 0xC0, 0x3D, 0xE0, 0x3E, 0xF8, 0x3E, 0x7F, 0xFE, 0x3F,
  0xFE, 0x1E, 0xFC, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xFF, 0x1F,
  0xFF, 0x3E, 0x07, 0x78, 0x07, 0x78, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0,
  0x07, 0x78, 0x07, 0x7C, 0x1F, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xE7, 0x00,
  0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00, 0x07, 0x00,
  0x07, 0x1F, 0xFB, 0xFF, 0xFF, 0xFF, 0xBC, 0x02, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03,
  0x80, 0x0E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00,
  0x0F, 0xF8, 0x3F, 0xFE, 0x7F, 0xFC, 0x78, 0x0C, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F, 0xF0, 0x1E, 0xFF, 0xFE,
  0xFF, 0xFC, 0x1F, 0xF0, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00,
  0x0E, 0x00, 0x0E, 0x00, 0x0E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x81, 0x07, 0xFF, 0x03, 0xFF, 0x01, 0xFE, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x03,
  0xBC, 0x07, 0x7C, 0x0E, 0x7F, 0xFC, 0x7F, 0xF8, 0x3F, 0xC0, 0xF0, 0x01,
  0xEF, 0x00, 0x3D, 0xE0, 0x07, 0x3C, 0x01, 0xE3, 0x80, 0x3C, 0x78, 0x07,
  0x0F, 0x01, 0xE0, 0xE0, 0x3C, 0x1E, 0x07, 0x03, 0xC1, 0xE0, 0x3C, 0x3C,
  0x07, 0x87, 0x00, 0x71, 0xE0, 0x0F, 0x38, 0x01, 0xEF, 0x00, 0x1F, 0xC0,
  0x03, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x70, 0x00, 0xE0, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xEE, 0x00, 0x0E, 0xF0, 0x00, 0xEF, 0x0E,
  0x0E, 0x70, 0xF0, 0xE7, 0x0F, 0x0E, 0x71, 0xF0, 0xE7, 0x1F, 0x9C, 0x71,
  0xF9, 0xC7, 0x3B, 0x9C, 0x7B, 0x9D, 0xC3, 0xB1, 0xDC, 0x3F, 0x1D, 0xC3,
  0xF0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1C, 0x07, 0x81, 0xC0, 0x78,
  0x78, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x1E, 0x0F, 0x07, 0x80, 0xF0, 0xE0,
  0x0F, 0x3C, 0x01, 0xEF, 0x00, 0x1F, 0xC0, 0x01, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x01, 0xFC, 0x00, 0x7B, 0xC0, 0x0F, 0x3C, 0x03, 0xC3, 0xC0,
  0xF0, 0x38, 0x3C, 0x07, 0x87, 0x80, 0x79, 0xE0, 0x0F, 0x38, 0x00, 0xF0,
  0xF0, 0x03, 0xFC, 0x00, 0xE7, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x8F,
  0x01, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x1E, 0x0E, 0x07, 0x83, 0x80, 0xE1,
  0xE0, 0x3C, 0x78, 0x0F, 0x1C, 0x01, 0xCF, 0x00, 0x7B, 0x80, 0x0E, 0xE0,
  0x03, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xE0, 0x00,
  0x78, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0xFF, 0x80, 0x3F, 0xC0, 0x0F, 0xC0,
  0x00, 0x7F, 0xFE, 0xFF, 0xFD, 0xFF, 0xF8, 0x01, 0xE0, 0x07, 0xC0, 0x1F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x3E, 0x00, 0x78,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00,
  0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x01, 0xFC,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xC0, 0x03, 0x80,
  0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01,
  0xC0, 0x03, 0x80, 0x07, 0x80, 0x0F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F,
  0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x01, 0xFF, 0x03, 0xFF, 0x00, 0x1E, 0x00, 0x1C,
  0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xFC, 0x00, 0xF8, 0x03, 0xF0, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38, 0x00,
  0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x83, 0xFF, 0x07, 0xFC, 0x0F, 0xE0,
  0x00, 0x1E, 0x01, 0x9F, 0xE0, 0x77, 0xFE, 0x3B, 0x87, 0xFE, 0xE0, 0xFF,
  0x30, 0x0F, 0x80,
};

const GFXglyph UbuntuMono_Regular43pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 22, 0, -1 },
  { 1, 6, 27, 22, 8, -27 },
  { 22, 10, 11, 22, 6, -29 },
  { 36, 19, 27, 22, 1, -27 },
  { 101, 17, 34, 22, 2, -30 },
  { 174, 20, 27, 22, 1, -27 },
  { 242, 19, 27, 22, 1, -27 },
  { 307, 4, 11, 22, 9, -29 },
  { 313, 12, 37, 22, 5, -30 },
  { 369, 12, 37, 22, 5, -30 },
  { 425, 17, 16, 22, 2, -27 },
  { 459, 18, 19, 22, 2, -21 },
  { 502, 9, 12, 22, 6, -6 },
  { 516, 9, 3, 22, 6, -12 },
  { 520, 6, 6, 22, 8, -6 },
  { 525, 16, 37, 22, 3, -30 },
  { 599, 18, 27, 22, 2, -27 },
  { 660, 16, 27, 22, 3, -27 },
  { 714, 17, 27, 22, 2, -27 },
  { 772, 16, 27, 22, 3, -27 },
  { 826, 18, 27, 22, 2, -27 },
  { 887, 16, 27, 22, 3, -27 },
  { 941, 17, 27, 22, 2, -27 },
  { 999, 17, 27, 22, 3, -27 },
  { 1057, 17, 27, 22, 2, -27 },
  { 1115, 17, 27, 22, 2, -27 },
  { 1173, 6, 20, 22, 8, -20 },
  { 1188, 9, 26, 22, 5, -20 },
  { 1218, 18, 17, 22, 2, -19 },
  { 1257, 18, 11, 22, 2, -17 },
  { 1282, 18, 17, 22, 2, -19 },
  { 1321, 14, 27, 22, 4, -27 },
  { 1369, 18, 33, 22, 2, -27 },
  { 1444, 21, 27, 22, 0, -27 },
  { 1515, 17, 27, 22, 2, -27 },
  { 1573, 18, 27, 22, 2, -27 },
  { 1634, 18, 27, 22, 2, -27 },
  { 1695, 16, 27, 22, 4, -27 },
  { 1749, 15, 27, 22, 4, -27 },
  { 1800, 18, 27, 22, 2, -27 },
  { 1861, 18, 27, 22, 2, -27 },
  { 1922, 14, 27, 22, 4, -27 },
  { 1970, 16, 27, 22, 2, -27 },
  { 2024, 18, 27, 22, 3, -27 },
  { 2085, 16, 27, 22, 4, -27 },
  { 2139, 19, 27, 22, 1, -27 },
  { 2204, 17, 27, 22, 2, -27 },
  { 2262, 19, 27, 22, 1, -27 },
  { 2327, 17, 27, 22, 3, -27 },
  { 2385, 19, 34, 22, 1, -27 },
  { 2466, 18, 27, 22, 2, -27 },
  { 2527, 17, 27, 22, 2, -27 },
  { 2585, 18, 27, 22, 2, -27 },
  { 2646, 17, 27, 22, 2, -27 },
  { 2704, 20, 27, 22, 1, -27 },
  { 2772, 19, 27, 22, 1, -27 },
  { 2837, 19, 27, 22, 1, -27 },
  { 2902, 20, 27, 22, 1, -27 },
  { 2970, 18, 27, 22, 2, -27 },
  { 3031, 10, 37, 22, 6, -30 },
  { 3078, 15, 37, 22, 3, -30 },
  { 3148, 10, 37, 22, 5, -30 },
  { 3195, 18, 15, 22, 2, -27 },
  { 3229, 21, 3, 22, 0, 4 },
  { 3237, 7, 8, 22, 7, -30 },
  { 3244, 17, 20, 22, 2, -20 },
  { 3287, 17, 30, 22, 3, -30 },
  { 3351, 17, 20, 22, 2, -20 },
  { 3394, 16, 30, 22, 2, -30 },
  { 3454, 18, 20, 22, 2, -20 },
  { 3499, 18, 30, 22, 3, -30 },
  { 3567, 16, 27, 22, 2, -20 },
  { 3621, 16, 30, 22, 3, -30 },
  { 3681, 17, 28, 22, 2, -28 },
  { 3741, 14, 35, 22, 3, -28 },
  { 3803, 18, 30, 22, 3, -30 },
  { 3871, 17, 30, 22, 2, -30 },
  { 3935, 18, 20, 22, 2, -20 },
  { 3980, 16, 20, 22, 3, -20 },
  { 4020, 18, 20, 22, 2, -20 },
  { 4065, 17, 27, 22, 3, -20 },
  { 4123, 16, 27, 22, 2, -20 },
  { 4177, 14, 20, 22, 5, -20 },
  { 4212, 16, 20, 22, 3, -20 },
  { 4252, 16, 26, 22, 3, -26 },
  { 4304, 15, 20, 22, 3, -20 },
  { 4342, 19, 20, 22, 1, -20 },
  { 4390, 20, 20, 22, 1, -20 },
  { 4440, 19, 20, 22, 1, -20 },
  { 4488, 18, 27, 22, 2, -20 },
  { 4549, 15, 20, 22, 3, -20 },
  { 4587, 15, 37, 22, 3, -30 },
  { 4657, 3, 37, 22, 9, -30 },
  { 4671, 15, 37, 22, 3, -30 },
  { 4741, 18, 6, 22, 2, -14 },
};

const GFXfont UbuntuMono_Regular43pt7b PROGMEM = {
  (uint8_t  *)UbuntuMono_Regular43pt7bBitmaps,
  (GFXglyph *)UbuntuMono_Regular43pt7bGlyphs,
  0x20, 0x7E, 43
};

#endif // _UBUNTUMONO_REGULAR43PT7B_H_
