#ifndef _NOTOSANS_MEDIUMITALIC17PT7B_H_
#define _NOTOSANS_MEDIUMITALIC17PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 17pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic17pt7bBitmaps[] PROGMEM = {
  0x00, 0x19, 0x8C, 0x63, 0x10, 0x8C, 0x00, 0x39, 0xC0, 0xDE, 0xE7, 0x20,
  0x04, 0xC0, 0x98, 0x32, 0x1F, 0xF7, 0xFE, 0x32, 0x06, 0x43, 0xFE, 0xFF,
  0xC6, 0x40, 0x88, 0x13, 0x00, 0x04, 0x0C, 0x3F, 0x69, 0x68, 0x68, 0x38,
  0x1E, 0x16, 0x16, 0x9E, 0xFC, 0x20, 0x20, 0x38, 0x66, 0xC4, 0x4C, 0x8C,
  0xD8, 0xCB, 0x0D, 0xAF, 0x77, 0x90, 0xD9, 0x09, 0x11, 0x13, 0x31, 0x26,
  0x1E, 0x1F, 0x0C, 0xC3, 0x30, 0xCC, 0x3E, 0x0E, 0x06, 0x8F, 0x33, 0x87,
  0xA0, 0xCC, 0xF1, 0xF6, 0xFA, 0x19, 0x88, 0xC4, 0x63, 0x10, 0x84, 0x21,
  0x0C, 0x61, 0x00, 0x18, 0x60, 0x82, 0x0C, 0x20, 0x82, 0x18, 0x61, 0x0C,
  0x61, 0x0C, 0x00, 0x18, 0x18, 0xD0, 0x7F, 0x37, 0x68, 0xC8, 0x0C, 0x18,
  0x18, 0x18, 0xFF, 0xFF, 0x18, 0x18, 0x18, 0x36, 0x6C, 0xF8, 0xFC, 0x01,
  0x81, 0x80, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x30, 0x30, 0x10, 0x18, 0x18,
  0x00, 0x1E, 0x33, 0x63, 0x63, 0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xC6, 0xCC,
  0x78, 0x1C, 0xEF, 0x96, 0x18, 0x61, 0x0C, 0x30, 0xC2, 0x18, 0x1F, 0x18,
  0xC0, 0x60, 0x30, 0x18, 0x18, 0x18, 0x18, 0x18, 0x38, 0x3F, 0xDF, 0xE0,
  0x1F, 0x18, 0xC0, 0x60, 0x30, 0x30, 0xF0, 0x38, 0x06, 0x03, 0x01, 0xB1,
  0x9F, 0x80, 0x03, 0x81, 0xC1, 0xC1, 0xA1, 0xB1, 0x99, 0x8C, 0x84, 0xFF,
  0x83, 0x01, 0x80, 0xC0, 0x3F, 0x30, 0x20, 0x60, 0x68, 0x7E, 0x06, 0x06,
  0x06, 0x06, 0x8C, 0xF8, 0x0F, 0x38, 0x30, 0x60, 0x4C, 0xFE, 0xC2, 0xC3,
  0xC2, 0xC6, 0xEE, 0x7C, 0x7F, 0x81, 0x80, 0xC0, 0xC0, 0x60, 0x60, 0x60,
  0x30, 0x30, 0x18, 0x18, 0x18, 0x00, 0x3F, 0x33, 0x63, 0x63, 0x36, 0x1C,
  0x7E, 0xC6, 0xC2, 0xC6, 0xC6, 0x7C, 0x3E, 0x67, 0x63, 0xC3, 0xC3, 0xC7,
  0x7F, 0x12, 0x06, 0x0C, 0x9C, 0xF8, 0x33, 0x00, 0x00, 0x0E, 0xE0, 0x18,
  0xC0, 0x00, 0x00, 0x06, 0x63, 0x30, 0x03, 0x0E, 0x38, 0xE0, 0xE0, 0x3C,
  0x07, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x70, 0x1C, 0x07, 0x07, 0x1C,
  0xF0, 0x80, 0x7C, 0x8C, 0x18, 0x30, 0xC3, 0x0C, 0x30, 0x00, 0x03, 0x87,
  0x00, 0x07, 0xE0, 0xC1, 0x8C, 0x06, 0xC7, 0x34, 0xCC, 0xE4, 0x46, 0x62,
  0x33, 0x33, 0x99, 0x96, 0x77, 0x30, 0x00, 0xC0, 0x03, 0xF8, 0x02, 0x00,
  0x03, 0x80, 0xE0, 0x78, 0x16, 0x0D, 0x82, 0x21, 0x88, 0xFE, 0x30, 0xD8,
  0x36, 0x0F, 0x03, 0x3F, 0x19, 0xC8, 0x6C, 0x36, 0x3B, 0xF1, 0x9C, 0x86,
  0xC3, 0x61, 0xBF, 0xDF, 0x80, 0x0F, 0xCE, 0x23, 0x01, 0x80, 0x60, 0x30,
  0x0C, 0x03, 0x00, 0xC0, 0x38, 0x07, 0x30, 0xFC, 0x3F, 0x0C, 0xE2, 0x1D,
  0x83, 0x60, 0xD8, 0x36, 0x0D, 0x06, 0xC1, 0xB0, 0xCF, 0xE3, 0xF0, 0x3F,
  0x98, 0x08, 0x0C, 0x06, 0x03, 0xF1, 0x80, 0x80, 0xC0, 0x60, 0x3F, 0x1F,
  0x80, 0x3F, 0x98, 0x08, 0x0C, 0x06, 0x03, 0xF1, 0xF8, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x00, 0x0F, 0xCE, 0x33, 0x01, 0x80, 0x60, 0x30, 0xFC, 0x7F,
  0x02, 0xC1, 0xB8, 0x67, 0x38, 0xFC, 0x30, 0x66, 0x08, 0x83, 0x30, 0x66,
  0x0C, 0xFF, 0x98, 0x22, 0x0C, 0xC1, 0x98, 0x33, 0x04, 0x61, 0x80, 0x3E,
  0x30, 0x60, 0xC1, 0x06, 0x0C, 0x18, 0x30, 0x41, 0x87, 0x80, 0x03, 0x03,
  0x03, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x0C, 0x18, 0x18,
  0xF0, 0x30, 0xCC, 0x62, 0x31, 0x98, 0x6C, 0x1E, 0x07, 0xC1, 0x30, 0xC4,
  0x31, 0x8C, 0x63, 0x0C, 0x30, 0xC2, 0x18, 0x61, 0x86, 0x10, 0xC3, 0x0F,
  0xFF, 0x38, 0x1C, 0xE0, 0xE3, 0x87, 0x9A, 0x1E, 0x68, 0xD9, 0xA2, 0x44,
  0x9B, 0x12, 0x4C, 0xCF, 0x33, 0x38, 0xCC, 0xE2, 0x23, 0x18, 0x30, 0x27,
  0x0C, 0xE1, 0xB4, 0x36, 0xC4, 0xD9, 0x91, 0xB2, 0x36, 0xC2, 0xD8, 0x73,
  0x0E, 0x40, 0xC0, 0x1F, 0x87, 0x39, 0xC3, 0xB0, 0x36, 0x07, 0x80, 0xF0,
  0x1E, 0x06, 0xC0, 0xDC, 0x31, 0xCE, 0x1F, 0x00, 0x3F, 0x19, 0xC8, 0x6C,
  0x36, 0x1B, 0x19, 0xF8, 0x80, 0xC0, 0x60, 0x30, 0x18, 0x00, 0x1F, 0x87,
  0x39, 0xC3, 0xB0, 0x36, 0x07, 0x80, 0xF0, 0x1E, 0x06, 0xC0, 0xDC, 0x31,
  0xDE, 0x1F, 0x00, 0x60, 0x06, 0x00, 0xE0, 0x3F, 0x19, 0xC8, 0x6C, 0x36,
  0x1B, 0x39, 0xF0, 0x98, 0xC6, 0x63, 0x31, 0x98, 0x60, 0x1F, 0x9C, 0x8C,
  0x06, 0x03, 0x00, 0xE0, 0x38, 0x0E, 0x03, 0x01, 0xB3, 0x9F, 0x80, 0x7F,
  0xC6, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x40, 0x60, 0x30, 0x18, 0x0C, 0x0C,
  0x00, 0x30, 0x66, 0x09, 0x83, 0x30, 0x66, 0x0C, 0xC1, 0x90, 0x26, 0x0C,
  0xC1, 0x98, 0x31, 0x9C, 0x1F, 0x00, 0x81, 0xC1, 0xB0, 0xD8, 0xCC, 0x66,
  0x63, 0x31, 0xB0, 0xD8, 0x38, 0x1C, 0x0C, 0x00, 0xC3, 0x0F, 0x1C, 0x3C,
  0x71, 0xB3, 0x46, 0xCD, 0x33, 0x64, 0xCD, 0x92, 0x34, 0x58, 0xF1, 0x43,
  0x87, 0x0E, 0x18, 0x30, 0x60, 0x18, 0x71, 0x8C, 0x0C, 0xC0, 0xD8, 0x07,
  0x00, 0x60, 0x0E, 0x00, 0xB0, 0x1B, 0x03, 0x18, 0x61, 0x8C, 0x18, 0xC3,
  0xC6, 0xC6, 0x4C, 0x58, 0x78, 0x70, 0x60, 0x60, 0x60, 0x60, 0x40, 0x3F,
  0xC0, 0x60, 0x38, 0x0C, 0x06, 0x03, 0x01, 0x80, 0xE0, 0x30, 0x18, 0x0F,
  0xF3, 0xFC, 0x1C, 0x43, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x84, 0x30, 0xC3,
  0xCE, 0x00, 0xDB, 0x64, 0x93, 0x6D, 0x90, 0x1C, 0x30, 0xC3, 0x08, 0x21,
  0x86, 0x18, 0x41, 0x0C, 0x33, 0xCE, 0x00, 0x18, 0x18, 0x3C, 0x24, 0x66,
  0x42, 0xC3, 0x81, 0xFE, 0xEC, 0x80, 0x3D, 0x67, 0x63, 0xC3, 0xC2, 0xC6,
  0xC6, 0xCE, 0x76, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x71, 0xCC, 0xC6, 0x43,
  0x61, 0xB0, 0xD8, 0xCE, 0xED, 0xE0, 0x3E, 0xC7, 0x06, 0x0C, 0x18, 0x30,
  0x72, 0x7C, 0x01, 0x80, 0xC0, 0x60, 0x33, 0xD3, 0x39, 0x8D, 0x86, 0xC2,
  0x63, 0x31, 0x99, 0xC7, 0x60, 0x3E, 0xCF, 0x1E, 0x7F, 0x98, 0x30, 0x62,
  0x7C, 0x03, 0xC1, 0xD0, 0x60, 0x18, 0x1F, 0x03, 0x00, 0xC0, 0x30, 0x08,
  0x06, 0x01, 0x80, 0x60, 0x18, 0x04, 0x03, 0x02, 0xC0, 0xE0, 0x00, 0x1E,
  0xCC, 0xE3, 0x19, 0x86, 0x61, 0x18, 0xC6, 0x31, 0x9C, 0x3B, 0x00, 0x80,
  0x63, 0x38, 0xFC, 0x00, 0x18, 0x0C, 0x04, 0x06, 0x03, 0x79, 0xCC, 0xC6,
  0x63, 0x61, 0xB0, 0x98, 0xCC, 0x6C, 0x30, 0x10, 0xC0, 0x03, 0x18, 0xC4,
  0x63, 0x18, 0xCC, 0x00, 0x04, 0x0C, 0x00, 0x00, 0xC1, 0x83, 0x04, 0x18,
  0x30, 0x60, 0xC1, 0x06, 0x0C, 0x78, 0xE0, 0x18, 0x0C, 0x04, 0x06, 0x03,
  0x19, 0x98, 0xD8, 0x58, 0x7C, 0x36, 0x19, 0x8C, 0xCC, 0x30, 0x18, 0xC4,
  0x63, 0x18, 0xC4, 0x63, 0x18, 0xCC, 0x00, 0x37, 0x3C, 0xE7, 0x33, 0x18,
  0xCC, 0x63, 0x61, 0x0D, 0x8C, 0x26, 0x31, 0x98, 0xC6, 0xC3, 0x18, 0x37,
  0x9C, 0xCC, 0x66, 0x36, 0x1B, 0x09, 0x8C, 0xC6, 0xC3, 0x00, 0x3E, 0x67,
  0xC3, 0xC3, 0xC3, 0xC3, 0xC6, 0xEE, 0x7C, 0x37, 0x1C, 0xCC, 0x64, 0x36,
  0x1B, 0x0D, 0x8C, 0xEE, 0x5E, 0x60, 0x30, 0x18, 0x08, 0x00, 0x3D, 0x67,
  0x63, 0xC3, 0xC2, 0xC6, 0xC6, 0xCE, 0x76, 0x04, 0x0C, 0x0C, 0x0C, 0x36,
  0x70, 0xC1, 0x86, 0x0C, 0x18, 0x30, 0xC0, 0x3E, 0xC5, 0x83, 0x83, 0xC1,
  0x81, 0x46, 0xF8, 0x30, 0x9F, 0x98, 0x61, 0x0C, 0x30, 0xC3, 0x4F, 0x00,
  0x61, 0xB1, 0x98, 0xD8, 0x6C, 0x36, 0x33, 0x19, 0x9C, 0x76, 0x00, 0xC3,
  0xC6, 0xC6, 0xCC, 0xCC, 0xD8, 0x50, 0x70, 0x60, 0xC6, 0x3C, 0xE3, 0xCA,
  0x6D, 0xA6, 0xD2, 0xCD, 0x2C, 0xF2, 0x8E, 0x38, 0xE3, 0x00, 0x31, 0xC6,
  0x61, 0xB0, 0x38, 0x0C, 0x07, 0x83, 0x60, 0xCC, 0xE3, 0x00, 0x30, 0xCC,
  0x63, 0x18, 0xCC, 0x13, 0x05, 0x81, 0x40, 0x70, 0x18, 0x06, 0x03, 0x03,
  0xC0, 0xE0, 0x00, 0x3F, 0x06, 0x0C, 0x18, 0x18, 0x30, 0x60, 0xC0, 0xFC,
  0x0E, 0x18, 0x60, 0xC1, 0x02, 0x3C, 0x70, 0x20, 0x40, 0x83, 0x06, 0x0E,
  0x0C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x18, 0x18, 0x30, 0x60, 0x81,
  0x03, 0x07, 0x18, 0x20, 0x41, 0x83, 0x1C, 0x30, 0x00, 0xF9, 0x9F,
};

const GFXglyph NotoSans_MediumItalic17pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 12, 5, 0, -12 },
  { 9, 5, 4, 7, 2, -12 },
  { 12, 11, 12, 11, 0, -12 },
  { 29, 8, 14, 9, 1, -13 },
  { 43, 12, 12, 14, 1, -12 },
  { 61, 10, 12, 12, 1, -12 },
  { 76, 2, 4, 4, 2, -12 },
  { 77, 5, 15, 5, 1, -12 },
  { 87, 6, 15, 5, -1, -12 },
  { 99, 8, 8, 9, 2, -13 },
  { 107, 8, 8, 10, 1, -10 },
  { 115, 4, 4, 5, -1, -2 },
  { 117, 5, 1, 5, 0, -5 },
  { 118, 3, 2, 5, 0, -2 },
  { 119, 9, 12, 6, -1, -12 },
  { 133, 8, 12, 9, 1, -12 },
  { 145, 6, 12, 9, 2, -12 },
  { 154, 9, 12, 9, 0, -12 },
  { 168, 9, 12, 9, 0, -12 },
  { 182, 9, 12, 9, 0, -12 },
  { 196, 8, 12, 9, 1, -12 },
  { 208, 8, 12, 9, 1, -12 },
  { 220, 9, 12, 9, 1, -12 },
  { 234, 8, 12, 9, 1, -12 },
  { 246, 8, 12, 9, 1, -12 },
  { 258, 4, 9, 5, 0, -9 },
  { 263, 5, 11, 5, -1, -9 },
  { 270, 8, 8, 10, 1, -10 },
  { 278, 8, 4, 10, 1, -8 },
  { 282, 8, 8, 10, 1, -10 },
  { 290, 7, 12, 7, 1, -12 },
  { 301, 13, 14, 14, 1, -12 },
  { 324, 10, 12, 10, -1, -12 },
  { 339, 9, 12, 10, 1, -12 },
  { 353, 10, 12, 10, 1, -12 },
  { 368, 10, 12, 11, 1, -12 },
  { 383, 9, 12, 9, 1, -12 },
  { 397, 9, 12, 8, 1, -12 },
  { 411, 10, 12, 12, 1, -12 },
  { 426, 11, 12, 12, 1, -12 },
  { 443, 7, 12, 6, 0, -12 },
  { 454, 8, 15, 5, -3, -12 },
  { 469, 10, 12, 10, 1, -12 },
  { 484, 6, 12, 8, 1, -12 },
  { 493, 14, 12, 15, 1, -12 },
  { 514, 11, 12, 12, 1, -12 },
  { 531, 11, 12, 12, 1, -12 },
  { 548, 9, 12, 10, 1, -12 },
  { 562, 11, 15, 12, 1, -12 },
  { 583, 9, 12, 10, 1, -12 },
  { 597, 9, 12, 9, 0, -12 },
  { 611, 9, 12, 9, 1, -12 },
  { 625, 11, 12, 12, 1, -12 },
  { 642, 9, 12, 10, 2, -12 },
  { 656, 14, 12, 15, 2, -12 },
  { 677, 12, 12, 9, -1, -12 },
  { 695, 8, 12, 9, 2, -12 },
  { 707, 10, 12, 9, 0, -12 },
  { 722, 6, 15, 5, 0, -12 },
  { 734, 3, 12, 6, 2, -12 },
  { 739, 6, 15, 5, -1, -12 },
  { 751, 8, 8, 10, 1, -12 },
  { 759, 7, 1, 7, -2, 2 },
  { 760, 3, 3, 5, 2, -13 },
  { 762, 8, 9, 10, 1, -9 },
  { 771, 9, 13, 10, 0, -13 },
  { 786, 7, 9, 8, 1, -9 },
  { 794, 9, 13, 10, 1, -13 },
  { 809, 7, 9, 9, 1, -9 },
  { 817, 10, 17, 6, -2, -13 },
  { 839, 10, 13, 10, 0, -9 },
  { 856, 9, 13, 10, 0, -13 },
  { 871, 5, 13, 5, 0, -13 },
  { 880, 7, 17, 5, -2, -13 },
  { 895, 9, 13, 9, 0, -13 },
  { 910, 5, 13, 5, 0, -13 },
  { 919, 14, 9, 15, 0, -9 },
  { 935, 9, 9, 10, 0, -9 },
  { 946, 8, 9, 10, 1, -9 },
  { 955, 9, 13, 10, 0, -9 },
  { 970, 8, 13, 10, 1, -9 },
  { 983, 7, 9, 7, 0, -9 },
  { 991, 7, 9, 8, 0, -9 },
  { 999, 6, 11, 6, 1, -11 },
  { 1008, 9, 9, 10, 1, -9 },
  { 1019, 8, 9, 8, 1, -9 },
  { 1028, 12, 9, 13, 1, -9 },
  { 1042, 10, 9, 8, -1, -9 },
  { 1054, 10, 13, 8, -1, -9 },
  { 1071, 8, 9, 8, 0, -9 },
  { 1080, 7, 15, 6, 0, -12 },
  { 1094, 2, 17, 9, 4, -13 },
  { 1099, 7, 15, 6, -1, -12 },
  { 1113, 8, 2, 10, 1, -7 },
};

const GFXfont NotoSans_MediumItalic17pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic17pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic17pt7bGlyphs,
  0x20, 0x7E, 23
};

#endif // _NOTOSANS_MEDIUMITALIC17PT7B_H_
