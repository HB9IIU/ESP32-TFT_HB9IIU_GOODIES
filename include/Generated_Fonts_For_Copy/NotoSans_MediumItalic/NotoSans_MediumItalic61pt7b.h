#ifndef _NOTOSANS_MEDIUMITALIC61PT7B_H_
#define _NOTOSANS_MEDIUMITALIC61PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 61pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic61pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x01,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xC0, 0x0F, 0xC0, 0x03, 0xC0,
  0x00, 0x1F, 0x87, 0xF3, 0xF8, 0x7F, 0x3F, 0x87, 0xF3, 0xF0, 0x7E, 0x3F,
  0x07, 0xE3, 0xF0, 0x7E, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x7E, 0x0F, 0xC7,
  0xE0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0x80, 0xF0,
  0x78, 0x0F, 0x0F, 0x81, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x01, 0xF0, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xE7, 0x8F, 0x80, 0xFE, 0x3C, 0x04, 0x07, 0xF0, 0xF0, 0x00, 0x1F,
  0x83, 0xC0, 0x00, 0x7E, 0x0F, 0x00, 0x01, 0xF8, 0x3C, 0x00, 0x07, 0xE1,
  0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00, 0x7F, 0x1E, 0x00, 0x00, 0xFE, 0x78,
  0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07, 0x9F, 0xE0, 0x00,
  0x1E, 0x3F, 0x80, 0x00, 0xF0, 0x7E, 0x00, 0x03, 0xC1, 0xF8, 0x00, 0x0F,
  0x07, 0xE0, 0x00, 0x3C, 0x1F, 0x80, 0x01, 0xF0, 0xFE, 0x20, 0x07, 0x83,
  0xF0, 0xE0, 0x1E, 0x3F, 0xC3, 0xF8, 0x7B, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0,
  0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0x00, 0x00, 0xF8, 0x03, 0xFF,
  0xF0, 0x00, 0x3E, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x0F, 0x80, 0x1F,
  0x00, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x01, 0xF8, 0x01,
  0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0x3F, 0x01, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x3F, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE1, 0xF8,
  0x00, 0x1F, 0x80, 0xF8, 0x3E, 0x0F, 0x83, 0xF0, 0x1F, 0x0F, 0x87, 0xFC,
  0x7E, 0x07, 0xE3, 0xF3, 0xFF, 0xC7, 0xC0, 0xF8, 0xFC, 0xFF, 0xFC, 0xF8,
  0x3F, 0x1F, 0x1F, 0xFF, 0x9F, 0xFF, 0xC7, 0xC7, 0xE1, 0xFB, 0xFF, 0xF1,
  0xF9, 0xF8, 0x1F, 0x3F, 0xFC, 0x7E, 0x3F, 0x03, 0xE3, 0xFF, 0x0F, 0x87,
  0xC0, 0x7C, 0x1F, 0x83, 0xE1, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x01,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC1, 0xF8, 0x07, 0xC0,
  0x01, 0xF0, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x03,
  0xE0, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0x80,
  0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x00, 0x3F, 0x0F, 0xC0,
  0x1F, 0x80, 0x07, 0xE3, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xC0, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xC3, 0xFC, 0x00,
  0x00, 0x3F, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x3F, 0x0F, 0xFB, 0xF8, 0x01, 0xF8, 0x7F, 0x87, 0xF0, 0x07, 0xE3,
  0xFC, 0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x3F, 0xC1, 0xFC, 0x7F, 0x00, 0x7F,
  0x07, 0xE1, 0xF8, 0x00, 0xFE, 0x3F, 0x8F, 0xE0, 0x01, 0xFD, 0xFC, 0x3F,
  0x80, 0x07, 0xFF, 0xE0, 0xFE, 0x00, 0x0F, 0xFF, 0x83, 0xF0, 0x00, 0x1F,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE,
  0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF8, 0x07, 0xFC, 0x07, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x3F, 0x80, 0x7F,
  0xFF, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0xFF, 0xF8, 0x03,
  0xFC, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xCF, 0xE7, 0xE3, 0xF1,
  0xF8, 0xF8, 0x7C, 0x7E, 0x3F, 0x1F, 0x0F, 0x87, 0xC3, 0xC1, 0xE1, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x7C, 0x00,
  0x7C, 0x07, 0xC0, 0x07, 0xF0, 0x78, 0x00, 0x7F, 0xC7, 0x80, 0x0F, 0xFF,
  0x78, 0x00, 0x3F, 0xFF, 0x1F, 0xF0, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xBF, 0xF0, 0x0F, 0xF8, 0x03, 0x01,
  0xFF, 0xC0, 0x00, 0x3F, 0x3C, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0xFC, 0x3E,
  0x00, 0x1F, 0xC1, 0xF0, 0x03, 0xF8, 0x1F, 0x00, 0x1F, 0x01, 0xF8, 0x00,
  0xE0, 0x1F, 0x80, 0x06, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03,
  0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0,
  0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF,
  0xFE, 0x1E, 0x3F, 0x9F, 0xDF, 0xFF, 0xFF, 0xFB, 0xFD, 0xFC, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFC,
  0x3F, 0xC0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x07, 0xF0, 0x03,
  0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xF7, 0xF0,
  0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x7E, 0x7F, 0x00, 0x01, 0xF9, 0xF8, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x3F, 0x3F, 0x80, 0x01, 0xFC,
  0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE, 0x3F,
  0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x03, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xFC, 0x03,
  0xFC, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x3F, 0xFE, 0x07, 0xFF, 0xE1, 0xFF, 0xFC,
  0x7F, 0xEF, 0xCF, 0xFC, 0xFC, 0xFF, 0x9F, 0xC7, 0xE1, 0xFC, 0x3C, 0x1F,
  0x83, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xE7, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x78,
  0x00, 0x7F, 0x00, 0x30, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0,
  0xFF, 0x80, 0x3E, 0x00, 0x7F, 0x80, 0x30, 0x00, 0x7F, 0x00, 0x40, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x08, 0x00, 0x01,
  0xFE, 0x1C, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x3F, 0xF0, 0x7F, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0xBE, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x1F, 0xC7, 0xE0, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01, 0xF8,
  0x07, 0xF0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x0B, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xDF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0xF0, 0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x08, 0x00, 0x03, 0xFC, 0x18, 0x00,
  0x0F, 0xF0, 0x3E, 0x00, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x17, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0x03, 0x80, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0xF0, 0x00,
  0x3F, 0x0F, 0xFC, 0x00, 0xFE, 0x7F, 0xFC, 0x01, 0xF9, 0xFF, 0xFC, 0x03,
  0xF7, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x1F, 0xFC, 0x07, 0xF8, 0x3F,
  0xE0, 0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x7F, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x1F,
  0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x7F, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE,
  0x3F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0x80, 0x07, 0xFC, 0x7F, 0x80, 0x1F, 0xE0, 0x7F, 0x80, 0x7F, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0xFE,
  0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF1,
  0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87,
  0xF0, 0x00, 0xFE, 0x0F, 0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xD0, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xF0, 0x1F, 0xE0, 0x3F,
  0xC1, 0xFC, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x7E, 0x7F, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7F, 0x3F, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFE, 0x7F, 0x00, 0x0F, 0xF3,
  0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xF8, 0x7F, 0x81, 0xFF, 0xC3, 0xFF,
  0xFF, 0x7E, 0x0F, 0xFF, 0xF7, 0xF0, 0x3F, 0xFF, 0x3F, 0x00, 0xFF, 0xF1,
  0xF8, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x03, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0xE0, 0x3F,
  0x81, 0xFF, 0x07, 0xFC, 0x1F, 0xE0, 0x7F, 0x81, 0xFC, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x1F, 0xC0, 0x7F, 0x03, 0xFE, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFF, 0x03, 0xF8, 0x03, 0xC0, 0x00, 0x00, 0x06, 0x00,
  0x07, 0xE0, 0x03, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0C, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0xC0,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xC7, 0xF0, 0xFF, 0xCF, 0x00, 0x3F, 0x88, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xFF, 0xC0, 0x3E, 0x0F, 0x80,
  0x1F, 0xFF, 0xF0, 0x3E, 0x1F, 0x80, 0x3F, 0xFF, 0xE0, 0x3E, 0x1F, 0x00,
  0x7F, 0xFF, 0xE0, 0x3E, 0x3F, 0x00, 0xFE, 0x03, 0xE0, 0x3F, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0x3F, 0x3E, 0x03, 0xF0, 0x07, 0xC0, 0x3F, 0x7C, 0x03,
  0xE0, 0x07, 0xC0, 0x3F, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x7C, 0x07,
  0xC0, 0x0F, 0xC0, 0x3E, 0x7C, 0x0F, 0xC0, 0x0F, 0x80, 0x3E, 0xFC, 0x0F,
  0x80, 0x0F, 0x80, 0x3E, 0xF8, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0xF8, 0x0F,
  0x80, 0x1F, 0x80, 0x7C, 0xF8, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0xF8, 0x0F,
  0x80, 0x3F, 0x00, 0xFC, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0xF8, 0xF8, 0x0F,
  0x80, 0x7F, 0x01, 0xF8, 0xF8, 0x0F, 0x80, 0xFF, 0x03, 0xF0, 0xFC, 0x0F,
  0xC1, 0xFF, 0x07, 0xF0, 0xFC, 0x0F, 0xFF, 0xEF, 0xFF, 0xE0, 0x7C, 0x07,
  0xFF, 0xCF, 0xFF, 0xC0, 0x7C, 0x03, 0xFF, 0x87, 0xFF, 0x80, 0x7E, 0x01,
  0xFF, 0x03, 0xFE, 0x00, 0x3E, 0x00, 0x70, 0x00, 0x70, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x40, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x2A, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0x9F, 0x00, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x3F, 0x9F, 0x00,
  0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0x7F, 0x1F, 0x80, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0, 0x0F, 0xFC, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x00, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF8, 0x3F, 0x00, 0x03, 0xFC, 0x0F, 0xC0, 0x03, 0xFF, 0x07, 0xF0, 0x1F,
  0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xF0, 0x01, 0xE0, 0x0F, 0xF8, 0x00, 0x04, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xC0, 0x07, 0xFF, 0x01,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xF8, 0x07, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x07, 0xE0,
  0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x00, 0x7F, 0x80, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00,
  0x1F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0x80, 0x00, 0x7F,
  0x81, 0xFC, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0x00,
  0x07, 0xFC, 0x03, 0xF0, 0x00, 0xFF, 0xE0, 0x1F, 0x80, 0x1F, 0xFE, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x01, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x03, 0xFF, 0x80, 0x0F, 0x80, 0x3F, 0xF0, 0x00, 0x0C, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x02, 0x3F, 0x80, 0x07,
  0xFF, 0xE1, 0xF8, 0x00, 0x7F, 0xFF, 0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0xFE,
  0x00, 0x1F, 0xFF, 0xC7, 0xF0, 0x00, 0xFF, 0xFC, 0x3F, 0x80, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xE0,
  0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x1F,
  0xF8, 0x00, 0x7F, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03,
  0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x07,
  0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x01,
  0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFF,
  0x00, 0x00, 0x07, 0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFD, 0xFC, 0x00, 0x00, 0x1F, 0xF1, 0xF8, 0x00, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0xFE, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0x80,
  0x00, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xF8,
  0x00, 0x00, 0xFF, 0xE0, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x03, 0xEF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0xFB, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x7E,
  0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xBE, 0x00, 0x01, 0xFB, 0xF0, 0x07,
  0xEF, 0xC0, 0x00, 0x7C, 0xFC, 0x01, 0xFB, 0xF0, 0x00, 0x3F, 0x3F, 0x00,
  0x7E, 0xFC, 0x00, 0x0F, 0x9F, 0xC0, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0,
  0x0F, 0xC7, 0xC0, 0x01, 0xF1, 0xF8, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x7E,
  0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0x80, 0x3F, 0x1F, 0x00, 0x1F, 0x8F,
  0xC0, 0x1F, 0x87, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x7E, 0x1F, 0x80, 0x7E,
  0x1F, 0xC0, 0x1F, 0x87, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x0F,
  0x81, 0xF8, 0x03, 0xF0, 0x3E, 0x07, 0xE0, 0x7E, 0x00, 0xFC, 0x0F, 0x81,
  0xF0, 0x3F, 0x80, 0x3F, 0x03, 0xE0, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0xF8,
  0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x0F,
  0x87, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF3, 0xF0, 0x1F, 0xC0, 0x1F, 0x80,
  0xFC, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xFF, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xF0, 0x01, 0xF8, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xC0, 0x1F, 0xE0, 0x00, 0x03, 0xF0,
  0x07, 0xF8, 0x00, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0x7F,
  0xC0, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xFE, 0x00,
  0x01, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0x80, 0x7E, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xBF, 0x00, 0x03, 0xF0, 0x07,
  0xEF, 0xE0, 0x00, 0xFC, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0x1F, 0xC0, 0x3F, 0x1F, 0xC0, 0x07, 0xE0, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x03, 0xF8,
  0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x03, 0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xE3, 0xF0, 0x07, 0xE0, 0x01,
  0xF8, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0xCF,
  0xC0, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x0F, 0xC0, 0x00, 0xFD, 0xF8, 0x03,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0x00,
  0x01, 0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xC0,
  0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xEF, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x80,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x07, 0xFC, 0x01, 0xF8, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xE0,
  0x3F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F,
  0xE0, 0x7F, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x7F, 0xE0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F,
  0xE0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0,
  0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x7F, 0x00, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0xFF, 0x80, 0x0F, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00,
  0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x07, 0xFC, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF0, 0x1F,
  0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x07,
  0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xF0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00,
  0x01, 0xFC, 0x1F, 0x80, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F,
  0x80, 0x1E, 0x01, 0xFE, 0x00, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x08, 0x00, 0x03, 0xFC, 0x1C, 0x00,
  0x0F, 0xF0, 0x3F, 0x00, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F,
  0x80, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x3F, 0x00,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x00,
  0x7F, 0xC0, 0x07, 0xF8, 0x01, 0xFF, 0x81, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F,
  0x00, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x03,
  0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0xFC,
  0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFC,
  0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0xFF, 0xC0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFF, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xEF,
  0xC0, 0x07, 0xE0, 0x7E, 0x00, 0x7E, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x07,
  0xEF, 0xC0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x7C, 0x01, 0xFC, 0x07, 0xE0,
  0x0F, 0xC7, 0xC0, 0x1F, 0xC0, 0x7E, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x87, 0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x7C, 0x03, 0xF0,
  0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0, 0x7C, 0x07,
  0xE0, 0x07, 0xE0, 0x7E, 0x07, 0xC0, 0xFE, 0x00, 0x7E, 0x07, 0xE0, 0x7C,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x07, 0xC0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0,
  0x7C, 0x1F, 0xC0, 0x07, 0xE1, 0xF8, 0x07, 0xC1, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x7C, 0x3F, 0x80, 0x07, 0xE1, 0xF0, 0x07, 0xC3, 0xF0, 0x00, 0x7E,
  0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x07, 0xEF, 0xC0,
  0x00, 0x7E, 0x7C, 0x00, 0x7E, 0xFC, 0x00, 0x03, 0xEF, 0xC0, 0x07, 0xEF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x07,
  0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0x80, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x03, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE,
  0x00, 0x1F, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0xFC, 0x0F, 0xC0,
  0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0,
  0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0,
  0x1F, 0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8,
  0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E,
  0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F,
  0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9,
  0xF0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x3F,
  0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0,
  0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x00, 0x7C, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x00, 0xF9, 0xF8, 0x00,
  0x03, 0xE7, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x7F, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x80, 0xFE, 0x1F, 0xC1, 0xF8, 0x3F, 0x83, 0xF0, 0x3F, 0x03, 0xE0,
  0x7E, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0xFF, 0xF0, 0xFC,
  0x03, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0,
  0xFF, 0x83, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0x07, 0xF0, 0x03, 0xFC, 0x1F,
  0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E, 0x1F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0xFE, 0x1F, 0x80, 0x03, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x1F,
  0xE0, 0xFE, 0x00, 0x7F, 0xC1, 0xFC, 0x01, 0xFF, 0x83, 0xFC, 0x07, 0xFE,
  0x03, 0xF8, 0x1F, 0x7C, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xF3, 0xF0,
  0x0F, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0x0F, 0x80, 0x0F, 0xFC, 0x1F, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xF8, 0x00, 0xFE,
  0x3F, 0xF8, 0x01, 0xF9, 0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xF8, 0x07, 0xEF,
  0xFF, 0xF0, 0x1F, 0xBE, 0x0F, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0,
  0x0F, 0xC0, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x3F,
  0xE0, 0x0F, 0xF0, 0x7F, 0xE0, 0x7F, 0xC1, 0xFB, 0xFF, 0xFF, 0x03, 0xF7,
  0xFF, 0xFC, 0x07, 0xC7, 0xFF, 0xF0, 0x0F, 0x87, 0xFF, 0xC0, 0x1F, 0x07,
  0xFE, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x81,
  0xFF, 0x01, 0xC0, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x81, 0xFF,
  0x00, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xFC, 0x1F, 0x80, 0x07, 0xFF,
  0x8F, 0xE0, 0x03, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFE, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFF, 0xC0, 0x3F, 0xC0, 0x1F, 0xF0, 0x1F,
  0xE0, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF8, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x0F, 0xC0,
  0x01, 0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x1F, 0xF0, 0x0F, 0xE0, 0x07, 0xFC, 0x03, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x03, 0xEF, 0x80, 0x1F, 0xFF, 0xF7, 0xE0, 0x07, 0xFF, 0xF9, 0xF8,
  0x00, 0xFF, 0xFC, 0x7E, 0x00, 0x1F, 0xFE, 0x1F, 0x00, 0x03, 0xFF, 0x07,
  0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFF,
  0xE0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F,
  0xF0, 0x3F, 0xC3, 0xFC, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0xC0, 0x0F,
  0xE7, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE7, 0xF0,
  0x07, 0xF8, 0xFE, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF0,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x18, 0x3F, 0xC0, 0x0F, 0x03, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x0F, 0x80, 0x0F, 0xFF, 0x07, 0xC0, 0x0F, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF,
  0xF3, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0,
  0x07, 0xFC, 0x0F, 0xF0, 0x03, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x0F,
  0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x3F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0,
  0x3F, 0x80, 0x1F, 0xF0, 0x1F, 0xC0, 0x1F, 0xF8, 0x0F, 0xF0, 0x1F, 0xF8,
  0x03, 0xF8, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0x7E, 0x00, 0xFF, 0xFF, 0x3F,
  0x00, 0x3F, 0xFF, 0x3F, 0x80, 0x0F, 0xFF, 0x1F, 0x80, 0x03, 0xFE, 0x0F,
  0xC0, 0x00, 0x10, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x00, 0xFF, 0x00, 0x78, 0x00,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x3F, 0x0F, 0xFF, 0x00,
  0xFC, 0x7F, 0xFE, 0x03, 0xF3, 0xFF, 0xF8, 0x0F, 0xDF, 0xFF, 0xF0, 0x7E,
  0xF8, 0x3F, 0xC1, 0xFF, 0xC0, 0x7F, 0x07, 0xFC, 0x00, 0xFC, 0x1F, 0xE0,
  0x03, 0xF0, 0xFF, 0x80, 0x0F, 0xC3, 0xFC, 0x00, 0x3F, 0x0F, 0xF0, 0x00,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F,
  0x1F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x1F, 0x87, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F,
  0xE3, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x1E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x00, 0x7E, 0x01,
  0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFE,
  0x01, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x03, 0xFC, 0x07, 0xF0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x07, 0xE3, 0xF8, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x01, 0xFB, 0xF8, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF3, 0xF8, 0x00, 0x0F, 0xF1, 0xFC,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x0F,
  0xE0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03,
  0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F,
  0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xF0, 0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0xF8, 0xFF, 0xFC, 0x1F, 0xFF, 0x80,
  0x7C, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0x9F, 0xFF, 0xF0,
  0x3F, 0x7C, 0x1F, 0xDF, 0x83, 0xF8, 0x1F, 0xF8, 0x07, 0xEF, 0x00, 0xFC,
  0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFF, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xC1, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x03,
  0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0x00, 0x01, 0xF8, 0x3F, 0xF0,
  0x01, 0xF8, 0x7F, 0xF8, 0x01, 0xF9, 0xFF, 0xFC, 0x01, 0xF3, 0xFF, 0xFE,
  0x03, 0xF7, 0xFF, 0xFE, 0x03, 0xF7, 0xE1, 0xFE, 0x03, 0xFF, 0x80, 0xFE,
  0x03, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC,
  0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8,
  0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8,
  0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFE, 0x03, 0xFE, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xC3, 0xFC, 0x00,
  0xFE, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFE,
  0xFE, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F,
  0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0xC0, 0x01, 0xFC, 0xFE,
  0x00, 0x1F, 0xC7, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xE0, 0xFF, 0x01,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x60, 0x00, 0x00,
  0x00, 0x3F, 0x03, 0xFC, 0x00, 0x07, 0xC1, 0xFF, 0xC0, 0x00, 0xF8, 0xFF,
  0xFC, 0x00, 0x1F, 0x3F, 0xFF, 0xC0, 0x03, 0xEF, 0xFF, 0xF8, 0x00, 0xFD,
  0xF0, 0x7F, 0x80, 0x1F, 0xF8, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x7E, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xF0, 0x07, 0xF8, 0x03, 0xFF,
  0x03, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0xE0, 0x03,
  0xF3, 0xFF, 0xF8, 0x00, 0x7E, 0x3F, 0xFE, 0x00, 0x0F, 0xC1, 0xFF, 0x00,
  0x03, 0xF8, 0x06, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x3E, 0x00, 0xFF,
  0xF0, 0x7C, 0x03, 0xFF, 0xF1, 0xF8, 0x0F, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF,
  0xFF, 0xC0, 0xFF, 0x83, 0xFF, 0x83, 0xFC, 0x03, 0xFF, 0x0F, 0xF0, 0x03,
  0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x0F,
  0xC0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0xC1, 0xFC, 0x00, 0xFF, 0x83, 0xF8,
  0x03, 0xFE, 0x03, 0xF8, 0x1F, 0xFC, 0x07, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x1F, 0x80, 0x0F, 0xF8,
  0x3F, 0x00, 0x01, 0x80, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x7F, 0x81, 0xF8, 0x7F, 0x80, 0xFC, 0xFF, 0xC0, 0x7C, 0xFF,
  0xE0, 0x3E, 0x7F, 0xF0, 0x3F, 0x7F, 0xF0, 0x1F, 0xFC, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0x81, 0xFC, 0x01, 0xC0, 0xFE, 0x00, 0x10, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F,
  0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x8C, 0x00, 0x1F, 0xC3,
  0xC0, 0x0F, 0xF0, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF,
  0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x07, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0x3F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0xFE, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x7F,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x7F, 0xC1, 0xFC, 0x01, 0xFF, 0x83, 0xF8,
  0x07, 0xFF, 0x03, 0xF8, 0x1F, 0x7C, 0x07, 0xFF, 0xFC, 0xF8, 0x0F, 0xFF,
  0xF3, 0xF0, 0x0F, 0xFF, 0xC7, 0xE0, 0x0F, 0xFF, 0x0F, 0xC0, 0x0F, 0xF8,
  0x1F, 0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0x80, 0x01, 0xFD, 0xFC, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFE,
  0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x00,
  0xFC, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xF0,
  0x07, 0xE0, 0x7F, 0x00, 0x3F, 0x03, 0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x8F,
  0xE0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0xF9, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF,
  0xC0, 0x07, 0xF8, 0x00, 0xFE, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xEF, 0xC0,
  0x0F, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xCF, 0xC0, 0x1F,
  0xF8, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0x8F, 0xC0, 0x1F, 0xF8,
  0x03, 0xF0, 0xFC, 0x03, 0xEF, 0x80, 0x7F, 0x0F, 0xC0, 0x3E, 0xF8, 0x07,
  0xE0, 0xFC, 0x07, 0xCF, 0x80, 0xFE, 0x0F, 0xC0, 0x7C, 0xF8, 0x0F, 0xE0,
  0xFC, 0x0F, 0xCF, 0x80, 0xFC, 0x0F, 0xC0, 0xF8, 0xF8, 0x1F, 0xC0, 0xFC,
  0x1F, 0x8F, 0x81, 0xF8, 0x0F, 0xC1, 0xF0, 0xFC, 0x3F, 0x80, 0xFC, 0x3F,
  0x0F, 0xC3, 0xF0, 0x0F, 0xC3, 0xE0, 0xFC, 0x7F, 0x00, 0xFC, 0x7E, 0x0F,
  0xC7, 0xE0, 0x0F, 0xC7, 0xC0, 0x7C, 0x7E, 0x00, 0xFC, 0x7C, 0x07, 0xCF,
  0xC0, 0x0F, 0xCF, 0xC0, 0x7C, 0xFC, 0x00, 0xFC, 0xF8, 0x07, 0xDF, 0x80,
  0x07, 0xDF, 0x80, 0x7D, 0xF8, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x07,
  0xDF, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x07, 0xFF, 0x00, 0x07, 0xFE,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x3F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07,
  0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x01, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0x7E, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFC, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x07,
  0xF0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF0, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x04, 0xFF, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFC, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x18, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE,
  0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x09, 0xFF, 0xE0, 0x00, 0xDF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xD0, 0x00, 0x3F, 0xFC, 0x80, 0x00, 0x1F, 0x00,
};

const GFXglyph NotoSans_MediumItalic61pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 17, 45, 16, 1, -44 },
  { 97, 20, 16, 25, 6, -44 },
  { 137, 38, 44, 39, 2, -44 },
  { 346, 30, 50, 34, 2, -46 },
  { 534, 43, 45, 50, 4, -44 },
  { 776, 38, 45, 42, 2, -44 },
  { 990, 9, 16, 14, 6, -44 },
  { 1008, 21, 54, 19, 2, -44 },
  { 1150, 21, 54, 19, -5, -44 },
  { 1292, 28, 29, 33, 6, -47 },
  { 1394, 29, 29, 35, 4, -36 },
  { 1500, 13, 15, 16, -3, -7 },
  { 1525, 16, 6, 19, 1, -19 },
  { 1537, 9, 9, 16, 1, -8 },
  { 1548, 31, 44, 23, -3, -44 },
  { 1719, 30, 45, 34, 3, -44 },
  { 1888, 20, 44, 34, 8, -44 },
  { 1998, 32, 44, 34, 0, -44 },
  { 2174, 31, 45, 34, 1, -44 },
  { 2349, 33, 44, 34, 0, -44 },
  { 2531, 31, 45, 34, 2, -44 },
  { 2706, 31, 45, 34, 3, -44 },
  { 2881, 31, 44, 34, 4, -44 },
  { 3052, 31, 45, 34, 2, -44 },
  { 3227, 29, 45, 34, 3, -44 },
  { 3391, 14, 35, 16, 1, -34 },
  { 3453, 18, 42, 16, -3, -34 },
  { 3548, 29, 30, 35, 4, -37 },
  { 3657, 29, 17, 35, 4, -30 },
  { 3719, 29, 30, 35, 4, -37 },
  { 3828, 23, 45, 27, 5, -44 },
  { 3958, 48, 50, 52, 3, -44 },
  { 4258, 36, 44, 35, -4, -44 },
  { 4456, 34, 44, 37, 2, -44 },
  { 4643, 35, 45, 36, 4, -44 },
  { 4840, 37, 44, 41, 2, -44 },
  { 5044, 32, 44, 32, 2, -44 },
  { 5220, 32, 44, 30, 2, -44 },
  { 5396, 37, 45, 42, 4, -44 },
  { 5605, 40, 44, 42, 2, -44 },
  { 5825, 25, 44, 21, -1, -44 },
  { 5963, 28, 56, 18, -10, -44 },
  { 6159, 39, 44, 35, 2, -44 },
  { 6374, 24, 44, 30, 2, -44 },
  { 6506, 50, 44, 52, 2, -44 },
  { 6781, 42, 44, 44, 2, -44 },
  { 7012, 38, 45, 44, 4, -44 },
  { 7226, 33, 44, 35, 2, -44 },
  { 7408, 38, 54, 44, 4, -44 },
  { 7665, 33, 44, 36, 2, -44 },
  { 7847, 31, 45, 31, 1, -44 },
  { 8022, 31, 44, 31, 5, -44 },
  { 8193, 37, 45, 42, 5, -44 },
  { 8402, 34, 44, 34, 6, -44 },
  { 8589, 52, 44, 53, 6, -44 },
  { 8875, 42, 44, 34, -3, -44 },
  { 9106, 32, 44, 32, 6, -44 },
  { 9282, 36, 44, 32, -1, -44 },
  { 9480, 24, 54, 18, -1, -44 },
  { 9642, 12, 44, 23, 7, -44 },
  { 9708, 23, 54, 18, -4, -44 },
  { 9864, 30, 28, 35, 2, -44 },
  { 9969, 26, 5, 24, -6, 5 },
  { 9986, 11, 10, 18, 9, -47 },
  { 10000, 31, 34, 35, 3, -33 },
  { 10132, 31, 47, 36, 2, -46 },
  { 10315, 26, 34, 28, 3, -33 },
  { 10426, 34, 47, 36, 3, -46 },
  { 10626, 27, 34, 31, 3, -33 },
  { 10741, 35, 62, 20, -7, -47 },
  { 11013, 33, 48, 36, 1, -33 },
  { 11211, 30, 46, 36, 2, -46 },
  { 11384, 15, 45, 16, 2, -45 },
  { 11469, 25, 60, 16, -8, -45 },
  { 11657, 33, 46, 32, 1, -46 },
  { 11847, 17, 46, 16, 1, -46 },
  { 11945, 49, 33, 54, 2, -33 },
  { 12148, 32, 34, 36, 1, -34 },
  { 12284, 29, 34, 35, 3, -33 },
  { 12408, 35, 48, 36, -2, -33 },
  { 12618, 31, 48, 36, 3, -33 },
  { 12804, 25, 33, 25, 2, -33 },
  { 12908, 26, 34, 27, 0, -33 },
  { 13019, 20, 41, 22, 3, -40 },
  { 13122, 31, 34, 36, 3, -33 },
  { 13254, 29, 33, 29, 3, -33 },
  { 13374, 44, 33, 45, 4, -33 },
  { 13556, 35, 33, 30, -3, -33 },
  { 13701, 37, 48, 29, -5, -33 },
  { 13923, 29, 33, 28, -1, -33 },
  { 14043, 25, 54, 21, 0, -44 },
  { 14212, 5, 60, 34, 15, -46 },
  { 14250, 24, 54, 21, -3, -44 },
  { 14412, 29, 9, 35, 4, -26 },
};

const GFXfont NotoSans_MediumItalic61pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic61pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic61pt7bGlyphs,
  0x20, 0x7E, 83
};

#endif // _NOTOSANS_MEDIUMITALIC61PT7B_H_
