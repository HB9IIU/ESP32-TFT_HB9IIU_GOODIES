#ifndef _NOTOSANS_MEDIUMITALIC69PT7B_H_
#define _NOTOSANS_MEDIUMITALIC69PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 69pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic69pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xC1, 0xFE, 0x7F, 0x83, 0xF8, 0xFE, 0x07, 0xF1, 0xFC, 0x0F, 0xC3,
  0xF8, 0x3F, 0x87, 0xE0, 0x7F, 0x0F, 0xC0, 0xFE, 0x1F, 0x81, 0xF8, 0x3F,
  0x03, 0xF0, 0xFC, 0x07, 0xE1, 0xF8, 0x0F, 0x83, 0xF0, 0x3F, 0x07, 0xC0,
  0x7E, 0x0F, 0x80, 0xFC, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07,
  0xC1, 0xF0, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE1,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x3E, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xEF, 0xBF, 0xC0, 0x1F, 0xE1, 0xE0,
  0x78, 0x03, 0xF8, 0x3C, 0x02, 0x00, 0xFF, 0x0F, 0x80, 0x00, 0x1F, 0xC1,
  0xF0, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x00, 0x7F, 0x07, 0x80, 0x00, 0x0F,
  0xE0, 0xF0, 0x00, 0x01, 0xFC, 0x3E, 0x00, 0x00, 0x3F, 0xC7, 0xC0, 0x00,
  0x07, 0xFC, 0xF8, 0x00, 0x00, 0x7F, 0xDE, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0x3F, 0xE0,
  0x00, 0x01, 0xE3, 0xFC, 0x00, 0x00, 0x7C, 0x3F, 0xC0, 0x00, 0x0F, 0x83,
  0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x3C, 0x0F, 0xE0, 0x00, 0x07,
  0x81, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x00, 0x3E, 0x0F, 0xE0, 0xC0,
  0x07, 0xC3, 0xFC, 0x1F, 0x00, 0xF0, 0xFF, 0x03, 0xFE, 0x1E, 0xFF, 0xE0,
  0x7F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x04, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xE0, 0x07, 0xFF, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xF3, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x7E, 0x0F, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x3F, 0xF8, 0xFC, 0x07, 0xE1,
  0xF8, 0x7F, 0xFC, 0xFC, 0x07, 0xE3, 0xF8, 0xFF, 0xFE, 0xFE, 0x0F, 0xC3,
  0xF1, 0xFF, 0xFF, 0x7F, 0x3F, 0xC7, 0xE3, 0xFC, 0x7F, 0x7F, 0xFF, 0x8F,
  0xC3, 0xF0, 0x3F, 0x3F, 0xFF, 0x1F, 0xC7, 0xF0, 0x3F, 0x3F, 0xFE, 0x1F,
  0x87, 0xE0, 0x3F, 0x1F, 0xFC, 0x3F, 0x0F, 0xE0, 0x3F, 0x07, 0xF0, 0x7E,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC,
  0x1F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x3F, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0x83, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x07, 0xF0, 0x00,
  0x0F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x0F, 0xC0, 0x00,
  0x07, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x00, 0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x01, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0xEF, 0xF0, 0x00,
  0xFE, 0x0F, 0xFC, 0x7F, 0x80, 0x1F, 0xC1, 0xFF, 0x03, 0xFC, 0x01, 0xFC,
  0x3F, 0xE0, 0x3F, 0xC0, 0x3F, 0x83, 0xFC, 0x01, 0xFE, 0x07, 0xF8, 0x7F,
  0x80, 0x0F, 0xF0, 0x7F, 0x07, 0xF8, 0x00, 0xFF, 0x8F, 0xF0, 0x7F, 0x00,
  0x07, 0xF9, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xFF, 0xC0, 0xFF, 0x00, 0x03,
  0xFF, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x80, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x0F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0x80, 0x03, 0xFF, 0xE0, 0x07,
  0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFC, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xFF, 0x7F, 0x80, 0x1F, 0xFF, 0xFF, 0xE3, 0xFC, 0x00, 0xFF, 0xFF,
  0xF8, 0x3F, 0xE0, 0x07, 0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xCF, 0xF3, 0xF8,
  0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x3F, 0x1F, 0x87, 0xE1, 0xF8, 0x7C,
  0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x20, 0x01, 0xF0, 0x00, 0x30, 0x01, 0xF0, 0x00, 0x7C, 0x03, 0xF0, 0x00,
  0x7F, 0x03, 0xE0, 0x00, 0xFF, 0xC3, 0xE0, 0x00, 0xFF, 0xF3, 0xE0, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xEF, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0x00, 0xFD, 0xF0, 0x00, 0x01, 0xF9, 0xF0, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF0, 0xF8, 0x00, 0x1F, 0xE0, 0xFC, 0x00,
  0x3F, 0xE0, 0xFC, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x0F, 0x00, 0x7F, 0x00, 0x07, 0x00, 0x7F, 0x00, 0x02, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE,
  0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xDF,
  0xFF, 0xE7, 0xFF, 0xFB, 0xFF, 0xFE, 0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF,
  0xF0, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFE, 0x1F, 0xF0, 0x03, 0xFE, 0x03, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0xFF, 0x80, 0x0F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07,
  0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0xE0, 0x00,
  0x1F, 0xC7, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xF3, 0xF8,
  0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x3F, 0x9F,
  0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFE,
  0x7F, 0x00, 0x00, 0x7F, 0x9F, 0xC0, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x07,
  0xF3, 0xFC, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0xC1, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x0F, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x81, 0xFF, 0x80, 0x3F, 0xFB, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xF0, 0x01,
  0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xFC, 0x3F, 0xFB, 0xF8, 0xFF, 0xEF, 0xE3, 0xFF, 0x9F, 0xC3, 0xFC, 0x3F,
  0x87, 0xF0, 0x7F, 0x07, 0x81, 0xFE, 0x0E, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xC3, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFE,
  0x00, 0x3E, 0x00, 0x0F, 0xF0, 0x00, 0xE0, 0x00, 0x7F, 0x80, 0x04, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x07,
  0xE0, 0x03, 0xFE, 0x00, 0x38, 0x00, 0x1F, 0xE0, 0x01, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x08, 0x00, 0x00, 0x3F, 0xE0,
  0xE0, 0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x01, 0xFF, 0xC0, 0xFF, 0xE1, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0x7E, 0x00, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x03, 0xFC, 0x3F, 0x80,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xFC, 0xFF,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xFC, 0x7F, 0xFC, 0x00, 0x20, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x80,
  0x00, 0x07, 0xFC, 0x1C, 0x00, 0x01, 0xFF, 0x03, 0xE0, 0x00, 0xFF, 0xE0,
  0x7F, 0xE3, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x0F, 0xA0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFE,
  0x00, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xE0,
  0x18, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x3F, 0x87, 0xFF, 0xC0,
  0x0F, 0xE7, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x1F, 0xFE, 0x01, 0xFF, 0x07, 0xFF, 0x00,
  0x3F, 0xC1, 0xFF, 0x00, 0x07, 0xF0, 0xFF, 0x80, 0x01, 0xFE, 0x3F, 0xE0,
  0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x1F, 0xE3,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07,
  0xF8, 0x1F, 0xC0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFF, 0x01, 0xFF, 0x00,
  0xFF, 0x80, 0x3F, 0xF9, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x02, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0xC1, 0xFF, 0x00, 0x07, 0xFC, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0x9F, 0xF0, 0x00, 0xFF, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x01, 0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC,
  0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x07,
  0xFC, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFE,
  0x0F, 0xF8, 0x07, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x03, 0xF8,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF1, 0xFE,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x1F, 0xCF,
  0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x0F, 0xF3, 0xFC, 0x00, 0x07, 0xF8,
  0xFE, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x03, 0xFE, 0x3F, 0xC0, 0x03, 0xFF,
  0x1F, 0xF0, 0x07, 0xFF, 0x07, 0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xFF, 0xFF,
  0xC0, 0xFF, 0xFF, 0xEF, 0xE0, 0x7F, 0xFF, 0xEF, 0xF0, 0x1F, 0xFF, 0xE7,
  0xF0, 0x03, 0xFF, 0xC3, 0xF8, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x18, 0x00, 0x7F, 0xF0, 0x0F, 0xF7,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00,
  0xF4, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x03, 0xFC, 0x07, 0xF8, 0x1F, 0xF0,
  0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFE, 0x03, 0xFC, 0x01, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x0F, 0xE0, 0x3F, 0xE0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF, 0x07, 0xFC, 0x0F,
  0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x03, 0xFC, 0x00,
  0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8, 0x01,
  0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0,
  0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xF8, 0x3F, 0xF0, 0xF8, 0x01, 0xFF, 0x08,
  0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x80,
  0x07, 0xFF, 0xF0, 0x07, 0xE1, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x1F,
  0x80, 0x0F, 0xFF, 0xFF, 0x01, 0xF8, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xCF, 0xC0, 0x1F, 0xF0, 0x1F, 0x80, 0x7E, 0x7E, 0x00, 0xFE, 0x00, 0xFC,
  0x03, 0xF7, 0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x1F, 0xBF, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0xFD, 0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xEF, 0x80, 0x7F,
  0x00, 0x1F, 0x80, 0x3F, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFF, 0xE0,
  0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7F,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xEF, 0xC0, 0x7E, 0x00, 0x3F, 0x00,
  0x3F, 0x7C, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFB, 0xE0, 0x3F, 0x00, 0x0F,
  0xC0, 0x0F, 0xDF, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC, 0xF8, 0x0F, 0xC0,
  0x07, 0xF0, 0x07, 0xE7, 0xC0, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x3F, 0x01,
  0xF8, 0x07, 0xFC, 0x07, 0xF1, 0xF8, 0x0F, 0xC0, 0x7F, 0xE0, 0x7F, 0x0F,
  0xC0, 0x7F, 0x87, 0xDF, 0x87, 0xF0, 0x7E, 0x01, 0xFF, 0xFC, 0xFF, 0xFF,
  0x03, 0xF0, 0x0F, 0xFF, 0xE7, 0xFF, 0xF0, 0x1F, 0xC0, 0x3F, 0xFC, 0x1F,
  0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x7F, 0xF0, 0x03, 0xF0, 0x00, 0xF0,
  0x00, 0x7C, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x3F,
  0x00, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x0F, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x01,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x07, 0xF8, 0x00, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00, 0x00,
  0x03, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xF0, 0x03, 0xFF, 0x80, 0x3F, 0xC0, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFF,
  0x00, 0xFE, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x03, 0xF8, 0x00, 0x3F, 0xE0, 0x0F, 0xE0, 0x00, 0x7F, 0xC0,
  0x3F, 0x80, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x81,
  0xFC, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x0F,
  0xFE, 0x07, 0xF0, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF7, 0xFE, 0x00, 0x3F, 0xF8,
  0x00, 0x7C, 0x00, 0xFF, 0xC0, 0x00, 0x10, 0x03, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x10, 0x00, 0xFF, 0xE0, 0x03, 0xE0, 0x01, 0xFF, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x01, 0xFE, 0x00, 0x1F,
  0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x81,
  0xFE, 0x00, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x03, 0xFE, 0x0F, 0xE0, 0x00,
  0x01, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x03, 0xFC, 0x00, 0x00, 0xFF, 0x81, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0xFE,
  0x00, 0x01, 0xFF, 0x80, 0x7F, 0x00, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x03,
  0xFF, 0xC0, 0x3F, 0xC0, 0x07, 0xFF, 0xC0, 0x1F, 0xC0, 0x7F, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x20, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0x7F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xFC, 0x00,
  0xFF, 0xE0, 0x00, 0x0E, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0x03,
  0xFF, 0xFC, 0x7F, 0x80, 0x01, 0xFF, 0xFE, 0x3F, 0xC0, 0x01, 0xFF, 0xFF,
  0x1F, 0xE0, 0x00, 0xFF, 0xFF, 0x8F, 0xF0, 0x00, 0x7F, 0xFF, 0xC7, 0xF8,
  0x00, 0x3F, 0xFF, 0xC3, 0xFC, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x03, 0xF8,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x83, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xE0,
  0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFF,
  0x80, 0x07, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00,
  0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x80, 0x7F, 0xE0, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F,
  0xC0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x0F, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFE,
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xE0, 0x00,
  0x03, 0xF8, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x80,
  0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x01, 0xFD, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0xFC, 0x00, 0x00, 0x07, 0xFE, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x87, 0xF8,
  0x00, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x07, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xBF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x1F, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x1F, 0xDF, 0x80, 0x00, 0x1F,
  0x9F, 0xC0, 0x0F, 0xEF, 0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x07, 0xF7, 0xE0,
  0x00, 0x0F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x0F, 0xE7, 0xF0, 0x01,
  0xF8, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0x80,
  0x03, 0xF8, 0xFE, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x1F,
  0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0xC0, 0x0F, 0xE1, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x07, 0xF0, 0xFC, 0x00,
  0x7E, 0x0F, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0x80, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0x03, 0xF8,
  0x00, 0xFE, 0x07, 0xE0, 0x3F, 0x81, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x1F,
  0x80, 0xFE, 0x00, 0x3F, 0x01, 0xF8, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x80,
  0xFC, 0x0F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x7E, 0x0F, 0xE0, 0x3F, 0x80,
  0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xC0, 0x07, 0xF0, 0x1F, 0x87, 0xF0,
  0x0F, 0xE0, 0x03, 0xF0, 0x07, 0xE3, 0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x03,
  0xF3, 0xF8, 0x07, 0xF8, 0x01, 0xFC, 0x01, 0xF9, 0xF8, 0x03, 0xF8, 0x00,
  0xFE, 0x00, 0xFD, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0xFC, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F,
  0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0xFE, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0xFE, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x3F, 0x80,
  0x03, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0,
  0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0,
  0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xE0, 0x07, 0xF0, 0x03, 0xF8,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFC,
  0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x7F, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0xBF, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x8F, 0xFF, 0x80, 0x07, 0xFF,
  0x00, 0x3F, 0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00,
  0x1F, 0xF0, 0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x87,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0,
  0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xBF, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xF3, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8,
  0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01,
  0xFC, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x0F,
  0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFF, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xDF, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x3F,
  0xF8, 0x01, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0,
  0x0F, 0xF8, 0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0xFF,
  0x80, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0xE0, 0x00, 0x00,
  0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xBF, 0xC0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFB, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xBF,
  0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x8F, 0xF0, 0x00, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x07, 0xFC,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF,
  0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF0,
  0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x1F, 0xE0, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F,
  0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xE0,
  0x0F, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x7F,
  0x80, 0x7F, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00,
  0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x7F, 0xF0, 0x07, 0xFE,
  0x00, 0x3C, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x10, 0x00, 0x01, 0xFF, 0x03, 0x80, 0x00, 0x7F, 0xE0, 0x7E,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF,
  0xFF, 0x80, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x03,
  0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x00,
  0xFF, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x0F,
  0xF0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0,
  0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x07,
  0xF9, 0xFC, 0x00, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x00, 0x7F, 0x8F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x03,
  0xFC, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0xFE, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x7F, 0x00, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF,
  0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF9, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFE, 0x3F, 0x80,
  0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x00, 0xFD, 0xFC, 0x00,
  0x3F, 0x80, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xF0, 0x1F, 0xC0, 0x07,
  0xE7, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xE1, 0xF8,
  0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x3F, 0x00, 0x7F, 0x80, 0x3F, 0x80,
  0x3F, 0x07, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x03, 0xFC,
  0x00, 0xFE, 0x01, 0xF8, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x03,
  0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x7E, 0x03, 0xF8, 0x00, 0x7F,
  0x03, 0xF8, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x83, 0xF8,
  0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x1F, 0xC0, 0x1F, 0x83, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x03, 0xF0,
  0xFE, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x1F,
  0x80, 0x0F, 0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x01, 0xF8, 0xFE, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x9F, 0x80, 0x07,
  0xE7, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x03, 0xF7, 0xF0,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x07, 0xDF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xBF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xF8,
  0xFF, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00,
  0x3F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xFC, 0x3F,
  0xC0, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x01,
  0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x20, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7F, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xE0, 0x3F, 0x80, 0xFE, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x03,
  0xF7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF,
  0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x3F, 0x81, 0xFC, 0x0F, 0xC0, 0x7E, 0x07,
  0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x10, 0x00, 0xFF, 0xE0,
  0x3E, 0x00, 0x3F, 0xFF, 0x87, 0xE0, 0x07, 0xFF, 0xFC, 0x7E, 0x00, 0xFF,
  0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xC0,
  0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF, 0x80, 0x0F,
  0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xE0,
  0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x3F, 0xF8, 0x07,
  0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF3, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xBF,
  0x80, 0x3F, 0xFF, 0xF3, 0xF0, 0x01, 0xFF, 0xFE, 0x3F, 0x00, 0x0F, 0xFF,
  0x83, 0xF0, 0x00, 0x7F, 0xF0, 0x3F, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0xE0, 0x01, 0xFC,
  0x3F, 0xFE, 0x00, 0x3F, 0x8F, 0xFF, 0xE0, 0x07, 0xF3, 0xFF, 0xFE, 0x00,
  0xFE, 0xFF, 0xFF, 0xC0, 0x3F, 0xBF, 0x0F, 0xFC, 0x07, 0xFF, 0x80, 0x7F,
  0x80, 0xFF, 0xE0, 0x07, 0xF8, 0x1F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00,
  0x1F, 0xE0, 0xFF, 0x80, 0x03, 0xFC, 0x1F, 0xF0, 0x00, 0x3F, 0x83, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x1F, 0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x1F, 0xF0, 0x01, 0xFF,
  0x07, 0xFE, 0x00, 0x7F, 0xC0, 0xFF, 0xE0, 0x1F, 0xF8, 0x1F, 0xFF, 0x8F,
  0xFE, 0x03, 0xF7, 0xFF, 0xFF, 0x80, 0xFE, 0x7F, 0xFF, 0xE0, 0x1F, 0x87,
  0xFF, 0xF8, 0x03, 0xF0, 0x7F, 0xFE, 0x00, 0x7C, 0x07, 0xFF, 0x00, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x1F, 0x01, 0xFF, 0x80, 0x0C, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x10,
  0x1F, 0xF8, 0x01, 0xC0, 0x3F, 0xF8, 0x3F, 0x00, 0x7F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x03, 0xFC, 0x00, 0x07, 0xFF, 0x07,
  0xF0, 0x00, 0x3F, 0xFF, 0x8F, 0xE0, 0x00, 0xFF, 0xFF, 0x1F, 0xC0, 0x03,
  0xFF, 0xFF, 0x3F, 0x80, 0x0F, 0xFF, 0xFF, 0x7E, 0x00, 0x3F, 0xF8, 0x7F,
  0xFC, 0x00, 0xFF, 0xC0, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xF0, 0x07,
  0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x07, 0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xF0,
  0x03, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF8, 0x03, 0xFF, 0x80, 0x0F, 0xF8,
  0x0F, 0xFF, 0x00, 0x1F, 0xFC, 0x7F, 0xFE, 0x00, 0x1F, 0xFF, 0xFD, 0xFC,
  0x00, 0x3F, 0xFF, 0xF3, 0xF0, 0x00, 0x3F, 0xFF, 0xC7, 0xE0, 0x00, 0x3F,
  0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xF8, 0x1F, 0x80, 0x00, 0x07, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFF, 0x80, 0xFF, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x07, 0xF8, 0x01,
  0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF8, 0xFF, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xFE,
  0x1F, 0xC0, 0x0F, 0xFC, 0x7F, 0x83, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x10, 0x1F, 0xF0, 0x01, 0xE0, 0x3F, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x83, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x02, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7B, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x08, 0x00, 0x3F, 0xF8,
  0x0F, 0x80, 0x07, 0xFF, 0xF0, 0xFC, 0x00, 0x7F, 0xFF, 0xC7, 0xE0, 0x07,
  0xFF, 0xFE, 0x7F, 0x00, 0x7F, 0xFF, 0xFB, 0xF8, 0x07, 0xFF, 0x0F, 0xFF,
  0x80, 0x7F, 0xE0, 0x1F, 0xFC, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xE0,
  0x03, 0xFF, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x3F, 0x81, 0xFE, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFF, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0xFF, 0x80, 0xFF, 0x00, 0x07,
  0xFC, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFF,
  0x00, 0x7F, 0xF0, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0x3F, 0xF8, 0xFD, 0xFC,
  0x00, 0xFF, 0xFF, 0xCF, 0xE0, 0x07, 0xFF, 0xFC, 0xFE, 0x00, 0x1F, 0xFF,
  0xC7, 0xF0, 0x00, 0x7F, 0xFC, 0x3F, 0x80, 0x00, 0xFF, 0x81, 0xFC, 0x00,
  0x01, 0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x02, 0x00, 0x00, 0xFF, 0x00, 0x1E, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x8F,
  0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x00, 0x02, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0xFC,
  0x00, 0x0F, 0xF0, 0x7F, 0xF0, 0x01, 0xFC, 0x3F, 0xFF, 0x00, 0x3F, 0x8F,
  0xFF, 0xF0, 0x07, 0xF3, 0xFF, 0xFE, 0x00, 0xFE, 0xFF, 0xFF, 0xE0, 0x3F,
  0xBF, 0x87, 0xFC, 0x07, 0xFF, 0xC0, 0x7F, 0x80, 0xFF, 0xE0, 0x07, 0xF8,
  0x1F, 0xF8, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0xC0, 0x03,
  0xFC, 0x1F, 0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x03, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x00,
  0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7B, 0xFF, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x3F, 0xF0, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xF9, 0xFE, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x7F,
  0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0xF8, 0x00,
  0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x0F, 0xC3, 0xFF,
  0xF8, 0x1F, 0xFF, 0xE0, 0x1F, 0x8F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC0, 0x3F,
  0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0xC0, 0xFE, 0xFC, 0x3F, 0xE7, 0xF0, 0xFF,
  0x81, 0xFF, 0xE0, 0x1F, 0xDF, 0x80, 0xFF, 0x03, 0xFF, 0x80, 0x3F, 0xFC,
  0x00, 0xFE, 0x07, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFC, 0x0F, 0xF8, 0x00,
  0xFF, 0xC0, 0x03, 0xF8, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x87, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x3F, 0x83, 0xFF, 0xC0, 0x07, 0xE0, 0xFF, 0xFC, 0x00,
  0xFC, 0x7F, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xFC, 0x07, 0xF3, 0xFF, 0xFF,
  0x80, 0xFE, 0xFF, 0x3F, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xE0, 0x7F, 0xE0, 0x03, 0xFC, 0x1F, 0xFC, 0x00, 0x7F, 0x83, 0xFF,
  0x00, 0x0F, 0xF0, 0x7F, 0xC0, 0x01, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x07, 0xF0, 0x7F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF0,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xE0,
  0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFE,
  0x1F, 0xF8, 0x0F, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0x87, 0xFC, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x0F, 0xF3, 0xFC,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0xFE, 0xFF,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x1F, 0xDF,
  0xC0, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xF8, 0x00, 0x03, 0xFB, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x7F,
  0x9F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x3F,
  0xC1, 0xFE, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F, 0xF8, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x01, 0xFF, 0x80,
  0x00, 0x7E, 0x0F, 0xFF, 0x80, 0x00, 0xFC, 0x3F, 0xFF, 0x80, 0x01, 0xF8,
  0xFF, 0xFF, 0x80, 0x03, 0xF3, 0xFF, 0xFF, 0x00, 0x0F, 0xEF, 0xC3, 0xFF,
  0x00, 0x1F, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F,
  0xF0, 0x07, 0xFC, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00,
  0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x01, 0xFF, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFF, 0x80,
  0x7F, 0xE0, 0x07, 0xFF, 0xE3, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0x9F, 0xFF, 0xF8, 0x00, 0x7F, 0x1F, 0xFF, 0xE0, 0x00, 0xFE, 0x1F,
  0xFF, 0x80, 0x01, 0xFC, 0x1F, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xC0, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x10,
  0x00, 0xFF, 0xE0, 0x3E, 0x00, 0x3F, 0xFF, 0x87, 0xE0, 0x07, 0xFF, 0xFC,
  0x7E, 0x00, 0xFF, 0xFF, 0xC7, 0xE0, 0x1F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF,
  0x87, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xFC, 0x07, 0xFC, 0x00, 0xFF, 0xC0,
  0xFF, 0x80, 0x0F, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x81, 0xFE, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x80, 0x7F, 0x80,
  0x3F, 0xF8, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF1, 0xFB, 0xF8, 0x03,
  0xFF, 0xFF, 0x3F, 0x80, 0x3F, 0xFF, 0xE7, 0xF0, 0x01, 0xFF, 0xFC, 0x7F,
  0x00, 0x0F, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x78,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x1F, 0xC1, 0xFF, 0x01, 0xF8,
  0x3F, 0xF0, 0x1F, 0x87, 0xFF, 0x01, 0xF8, 0xFF, 0xE0, 0x1F, 0x9F, 0xFE,
  0x03, 0xFB, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xC0, 0xFF, 0x00, 0x0C, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xE3, 0x00, 0x00, 0xFE, 0x1E, 0x00, 0x1F, 0xF0,
  0xFE, 0x03, 0xFF, 0x87, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x00,
  0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xC0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0x0E, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0,
  0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x07,
  0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0,
  0xFE, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x01, 0xFF, 0x03, 0xF8, 0x00, 0x3F,
  0xE0, 0x7F, 0x00, 0x0F, 0xFC, 0x0F, 0xE0, 0x03, 0xFF, 0x81, 0xFE, 0x00,
  0xFF, 0xE0, 0x3F, 0xC0, 0x3E, 0xFC, 0x07, 0xFE, 0x3F, 0x9F, 0x80, 0x7F,
  0xFF, 0xF7, 0xF0, 0x0F, 0xFF, 0xFC, 0xFE, 0x00, 0xFF, 0xFE, 0x1F, 0x80,
  0x0F, 0xFF, 0x83, 0xF0, 0x00, 0xFF, 0xE0, 0x7E, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xDF, 0xC0, 0x00, 0x1F, 0xE7, 0xF0,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x01, 0xFE, 0x1F,
  0xC0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x80,
  0x7F, 0x80, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xF8, 0x0F, 0xF0, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xFB, 0xF8,
  0x00, 0x7F, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0xFF, 0x3F,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x8F, 0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xE3,
  0xF8, 0x01, 0xFB, 0xE0, 0x07, 0xF8, 0xFE, 0x00, 0x7E, 0xF8, 0x01, 0xFC,
  0x3F, 0x80, 0x3F, 0x3E, 0x00, 0xFF, 0x0F, 0xE0, 0x0F, 0xCF, 0x80, 0x3F,
  0x81, 0xF8, 0x07, 0xE7, 0xE0, 0x1F, 0xE0, 0x7E, 0x01, 0xF9, 0xF8, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x7E, 0x03, 0xFC, 0x07, 0xE0, 0x3F, 0x1F, 0x80,
  0xFE, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F, 0x80, 0x7E, 0x07, 0xE1, 0xF8,
  0x1F, 0xC0, 0x1F, 0x81, 0xF8, 0x3E, 0x07, 0xF0, 0x07, 0xE0, 0xFC, 0x0F,
  0x83, 0xF8, 0x01, 0xF8, 0x3F, 0x03, 0xE0, 0xFE, 0x00, 0x7E, 0x1F, 0x80,
  0xF8, 0x7F, 0x00, 0x1F, 0x87, 0xE0, 0x3F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8,
  0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0xFC, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x3F,
  0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x3F, 0x7F, 0x00, 0x07, 0xE7,
  0xE0, 0x0F, 0xDF, 0xC0, 0x01, 0xFB, 0xF0, 0x03, 0xF7, 0xE0, 0x00, 0x7E,
  0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x3E, 0xFC, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x07, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFF, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x80,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07,
  0xF1, 0xFE, 0x00, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x3F, 0xE0,
  0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x07, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F,
  0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x01,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x8F, 0xFF, 0xC0, 0x00, 0xDF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFC, 0xC0, 0x00, 0x1F, 0xFC, 0x40, 0x00,
  0x00, 0x40, 0x00,
};

const GFXglyph NotoSans_MediumItalic69pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 19, 50, 19, 1, -49 },
  { 120, 23, 18, 28, 7, -49 },
  { 172, 43, 49, 45, 2, -49 },
  { 436, 35, 56, 38, 2, -52 },
  { 681, 48, 51, 56, 5, -50 },
  { 987, 44, 51, 47, 2, -50 },
  { 1268, 10, 18, 16, 7, -49 },
  { 1291, 23, 60, 21, 3, -49 },
  { 1464, 23, 61, 21, -5, -50 },
  { 1640, 32, 33, 38, 7, -53 },
  { 1772, 33, 33, 39, 4, -41 },
  { 1909, 15, 17, 18, -3, -8 },
  { 1941, 18, 7, 22, 2, -22 },
  { 1957, 10, 10, 18, 1, -9 },
  { 1970, 35, 49, 26, -3, -49 },
  { 2185, 34, 51, 38, 3, -50 },
  { 2402, 23, 49, 38, 9, -49 },
  { 2543, 37, 50, 38, 0, -50 },
  { 2775, 36, 51, 38, 1, -50 },
  { 3005, 37, 49, 38, 0, -49 },
  { 3232, 35, 50, 38, 2, -49 },
  { 3451, 34, 51, 38, 4, -50 },
  { 3668, 34, 49, 38, 5, -49 },
  { 3877, 35, 51, 38, 3, -50 },
  { 4101, 33, 51, 38, 3, -50 },
  { 4312, 15, 39, 18, 1, -38 },
  { 4386, 19, 47, 18, -3, -38 },
  { 4498, 33, 34, 39, 4, -42 },
  { 4639, 32, 19, 39, 5, -34 },
  { 4715, 33, 34, 39, 4, -42 },
  { 4856, 27, 51, 30, 5, -50 },
  { 5029, 53, 55, 59, 4, -49 },
  { 5394, 41, 49, 40, -4, -49 },
  { 5646, 38, 49, 42, 3, -49 },
  { 5879, 39, 51, 41, 5, -50 },
  { 6128, 41, 49, 46, 3, -49 },
  { 6380, 36, 49, 36, 3, -49 },
  { 6601, 36, 49, 34, 3, -49 },
  { 6822, 41, 51, 47, 5, -50 },
  { 7084, 45, 49, 47, 3, -49 },
  { 7360, 29, 49, 24, -2, -49 },
  { 7538, 32, 63, 20, -11, -49 },
  { 7790, 43, 49, 40, 3, -49 },
  { 8054, 27, 49, 34, 3, -49 },
  { 8220, 57, 49, 59, 2, -49 },
  { 8570, 48, 49, 50, 2, -49 },
  { 8864, 43, 51, 50, 5, -50 },
  { 9139, 37, 49, 40, 3, -49 },
  { 9366, 43, 62, 50, 5, -50 },
  { 9700, 37, 49, 41, 3, -49 },
  { 9927, 35, 51, 35, 1, -50 },
  { 10151, 35, 49, 35, 6, -49 },
  { 10366, 43, 50, 47, 5, -49 },
  { 10635, 39, 49, 39, 6, -49 },
  { 10874, 59, 49, 60, 7, -49 },
  { 11236, 48, 49, 38, -4, -49 },
  { 11530, 37, 49, 36, 6, -49 },
  { 11757, 41, 49, 37, -1, -49 },
  { 12009, 27, 60, 21, -1, -49 },
  { 12212, 14, 49, 26, 7, -49 },
  { 12298, 27, 60, 21, -5, -49 },
  { 12501, 35, 32, 39, 2, -50 },
  { 12641, 28, 5, 27, -6, 6 },
  { 12659, 12, 11, 20, 10, -53 },
  { 12676, 36, 39, 40, 3, -38 },
  { 12852, 35, 53, 40, 2, -52 },
  { 13084, 30, 39, 32, 3, -38 },
  { 13231, 39, 53, 40, 3, -52 },
  { 13490, 31, 39, 36, 3, -38 },
  { 13642, 39, 70, 23, -8, -53 },
  { 13984, 37, 55, 40, 2, -38 },
  { 14239, 35, 52, 40, 2, -52 },
  { 14467, 18, 51, 19, 2, -51 },
  { 14582, 29, 68, 19, -9, -51 },
  { 14829, 36, 52, 36, 2, -52 },
  { 15063, 18, 52, 19, 2, -52 },
  { 15180, 55, 38, 61, 2, -38 },
  { 15442, 35, 38, 40, 2, -38 },
  { 15609, 33, 39, 39, 3, -38 },
  { 15770, 39, 55, 40, -2, -38 },
  { 16039, 36, 55, 40, 3, -38 },
  { 16287, 28, 38, 28, 2, -38 },
  { 16420, 29, 39, 31, 0, -38 },
  { 16562, 23, 46, 25, 3, -45 },
  { 16695, 35, 38, 40, 4, -37 },
  { 16862, 34, 37, 33, 3, -37 },
  { 17020, 50, 37, 51, 4, -37 },
  { 17252, 40, 37, 34, -3, -37 },
  { 17437, 43, 54, 33, -6, -37 },
  { 17728, 32, 37, 31, -1, -37 },
  { 17876, 27, 60, 24, 1, -49 },
  { 18079, 6, 68, 38, 17, -52 },
  { 18130, 27, 60, 24, -3, -49 },
  { 18333, 33, 10, 39, 4, -29 },
};

const GFXfont NotoSans_MediumItalic69pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic69pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic69pt7bGlyphs,
  0x20, 0x7E, 94
};

#endif // _NOTOSANS_MEDIUMITALIC69PT7B_H_
