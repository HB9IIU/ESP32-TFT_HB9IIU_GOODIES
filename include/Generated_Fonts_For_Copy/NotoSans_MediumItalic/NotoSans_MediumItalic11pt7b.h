#ifndef _NOTOSANS_MEDIUMITALIC11PT7B_H_
#define _NOTOSANS_MEDIUMITALIC11PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 11pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic11pt7bBitmaps[] PROGMEM = {
  0x00, 0x25, 0xA4, 0x86, 0xFA, 0xA0, 0x14, 0x29, 0xF9, 0x22, 0x9F, 0xD2,
  0x28, 0x18, 0xF5, 0x1C, 0x18, 0xAF, 0x88, 0x20, 0x62, 0xA4, 0xA8, 0xAE,
  0xD9, 0x2A, 0x4A, 0xCE, 0x18, 0x48, 0xB1, 0xC7, 0x39, 0xF3, 0x3F, 0xE8,
  0x12, 0x64, 0x4C, 0xCC, 0x44, 0x21, 0x11, 0x11, 0x22, 0x48, 0x37, 0x0F,
  0xA1, 0x00, 0x21, 0x09, 0xF2, 0x10, 0xE0, 0xE0, 0xC0, 0x04, 0x20, 0x84,
  0x30, 0x84, 0x30, 0x72, 0x63, 0x18, 0xCA, 0x5C, 0x37, 0xB2, 0x22, 0x64,
  0x39, 0x30, 0x42, 0x10, 0x84, 0x3E, 0x39, 0x10, 0x4E, 0x18, 0x20, 0xBC,
  0x0C, 0x51, 0x8A, 0x4B, 0xF1, 0x04, 0x3C, 0x82, 0x1E, 0x08, 0x20, 0xBC,
  0x3A, 0x21, 0xE9, 0xCE, 0x5E, 0xF8, 0x44, 0x62, 0x21, 0x10, 0x38, 0x92,
  0x4E, 0x79, 0x2C, 0x9E, 0x39, 0xB4, 0x53, 0x7C, 0x21, 0xBC, 0x68, 0x01,
  0x80, 0x32, 0x00, 0x06, 0xC0, 0x09, 0xB1, 0x83, 0x04, 0xF8, 0x3E, 0x86,
  0x0C, 0x3E, 0x40, 0xF1, 0x12, 0x48, 0x08, 0x1C, 0x63, 0x9D, 0xA5, 0xA5,
  0xA9, 0xB6, 0x80, 0x7C, 0x0C, 0x18, 0x50, 0xA2, 0x47, 0xD0, 0xE1, 0x3C,
  0x4C, 0x93, 0xE4, 0xC8, 0x93, 0x7C, 0x3D, 0x8C, 0x20, 0x82, 0x08, 0x1E,
  0x3C, 0x4C, 0x8B, 0x14, 0x28, 0xD3, 0x7C, 0x3C, 0x82, 0x1E, 0x41, 0x04,
  0x3E, 0x3C, 0x82, 0x18, 0x79, 0x04, 0x30, 0x3D, 0x9C, 0x20, 0x9E, 0x38,
  0x9E, 0x23, 0x22, 0x22, 0x7E, 0x46, 0x44, 0x44, 0xC4, 0x72, 0x22, 0x64,
  0x4E, 0x08, 0x42, 0x31, 0x08, 0x42, 0x27, 0x00, 0x22, 0x48, 0xA3, 0x87,
  0x0B, 0x12, 0x66, 0x21, 0x08, 0xC4, 0x21, 0x1F, 0x31, 0x98, 0xCC, 0xAA,
  0x55, 0x5A, 0xA9, 0x65, 0xB2, 0x21, 0x31, 0x33, 0x5A, 0x4A, 0x4A, 0x4E,
  0xC4, 0x38, 0x8B, 0x1C, 0x38, 0x50, 0xA3, 0x3C, 0x3C, 0x92, 0x59, 0x79,
  0x04, 0x30, 0x38, 0x8B, 0x1C, 0x38, 0x50, 0xA3, 0x3C, 0x10, 0x10, 0x38,
  0x92, 0x59, 0x79, 0x24, 0xB3, 0x3D, 0x84, 0x18, 0x18, 0x20, 0xBC, 0xFC,
  0x82, 0x08, 0x61, 0x04, 0x10, 0x46, 0x8B, 0x14, 0x28, 0xD1, 0x22, 0x78,
  0x86, 0x28, 0xA4, 0xD1, 0x86, 0x10, 0x88, 0xE2, 0x29, 0x92, 0x54, 0xA7,
  0x29, 0x8C, 0x63, 0x10, 0x33, 0x12, 0x14, 0x18, 0x18, 0x3C, 0x24, 0xC4,
  0x8F, 0x25, 0x18, 0x61, 0x04, 0x10, 0x7C, 0x30, 0x84, 0x21, 0x84, 0x3E,
  0x32, 0x44, 0x44, 0x48, 0x8C, 0xA5, 0x55, 0x38, 0x84, 0x21, 0x10, 0x84,
  0x27, 0x00, 0x10, 0xC2, 0x92, 0xC4, 0xF8, 0xC0, 0x7E, 0xE7, 0x29, 0x78,
  0x20, 0x87, 0x99, 0x45, 0x34, 0xAE, 0x78, 0x88, 0x8E, 0x0C, 0x27, 0xA6,
  0x9A, 0x49, 0x3C, 0x79, 0xBC, 0x8F, 0x1C, 0x43, 0x8C, 0x20, 0x82, 0x08,
  0x61, 0x08, 0x00, 0x3D, 0x34, 0xD2, 0x49, 0xE0, 0xA4, 0x60, 0x20, 0x87,
  0xD9, 0x45, 0x34, 0xB2, 0x21, 0xA4, 0x96, 0x10, 0x32, 0x22, 0x26, 0x44,
  0x80, 0x20, 0x86, 0xD6, 0x71, 0x45, 0x32, 0x25, 0xA4, 0x96, 0x5B, 0xB2,
  0x53, 0x29, 0x14, 0x9E, 0x48, 0x5D, 0x94, 0x53, 0x4B, 0x20, 0x74, 0xE3,
  0x39, 0x70, 0x59, 0x94, 0x53, 0x4B, 0xE8, 0x20, 0x80, 0x7C, 0xE7, 0x29,
  0x78, 0x46, 0x20, 0x5B, 0x10, 0x84, 0x60, 0x7A, 0x18, 0x61, 0x78, 0x2F,
  0x44, 0x44, 0x60, 0xCC, 0x63, 0x29, 0x78, 0x9C, 0xAD, 0x4C, 0x60, 0x93,
  0xB2, 0xB4, 0xD4, 0xD4, 0x98, 0x4D, 0xE3, 0x0C, 0x52, 0x60, 0x26, 0x48,
  0xB1, 0x43, 0x06, 0x08, 0x30, 0xC0, 0x78, 0x8C, 0xC4, 0x78, 0x12, 0x22,
  0xC4, 0x44, 0x46, 0xFF, 0xE0, 0x62, 0x22, 0x23, 0x44, 0x48, 0xCD, 0xC0,
};

const GFXglyph NotoSans_MediumItalic11pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 3, 8, 3, 0, -8 },
  { 4, 4, 3, 5, 1, -8 },
  { 6, 7, 8, 7, 0, -8 },
  { 13, 6, 9, 6, 0, -8 },
  { 20, 8, 8, 9, 1, -8 },
  { 28, 7, 8, 8, 0, -8 },
  { 35, 2, 3, 3, 1, -8 },
  { 36, 4, 10, 3, 0, -8 },
  { 41, 4, 10, 3, -1, -8 },
  { 46, 5, 5, 6, 1, -8 },
  { 50, 5, 6, 6, 1, -7 },
  { 54, 2, 2, 3, 0, -1 },
  { 55, 3, 1, 3, 0, -3 },
  { 56, 2, 1, 3, 0, -1 },
  { 57, 6, 8, 4, -1, -8 },
  { 63, 5, 8, 6, 1, -8 },
  { 68, 4, 8, 6, 1, -8 },
  { 72, 6, 8, 6, 0, -8 },
  { 78, 6, 8, 6, 0, -8 },
  { 84, 6, 8, 6, 0, -8 },
  { 90, 6, 8, 6, 0, -8 },
  { 96, 5, 8, 6, 1, -8 },
  { 101, 5, 8, 6, 1, -8 },
  { 106, 6, 8, 6, 0, -8 },
  { 112, 6, 8, 6, 0, -8 },
  { 118, 3, 6, 3, 0, -6 },
  { 121, 4, 7, 3, -1, -6 },
  { 125, 5, 6, 6, 1, -7 },
  { 129, 5, 3, 6, 1, -5 },
  { 131, 5, 6, 6, 1, -7 },
  { 135, 4, 8, 5, 1, -8 },
  { 139, 8, 9, 9, 1, -8 },
  { 148, 7, 8, 6, -1, -8 },
  { 155, 7, 8, 7, 0, -8 },
  { 162, 6, 8, 7, 1, -8 },
  { 168, 7, 8, 7, 0, -8 },
  { 175, 6, 8, 6, 0, -8 },
  { 181, 6, 8, 5, 0, -8 },
  { 187, 6, 8, 8, 1, -8 },
  { 193, 8, 8, 8, 0, -8 },
  { 201, 4, 8, 4, 0, -8 },
  { 205, 5, 10, 3, -2, -8 },
  { 212, 7, 8, 6, 0, -8 },
  { 219, 5, 8, 5, 0, -8 },
  { 224, 9, 8, 9, 0, -8 },
  { 233, 8, 8, 8, 0, -8 },
  { 241, 7, 8, 8, 1, -8 },
  { 248, 6, 8, 6, 0, -8 },
  { 254, 7, 10, 8, 1, -8 },
  { 263, 6, 8, 6, 0, -8 },
  { 269, 6, 8, 6, 0, -8 },
  { 275, 6, 8, 6, 1, -8 },
  { 281, 7, 8, 7, 1, -8 },
  { 288, 6, 8, 6, 1, -8 },
  { 294, 10, 8, 10, 1, -8 },
  { 304, 8, 8, 6, -1, -8 },
  { 312, 6, 8, 6, 1, -8 },
  { 318, 6, 8, 6, 0, -8 },
  { 324, 4, 10, 3, 0, -8 },
  { 329, 2, 8, 4, 1, -8 },
  { 331, 5, 10, 3, -1, -8 },
  { 338, 6, 5, 6, 0, -8 },
  { 342, 5, 1, 4, -1, 1 },
  { 343, 2, 1, 3, 2, -8 },
  { 344, 5, 6, 6, 1, -6 },
  { 348, 6, 8, 6, 0, -8 },
  { 354, 4, 6, 5, 1, -6 },
  { 357, 6, 8, 6, 1, -8 },
  { 363, 4, 6, 6, 1, -6 },
  { 366, 6, 11, 4, -1, -8 },
  { 375, 6, 9, 6, 0, -6 },
  { 382, 6, 8, 6, 0, -8 },
  { 388, 3, 8, 3, 0, -8 },
  { 391, 4, 11, 3, -1, -8 },
  { 397, 6, 8, 6, 0, -8 },
  { 403, 3, 8, 3, 0, -8 },
  { 406, 9, 6, 10, 0, -6 },
  { 413, 6, 6, 6, 0, -6 },
  { 418, 5, 6, 6, 1, -6 },
  { 422, 6, 9, 6, 0, -6 },
  { 429, 5, 9, 6, 1, -6 },
  { 435, 5, 6, 4, 0, -6 },
  { 439, 5, 6, 5, 0, -6 },
  { 443, 4, 7, 4, 0, -7 },
  { 447, 5, 6, 6, 1, -6 },
  { 451, 5, 6, 5, 1, -6 },
  { 455, 8, 6, 8, 1, -6 },
  { 461, 6, 6, 5, 0, -6 },
  { 466, 7, 9, 5, -1, -6 },
  { 474, 5, 6, 5, 0, -6 },
  { 478, 4, 10, 4, 0, -8 },
  { 483, 1, 11, 6, 3, -8 },
  { 485, 4, 10, 4, 0, -8 },
  { 490, 5, 2, 6, 1, -5 },
};

const GFXfont NotoSans_MediumItalic11pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic11pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic11pt7bGlyphs,
  0x20, 0x7E, 15
};

#endif // _NOTOSANS_MEDIUMITALIC11PT7B_H_
