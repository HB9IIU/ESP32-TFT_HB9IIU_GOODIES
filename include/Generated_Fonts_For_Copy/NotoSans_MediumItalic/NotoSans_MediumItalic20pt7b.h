#ifndef _NOTOSANS_MEDIUMITALIC20PT7B_H_
#define _NOTOSANS_MEDIUMITALIC20PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 20pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic20pt7bBitmaps[] PROGMEM = {
  0x00, 0x1C, 0x61, 0x86, 0x38, 0xC3, 0x0C, 0x31, 0x80, 0x18, 0xE3, 0x80,
  0x6E, 0x9B, 0x36, 0x4C, 0x80, 0x06, 0x60, 0xC4, 0x0C, 0xC0, 0x8C, 0x7F,
  0xF1, 0x98, 0x19, 0x81, 0x18, 0xFF, 0xEF, 0xFE, 0x23, 0x02, 0x20, 0x66,
  0x06, 0x60, 0x02, 0x01, 0x81, 0xFC, 0xD2, 0x64, 0x19, 0x03, 0xC0, 0xF8,
  0x0F, 0x02, 0xC0, 0xBA, 0x6C, 0xFF, 0x3F, 0x01, 0x00, 0xC0, 0x3C, 0x1D,
  0x98, 0x46, 0x63, 0x11, 0x98, 0x46, 0xC3, 0x12, 0x64, 0xDF, 0xDE, 0xD9,
  0x06, 0xC4, 0x13, 0x10, 0xCC, 0xC6, 0x33, 0x30, 0xD9, 0x81, 0xC0, 0x02,
  0x00, 0xF8, 0x19, 0xC3, 0x8C, 0x31, 0xC1, 0xB8, 0x1F, 0x01, 0xC0, 0x7E,
  0x3E, 0x66, 0xC3, 0x6C, 0x3C, 0xC1, 0xCF, 0xFC, 0x7C, 0x60, 0x6B, 0x6C,
  0x0E, 0x30, 0xC1, 0x86, 0x0C, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C, 0x18,
  0x30, 0x60, 0x60, 0x0C, 0x0C, 0x18, 0x30, 0x60, 0xC1, 0x83, 0x06, 0x0C,
  0x18, 0x60, 0xC3, 0x06, 0x18, 0xE0, 0x0C, 0x06, 0x33, 0x1F, 0x01, 0xF9,
  0xE1, 0x90, 0xCC, 0x46, 0x00, 0x0C, 0x03, 0x00, 0xC0, 0x30, 0xFF, 0xFF,
  0xF0, 0xC0, 0x30, 0x0C, 0x03, 0x00, 0x37, 0x64, 0xC0, 0x7F, 0xE0, 0x7F,
  0x80, 0x00, 0xC0, 0x60, 0x18, 0x0C, 0x06, 0x01, 0x80, 0xC0, 0x30, 0x18,
  0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x00, 0x02, 0x07, 0xE3, 0x98, 0xC7,
  0x60, 0xD8, 0x3E, 0x0F, 0x07, 0xC1, 0xB0, 0x6C, 0x1B, 0x0E, 0xC3, 0x1F,
  0x87, 0xC0, 0x1D, 0xFE, 0xF6, 0x18, 0x61, 0x8C, 0x30, 0xC3, 0x1C, 0x61,
  0x80, 0x1F, 0xC7, 0x38, 0x43, 0x80, 0x70, 0x0C, 0x01, 0x80, 0x60, 0x18,
  0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0F, 0xF9, 0xFF, 0x00, 0x3F, 0xC3, 0x18,
  0x03, 0x80, 0x70, 0x0C, 0x03, 0x07, 0xC0, 0x3C, 0x01, 0x80, 0x38, 0x06,
  0x40, 0xCF, 0xF8, 0xFC, 0x00, 0x00, 0xE0, 0x38, 0x0F, 0x03, 0x60, 0xCC,
  0x33, 0x06, 0x61, 0x8C, 0x61, 0x9F, 0xFF, 0xFF, 0x01, 0x80, 0x30, 0x0E,
  0x00, 0x1F, 0xCF, 0xE3, 0x00, 0xC0, 0x30, 0x1F, 0x87, 0xF0, 0x0E, 0x01,
  0x80, 0x60, 0x3A, 0x0C, 0xFF, 0x3F, 0x00, 0x0F, 0xC7, 0x13, 0x80, 0xC0,
  0x60, 0x1B, 0xC7, 0xFB, 0x86, 0xC1, 0xB0, 0x6C, 0x1B, 0x8C, 0x7F, 0x0F,
  0x80, 0x7F, 0xDF, 0xF0, 0x18, 0x06, 0x03, 0x01, 0xC0, 0x60, 0x30, 0x0C,
  0x06, 0x03, 0x80, 0xC0, 0x70, 0x38, 0x00, 0x02, 0x07, 0xE3, 0x9C, 0xC3,
  0x30, 0xCC, 0x61, 0xB8, 0x78, 0x77, 0x38, 0xEC, 0x1B, 0x06, 0xC3, 0xBF,
  0xC7, 0xE0, 0x1F, 0x0C, 0xE6, 0x19, 0x86, 0x61, 0xD8, 0x66, 0x39, 0xFE,
  0x39, 0x80, 0xC0, 0x30, 0x18, 0xFE, 0x3E, 0x00, 0x39, 0xCC, 0x00, 0x00,
  0x00, 0x67, 0x38, 0x1C, 0x71, 0x80, 0x00, 0x00, 0x00, 0x00, 0xC6, 0x18,
  0xC3, 0x00, 0x00, 0xC0, 0xF0, 0xF0, 0xF0, 0xE0, 0x3C, 0x03, 0xC0, 0x1E,
  0x01, 0xC0, 0x10, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0xC0,
  0x3C, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0xF0, 0xF1, 0xE0, 0xE0, 0x20, 0x00,
  0xFF, 0x9C, 0x18, 0x30, 0x63, 0x8E, 0x38, 0x60, 0x80, 0x02, 0x0C, 0x18,
  0x00, 0x07, 0xF8, 0x0E, 0x1C, 0x18, 0x06, 0x30, 0x06, 0x63, 0xF2, 0x46,
  0x23, 0xCC, 0x63, 0xCC, 0x62, 0xCC, 0x66, 0xCC, 0xC6, 0xCF, 0xFC, 0xC7,
  0x38, 0x60, 0x00, 0x70, 0x10, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xC0, 0x1C,
  0x03, 0xC0, 0x7C, 0x06, 0x40, 0xE6, 0x0C, 0x61, 0x86, 0x1F, 0xE3, 0xFE,
  0x30, 0x66, 0x06, 0x60, 0x6C, 0x07, 0x1F, 0xC7, 0xFC, 0xC1, 0x98, 0x33,
  0x0E, 0x63, 0x9F, 0xC3, 0x1C, 0x60, 0xCC, 0x1B, 0x83, 0x60, 0xEF, 0xF9,
  0xFC, 0x00, 0x0F, 0xF1, 0xE6, 0x38, 0x03, 0x00, 0x70, 0x06, 0x00, 0x60,
  0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x3F, 0x81, 0xF8, 0x1F,
  0xC3, 0xFE, 0x30, 0x63, 0x07, 0x30, 0x73, 0x03, 0x60, 0x76, 0x07, 0x60,
  0x66, 0x06, 0xE0, 0xCC, 0x3C, 0xFF, 0x8F, 0xE0, 0x1F, 0xCF, 0xF3, 0x00,
  0xC0, 0x30, 0x0C, 0x27, 0xF1, 0x80, 0x60, 0x18, 0x0E, 0x03, 0x00, 0xFF,
  0x3F, 0x80, 0x1F, 0xCF, 0xF3, 0x00, 0xC0, 0x30, 0x0C, 0x07, 0xF9, 0xFC,
  0x60, 0x18, 0x0E, 0x03, 0x00, 0xC0, 0x30, 0x00, 0x0F, 0xF1, 0xE7, 0x38,
  0x03, 0x00, 0x70, 0x06, 0x00, 0x61, 0xFE, 0x3E, 0xE0, 0x6E, 0x06, 0x60,
  0x67, 0x0E, 0x3F, 0xC1, 0xFC, 0x18, 0x19, 0xC1, 0x8C, 0x0C, 0x60, 0x63,
  0x03, 0x18, 0x39, 0xFF, 0x8F, 0xFC, 0x60, 0x63, 0x03, 0x38, 0x39, 0x81,
  0x8C, 0x0C, 0x60, 0x60, 0x3F, 0x0C, 0x0C, 0x1C, 0x18, 0x18, 0x18, 0x18,
  0x30, 0x30, 0x30, 0x30, 0x70, 0xF8, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30,
  0x18, 0x1C, 0x0C, 0x06, 0x03, 0x01, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0xF8, 0x78, 0x00, 0x18, 0x73, 0x0E, 0x31, 0xC3, 0x38, 0x37, 0x03, 0xE0,
  0x6C, 0x07, 0x60, 0x66, 0x06, 0x70, 0xE3, 0x0C, 0x30, 0xC1, 0x8C, 0x18,
  0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60, 0xE0, 0xC0,
  0xFF, 0xFE, 0x1C, 0x07, 0x3C, 0x0F, 0x3C, 0x1B, 0x3C, 0x1E, 0x3C, 0x36,
  0x24, 0x36, 0x64, 0x66, 0x64, 0x6C, 0x66, 0xCC, 0x66, 0xCC, 0xC7, 0x8C,
  0xC7, 0x8C, 0xC7, 0x18, 0xC6, 0x18, 0x18, 0x1C, 0xF0, 0x63, 0xC1, 0x8F,
  0x06, 0x36, 0x18, 0x98, 0xC6, 0x73, 0x18, 0xCC, 0x63, 0x31, 0x87, 0x8C,
  0x1E, 0x30, 0x78, 0xC0, 0xE3, 0x03, 0x80, 0x01, 0x00, 0x7F, 0x07, 0x1C,
  0x70, 0x63, 0x03, 0xB0, 0x0D, 0x80, 0x6C, 0x03, 0xE0, 0x3F, 0x01, 0xB8,
  0x0C, 0xC0, 0xE7, 0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x1F, 0x87, 0xF8, 0xC3,
  0x98, 0x73, 0x0E, 0x61, 0x98, 0xF3, 0xFC, 0x7C, 0x0C, 0x03, 0x80, 0x60,
  0x0C, 0x01, 0x80, 0x00, 0x01, 0x00, 0x7F, 0x07, 0xBC, 0x70, 0x63, 0x03,
  0xB0, 0x0D, 0x80, 0x6C, 0x03, 0xE0, 0x3F, 0x01, 0xB8, 0x0C, 0xC0, 0xE7,
  0x0E, 0x1F, 0xE0, 0x7E, 0x00, 0x70, 0x01, 0x80, 0x0F, 0x00, 0x1F, 0x87,
  0xF8, 0xC3, 0x18, 0x73, 0x0C, 0x61, 0x9F, 0xE3, 0xF8, 0x66, 0x0C, 0x63,
  0x8C, 0x61, 0xCC, 0x19, 0x83, 0x80, 0x0F, 0xE3, 0x98, 0xE0, 0x18, 0x03,
  0x80, 0x38, 0x07, 0x80, 0x38, 0x03, 0x80, 0x30, 0x06, 0x41, 0xCF, 0xF1,
  0xFC, 0x00, 0xFF, 0xFF, 0xF1, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x03, 0x01, 0xC0, 0x60, 0x18, 0x00, 0x70, 0x36, 0x06, 0x60,
  0x66, 0x06, 0x60, 0x6E, 0x0E, 0xC0, 0xCC, 0x0C, 0xC0, 0xCC, 0x0C, 0xC1,
  0x8C, 0x18, 0xFF, 0x07, 0xE0, 0xC0, 0xF8, 0x1B, 0x07, 0x60, 0xCC, 0x39,
  0x86, 0x19, 0xC3, 0x30, 0x6C, 0x0D, 0x81, 0xE0, 0x3C, 0x07, 0x00, 0xE0,
  0x00, 0xC1, 0xC1, 0xE0, 0xE1, 0xB0, 0xF0, 0xD8, 0x78, 0xCC, 0x6C, 0x66,
  0x36, 0x73, 0x33, 0x31, 0x99, 0x98, 0xD8, 0xD8, 0x6C, 0x6C, 0x34, 0x3C,
  0x1E, 0x1E, 0x07, 0x0E, 0x03, 0x07, 0x00, 0x1C, 0x1C, 0x30, 0xC0, 0xC6,
  0x01, 0xB8, 0x06, 0xC0, 0x1E, 0x00, 0x30, 0x01, 0xE0, 0x0D, 0x80, 0x76,
  0x01, 0x8C, 0x0C, 0x30, 0x60, 0xC3, 0x83, 0x80, 0xC1, 0xF0, 0x66, 0x31,
  0x9C, 0x66, 0x1B, 0x03, 0xC0, 0xE0, 0x30, 0x0C, 0x03, 0x00, 0xC0, 0x60,
  0x18, 0x00, 0x1F, 0xF3, 0xFE, 0x00, 0xC0, 0x1C, 0x03, 0x80, 0x70, 0x06,
  0x00, 0xC0, 0x1C, 0x03, 0x80, 0x30, 0x06, 0x00, 0xFF, 0x8F, 0xF8, 0x1F,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x30, 0x60, 0x60, 0x60, 0x60,
  0x40, 0xC0, 0xC0, 0xF0, 0xCC, 0x46, 0x66, 0x66, 0x62, 0x33, 0x33, 0x1E,
  0x0C, 0x18, 0x30, 0xC1, 0x83, 0x06, 0x0C, 0x30, 0x60, 0xC1, 0x82, 0x0C,
  0x18, 0xF0, 0x0C, 0x07, 0x01, 0xE0, 0xC8, 0x33, 0x18, 0xC6, 0x1B, 0x06,
  0xC0, 0xC0, 0xFF, 0xCC, 0x80, 0x1E, 0xCF, 0xF7, 0x1D, 0x86, 0xE1, 0xB0,
  0x6C, 0x1B, 0x0E, 0xC7, 0x3F, 0xC7, 0xB0, 0x0C, 0x03, 0x00, 0x60, 0x0C,
  0x01, 0xB8, 0x3F, 0x8E, 0x39, 0xC3, 0x30, 0x66, 0x1D, 0xC3, 0x30, 0x67,
  0x1C, 0xFF, 0x33, 0xC0, 0x1F, 0x3F, 0x70, 0x60, 0xE0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xFE, 0x7E, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x61, 0xEC, 0x7F, 0x9C,
  0x73, 0x0C, 0xE1, 0x98, 0x33, 0x06, 0x61, 0xCC, 0x71, 0xFE, 0x1E, 0xC0,
  0x1F, 0x1F, 0xDC, 0x6C, 0x3C, 0x77, 0xF3, 0x01, 0x80, 0xC0, 0x3B, 0x1F,
  0x80, 0x01, 0xE0, 0x74, 0x0C, 0x03, 0x00, 0xFC, 0x3F, 0x01, 0x80, 0x70,
  0x0C, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00, 0xC0, 0x18,
  0x06, 0x03, 0xC0, 0x70, 0x00, 0x0F, 0x63, 0xFC, 0xE3, 0x98, 0x67, 0x0C,
  0xC1, 0x98, 0x33, 0x0E, 0x63, 0x8F, 0xF0, 0xF6, 0x00, 0xC0, 0x31, 0x06,
  0x3F, 0x83, 0xE0, 0x0C, 0x03, 0x00, 0x60, 0x0C, 0x01, 0xBC, 0x3F, 0x8F,
  0x39, 0xC7, 0x30, 0xC6, 0x19, 0xC3, 0x30, 0x66, 0x1C, 0xC3, 0x38, 0x60,
  0x0C, 0x70, 0x80, 0x18, 0x63, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x8E, 0x00,
  0x01, 0x81, 0xC0, 0x40, 0x00, 0x30, 0x18, 0x18, 0x0C, 0x06, 0x03, 0x03,
  0x81, 0x80, 0xC0, 0x60, 0x30, 0x38, 0x18, 0x0C, 0x3E, 0x1C, 0x00, 0x0C,
  0x03, 0x00, 0x60, 0x0C, 0x01, 0x8E, 0x73, 0x8C, 0xE1, 0xB8, 0x3E, 0x07,
  0xC1, 0xD8, 0x33, 0x86, 0x30, 0xC7, 0x38, 0x60, 0x0C, 0x61, 0x86, 0x18,
  0x63, 0x0C, 0x30, 0xC7, 0x18, 0x61, 0x8E, 0x00, 0x13, 0x8F, 0x0B, 0xEF,
  0x8E, 0x3C, 0xE7, 0x1C, 0x73, 0x0C, 0x31, 0x86, 0x19, 0xC3, 0x0C, 0xC3,
  0x86, 0x61, 0x87, 0x30, 0xC3, 0x38, 0x61, 0x80, 0x1B, 0xC6, 0xF8, 0xF3,
  0x9C, 0x73, 0x0C, 0x61, 0x9C, 0x33, 0x06, 0x61, 0xCC, 0x33, 0x86, 0x00,
  0x1E, 0x1F, 0xDC, 0x6C, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC3, 0x3F, 0x8F,
  0x80, 0x09, 0xC0, 0xBE, 0x1C, 0x71, 0xC3, 0x18, 0x31, 0x87, 0x38, 0x63,
  0x06, 0x38, 0xE3, 0xFC, 0x37, 0x86, 0x00, 0x60, 0x06, 0x00, 0x60, 0x0E,
  0x00, 0x1E, 0xCF, 0xF7, 0x1D, 0x86, 0xE1, 0xB0, 0x6C, 0x1B, 0x0E, 0xC7,
  0x3F, 0xC7, 0xB0, 0x0C, 0x07, 0x01, 0x80, 0x60, 0x18, 0x1B, 0x8B, 0x8F,
  0x07, 0x03, 0x01, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x00, 0x1F, 0x9F,
  0x9C, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x06, 0x7F, 0x3F, 0x00, 0x10,
  0x61, 0xFF, 0xE6, 0x0C, 0x18, 0x30, 0x61, 0x83, 0x07, 0xC7, 0x80, 0x30,
  0xDC, 0x36, 0x0D, 0x87, 0x61, 0x98, 0x6C, 0x1B, 0x0E, 0xC7, 0x3F, 0xC7,
  0xB0, 0xC1, 0xF0, 0x6C, 0x33, 0x0C, 0xC6, 0x19, 0x86, 0xC1, 0xB0, 0x78,
  0x1E, 0x07, 0x00, 0xC3, 0x0F, 0x87, 0x1B, 0x1E, 0x76, 0x2C, 0xCC, 0xD9,
  0x99, 0xB6, 0x36, 0x6C, 0x6C, 0xF0, 0x51, 0xE0, 0xE3, 0x81, 0x87, 0x00,
  0x18, 0x71, 0x8E, 0x0D, 0xC0, 0xD8, 0x0F, 0x00, 0x60, 0x0F, 0x01, 0xB0,
  0x3B, 0x07, 0x18, 0xE1, 0xC0, 0x18, 0x38, 0xC1, 0x86, 0x18, 0x30, 0xC0,
  0xCC, 0x06, 0x60, 0x36, 0x01, 0xB0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C,
  0x00, 0xC0, 0x0C, 0x03, 0xE0, 0x1C, 0x00, 0x3F, 0x9F, 0xC0, 0xC0, 0xC0,
  0xC0, 0xE0, 0xE0, 0x60, 0x60, 0x7F, 0x3F, 0x80, 0x07, 0x0E, 0x0C, 0x0C,
  0x18, 0x18, 0x18, 0x70, 0xE0, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x78,
  0x38, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x1C, 0x0E, 0x06, 0x06, 0x0C, 0x0C,
  0x0C, 0x0E, 0x03, 0x0E, 0x18, 0x18, 0x18, 0x30, 0x30, 0xF0, 0xE0, 0xFC,
  0xE3, 0xF0,
};

const GFXglyph NotoSans_MediumItalic20pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 5, 0, -1 },
  { 1, 6, 14, 5, 0, -14 },
  { 12, 7, 5, 8, 2, -14 },
  { 17, 12, 14, 13, 1, -14 },
  { 38, 10, 16, 11, 1, -15 },
  { 58, 14, 14, 16, 1, -14 },
  { 83, 12, 15, 14, 1, -15 },
  { 106, 3, 5, 5, 2, -14 },
  { 108, 7, 17, 6, 1, -14 },
  { 123, 7, 17, 6, -2, -14 },
  { 138, 9, 9, 11, 2, -15 },
  { 149, 10, 10, 11, 1, -12 },
  { 162, 4, 5, 5, -1, -2 },
  { 165, 6, 2, 6, 0, -6 },
  { 167, 3, 3, 5, 0, -3 },
  { 169, 10, 14, 8, -1, -14 },
  { 187, 10, 15, 11, 1, -15 },
  { 206, 6, 14, 11, 3, -14 },
  { 217, 11, 14, 11, 0, -14 },
  { 237, 11, 14, 11, 0, -14 },
  { 257, 11, 14, 11, 0, -14 },
  { 277, 10, 14, 11, 1, -14 },
  { 295, 10, 14, 11, 1, -14 },
  { 313, 10, 14, 11, 1, -14 },
  { 331, 10, 15, 11, 1, -15 },
  { 350, 10, 14, 11, 1, -14 },
  { 368, 5, 11, 5, 0, -11 },
  { 375, 6, 14, 5, -1, -11 },
  { 386, 10, 10, 11, 1, -12 },
  { 399, 10, 6, 11, 1, -10 },
  { 407, 10, 10, 11, 1, -12 },
  { 420, 7, 14, 9, 2, -14 },
  { 433, 16, 16, 17, 1, -14 },
  { 465, 12, 14, 12, -1, -14 },
  { 486, 11, 14, 12, 1, -14 },
  { 506, 12, 14, 12, 1, -14 },
  { 527, 12, 14, 13, 1, -14 },
  { 548, 10, 14, 10, 1, -14 },
  { 566, 10, 14, 10, 1, -14 },
  { 584, 12, 14, 14, 1, -14 },
  { 605, 13, 14, 14, 1, -14 },
  { 628, 8, 14, 7, 0, -14 },
  { 642, 9, 18, 6, -3, -14 },
  { 663, 12, 14, 12, 1, -14 },
  { 684, 8, 14, 10, 1, -14 },
  { 698, 16, 14, 17, 1, -14 },
  { 726, 14, 14, 14, 1, -14 },
  { 751, 13, 15, 14, 1, -15 },
  { 776, 11, 14, 12, 1, -14 },
  { 796, 13, 18, 14, 1, -15 },
  { 826, 11, 14, 12, 1, -14 },
  { 846, 11, 14, 10, 0, -14 },
  { 866, 10, 14, 10, 2, -14 },
  { 884, 12, 14, 14, 2, -14 },
  { 905, 11, 14, 11, 2, -14 },
  { 925, 17, 14, 17, 2, -14 },
  { 955, 14, 14, 11, -1, -14 },
  { 980, 10, 14, 11, 2, -14 },
  { 998, 12, 14, 11, 0, -14 },
  { 1019, 8, 17, 6, 0, -14 },
  { 1036, 4, 14, 8, 2, -14 },
  { 1043, 7, 17, 6, -1, -14 },
  { 1058, 10, 9, 11, 1, -14 },
  { 1070, 8, 1, 8, -2, 2 },
  { 1071, 3, 3, 6, 3, -15 },
  { 1073, 10, 11, 12, 1, -11 },
  { 1087, 11, 15, 12, 0, -15 },
  { 1108, 8, 11, 9, 1, -11 },
  { 1119, 11, 15, 12, 1, -15 },
  { 1140, 9, 11, 10, 1, -11 },
  { 1153, 11, 20, 7, -2, -15 },
  { 1181, 11, 16, 12, 0, -11 },
  { 1203, 11, 15, 12, 0, -15 },
  { 1224, 6, 15, 5, 0, -15 },
  { 1236, 9, 20, 5, -3, -15 },
  { 1259, 11, 15, 10, 0, -15 },
  { 1280, 6, 15, 5, 0, -15 },
  { 1292, 17, 11, 18, 0, -11 },
  { 1316, 11, 11, 12, 0, -11 },
  { 1332, 9, 11, 11, 1, -11 },
  { 1345, 12, 16, 12, -1, -11 },
  { 1369, 10, 16, 12, 1, -11 },
  { 1389, 9, 11, 8, 0, -11 },
  { 1402, 9, 11, 9, 0, -11 },
  { 1415, 7, 13, 7, 1, -13 },
  { 1427, 10, 11, 12, 1, -11 },
  { 1441, 10, 11, 10, 1, -11 },
  { 1455, 15, 11, 15, 1, -11 },
  { 1476, 12, 11, 10, -1, -11 },
  { 1493, 13, 16, 10, -2, -11 },
  { 1519, 9, 11, 9, 0, -11 },
  { 1532, 8, 17, 7, 0, -14 },
  { 1549, 2, 20, 11, 5, -15 },
  { 1554, 8, 17, 7, -1, -14 },
  { 1571, 10, 2, 11, 1, -8 },
};

const GFXfont NotoSans_MediumItalic20pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic20pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic20pt7bGlyphs,
  0x20, 0x7E, 27
};

#endif // _NOTOSANS_MEDIUMITALIC20PT7B_H_
