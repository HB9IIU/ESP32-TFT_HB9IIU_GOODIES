#ifndef _NOTOSANS_MEDIUMITALIC50PT7B_H_
#define _NOTOSANS_MEDIUMITALIC50PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 50pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic50pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x3F, 0x01, 0xF8, 0x0F,
  0xC0, 0x7E, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0,
  0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF0, 0x0F,
  0x80, 0x7C, 0x03, 0xE0, 0x1E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x04, 0x01, 0xF0, 0x1F, 0xC0, 0xFE, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x07,
  0x00, 0x00, 0x3E, 0x1F, 0x3E, 0x1F, 0x3E, 0x1F, 0x3C, 0x1E, 0x7C, 0x3E,
  0x7C, 0x3E, 0x7C, 0x3E, 0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x38,
  0x70, 0x78, 0xF0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0xC0, 0xF0,
  0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xE0, 0x00, 0x07, 0x81, 0xE0,
  0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0,
  0x00, 0x1F, 0x03, 0xC0, 0x00, 0x1E, 0x03, 0xC0, 0x00, 0x1E, 0x07, 0x80,
  0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFE,
  0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00,
  0x00, 0x78, 0x1E, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8,
  0x03, 0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00,
  0x07, 0x80, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00,
  0x07, 0x81, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00,
  0x0F, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x78, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x07,
  0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x03, 0xE3, 0x83, 0x03,
  0xE1, 0xC0, 0x01, 0xF0, 0xE0, 0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x78, 0x00,
  0x3E, 0x38, 0x00, 0x1F, 0x9C, 0x00, 0x0F, 0xEE, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7B, 0xF0, 0x00, 0x38, 0xFC, 0x00, 0x1C,
  0x7E, 0x00, 0x0E, 0x1F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x0F, 0x84, 0x03,
  0x87, 0xC3, 0x81, 0xCF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x03, 0x80, 0x00, 0x03, 0xC0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x0F, 0x81, 0xFF, 0x80, 0x03, 0xE0, 0x7F, 0xF8,
  0x00, 0x78, 0x0F, 0xFF, 0x00, 0x1E, 0x03, 0xE1, 0xE0, 0x07, 0x80, 0x78,
  0x3C, 0x01, 0xF0, 0x1F, 0x07, 0xC0, 0x3C, 0x03, 0xC0, 0xF8, 0x0F, 0x00,
  0xF8, 0x1E, 0x03, 0xE0, 0x1F, 0x03, 0xC0, 0xF8, 0x03, 0xC0, 0x78, 0x1E,
  0x00, 0x78, 0x0F, 0x07, 0x80, 0x0F, 0x03, 0xE1, 0xF0, 0x01, 0xE0, 0x7C,
  0x7C, 0x00, 0x3C, 0x0F, 0x0F, 0x0F, 0x87, 0x83, 0xE3, 0xC7, 0xFC, 0xF0,
  0x78, 0xF9, 0xFF, 0xDF, 0x1F, 0x3E, 0x7F, 0xFB, 0xFF, 0xC7, 0x9F, 0x0F,
  0x3F, 0xF1, 0xE3, 0xE1, 0xF7, 0xFC, 0x7C, 0xF8, 0x3E, 0x3F, 0x1F, 0x1E,
  0x07, 0xC0, 0x03, 0xC3, 0xC0, 0xF8, 0x00, 0xF0, 0xF8, 0x1F, 0x00, 0x3E,
  0x1F, 0x03, 0xC0, 0x0F, 0x83, 0xC0, 0x78, 0x01, 0xE0, 0x78, 0x0F, 0x00,
  0x78, 0x0F, 0x03, 0xE0, 0x1F, 0x01, 0xE0, 0x78, 0x07, 0xC0, 0x3C, 0x0F,
  0x00, 0xF0, 0x07, 0x83, 0xE0, 0x3C, 0x00, 0xF0, 0xF8, 0x0F, 0x80, 0x1F,
  0xBF, 0x01, 0xE0, 0x01, 0xFF, 0xC0, 0x78, 0x00, 0x3F, 0xF0, 0x1F, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0xF8,
  0x07, 0xC0, 0x01, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0xFC, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x3F, 0x7F,
  0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xF8, 0x7F, 0xFC, 0x03,
  0xF3, 0xF8, 0xFC, 0x07, 0xC7, 0xE1, 0xF8, 0x1F, 0x9F, 0x81, 0xF8, 0x3E,
  0x7E, 0x01, 0xF8, 0xF8, 0xF8, 0x01, 0xF3, 0xF1, 0xF0, 0x03, 0xFF, 0xC3,
  0xE0, 0x03, 0xFF, 0x07, 0xC0, 0x03, 0xFE, 0x0F, 0x80, 0x07, 0xF8, 0x1F,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0xE0, 0x7F, 0x83, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xCF, 0xC0, 0x7F, 0xFE, 0x0F, 0xC0, 0x7F,
  0xF0, 0x1F, 0xC0, 0x0C, 0x00, 0x00, 0x00, 0x3E, 0x7C, 0xF9, 0xE7, 0xCF,
  0x9F, 0x3C, 0x78, 0xF1, 0xC3, 0x8F, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0x80, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x80,
  0x03, 0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x1F, 0x00,
  0x1F, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xE0, 0x0C, 0x03, 0xC0, 0x1E, 0x07, 0x00, 0x3F,
  0x1E, 0x00, 0xFF, 0xBC, 0x00, 0xFF, 0xF0, 0x3C, 0x3F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3F, 0x83, 0xC0, 0xF7, 0x80, 0x03, 0xEF,
  0x00, 0x0F, 0x9E, 0x00, 0x7E, 0x1E, 0x01, 0xF8, 0x3C, 0x01, 0xF0, 0x7C,
  0x00, 0xC0, 0x78, 0x01, 0x00, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x07, 0xC3,
  0xF0, 0xFC, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83,
  0xC0, 0x7F, 0xFB, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x18, 0xFB,
  0xFF, 0xFF, 0xFF, 0xBF, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x3F, 0xFF, 0xC0, 0x3F,
  0xCF, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7C, 0x1F, 0x80, 0x3E, 0x0F,
  0xC0, 0x1F, 0x8F, 0xC0, 0x0F, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0xFC, 0x00, 0x3F,
  0x7E, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xCF, 0x80, 0x03,
  0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xF9, 0xF8, 0x00,
  0x7C, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0x1F, 0x00, 0x3F, 0x0F, 0x80,
  0x1F, 0x87, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0, 0x7E,
  0x1F, 0xC0, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x1F, 0xC0, 0x1F,
  0xC0, 0x3F, 0xE0, 0x3F, 0xF0, 0x7F, 0xF8, 0xFF, 0xFD, 0xFF, 0x7C, 0x7F,
  0x3E, 0x3E, 0x1F, 0x0E, 0x1F, 0x84, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x1F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xC0, 0x3F, 0xE7, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x30, 0x03, 0xF0, 0x04,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFE,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFF, 0xE0, 0x3F, 0x87, 0xF8, 0x0E, 0x00, 0xFC, 0x04, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE3, 0x00,
  0x07, 0xF1, 0xF0, 0x0F, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xF0, 0x07, 0xFF, 0xE0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7D, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E, 0x7C, 0x00, 0x0F,
  0x8F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x1F, 0x81,
  0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0x80, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x70, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x0C, 0x00, 0x1F, 0xC3, 0xE0, 0x1F, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x1F, 0xFF,
  0xE0, 0x1F, 0xF8, 0x30, 0x1F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0xFF, 0x80, 0xF9,
  0xFF, 0xE0, 0x7D, 0xFF, 0xF8, 0x3F, 0xFF, 0xFC, 0x1F, 0xE0, 0x7F, 0x1F,
  0xE0, 0x1F, 0x8F, 0xE0, 0x07, 0xC7, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1,
  0xF0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x3F,
  0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xE0, 0x0F, 0xC1, 0xF0, 0x0F,
  0xC0, 0xFE, 0x0F, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x04, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0x83, 0xF8, 0x1F, 0x80, 0xFC,
  0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x83,
  0xF0, 0x07, 0xE7, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFE, 0xFE, 0x01, 0xFC, 0x3F, 0x81, 0xF8,
  0x0F, 0xC1, 0xF8, 0x03, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x7C,
  0x00, 0x3F, 0x3E, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0xCF, 0x80, 0x07, 0xC7,
  0xE0, 0x03, 0xE3, 0xF0, 0x03, 0xF0, 0xFE, 0x07, 0xF0, 0x7F, 0xFF, 0xF8,
  0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF,
  0xFC, 0x07, 0xF0, 0xFE, 0x0F, 0xC0, 0x7E, 0x0F, 0x80, 0x3F, 0x1F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E, 0x00,
  0x3F, 0x3F, 0x00, 0x7F, 0x3F, 0x80, 0xFF, 0x1F, 0xE3, 0xFE, 0x1F, 0xFF,
  0xFE, 0x0F, 0xFF, 0xBE, 0x07, 0xFF, 0x3E, 0x01, 0xF8, 0x7C, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0xC0, 0x3F,
  0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0,
  0x00, 0x06, 0x00, 0x00, 0x01, 0x80, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F,
  0x83, 0xF0, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x07,
  0xF0, 0xFE, 0x1F, 0xC3, 0xF0, 0x7E, 0x07, 0x00, 0x00, 0x18, 0x00, 0xFC,
  0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0x00, 0x00, 0x03, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0x80, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x07, 0xFE, 0x03, 0xFF, 0xE1, 0xFF, 0xFF, 0x3F, 0xFF, 0xE3, 0xE1, 0xFE,
  0x70, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00,
  0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x04,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x1F,
  0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x07, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xC0, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x3E,
  0x00, 0x00, 0x01, 0xF1, 0xF0, 0x03, 0xFC, 0x07, 0xC7, 0x80, 0x3F, 0xFE,
  0x0F, 0x3E, 0x03, 0xFF, 0xF8, 0x3C, 0xF0, 0x1F, 0xFF, 0xC0, 0xF7, 0xC0,
  0xFC, 0x0F, 0x03, 0xDE, 0x07, 0xC0, 0x7C, 0x0F, 0x78, 0x1E, 0x01, 0xE0,
  0x3F, 0xE0, 0xF8, 0x07, 0x80, 0xFF, 0x03, 0xC0, 0x1E, 0x03, 0xFC, 0x1F,
  0x00, 0xF8, 0x0F, 0xF0, 0x7C, 0x03, 0xC0, 0x3F, 0xC1, 0xE0, 0x0F, 0x01,
  0xFF, 0x07, 0x80, 0x7C, 0x07, 0xBC, 0x1E, 0x01, 0xF0, 0x3E, 0xF0, 0x78,
  0x0F, 0xC0, 0xF3, 0xC1, 0xF0, 0x3F, 0x07, 0xCF, 0x07, 0xC1, 0xFC, 0x3E,
  0x3C, 0x0F, 0xFE, 0xFF, 0xF0, 0xF0, 0x3F, 0xF1, 0xFF, 0x83, 0xE0, 0x7F,
  0x83, 0xFC, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3E, 0xF8,
  0x00, 0x01, 0xF3, 0xC0, 0x00, 0x1F, 0x1E, 0x00, 0x00, 0xF8, 0xF0, 0x00,
  0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x01, 0xF0, 0x1F,
  0x00, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x00,
  0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0x03,
  0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x7E, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07, 0xDF, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x01, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0x00, 0xFE, 0x03, 0xE0, 0x07, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3E,
  0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x3F, 0x01, 0xF0, 0x01, 0xF8, 0x1F,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xE0, 0x00,
  0xF8, 0x3E, 0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF8, 0x7C, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFE, 0xFF, 0x00, 0xFF, 0x00, 0x30, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x10, 0x03, 0xFE, 0x0F, 0x80, 0x1F, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xC0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0,
  0x7F, 0xC0, 0x3E, 0x00, 0x7F, 0x00, 0xF8, 0x00, 0xFE, 0x03, 0xE0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F,
  0x07, 0xC0, 0x00, 0xFC, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0xF8, 0x7C, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF0, 0xF8, 0x00, 0x1F, 0xC3, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0xC1, 0xF8, 0x01, 0xFE, 0x07, 0xC0, 0x1F, 0xF0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0xF7, 0xF8, 0x07, 0xF8, 0x00, 0xE0, 0x3F,
  0x80, 0x00, 0x81, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0xE7, 0xC0, 0x0F, 0xFF, 0x1F,
  0x00, 0x3F, 0xFC, 0xFC, 0x00, 0xFF, 0xF3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xE1, 0xF0, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF0, 0x7F, 0x00, 0x07,
  0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFC, 0x07, 0xFC, 0x0F, 0xE0,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xE0,
  0x1F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8,
  0x07, 0xC0, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0xF8, 0x07, 0xC0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xE0, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x7E, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0xF8, 0x07, 0xF0, 0x01, 0xF0, 0x1F, 0xC0, 0x03, 0xE0, 0x7F, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x3E, 0x1F, 0xC0, 0x00, 0x7C,
  0x3F, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x07, 0xCF,
  0xC0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01, 0xFE, 0xFC, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x0F, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC, 0x03,
  0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFE,
  0x00, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x1F, 0xF0,
  0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x0F, 0xF8, 0x00, 0x0F, 0x7C, 0x07, 0xBC,
  0x00, 0x0F, 0xFC, 0x03, 0xDF, 0x00, 0x07, 0xBE, 0x03, 0xEF, 0x80, 0x07,
  0xDF, 0x01, 0xF7, 0xC0, 0x07, 0xCF, 0x80, 0xFB, 0xE0, 0x03, 0xEF, 0x80,
  0x7C, 0xF0, 0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x01, 0xF3, 0xE0, 0x3E, 0x3C,
  0x01, 0xF1, 0xF0, 0x1F, 0x1E, 0x00, 0xF9, 0xF8, 0x0F, 0x8F, 0x00, 0xF8,
  0xF8, 0x07, 0xC7, 0x80, 0x78, 0x7C, 0x07, 0xC3, 0xE0, 0x7C, 0x3E, 0x03,
  0xE1, 0xF0, 0x3C, 0x1F, 0x01, 0xF0, 0xF8, 0x3E, 0x1F, 0x80, 0xF8, 0x7C,
  0x1E, 0x0F, 0x80, 0x7C, 0x1E, 0x1F, 0x07, 0xC0, 0x7C, 0x0F, 0x0F, 0x03,
  0xE0, 0x3E, 0x07, 0x8F, 0x81, 0xF0, 0x1F, 0x03, 0xCF, 0x81, 0xF8, 0x0F,
  0x81, 0xE7, 0xC0, 0xF8, 0x07, 0xC0, 0xF7, 0xC0, 0x7C, 0x07, 0xC0, 0x7F,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0xE0, 0x1F,
  0x80, 0xF8, 0x07, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xF0, 0x07, 0xC0, 0x7C,
  0x01, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x7C,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x01, 0xF0,
  0x1F, 0xC0, 0x00, 0x7C, 0x07, 0xF0, 0x00, 0x1F, 0x03, 0xFE, 0x00, 0x0F,
  0x80, 0xFF, 0x80, 0x03, 0xE0, 0x3F, 0xE0, 0x00, 0xF8, 0x0F, 0x7C, 0x00,
  0x3E, 0x03, 0xDF, 0x00, 0x0F, 0x81, 0xF7, 0xE0, 0x07, 0xC0, 0x7C, 0xF8,
  0x01, 0xF0, 0x1F, 0x3E, 0x00, 0x7C, 0x07, 0xCF, 0xC0, 0x1F, 0x01, 0xE1,
  0xF0, 0x0F, 0xC0, 0xF8, 0x7C, 0x03, 0xE0, 0x3E, 0x0F, 0x80, 0xF8, 0x0F,
  0x83, 0xE0, 0x3E, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x1F, 0x07, 0xE0,
  0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x3E, 0x1F,
  0x01, 0xF0, 0x0F, 0x87, 0xC0, 0xF8, 0x03, 0xF3, 0xE0, 0x3E, 0x00, 0x7C,
  0xF8, 0x0F, 0x80, 0x1F, 0x3E, 0x03, 0xE0, 0x07, 0xEF, 0x80, 0xF8, 0x00,
  0xFB, 0xE0, 0x7C, 0x00, 0x3E, 0xF0, 0x1F, 0x00, 0x07, 0xFC, 0x07, 0xC0,
  0x01, 0xFF, 0x01, 0xF0, 0x00, 0x7F, 0xC0, 0x7C, 0x00, 0x0F, 0xF0, 0x3E,
  0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0x9F, 0xF8, 0x03, 0xFC, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E,
  0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC,
  0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC0, 0x0F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x06, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x07,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07, 0xE0, 0x3F,
  0x80, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07, 0xE0, 0xFC,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x7E,
  0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80,
  0x3F, 0x81, 0xF0, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF,
  0xDF, 0xF8, 0x03, 0xFC, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3E, 0x1F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7C, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0xFC, 0x7C, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00,
  0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xF0,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x07,
  0xE0, 0x3F, 0x80, 0xF8, 0x03, 0xF0, 0x1F, 0x00, 0x3F, 0x03, 0xE0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0xFC,
  0x0F, 0x80, 0x7F, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xC0, 0xF8, 0x01,
  0xF8, 0x1F, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0x80, 0xFC, 0x01, 0xF8, 0x1F,
  0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xC3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x3F, 0xF7, 0xF0,
  0x3F, 0x80, 0x38, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC3, 0x00, 0x0F, 0xE1, 0xF0, 0x1F, 0xE0,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xE7, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xF8, 0x1F, 0x00, 0x01,
  0xF0, 0x7E, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x1F,
  0x03, 0xE0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0x7C, 0x1F, 0x80, 0x01, 0xF8,
  0x3E, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83,
  0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x1F,
  0x00, 0x01, 0xF0, 0x3E, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0,
  0x00, 0x1F, 0x83, 0xE0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0x80,
  0x00, 0xF8, 0x3F, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xC0, 0x00,
  0xFC, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x3F,
  0x80, 0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF,
  0x80, 0x00, 0xFC, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x01, 0xF8, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0,
  0x7C, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xF8, 0x07, 0xC0,
  0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xE0,
  0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xC0, 0xFC, 0x00, 0x3E,
  0x0F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xF0,
  0x00, 0x3E, 0x3E, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07,
  0xFF, 0x00, 0x07, 0xE0, 0x00, 0xFB, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x7C,
  0x00, 0x3F, 0x80, 0x07, 0xCF, 0x80, 0x07, 0xF0, 0x01, 0xF9, 0xF0, 0x01,
  0xFE, 0x00, 0x3E, 0x3E, 0x00, 0x3F, 0xC0, 0x07, 0xC7, 0xC0, 0x0F, 0xF8,
  0x01, 0xF8, 0xF8, 0x01, 0xEF, 0x00, 0x3E, 0x1F, 0x00, 0x3D, 0xE0, 0x0F,
  0xC3, 0xF0, 0x0F, 0xBC, 0x01, 0xF0, 0x3E, 0x01, 0xE7, 0x80, 0x7E, 0x07,
  0xC0, 0x7C, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x1F, 0x01, 0xF0, 0x1F, 0x03,
  0xE3, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x7C, 0x0F, 0x80, 0x7C, 0x1F, 0x0F,
  0x83, 0xF0, 0x0F, 0x83, 0xE1, 0xF0, 0x7C, 0x01, 0xF0, 0xF8, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x07, 0xC3, 0xE0, 0x07, 0xC7, 0xC0, 0xF8, 0x7C, 0x00,
  0xF8, 0xF8, 0x1F, 0x1F, 0x00, 0x1F, 0x1E, 0x03, 0xE3, 0xE0, 0x03, 0xE7,
  0xC0, 0x3C, 0xF8, 0x00, 0x7C, 0xF0, 0x07, 0x9F, 0x00, 0x0F, 0xBE, 0x00,
  0xF3, 0xC0, 0x01, 0xF7, 0xC0, 0x1E, 0xF8, 0x00, 0x3E, 0xF0, 0x03, 0xDF,
  0x00, 0x07, 0xFE, 0x00, 0x7B, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x0F, 0xE0, 0x0F, 0x80, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x1F, 0x80, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x01, 0xF0, 0x7C, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x01, 0xF9, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x03, 0xF0, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF8, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x7E, 0x00, 0xFC,
  0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0x3E, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC1, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1,
  0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3E, 0x0F, 0x83, 0xE0, 0xF8, 0x1E,
  0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x00, 0x3F,
  0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x03, 0xDE, 0x00, 0x01, 0xEF,
  0x80, 0x01, 0xE3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0xF8,
  0x3E, 0x00, 0x78, 0x0F, 0x00, 0x7C, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x3E,
  0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x8F,
  0x80, 0x03, 0xC7, 0x80, 0x01, 0xF7, 0xC0, 0x00, 0x7B, 0xC0, 0x00, 0x3E,
  0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0xFC,
  0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x00, 0x7F, 0x83, 0xC0,
  0x7F, 0xF1, 0xF0, 0x3F, 0xFE, 0x78, 0x1F, 0xFF, 0xFE, 0x0F, 0xF0, 0xFF,
  0x83, 0xF0, 0x1F, 0xE1, 0xF8, 0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xE3, 0xF0, 0x01, 0xF8,
  0xFC, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07,
  0xF0, 0xFC, 0x03, 0xFC, 0x1F, 0x01, 0xFE, 0x07, 0xE0, 0xF7, 0x81, 0xFF,
  0xFB, 0xE0, 0x3F, 0xFC, 0xF8, 0x07, 0xFE, 0x3E, 0x00, 0xFF, 0x0F, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x87, 0xF0, 0x03, 0xE7, 0xFE, 0x01, 0xFB, 0xFF,
  0xC0, 0x7D, 0xFF, 0xF8, 0x1F, 0xF0, 0x7E, 0x07, 0xF8, 0x0F, 0x81, 0xFC,
  0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xC3,
  0xE0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0x3F, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0x7F,
  0x80, 0xFE, 0x1F, 0xF0, 0x7F, 0x07, 0xFF, 0xFF, 0x81, 0xE7, 0xFF, 0xC0,
  0x78, 0xFF, 0xE0, 0x3C, 0x1F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F,
  0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F, 0xF0, 0x30,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x01, 0x07, 0xF0,
  0x1C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F, 0xF0,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x07, 0xF8, 0x7C, 0x01, 0xFF, 0xCF,
  0xC0, 0x3F, 0xFE, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xF8, 0x0F,
  0xC0, 0x7F, 0x81, 0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF0, 0x03,
  0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00,
  0x7E, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x0F, 0xC0,
  0xFC, 0x01, 0xFC, 0x0F, 0xC0, 0x3F, 0xC0, 0x7C, 0x07, 0xF8, 0x07, 0xE0,
  0xFF, 0x80, 0x7F, 0xFE, 0xF8, 0x03, 0xFF, 0xCF, 0x80, 0x1F, 0xF8, 0xF0,
  0x00, 0xFF, 0x0F, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03,
  0xFF, 0xE0, 0x3F, 0xFF, 0x81, 0xFF, 0xFF, 0x0F, 0xE0, 0xFC, 0x3F, 0x01,
  0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x03, 0xF7,
  0xE0, 0x3F, 0x9F, 0x8F, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x0F, 0xFF,
  0xE0, 0x3F, 0xE0, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x87, 0xF0, 0x0E, 0x0F,
  0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0x08,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xC1, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x67, 0xF0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x3F, 0xC1, 0xE0, 0x1F, 0xFC, 0x7C, 0x07, 0xFF,
  0xCF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0x87, 0xFC, 0x0F, 0xC0, 0x7F, 0x83,
  0xF0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0x7C,
  0x00, 0x3E, 0x0F, 0x80, 0x07, 0xC3, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3E,
  0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x7F, 0x07, 0xE0,
  0x1F, 0xE0, 0x7C, 0x07, 0xF8, 0x0F, 0xC1, 0xFF, 0x01, 0xFF, 0xFB, 0xE0,
  0x1F, 0xFE, 0x7C, 0x01, 0xFF, 0x9F, 0x00, 0x1F, 0xE3, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x18, 0x00, 0xFC, 0x03, 0xF0, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x87, 0xF8, 0x03, 0xE7, 0xFF, 0x01, 0xFB, 0xFF,
  0xE0, 0x7D, 0xFF, 0xF8, 0x1F, 0xF8, 0x7E, 0x07, 0xF8, 0x0F, 0xC1, 0xFC,
  0x03, 0xF0, 0xFE, 0x00, 0xFC, 0x3F, 0x80, 0x3E, 0x0F, 0xC0, 0x0F, 0x83,
  0xF0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x00, 0x1F,
  0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x7E,
  0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC1, 0xF0, 0x01, 0xF0,
  0x7C, 0x00, 0x7C, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x8F, 0xC0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0,
  0x1F, 0x80, 0x3E, 0x07, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0x3F, 0x1F, 0x80, 0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x7E,
  0x00, 0x07, 0xDF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03,
  0xFF, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x81, 0xF8, 0x01, 0xF0, 0x3F, 0x00, 0x7E,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3E, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0,
  0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8,
  0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x7C,
  0x03, 0xF0, 0x00, 0x03, 0xC1, 0xFC, 0x03, 0xFC, 0x03, 0xC7, 0xFE, 0x0F,
  0xFE, 0x07, 0xCF, 0xFF, 0x1F, 0xFF, 0x07, 0xDF, 0xFF, 0x3F, 0xFF, 0x07,
  0xFC, 0x1F, 0x7C, 0x3F, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0x07, 0xF0, 0x0F,
  0xE0, 0x1F, 0x0F, 0xE0, 0x0F, 0xE0, 0x1F, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F,
  0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x1F, 0x00, 0x1F, 0x00,
  0x3E, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x00, 0x7E, 0x3E, 0x00, 0x3E,
  0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x00, 0x7C,
  0x7E, 0x00, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0x7C, 0x00, 0xFC, 0x7C, 0x00,
  0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x00,
  0xF8, 0xFC, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x00, 0x20, 0x00, 0xF0, 0x7F,
  0x80, 0x3C, 0x7F, 0xF0, 0x1F, 0x3F, 0xFE, 0x07, 0xDF, 0xFF, 0x81, 0xFF,
  0x87, 0xF0, 0x7F, 0x80, 0xFC, 0x3F, 0xC0, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3,
  0xF8, 0x03, 0xF0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00,
  0x1F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x07, 0xE1, 0xF8, 0x01, 0xF8,
  0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x03,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x07, 0xFF,
  0xFC, 0x0F, 0xF0, 0xFE, 0x0F, 0xC0, 0x3E, 0x1F, 0x80, 0x3F, 0x3F, 0x00,
  0x3F, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7E, 0x7C, 0x00,
  0xFC, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF8, 0x3F, 0x07, 0xF0, 0x3F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0xF0,
  0x7F, 0x00, 0x0F, 0x1F, 0xF8, 0x01, 0xF3, 0xFF, 0xC0, 0x1F, 0x7F, 0xFE,
  0x01, 0xFF, 0x07, 0xE0, 0x1F, 0xE0, 0x3E, 0x01, 0xFC, 0x03, 0xF0, 0x3F,
  0x80, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x07, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x81,
  0xFE, 0x03, 0xF8, 0x1F, 0xF0, 0x7F, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x7F,
  0xFC, 0x01, 0xF3, 0xFF, 0x80, 0x3F, 0x1F, 0xE0, 0x03, 0xE0, 0x20, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x83, 0xC0, 0x7F, 0xF1, 0xF0, 0x3F, 0xFE,
  0x78, 0x1F, 0xFF, 0xDE, 0x0F, 0xF0, 0xFF, 0x83, 0xF0, 0x1F, 0xE1, 0xF8,
  0x03, 0xF8, 0x7E, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7,
  0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x3E, 0x1F, 0x00, 0x0F,
  0x87, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x3F, 0x00,
  0x3F, 0x0F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x03, 0xFC, 0x1F,
  0x01, 0xFE, 0x07, 0xE0, 0xFF, 0x81, 0xFF, 0xFB, 0xE0, 0x3F, 0xFC, 0xF8,
  0x07, 0xFE, 0x7C, 0x00, 0xFF, 0x1F, 0x00, 0x04, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xC3,
  0xF8, 0x1E, 0x3F, 0xC1, 0xF3, 0xFC, 0x0F, 0xBF, 0xE0, 0x7F, 0xFB, 0x03,
  0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF, 0xE0, 0xFC, 0x07, 0x07, 0xC0,
  0x08, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x80, 0x03, 0xFE,
  0x00, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7E, 0x40, 0x03, 0xE3, 0x80, 0x3F, 0x1F, 0xFF, 0xF8,
  0xFF, 0xFF, 0x87, 0xFF, 0xF8, 0x0F, 0xFF, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x70, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0x7F, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x83, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0,
  0x83, 0xFF, 0x81, 0xFF, 0xC0, 0x7F, 0xE0, 0x1F, 0xF0, 0x00, 0x80, 0x00,
  0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xE0, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00,
  0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0x8F, 0xC0,
  0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8,
  0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F,
  0x00, 0x7F, 0x0F, 0x80, 0x7F, 0x87, 0xC0, 0x7F, 0x83, 0xF0, 0x7B, 0xC1,
  0xFF, 0xFB, 0xE0, 0x7F, 0xF9, 0xF0, 0x3F, 0xF8, 0xF8, 0x07, 0xF8, 0x78,
  0x00, 0x40, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x1F, 0x9F, 0x00,
  0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0,
  0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x7C, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x0F,
  0x81, 0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x7C, 0x00,
  0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x00,
  0x07, 0x9F, 0x80, 0x03, 0xCF, 0x80, 0x01, 0xE7, 0xC0, 0x00, 0xF7, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x3F,
  0x80, 0x3F, 0xF8, 0x03, 0xF8, 0x03, 0xEF, 0x80, 0x7F, 0x80, 0x7E, 0xF8,
  0x07, 0xF8, 0x07, 0xCF, 0x80, 0xFF, 0x80, 0xFC, 0xF8, 0x0F, 0x78, 0x0F,
  0x8F, 0x80, 0xF7, 0x81, 0xF8, 0xF8, 0x1E, 0x78, 0x1F, 0x0F, 0x81, 0xE7,
  0x81, 0xF0, 0xF8, 0x3E, 0x78, 0x3E, 0x0F, 0x83, 0xC7, 0x83, 0xE0, 0xF8,
  0x7C, 0x78, 0x7C, 0x0F, 0x87, 0x87, 0x87, 0xC0, 0x78, 0xF8, 0x78, 0xF8,
  0x07, 0x8F, 0x07, 0x8F, 0x80, 0x79, 0xF0, 0x78, 0xF8, 0x07, 0x9E, 0x07,
  0x9F, 0x00, 0x79, 0xE0, 0x79, 0xF0, 0x07, 0xBC, 0x07, 0xBE, 0x00, 0x7B,
  0xC0, 0x7B, 0xE0, 0x07, 0xBC, 0x07, 0xBC, 0x00, 0x7F, 0x80, 0x7F, 0xC0,
  0x07, 0xF8, 0x07, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0x81,
  0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x7E, 0x1F, 0x80, 0x03,
  0xE0, 0x7C, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00,
  0x7C, 0x03, 0xF0, 0x03, 0xF0, 0x3F, 0x80, 0x0F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x07, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x0F,
  0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00,
  0x1F, 0x07, 0xC0, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00,
  0x7C, 0xFC, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x02, 0x3F, 0xC0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03,
  0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x01, 0xFF,
  0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x03,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0x00, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xE0,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0xFF,
  0x80, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0, 0x01,
  0x7F, 0xF8, 0x03, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFC, 0x80, 0x01, 0xF0,
};

const GFXglyph NotoSans_MediumItalic50pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 37, 13, 1, -36 },
  { 62, 16, 13, 21, 5, -36 },
  { 88, 32, 36, 32, 1, -36 },
  { 232, 25, 41, 28, 2, -38 },
  { 361, 35, 37, 41, 4, -36 },
  { 523, 31, 37, 34, 2, -36 },
  { 667, 7, 13, 12, 5, -36 },
  { 679, 17, 44, 15, 2, -36 },
  { 773, 17, 44, 15, -4, -36 },
  { 867, 23, 23, 27, 5, -38 },
  { 934, 24, 24, 29, 3, -30 },
  { 1006, 10, 12, 13, -2, -6 },
  { 1021, 13, 5, 16, 1, -16 },
  { 1030, 7, 8, 13, 1, -7 },
  { 1037, 25, 36, 19, -2, -36 },
  { 1150, 25, 37, 28, 2, -36 },
  { 1266, 17, 36, 28, 6, -36 },
  { 1343, 27, 36, 28, 0, -36 },
  { 1465, 25, 37, 28, 1, -36 },
  { 1581, 27, 36, 28, 0, -36 },
  { 1703, 26, 37, 28, 1, -36 },
  { 1824, 25, 37, 28, 3, -36 },
  { 1940, 26, 36, 28, 3, -36 },
  { 2057, 25, 37, 28, 2, -36 },
  { 2173, 24, 37, 28, 2, -36 },
  { 2284, 11, 29, 13, 1, -28 },
  { 2324, 15, 34, 13, -3, -28 },
  { 2388, 24, 25, 29, 3, -31 },
  { 2463, 24, 14, 29, 3, -25 },
  { 2505, 24, 25, 29, 3, -31 },
  { 2580, 19, 37, 22, 4, -36 },
  { 2668, 38, 41, 43, 3, -36 },
  { 2863, 29, 36, 29, -3, -36 },
  { 2994, 28, 36, 30, 2, -36 },
  { 3120, 29, 37, 30, 3, -36 },
  { 3255, 30, 36, 34, 2, -36 },
  { 3390, 26, 36, 26, 2, -36 },
  { 3507, 26, 36, 25, 2, -36 },
  { 3624, 30, 37, 34, 3, -36 },
  { 3763, 33, 36, 34, 2, -36 },
  { 3912, 21, 36, 17, -1, -36 },
  { 4007, 23, 46, 15, -8, -36 },
  { 4140, 31, 36, 29, 2, -36 },
  { 4280, 19, 36, 25, 2, -36 },
  { 4366, 41, 36, 43, 2, -36 },
  { 4551, 34, 36, 36, 2, -36 },
  { 4704, 32, 37, 36, 3, -36 },
  { 4852, 27, 36, 29, 2, -36 },
  { 4974, 32, 45, 36, 3, -36 },
  { 5154, 27, 36, 29, 2, -36 },
  { 5276, 25, 37, 26, 1, -36 },
  { 5392, 26, 36, 26, 4, -36 },
  { 5509, 31, 37, 34, 4, -36 },
  { 5653, 28, 36, 28, 5, -36 },
  { 5779, 43, 36, 43, 5, -36 },
  { 5973, 35, 36, 28, -3, -36 },
  { 6131, 26, 36, 26, 5, -36 },
  { 6248, 30, 36, 27, -1, -36 },
  { 6383, 20, 44, 15, -1, -36 },
  { 6493, 10, 36, 19, 5, -36 },
  { 6538, 20, 44, 15, -4, -36 },
  { 6648, 25, 23, 28, 2, -36 },
  { 6720, 21, 4, 20, -5, 4 },
  { 6731, 9, 8, 15, 7, -38 },
  { 6740, 26, 28, 29, 2, -27 },
  { 6831, 26, 39, 29, 1, -38 },
  { 6958, 22, 28, 23, 2, -27 },
  { 7035, 28, 39, 29, 2, -38 },
  { 7172, 22, 28, 26, 2, -27 },
  { 7249, 29, 50, 17, -6, -38 },
  { 7431, 27, 39, 29, 1, -27 },
  { 7563, 26, 38, 29, 1, -38 },
  { 7687, 13, 37, 14, 1, -37 },
  { 7748, 20, 49, 14, -6, -37 },
  { 7871, 27, 38, 26, 1, -38 },
  { 8000, 14, 38, 14, 1, -38 },
  { 8067, 40, 27, 44, 1, -27 },
  { 8202, 26, 28, 29, 1, -28 },
  { 8293, 24, 27, 28, 2, -27 },
  { 8374, 28, 39, 29, -1, -27 },
  { 8511, 26, 39, 29, 2, -27 },
  { 8638, 21, 27, 20, 1, -27 },
  { 8709, 21, 28, 22, 0, -27 },
  { 8783, 17, 34, 18, 2, -33 },
  { 8856, 25, 28, 29, 3, -27 },
  { 8944, 25, 27, 24, 2, -27 },
  { 9029, 36, 27, 37, 3, -27 },
  { 9151, 29, 27, 25, -2, -27 },
  { 9249, 31, 39, 24, -4, -27 },
  { 9401, 24, 27, 23, -1, -27 },
  { 9482, 20, 44, 18, 0, -36 },
  { 9592, 5, 50, 28, 12, -38 },
  { 9624, 19, 44, 18, -2, -36 },
  { 9729, 24, 7, 29, 3, -21 },
};

const GFXfont NotoSans_MediumItalic50pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic50pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic50pt7bGlyphs,
  0x20, 0x7E, 68
};

#endif // _NOTOSANS_MEDIUMITALIC50PT7B_H_
