#ifndef _NOTOSANS_MEDIUMITALIC40PT7B_H_
#define _NOTOSANS_MEDIUMITALIC40PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 40pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic40pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C,
  0x07, 0x80, 0xF0, 0x1E, 0x03, 0x80, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x40, 0x00, 0x3C, 0x7B, 0xE3, 0xDE, 0x3E,
  0xF1, 0xE7, 0x8F, 0x38, 0x79, 0xC3, 0x8E, 0x1C, 0x70, 0xE7, 0x07, 0x38,
  0x70, 0x00, 0x1C, 0x1C, 0x00, 0x0E, 0x0E, 0x00, 0x0F, 0x07, 0x00, 0x07,
  0x07, 0x80, 0x03, 0x83, 0x80, 0x03, 0xC1, 0xC0, 0x01, 0xC0, 0xE0, 0x00,
  0xE0, 0xF0, 0x00, 0x70, 0x70, 0x0F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xF0, 0x1E, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00,
  0x03, 0x83, 0x80, 0x03, 0x81, 0xC0, 0x01, 0xC1, 0xE0, 0x3F, 0xFF, 0xFF,
  0x9F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE0, 0x38, 0x38, 0x00, 0x3C, 0x1C,
  0x00, 0x1C, 0x0E, 0x00, 0x0E, 0x0F, 0x00, 0x07, 0x07, 0x00, 0x07, 0x83,
  0x80, 0x03, 0x83, 0xC0, 0x01, 0xC1, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00,
  0xE0, 0x00, 0x0E, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0xF0, 0x7F, 0xFF, 0x07,
  0xFD, 0xE0, 0xF9, 0xC2, 0x0F, 0x1C, 0x00, 0xF1, 0x80, 0x0F, 0x38, 0x00,
  0xF3, 0x80, 0x0F, 0xB8, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xE0,
  0x00, 0xFF, 0x80, 0x07, 0xF8, 0x00, 0x67, 0xC0, 0x06, 0x3C, 0x00, 0xE3,
  0xC0, 0x0E, 0x3C, 0x00, 0xE3, 0xCC, 0x0C, 0x78, 0xF9, 0xDF, 0x8F, 0xFF,
  0xF0, 0xFF, 0xFE, 0x01, 0xFF, 0x00, 0x01, 0x80, 0x00, 0x38, 0x00, 0x03,
  0x80, 0x00, 0x38, 0x00, 0x07, 0xC0, 0x01, 0xC0, 0xFE, 0x00, 0x3C, 0x1F,
  0xF0, 0x07, 0x83, 0xC7, 0x00, 0xF0, 0x78, 0x78, 0x0E, 0x07, 0x87, 0x81,
  0xE0, 0x70, 0x78, 0x3C, 0x0F, 0x07, 0x87, 0x80, 0xF0, 0x70, 0x70, 0x0F,
  0x07, 0x0F, 0x00, 0xE0, 0x71, 0xE0, 0x0E, 0x0F, 0x3C, 0x30, 0xE0, 0xE3,
  0x9F, 0xCF, 0x1E, 0x7B, 0xFE, 0xF3, 0xCF, 0x3F, 0xF7, 0xFC, 0xE7, 0x8F,
  0x7F, 0x9C, 0xF0, 0xF1, 0xE3, 0xCF, 0x0F, 0x00, 0x78, 0xE0, 0xF0, 0x07,
  0x0E, 0x0F, 0x00, 0xE1, 0xE0, 0xF0, 0x1E, 0x1E, 0x0E, 0x03, 0xC1, 0xE0,
  0xE0, 0x38, 0x1E, 0x1E, 0x07, 0x01, 0xE1, 0xC0, 0xF0, 0x1E, 0x3C, 0x1E,
  0x00, 0xFF, 0x81, 0xC0, 0x0F, 0xF8, 0x3C, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x3E,
  0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xE0, 0x03,
  0xC1, 0xF0, 0x01, 0xE1, 0xF0, 0x00, 0xF9, 0xF0, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xF8, 0x0F,
  0x1F, 0x3E, 0x07, 0x9F, 0x0F, 0x07, 0x9F, 0x07, 0xC7, 0xCF, 0x01, 0xF3,
  0xCF, 0x80, 0x7B, 0xC7, 0xC0, 0x3F, 0xE3, 0xE0, 0x0F, 0xE1, 0xF0, 0x03,
  0xE0, 0x78, 0x07, 0xF0, 0x3F, 0x0F, 0xFC, 0x1F, 0xFF, 0xDF, 0x07, 0xFF,
  0xC7, 0xC0, 0xFF, 0x83, 0xF0, 0x3D, 0xF7, 0x9E, 0x79, 0xC7, 0x1C, 0x73,
  0x8E, 0x00, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x1E, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x78, 0x07, 0xC0, 0x3C,
  0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x70, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x07, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0xE0, 0x0F, 0x80,
  0x00, 0x00, 0x40, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x07,
  0x00, 0xC1, 0xE0, 0x3E, 0x38, 0x07, 0xF7, 0x00, 0x7F, 0xFF, 0xE0, 0xFF,
  0xF8, 0x0F, 0xFF, 0x03, 0xF0, 0x60, 0xF7, 0x00, 0x3C, 0xE0, 0x0F, 0x9E,
  0x03, 0xE1, 0xC0, 0x38, 0x3C, 0x02, 0x07, 0x80, 0x00, 0xE0, 0x00, 0x01,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F,
  0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78, 0x78, 0x00, 0x7F,
  0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x3F, 0xF0, 0x0F, 0xFF, 0x03, 0xFF, 0xE0, 0xF8, 0x3E, 0x3E, 0x03, 0xC7,
  0xC0, 0x79, 0xF0, 0x0F, 0x3E, 0x01, 0xE7, 0x80, 0x3D, 0xF0, 0x07, 0xBC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x01, 0xEF, 0x00, 0x7D, 0xE0,
  0x0F, 0x3C, 0x03, 0xE7, 0xC0, 0x78, 0x78, 0x1F, 0x0F, 0x8F, 0xC0, 0xFF,
  0xF0, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFE, 0x0F,
  0xF1, 0xFF, 0x1F, 0xFB, 0xFB, 0xCF, 0x1E, 0x71, 0xF1, 0x0F, 0x00, 0x78,
  0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01,
  0xE0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x00,
  0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x3C, 0x0F, 0x81, 0x80, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xFF, 0xFF, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x8F, 0xFF, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFC, 0x07, 0xFF, 0xE0, 0xFF, 0xFF, 0x07, 0x01, 0xF0,
  0x40, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x3F, 0xF0, 0x03, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x80,
  0x0F, 0x8F, 0x03, 0xF8, 0xFF, 0xFF, 0x0F, 0xFF, 0xE0, 0x7F, 0xF8, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00,
  0x7F, 0x00, 0x07, 0xF8, 0x00, 0x7B, 0xC0, 0x03, 0xDE, 0x00, 0x3C, 0xE0,
  0x03, 0xCF, 0x00, 0x3C, 0x78, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x03, 0xE1,
  0xE0, 0x1E, 0x0F, 0x01, 0xE0, 0x78, 0x1E, 0x03, 0xC1, 0xE0, 0x3E, 0x1E,
  0x01, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0xF0,
  0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x80, 0x0F, 0x87, 0x81,
  0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xF8, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x07, 0xFF, 0x00, 0xFF, 0xF0, 0x1F, 0xFE, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC7, 0xE0, 0x7D, 0xFF, 0x07, 0xBF, 0xF8, 0x7F, 0x8F, 0xC7,
  0xE0, 0x7C, 0x7C, 0x03, 0xCF, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C,
  0xF0, 0x03, 0xCF, 0x00, 0x7C, 0xF8, 0x07, 0x87, 0x80, 0x78, 0x78, 0x0F,
  0x87, 0xE3, 0xF0, 0x3F, 0xFE, 0x01, 0xFF, 0xC0, 0x0F, 0xF0, 0x00, 0x3F,
  0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xE7, 0xFF, 0xFE, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x7E, 0x7E, 0x0F, 0x81,
  0xF0, 0xF0, 0x1F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xF0, 0xF0,
  0x1E, 0x0F, 0x83, 0xC0, 0x7C, 0xFC, 0x03, 0xFF, 0x00, 0x1F, 0xE0, 0x07,
  0xFC, 0x01, 0xFF, 0xE0, 0x3F, 0x1F, 0x07, 0xC0, 0xF8, 0xF8, 0x07, 0x8F,
  0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0xCF, 0x00, 0x78,
  0xF8, 0x0F, 0x8F, 0xC1, 0xF8, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFE, 0x07, 0xFF, 0xE1, 0xF0,
  0x7C, 0x7C, 0x07, 0xCF, 0x00, 0xF9, 0xE0, 0x0F, 0x7C, 0x01, 0xEF, 0x00,
  0x3D, 0xE0, 0x07, 0xBC, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x0F, 0xCF, 0x83,
  0xF1, 0xFF, 0xFE, 0x1F, 0xFB, 0xC1, 0xFE, 0x78, 0x04, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7E,
  0x18, 0x3F, 0x83, 0xFF, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x00, 0x0F, 0x0F,
  0x87, 0xE3, 0xE1, 0xF0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x3E, 0x1F, 0x0F, 0x87, 0x81, 0x00,
  0x01, 0xE0, 0x3E, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x18, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x03, 0x80,
  0x78, 0x07, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0C, 0x00, 0x07,
  0x80, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0xC0, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0x80, 0x00, 0x70, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x18, 0x00,
  0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x08, 0x00, 0x00, 0x07, 0xF0,
  0x3F, 0xF8, 0x7F, 0xFC, 0x7F, 0xFE, 0x30, 0x1E, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xFC,
  0xFF, 0x80, 0x1F, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x0F, 0x01, 0xE0, 0x00,
  0x0F, 0x07, 0x80, 0x00, 0x0E, 0x1E, 0x01, 0xF0, 0x1E, 0x38, 0x0F, 0xFC,
  0x3C, 0xF0, 0x7F, 0xF8, 0x39, 0xC1, 0xF0, 0xF0, 0x77, 0x83, 0xC1, 0xE0,
  0xEE, 0x0F, 0x03, 0x81, 0xDC, 0x3C, 0x07, 0x03, 0xF8, 0x78, 0x1E, 0x07,
  0xF0, 0xE0, 0x3C, 0x1F, 0xC1, 0xC0, 0x70, 0x3B, 0x83, 0x81, 0xE0, 0x77,
  0x07, 0x03, 0xC1, 0xEF, 0x0E, 0x0F, 0x87, 0x9E, 0x1E, 0x3F, 0x1E, 0x3C,
  0x3F, 0xEF, 0xFC, 0x38, 0x3F, 0x8F, 0xE0, 0x78, 0x3E, 0x0F, 0x80, 0xF0,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x40, 0x01, 0xFF, 0x3F, 0x80, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xEE, 0x00,
  0x03, 0xDE, 0x00, 0x0F, 0x3C, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x00,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x0F, 0x00, 0x7C,
  0x1E, 0x00, 0xF0, 0x1E, 0x03, 0xE0, 0x3C, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xF0, 0x3F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x0F,
  0x0F, 0x00, 0x1F, 0x3E, 0x00, 0x3E, 0x78, 0x00, 0x3D, 0xF0, 0x00, 0x7F,
  0xC0, 0x00, 0xFF, 0x80, 0x01, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xE0,
  0x0F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x3C, 0x0F, 0xC0, 0xF8, 0x07, 0xC1,
  0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x3E,
  0x01, 0xF0, 0x78, 0x07, 0xC0, 0xFF, 0xFF, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xE0, 0x0F, 0xFF, 0xF0, 0x1E, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x78, 0x03,
  0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x0F, 0x00, 0x3E,
  0x1E, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x03,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0xFC,
  0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7E, 0x01, 0x81, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x40, 0x7F, 0x1F, 0x00, 0xFF, 0xFE, 0x00,
  0x7F, 0xFC, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFF, 0xF0,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x3C, 0x0F, 0xE0, 0x3E, 0x01,
  0xF0, 0x1F, 0x00, 0x7C, 0x0F, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0x83, 0xE0, 0x03, 0xE1, 0xE0, 0x01, 0xF0, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1E, 0x00, 0x1F, 0x0F,
  0x00, 0x0F, 0x87, 0x80, 0x07, 0xC7, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE1,
  0xE0, 0x03, 0xE0, 0xF0, 0x03, 0xF0, 0x78, 0x03, 0xF0, 0x7C, 0x07, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x3F, 0xFF, 0x03, 0xFF, 0xF8,
  0x1F, 0xFF, 0x80, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x7F, 0xFF, 0x01, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x07,
  0xF0, 0x0E, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x0F, 0xFC, 0xF0, 0x0F, 0xFC, 0xF0,
  0x0F, 0xFC, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0, 0x00, 0x78, 0xF0,
  0x00, 0x78, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0xF0, 0x7E,
  0x00, 0xF0, 0x3F, 0x87, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x07,
  0xFF, 0x80, 0x03, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x78, 0x0F, 0x00, 0x0F,
  0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x01, 0xE0, 0x3C, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xF0, 0x01, 0xF0,
  0x3E, 0x00, 0x3C, 0x07, 0x80, 0x07, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x1E, 0x00, 0x1E, 0x03,
  0xC0, 0x03, 0xC0, 0x78, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xC0, 0x78, 0x00, 0x78, 0x0F, 0x00, 0x0F, 0x01, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x3C, 0x00, 0x3C,
  0x0F, 0x80, 0x0F, 0x80, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0xFF, 0xC0, 0x3F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x1F,
  0xF8, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0xF0, 0x0F, 0xF8,
  0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x03,
  0xE0, 0x3C, 0x01, 0xF0, 0x0F, 0x00, 0xF8, 0x03, 0xC0, 0x7C, 0x01, 0xF0,
  0x3E, 0x00, 0x78, 0x1F, 0x00, 0x1E, 0x0F, 0x80, 0x07, 0x87, 0xC0, 0x01,
  0xE3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0x3C, 0xF8, 0x00, 0x0F, 0x7C, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xBE,
  0x00, 0x07, 0xC7, 0x80, 0x01, 0xE1, 0xF0, 0x00, 0xF8, 0x3C, 0x00, 0x3E,
  0x0F, 0x00, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0x78, 0x00, 0xF0, 0x1F, 0x00,
  0x7C, 0x07, 0xC0, 0x1E, 0x00, 0xF8, 0x07, 0x80, 0x3E, 0x01, 0xE0, 0x07,
  0x80, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xF0,
  0x3F, 0xC0, 0x07, 0xF8, 0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0x70, 0x03, 0xDE,
  0x07, 0xB8, 0x01, 0xCF, 0x03, 0x9C, 0x01, 0xEF, 0x03, 0xCE, 0x00, 0xE7,
  0x81, 0xE7, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x71, 0xE0, 0x79, 0xE0, 0x79,
  0xF0, 0x78, 0xF0, 0x78, 0xF0, 0x3C, 0x78, 0x3C, 0x78, 0x1E, 0x1C, 0x3C,
  0x3C, 0x0F, 0x0E, 0x1E, 0x1E, 0x07, 0x87, 0x1E, 0x1E, 0x07, 0x83, 0x8F,
  0x0F, 0x03, 0xC1, 0xCF, 0x07, 0x81, 0xE0, 0xF7, 0x03, 0xC0, 0xF0, 0x7F,
  0x83, 0xE0, 0x78, 0x3F, 0x81, 0xE0, 0x78, 0x1F, 0xC0, 0xF0, 0x3C, 0x0F,
  0xC0, 0x78, 0x1E, 0x03, 0xE0, 0x3C, 0x0F, 0x01, 0xE0, 0x3E, 0x0F, 0x80,
  0xF0, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0x03, 0xF0,
  0x00, 0xF0, 0x3F, 0x00, 0x1E, 0x03, 0xF8, 0x01, 0xE0, 0x7F, 0x80, 0x1E,
  0x07, 0xF8, 0x01, 0xE0, 0x7B, 0xC0, 0x1E, 0x07, 0xBC, 0x03, 0xC0, 0x73,
  0xC0, 0x3C, 0x0F, 0x1E, 0x03, 0xC0, 0xF1, 0xE0, 0x3C, 0x0F, 0x1F, 0x07,
  0xC0, 0xF0, 0xF0, 0x78, 0x1E, 0x0F, 0x07, 0x81, 0xE0, 0xF8, 0x78, 0x1E,
  0x07, 0x87, 0x81, 0xE0, 0x78, 0xF0, 0x1E, 0x03, 0xCF, 0x03, 0xC0, 0x3C,
  0xF0, 0x3C, 0x03, 0xCF, 0x03, 0xC0, 0x1E, 0xF0, 0x3C, 0x01, 0xEE, 0x03,
  0xC0, 0x1F, 0xE0, 0x78, 0x00, 0xFE, 0x07, 0x80, 0x0F, 0xE0, 0x78, 0x00,
  0xFE, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0xFE, 0x07,
  0xE0, 0x7C, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x1E, 0x3E, 0x00,
  0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1E, 0xF0,
  0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE, 0x00, 0x03, 0xCF,
  0x00, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x7E, 0x01, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xF0,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF,
  0x00, 0xFF, 0xFE, 0x03, 0xC0, 0xFC, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xC1,
  0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0,
  0x1F, 0x0F, 0x00, 0xF8, 0x3C, 0x07, 0xE0, 0xF1, 0xFF, 0x07, 0xFF, 0xF8,
  0x1F, 0xFF, 0xC0, 0x7F, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0xFF, 0xFF,
  0x80, 0xFE, 0x07, 0xE0, 0x7C, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x1E, 0x3E, 0x00, 0x0F, 0xBE, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xEF, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0,
  0x00, 0x1E, 0xF0, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDE,
  0x00, 0x03, 0xCF, 0x00, 0x03, 0xE7, 0xC0, 0x01, 0xE3, 0xE0, 0x01, 0xF0,
  0xF8, 0x01, 0xF0, 0x7E, 0x01, 0xF8, 0x1F, 0xC7, 0xF8, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x3F,
  0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x07,
  0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x07, 0xC3,
  0xC0, 0x1E, 0x0F, 0x00, 0xF8, 0x3C, 0x0F, 0xC0, 0xFF, 0xFE, 0x07, 0xFF,
  0xF0, 0x1F, 0xFE, 0x00, 0x78, 0x7C, 0x01, 0xE0, 0xF0, 0x0F, 0x83, 0xC0,
  0x3E, 0x0F, 0x80, 0xF0, 0x1E, 0x03, 0xC0, 0x7C, 0x0F, 0x01, 0xF0, 0x7C,
  0x03, 0xC1, 0xF0, 0x0F, 0x87, 0x80, 0x3E, 0x1E, 0x00, 0x78, 0xF8, 0x01,
  0xF0, 0x00, 0x7F, 0x80, 0x1F, 0xFE, 0x03, 0xFF, 0xF0, 0x7F, 0xFE, 0x0F,
  0xC0, 0x60, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00,
  0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x80, 0x1F, 0x0F, 0x07, 0xF0, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0, 0x7F,
  0xF0, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xDF, 0xFF, 0xFC, 0xFF, 0xFF,
  0xE8, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x87, 0x80,
  0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0x78, 0x00, 0x78, 0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x1E, 0x1F,
  0x00, 0x1F, 0x0F, 0x00, 0x0F, 0x87, 0x80, 0x07, 0x83, 0xC0, 0x03, 0xC3,
  0xE0, 0x01, 0xE1, 0xF0, 0x01, 0xF0, 0xF0, 0x00, 0xF0, 0x78, 0x00, 0x78,
  0x3C, 0x00, 0x3C, 0x3E, 0x00, 0x3E, 0x1E, 0x00, 0x1F, 0x0F, 0x00, 0x0F,
  0x07, 0x80, 0x07, 0x83, 0xC0, 0x07, 0xC1, 0xF0, 0x07, 0xC0, 0xFC, 0x07,
  0xE0, 0x3F, 0x8F, 0xE0, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xBC, 0x00,
  0x3E, 0xF0, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x3E, 0x3C, 0x00, 0xF0,
  0xF8, 0x07, 0xC1, 0xE0, 0x1E, 0x07, 0x80, 0xF8, 0x1E, 0x03, 0xC0, 0x78,
  0x1F, 0x01, 0xE0, 0x78, 0x07, 0x83, 0xE0, 0x1E, 0x0F, 0x00, 0x78, 0x7C,
  0x01, 0xE1, 0xE0, 0x07, 0x8F, 0x80, 0x0E, 0x3C, 0x00, 0x3D, 0xF0, 0x00,
  0xF7, 0x80, 0x03, 0xDE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xFC, 0x00, 0x78, 0x01, 0xFF, 0x00, 0x3E, 0x00, 0x7B, 0xC0,
  0x0F, 0x80, 0x3E, 0xF0, 0x07, 0xE0, 0x0F, 0x3C, 0x01, 0xF8, 0x03, 0xCF,
  0x00, 0xFE, 0x01, 0xF3, 0xC0, 0x3B, 0x80, 0x78, 0xF0, 0x1E, 0xF0, 0x3E,
  0x3C, 0x07, 0xBC, 0x0F, 0x0F, 0x03, 0xCF, 0x07, 0xC1, 0xC0, 0xF3, 0xC1,
  0xE0, 0x78, 0x78, 0xF0, 0x78, 0x1E, 0x1E, 0x3C, 0x3C, 0x07, 0x87, 0x0F,
  0x0F, 0x01, 0xE3, 0xC3, 0xC7, 0x80, 0x78, 0xE0, 0xF1, 0xE0, 0x1E, 0x78,
  0x3C, 0xF8, 0x07, 0x9E, 0x0F, 0x3C, 0x01, 0xEF, 0x03, 0xCF, 0x00, 0x7B,
  0xC0, 0xF7, 0x80, 0x1E, 0xE0, 0x1D, 0xE0, 0x07, 0xF8, 0x07, 0x70, 0x01,
  0xDC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x07, 0xE0, 0x07, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0x78, 0x07, 0xC0, 0x1F,
  0x00, 0x78, 0x07, 0xC0, 0x0F, 0x01, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0x1E,
  0x0F, 0x80, 0x03, 0xC3, 0xE0, 0x00, 0x7C, 0xF8, 0x00, 0x07, 0x9E, 0x00,
  0x00, 0xF7, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0x78, 0x00, 0x03, 0xCF, 0x00, 0x00, 0xF9, 0xE0, 0x00, 0x3E, 0x1E,
  0x00, 0x07, 0x83, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0x80, 0x1F,
  0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x03, 0xE0, 0x3E, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xBC, 0x00, 0x79,
  0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3C, 0x03, 0xC1, 0xE0, 0x3E, 0x07, 0x83,
  0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x0F, 0x1F, 0x00, 0x3C, 0xF0, 0x01,
  0xEF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0,
  0x01, 0xFE, 0x03, 0xFC, 0x0F, 0xF8, 0x1F, 0xE0, 0x3C, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xFF, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0xF0, 0xF0, 0x70, 0x78, 0x78, 0x78,
  0x78, 0x78, 0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1E,
  0x1E, 0x1E, 0x1E, 0x1E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x0F, 0x07, 0x00,
  0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x00, 0x00, 0x30, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1D, 0xC0,
  0x01, 0xDE, 0x00, 0x38, 0xE0, 0x07, 0x8F, 0x00, 0x70, 0x70, 0x0F, 0x07,
  0x80, 0xE0, 0x38, 0x1E, 0x03, 0xC1, 0xC0, 0x1C, 0x3C, 0x01, 0xC3, 0x80,
  0x1E, 0x78, 0x00, 0xEF, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0xF1,
  0xF1, 0xE1, 0xC3, 0xC3, 0xC3, 0x80, 0x00, 0xF8, 0x70, 0x3F, 0xC7, 0x0F,
  0xFE, 0xF0, 0xFF, 0xFF, 0x1F, 0x07, 0xE3, 0xE0, 0x3E, 0x3C, 0x03, 0xE7,
  0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x80, 0x3C,
  0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x1F,
  0x8F, 0x83, 0xF8, 0xFC, 0x7F, 0x87, 0xFF, 0x70, 0x7F, 0xE7, 0x01, 0xF8,
  0xF0, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x8F, 0x80,
  0xF3, 0xFC, 0x0F, 0x7F, 0xE0, 0xFF, 0xFF, 0x0F, 0xC1, 0xF1, 0xF8, 0x0F,
  0x1F, 0x80, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00,
  0xF3, 0xC0, 0x0F, 0x3C, 0x01, 0xF3, 0xC0, 0x1F, 0x3C, 0x01, 0xE7, 0xC0,
  0x3E, 0x7C, 0x03, 0xC7, 0xE0, 0x7C, 0x7F, 0x1F, 0x87, 0x7F, 0xF0, 0xF3,
  0xFE, 0x0E, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFF, 0xC1, 0xFF, 0xC1, 0xFF,
  0xE1, 0xF0, 0x11, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x87, 0x0F, 0xFF, 0x83, 0xFF,
  0xC0, 0x7F, 0xC0, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00,
  0x3E, 0x00, 0xF0, 0xF0, 0x0F, 0xF3, 0xC0, 0xFF, 0xEF, 0x07, 0xFF, 0xFC,
  0x1F, 0x07, 0xE0, 0xF8, 0x0F, 0x83, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x78,
  0x03, 0xE1, 0xE0, 0x0F, 0x0F, 0x80, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x07,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x83,
  0xE0, 0xFE, 0x0F, 0xC7, 0xF0, 0x1F, 0xFD, 0xC0, 0x7F, 0xE7, 0x00, 0x7E,
  0x3C, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x7F, 0xF8, 0x3F, 0x3E, 0x1F,
  0x07, 0x8F, 0x81, 0xF3, 0xC0, 0x79, 0xF0, 0x1E, 0x78, 0x1F, 0xBE, 0x7F,
  0xCF, 0xFF, 0xE3, 0xFF, 0xE0, 0xFF, 0xC0, 0x3C, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x87, 0xC0, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFE, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0xFF,
  0xF8, 0x03, 0xFF, 0xC0, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x7C, 0x38,
  0x0F, 0xF1, 0xC1, 0xFF, 0xDE, 0x1F, 0xFF, 0xF0, 0xF8, 0x3F, 0x0F, 0x80,
  0xF8, 0x78, 0x07, 0xC7, 0xC0, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F, 0x1F,
  0x00, 0x78, 0xF8, 0x03, 0xC7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x0F,
  0x0F, 0x00, 0xF8, 0x78, 0x0F, 0xC3, 0xE0, 0xFE, 0x1F, 0x8E, 0xE0, 0x7F,
  0xEF, 0x03, 0xFE, 0x78, 0x07, 0xE3, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x20, 0x07, 0x81, 0x80, 0xFC, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x01, 0x60, 0x00, 0x03, 0xE0, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x8F, 0x80, 0xF1, 0xFE, 0x0F, 0x7F,
  0xF0, 0xFF, 0xFF, 0x0F, 0xE0, 0xF1, 0xFC, 0x0F, 0x1F, 0x80, 0xF1, 0xF0,
  0x0F, 0x1F, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xC0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3C, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x03, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x00, 0x78,
  0x01, 0x80, 0xF0, 0x3C, 0x1F, 0x03, 0x80, 0x00, 0x00, 0x00, 0x07, 0x83,
  0xE0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0xF8,
  0x3C, 0x00, 0x00, 0x06, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x70, 0x00, 0x03, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0xF8, 0x7C, 0x0F,
  0x83, 0xC0, 0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x78,
  0xF8, 0x03, 0xCF, 0x80, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0x3C, 0x00, 0xF1, 0xF0, 0x0F, 0x87,
  0x80, 0x78, 0x3E, 0x03, 0xC0, 0xF0, 0x1E, 0x07, 0xC1, 0xF0, 0x1E, 0x0F,
  0x80, 0xF8, 0x78, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C,
  0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x3E,
  0x07, 0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03, 0xC0, 0x78, 0x0F,
  0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x00, 0x07,
  0x0F, 0x80, 0x78, 0x0F, 0x3F, 0xC1, 0xFE, 0x0F, 0x7F, 0xE7, 0xFE, 0x0F,
  0xFF, 0xE7, 0xFF, 0x0F, 0xE1, 0xEE, 0x0F, 0x0F, 0x81, 0xFC, 0x0F, 0x1F,
  0x81, 0xF8, 0x0F, 0x1F, 0x01, 0xF0, 0x0F, 0x1F, 0x01, 0xF0, 0x0F, 0x1E,
  0x01, 0xE0, 0x1F, 0x3E, 0x01, 0xE0, 0x1E, 0x3C, 0x01, 0xE0, 0x1E, 0x3C,
  0x03, 0xE0, 0x1E, 0x3C, 0x03, 0xC0, 0x1E, 0x3C, 0x03, 0xC0, 0x3E, 0x7C,
  0x03, 0xC0, 0x3C, 0x78, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0xC0, 0x3C, 0x78,
  0x07, 0x80, 0x3C, 0x78, 0x07, 0x80, 0x7C, 0xF8, 0x07, 0x80, 0x78, 0xF0,
  0x0F, 0x80, 0x78, 0x0F, 0x0F, 0xC0, 0xF3, 0xFE, 0x0F, 0x7F, 0xF0, 0xFF,
  0xFF, 0x0F, 0xE0, 0xF1, 0xFC, 0x0F, 0x1F, 0x80, 0xF1, 0xF0, 0x0F, 0x1F,
  0x00, 0xF1, 0xE0, 0x1F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3,
  0xC0, 0x1E, 0x7C, 0x03, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x07, 0xCF, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x00, 0x78, 0x00, 0xFC,
  0x00, 0x7F, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE1, 0xF0, 0x7C, 0x7C, 0x07,
  0xDF, 0x00, 0xFB, 0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F,
  0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3E,
  0xF8, 0x0F, 0x9F, 0x01, 0xF1, 0xF0, 0xFC, 0x1F, 0xFF, 0x03, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x01, 0xC3, 0xE0, 0x0F, 0x3F, 0xC0, 0x3D, 0xFF, 0x80,
  0xFF, 0xFF, 0x03, 0xF0, 0x7C, 0x0F, 0x80, 0xF0, 0x7E, 0x03, 0xC1, 0xF0,
  0x0F, 0x07, 0x80, 0x3C, 0x1E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F,
  0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x87, 0xC0, 0x3E, 0x1F,
  0x00, 0xF0, 0x7E, 0x07, 0xC1, 0xFC, 0x7E, 0x07, 0xFF, 0xF0, 0x3C, 0xFF,
  0x80, 0xF1, 0xFC, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0xF8, 0x70, 0x3F, 0xC7,
  0x0F, 0xFE, 0xF1, 0xFF, 0xFF, 0x1F, 0x07, 0xE3, 0xE0, 0x3E, 0x3C, 0x03,
  0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xE7, 0x80, 0x3C, 0xF8, 0x03, 0xCF, 0x00,
  0x3C, 0xF0, 0x07, 0xCF, 0x00, 0x7C, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0,
  0x1F, 0x8F, 0x83, 0xF8, 0xFC, 0x77, 0x07, 0xFE, 0xF0, 0x7F, 0xCF, 0x01,
  0xF8, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x07, 0x0F, 0x87, 0x9F, 0x83, 0xDF, 0xC1, 0xFF, 0xE0,
  0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0xC3, 0xFF, 0xE3, 0xFB, 0xE1, 0xE0,
  0x10, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3C,
  0x00, 0x1E, 0x40, 0x1F, 0x38, 0x1F, 0x1F, 0xFF, 0x8F, 0xFF, 0x83, 0xFF,
  0x00, 0x03, 0x80, 0x3C, 0x01, 0xC0, 0x1E, 0x01, 0xFF, 0xBF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE1, 0x0F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x1F, 0x00, 0xF1, 0xE0,
  0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x01, 0xF3, 0xE0, 0x1E, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x3E, 0x78, 0x03, 0xC7,
  0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x7C, 0xF8, 0x07, 0x8F, 0x00, 0xF8,
  0xF0, 0x1F, 0x8F, 0x83, 0xF8, 0xF8, 0x77, 0x87, 0xFF, 0x70, 0x7F, 0xE7,
  0x03, 0xF8, 0x70, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0x78, 0x03,
  0xEF, 0x80, 0x78, 0xF0, 0x1F, 0x1E, 0x03, 0xC3, 0xC0, 0xF0, 0x78, 0x3E,
  0x0F, 0x07, 0x81, 0xE1, 0xF0, 0x3C, 0x3C, 0x07, 0x8F, 0x80, 0xF1, 0xE0,
  0x0E, 0x7C, 0x01, 0xCF, 0x00, 0x3D, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x7F,
  0x80, 0x7C, 0x07, 0xFC, 0x07, 0xE0, 0x3D, 0xE0, 0x3F, 0x01, 0xEF, 0x03,
  0xF8, 0x1E, 0x38, 0x1D, 0xC0, 0xF1, 0xC0, 0xEE, 0x0F, 0x8F, 0x0F, 0x70,
  0x78, 0x78, 0x73, 0x87, 0xC3, 0xC7, 0x9C, 0x3C, 0x1E, 0x38, 0xE3, 0xE0,
  0xF3, 0xC7, 0x1E, 0x07, 0x9C, 0x38, 0xF0, 0x3D, 0xE1, 0xCF, 0x01, 0xEE,
  0x0E, 0x78, 0x0F, 0x70, 0x77, 0x80, 0x7F, 0x83, 0xBC, 0x03, 0xB8, 0x1D,
  0xC0, 0x1F, 0xC0, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x01,
  0xF0, 0x1F, 0x07, 0xC0, 0x1E, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x3C, 0xF0,
  0x00, 0x7B, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7B, 0xC0, 0x01,
  0xE7, 0x80, 0x07, 0xCF, 0x80, 0x1F, 0x0F, 0x00, 0x7C, 0x1F, 0x01, 0xF0,
  0x1E, 0x03, 0xC0, 0x3C, 0x1F, 0x80, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x07,
  0x80, 0x1F, 0x07, 0x80, 0x1E, 0x07, 0xC0, 0x3E, 0x03, 0xC0, 0x3C, 0x03,
  0xC0, 0x7C, 0x03, 0xC0, 0x78, 0x03, 0xC0, 0xF0, 0x03, 0xC0, 0xF0, 0x03,
  0xC1, 0xE0, 0x03, 0xC1, 0xE0, 0x01, 0xE3, 0xC0, 0x01, 0xE7, 0xC0, 0x01,
  0xE7, 0x80, 0x01, 0xE7, 0x80, 0x01, 0xEF, 0x00, 0x01, 0xEF, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x60, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF,
  0xFC, 0x1F, 0xFF, 0x83, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xE1, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0x00, 0x7C,
  0x00, 0xFC, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0x80, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF8, 0x01, 0x00, 0x01, 0xF0, 0x01, 0xF8, 0x03, 0xF8, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0xFF, 0xF3, 0xFF, 0xF8, 0x07, 0xFD,
  0x00, 0x3E, 0x00,
};

const GFXglyph NotoSans_MediumItalic40pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 11, 30, 11, 1, -29 },
  { 43, 13, 11, 16, 4, -29 },
  { 61, 25, 29, 26, 1, -29 },
  { 152, 20, 32, 22, 1, -30 },
  { 232, 28, 29, 33, 3, -29 },
  { 334, 25, 29, 27, 1, -29 },
  { 425, 6, 11, 9, 4, -29 },
  { 434, 13, 35, 12, 2, -29 },
  { 491, 14, 35, 12, -3, -29 },
  { 553, 19, 19, 22, 4, -31 },
  { 599, 19, 20, 23, 3, -24 },
  { 647, 9, 10, 11, -2, -5 },
  { 659, 10, 4, 13, 1, -13 },
  { 664, 5, 6, 11, 1, -5 },
  { 668, 20, 29, 15, -2, -29 },
  { 741, 19, 29, 22, 2, -29 },
  { 810, 13, 29, 22, 5, -29 },
  { 858, 21, 29, 22, 0, -29 },
  { 935, 20, 29, 22, 1, -29 },
  { 1008, 21, 29, 22, 0, -29 },
  { 1085, 21, 29, 22, 1, -29 },
  { 1162, 20, 29, 22, 2, -29 },
  { 1235, 20, 29, 22, 3, -29 },
  { 1308, 20, 29, 22, 2, -29 },
  { 1381, 19, 29, 22, 2, -29 },
  { 1450, 9, 23, 11, 1, -22 },
  { 1476, 12, 27, 11, -2, -22 },
  { 1517, 19, 21, 23, 3, -25 },
  { 1567, 18, 11, 23, 3, -20 },
  { 1592, 19, 21, 23, 3, -25 },
  { 1642, 16, 30, 18, 3, -29 },
  { 1702, 31, 33, 34, 2, -29 },
  { 1830, 23, 29, 23, -2, -29 },
  { 1914, 23, 29, 24, 1, -29 },
  { 1998, 23, 29, 24, 3, -29 },
  { 2082, 25, 29, 27, 1, -29 },
  { 2173, 21, 29, 21, 1, -29 },
  { 2250, 21, 29, 20, 1, -29 },
  { 2327, 24, 29, 27, 3, -29 },
  { 2414, 27, 29, 27, 1, -29 },
  { 2512, 17, 29, 14, -1, -29 },
  { 2574, 18, 37, 12, -6, -29 },
  { 2658, 26, 29, 23, 1, -29 },
  { 2753, 16, 29, 20, 1, -29 },
  { 2811, 33, 29, 34, 1, -29 },
  { 2931, 28, 29, 29, 1, -29 },
  { 3033, 25, 29, 29, 3, -29 },
  { 3124, 22, 29, 23, 1, -29 },
  { 3204, 25, 36, 29, 3, -29 },
  { 3317, 22, 29, 23, 1, -29 },
  { 3397, 20, 29, 20, 1, -29 },
  { 3470, 21, 29, 20, 3, -29 },
  { 3547, 25, 29, 27, 3, -29 },
  { 3638, 22, 29, 23, 4, -29 },
  { 3718, 34, 29, 35, 4, -29 },
  { 3842, 27, 29, 22, -2, -29 },
  { 3940, 21, 29, 21, 4, -29 },
  { 4017, 24, 29, 21, -1, -29 },
  { 4104, 15, 35, 12, 0, -29 },
  { 4170, 8, 29, 15, 4, -29 },
  { 4199, 16, 35, 12, -3, -29 },
  { 4269, 20, 18, 23, 1, -29 },
  { 4314, 17, 2, 16, -4, 4 },
  { 4319, 7, 7, 12, 6, -31 },
  { 4326, 20, 22, 23, 2, -22 },
  { 4381, 20, 30, 23, 1, -30 },
  { 4456, 17, 22, 18, 2, -22 },
  { 4503, 22, 30, 23, 2, -30 },
  { 4586, 18, 22, 21, 2, -22 },
  { 4636, 22, 41, 13, -4, -31 },
  { 4749, 21, 32, 23, 1, -22 },
  { 4833, 20, 30, 23, 1, -30 },
  { 4908, 10, 30, 11, 1, -30 },
  { 4946, 16, 40, 11, -5, -30 },
  { 5026, 21, 30, 21, 1, -30 },
  { 5105, 11, 30, 11, 1, -30 },
  { 5147, 32, 22, 35, 1, -22 },
  { 5235, 20, 22, 23, 1, -22 },
  { 5290, 19, 22, 23, 2, -22 },
  { 5343, 22, 32, 23, -1, -22 },
  { 5431, 20, 32, 23, 2, -22 },
  { 5511, 17, 22, 16, 1, -22 },
  { 5558, 17, 22, 18, 0, -22 },
  { 5605, 13, 26, 14, 2, -26 },
  { 5648, 20, 22, 23, 2, -22 },
  { 5703, 19, 22, 19, 2, -22 },
  { 5756, 29, 22, 30, 2, -22 },
  { 5836, 23, 22, 20, -2, -22 },
  { 5900, 24, 32, 19, -3, -22 },
  { 5996, 19, 22, 18, -1, -22 },
  { 6049, 16, 35, 14, 0, -29 },
  { 6119, 3, 39, 22, 10, -30 },
  { 6134, 16, 35, 14, -2, -29 },
  { 6204, 19, 6, 23, 3, -17 },
};

const GFXfont NotoSans_MediumItalic40pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic40pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic40pt7bGlyphs,
  0x20, 0x7E, 54
};

#endif // _NOTOSANS_MEDIUMITALIC40PT7B_H_
