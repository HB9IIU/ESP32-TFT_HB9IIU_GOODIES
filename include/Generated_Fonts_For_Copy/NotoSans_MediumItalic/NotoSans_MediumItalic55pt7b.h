#ifndef _NOTOSANS_MEDIUMITALIC55PT7B_H_
#define _NOTOSANS_MEDIUMITALIC55PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 55pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic55pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0xFC, 0x03, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x1C, 0x00, 0x3F, 0x1F, 0xCF, 0x87, 0xE7, 0xE1, 0xF9, 0xF8,
  0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0xC1, 0xF1, 0xE0, 0x78, 0x78, 0x3E,
  0x3E, 0x0F, 0x8F, 0x83, 0xC3, 0xC0, 0xF0, 0xF0, 0x3C, 0x3C, 0x0F, 0x00,
  0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0,
  0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x1E,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00,
  0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x78, 0x00, 0x00, 0xF8, 0x0F, 0x00,
  0x00, 0x1E, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00,
  0xF8, 0x0F, 0x00, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x7C, 0x00,
  0x00, 0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x3C,
  0x00, 0x00, 0x78, 0x0F, 0x80, 0x00, 0x1F, 0x01, 0xE0, 0x00, 0x03, 0xE0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF8, 0x1F, 0xC7, 0x07, 0x03, 0xF1, 0xE0, 0x20, 0x7C, 0x3C, 0x00, 0x1F,
  0x87, 0x80, 0x03, 0xF0, 0xE0, 0x00, 0x7E, 0x1C, 0x00, 0x0F, 0xC7, 0x80,
  0x00, 0xFC, 0xF0, 0x00, 0x1F, 0xDE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F,
  0xF8, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xDF, 0xE0, 0x00, 0x79, 0xFC, 0x00, 0x0F,
  0x1F, 0x80, 0x01, 0xE3, 0xF0, 0x00, 0x38, 0x3E, 0x00, 0x0F, 0x0F, 0xC0,
  0x01, 0xE1, 0xF8, 0x80, 0x3C, 0x7F, 0x1C, 0x07, 0x1F, 0xC3, 0xF8, 0xEF,
  0xF0, 0x7F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0xFC, 0x00,
  0x0F, 0x80, 0x7F, 0xFC, 0x00, 0x3E, 0x01, 0xFD, 0xF8, 0x00, 0x78, 0x03,
  0xE1, 0xF0, 0x01, 0xF0, 0x0F, 0x81, 0xE0, 0x07, 0xC0, 0x1F, 0x03, 0xE0,
  0x1F, 0x00, 0x7C, 0x07, 0x80, 0x3E, 0x00, 0xF8, 0x0F, 0x00, 0xF8, 0x01,
  0xF0, 0x1E, 0x03, 0xE0, 0x03, 0xC0, 0x7C, 0x0F, 0x80, 0x0F, 0x80, 0xF8,
  0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x7C, 0x00, 0x3E, 0x03, 0xE1, 0xF0, 0x00,
  0x7C, 0x07, 0x87, 0xC0, 0x00, 0xF8, 0x1F, 0x0F, 0x8F, 0xE1, 0xF0, 0x3E,
  0x3E, 0x3F, 0xE3, 0xE0, 0xF8, 0xF8, 0xFF, 0xE7, 0xC3, 0xF3, 0xE3, 0xFF,
  0xE7, 0xEF, 0xC7, 0xCF, 0xC7, 0xCF, 0xFF, 0x1F, 0x3F, 0x0F, 0x8F, 0xFC,
  0x7C, 0x7C, 0x0F, 0x8F, 0xF1, 0xF0, 0xF8, 0x1F, 0x07, 0x83, 0xE3, 0xE0,
  0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0xF0, 0x00,
  0xF8, 0x3E, 0x03, 0xE0, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x07, 0xC0, 0xF8,
  0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0x3C, 0x03, 0xE0, 0x7C, 0x00,
  0xF8, 0x07, 0xC0, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0x80, 0x1F,
  0x07, 0xC0, 0x1F, 0x00, 0x3F, 0x1F, 0x80, 0x7C, 0x00, 0x3F, 0xFE, 0x01,
  0xF0, 0x00, 0x7F, 0xF8, 0x07, 0xC0, 0x00, 0x7F, 0xE0, 0x1F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0x7E,
  0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0xF8, 0x03, 0xE0, 0x00, 0x7E, 0x00,
  0xF8, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xF8,
  0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xF0, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x01,
  0xF7, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xF0, 0x03, 0xF1, 0xFE, 0x7E, 0x00, 0xFC, 0xFF, 0x1F, 0xC0,
  0x7E, 0x3F, 0x03, 0xF8, 0x1F, 0x9F, 0x80, 0x7E, 0x0F, 0xCF, 0xE0, 0x0F,
  0xC7, 0xE3, 0xF0, 0x03, 0xF9, 0xF8, 0xFC, 0x00, 0x7F, 0xFC, 0x3F, 0x00,
  0x0F, 0xFE, 0x0F, 0xC0, 0x03, 0xFF, 0x03, 0xF0, 0x00, 0x7F, 0xC0, 0xFC,
  0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x0F, 0xF8, 0x0F, 0xF0, 0x0F, 0xFF, 0x01,
  0xFF, 0x1F, 0xFF, 0xE0, 0x7F, 0xFF, 0xFD, 0xF8, 0x0F, 0xFF, 0xFE, 0x7F,
  0x01, 0xFF, 0xFE, 0x0F, 0xE0, 0x1F, 0xFE, 0x01, 0xFC, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8,
  0xF8, 0xF0, 0xF0, 0xF0, 0x00, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x03,
  0x00, 0xF8, 0x01, 0xF0, 0x3C, 0x00, 0x7F, 0x0F, 0x00, 0x1F, 0xF3, 0xC0,
  0x0F, 0xFF, 0xE0, 0x04, 0x3F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x07, 0xF7, 0xFC, 0x07, 0xFC, 0x01, 0x03, 0xF7, 0x80, 0x01,
  0xF9, 0xE0, 0x00, 0xFC, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x83, 0xE0,
  0x07, 0xC0, 0xF8, 0x00, 0xE0, 0x3E, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE1, 0xFC,
  0x3F, 0x0F, 0xE1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xF0,
  0x7C, 0x0F, 0x00, 0x7F, 0xFE, 0xFF, 0xF9, 0xFF, 0xF3, 0xFF, 0xEF, 0xFF,
  0xC0, 0x3E, 0x7E, 0xFF, 0xFF, 0xFE, 0xFE, 0xFC, 0x38, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x03, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0x0F, 0xE0, 0x7F, 0x01,
  0xFC, 0x1F, 0x80, 0x3F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF0, 0x03, 0xF1, 0xF8,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3,
  0xF0, 0x00, 0x7D, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x03,
  0xF7, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x07, 0xEF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F,
  0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07, 0xE3, 0xF0, 0x03, 0xF8, 0xFC, 0x00,
  0xFC, 0x1F, 0x80, 0x7F, 0x07, 0xE0, 0x3F, 0x81, 0xFE, 0x3F, 0xC0, 0x3F,
  0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x07,
  0xFE, 0x03, 0xFF, 0x83, 0xFF, 0xE3, 0xFF, 0xF9, 0xFF, 0x7C, 0xFF, 0x9F,
  0x1F, 0x8F, 0xC3, 0x83, 0xF0, 0xC0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0x07, 0xF8, 0x03, 0xE0, 0x0F, 0xE0, 0x0C, 0x00,
  0x7F, 0x00, 0x40, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF,
  0xFF, 0xC3, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x1F, 0x81, 0xFE, 0x01, 0xE0, 0x07, 0xF0, 0x08, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x88, 0x00, 0x07, 0xF0, 0xE0, 0x00, 0xFF, 0x0F,
  0xF0, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0xF9,
  0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC3, 0xE0,
  0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07,
  0xC0, 0x7C, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFE, 0x00, 0x7C, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x80,
  0x00, 0xFE, 0x0E, 0x00, 0x3F, 0xE0, 0xFC, 0x1F, 0xFC, 0x0F, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x3F,
  0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0x80, 0x80,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x1F, 0xF8,
  0x07, 0xCF, 0xFF, 0x81, 0xFB, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x87, 0xFE,
  0x07, 0xF0, 0xFF, 0x00, 0x7E, 0x1F, 0xC0, 0x0F, 0xE7, 0xF0, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0x9F, 0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00,
  0x0F, 0xCF, 0xC0, 0x01, 0xF1, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0xC1, 0xFC, 0x07,
  0xF0, 0x1F, 0xE3, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xF3,
  0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xC0, 0xFE, 0x03, 0xF8, 0x07, 0xF0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x3F, 0x03, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x03,
  0xF8, 0x0F, 0xC0, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x7F, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xC0, 0x0F, 0xF1, 0xFE, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0x80,
  0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x7F,
  0x07, 0xFC, 0x1F, 0xE0, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0x03, 0xFC, 0x1F, 0xE0, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7E,
  0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00,
  0x3F, 0x3E, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x07, 0xF3, 0xF0, 0x03, 0xF8,
  0xFC, 0x01, 0xFE, 0x3F, 0xC1, 0xFF, 0x87, 0xFF, 0xFF, 0xE1, 0xFF, 0xFD,
  0xF8, 0x3F, 0xFE, 0x7C, 0x03, 0xFE, 0x3F, 0x00, 0x1E, 0x0F, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC,
  0x08, 0x01, 0xFE, 0x03, 0xC3, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x7F, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x30,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0,
  0x7E, 0x0F, 0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x38, 0x00, 0x00,
  0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x30, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x80, 0x00, 0x00, 0x30, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x1F, 0xFF,
  0xFC, 0x3F, 0xFF, 0xF8, 0xFC, 0x1F, 0xE1, 0x80, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x01,
  0xF0, 0x3F, 0x00, 0x05, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xFF, 0x03, 0xE1,
  0xF0, 0x07, 0xFF, 0xF0, 0x3C, 0x3C, 0x03, 0xFF, 0xFE, 0x07, 0x8F, 0x80,
  0xFF, 0x1F, 0x80, 0xF9, 0xE0, 0x3F, 0x81, 0xF0, 0x1F, 0x7C, 0x07, 0xC0,
  0x3E, 0x03, 0xEF, 0x81, 0xF0, 0x07, 0xC0, 0x7D, 0xE0, 0x3E, 0x00, 0xF0,
  0x0F, 0x7C, 0x0F, 0x80, 0x3E, 0x01, 0xEF, 0x81, 0xF0, 0x07, 0xC0, 0x3D,
  0xF0, 0x3C, 0x00, 0xF8, 0x0F, 0xBE, 0x0F, 0x80, 0x3E, 0x01, 0xF7, 0xC1,
  0xF0, 0x07, 0xC0, 0x3E, 0xF0, 0x3E, 0x00, 0xF8, 0x0F, 0x9E, 0x07, 0xC0,
  0x3F, 0x01, 0xF3, 0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x7C, 0x1F, 0x01, 0xF8,
  0x0F, 0x8F, 0x83, 0xF0, 0x7F, 0x87, 0xE1, 0xF0, 0x3F, 0xFE, 0xFF, 0xF8,
  0x3E, 0x07, 0xFF, 0x9F, 0xFE, 0x03, 0xC0, 0x7F, 0xE1, 0xFF, 0x80, 0x7C,
  0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x03, 0x00,
  0x00, 0x3F, 0xF0, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0xF9, 0xF8, 0x00, 0x01, 0xF8, 0xF8,
  0x00, 0x01, 0xF0, 0xF8, 0x00, 0x03, 0xF0, 0xF8, 0x00, 0x03, 0xE0, 0xF8,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xF0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3E,
  0x1F, 0xC0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xC0,
  0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x3F, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x03,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xE0,
  0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFC, 0x3F, 0x80,
  0xFF, 0x80, 0x06, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x1C, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x01,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x04, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xC0, 0x1F, 0xF0, 0x07, 0xE0, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFE,
  0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x3E, 0x00,
  0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7F, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xE0, 0x7E,
  0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x3F, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0x87, 0xF0, 0x07, 0xFC, 0x00, 0x38, 0x07, 0xF8, 0x00,
  0x04, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x0F, 0xFF, 0xCF, 0xC0, 0x07, 0xFF, 0xC7, 0xE0, 0x03, 0xFF, 0xE3, 0xF0,
  0x01, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0xFC, 0x7E,
  0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0x83, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF0, 0x3F, 0xC0, 0x01, 0xF8,
  0x0F, 0xF8, 0x01, 0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x7E,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x0F, 0x80, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x03,
  0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0,
  0x0C, 0x3F, 0xE0, 0x07, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x01, 0xF8, 0xFE,
  0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFB,
  0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xE7, 0xE0, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x03, 0xF0,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01,
  0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xC0, 0x01,
  0xFC, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFE, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F,
  0xE0, 0x00, 0x07, 0xFE, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x01, 0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0x7C, 0x03, 0xFF, 0x80, 0x00,
  0xFB, 0xE0, 0x1F, 0x3C, 0x00, 0x0F, 0x9F, 0x00, 0xF9, 0xE0, 0x00, 0x7D,
  0xF8, 0x07, 0xCF, 0x80, 0x07, 0xCF, 0xC0, 0x3E, 0x7C, 0x00, 0x3E, 0x7C,
  0x03, 0xF3, 0xE0, 0x03, 0xE3, 0xE0, 0x1F, 0x9F, 0x00, 0x1F, 0x3F, 0x00,
  0xF8, 0xF8, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x8F, 0xC0, 0x3E,
  0x3E, 0x00, 0xF8, 0x7C, 0x03, 0xF1, 0xF0, 0x0F, 0xC3, 0xE0, 0x1F, 0x87,
  0x80, 0x7C, 0x3F, 0x00, 0xF8, 0x3C, 0x07, 0xC1, 0xF8, 0x07, 0xC1, 0xF0,
  0x3E, 0x0F, 0xC0, 0x7E, 0x0F, 0x83, 0xE0, 0x7C, 0x03, 0xF0, 0x7C, 0x1F,
  0x07, 0xE0, 0x1F, 0x03, 0xE1, 0xF0, 0x3F, 0x00, 0xF8, 0x1F, 0x0F, 0x81,
  0xF8, 0x07, 0xC0, 0xF8, 0xF8, 0x0F, 0xC0, 0x7E, 0x07, 0xC7, 0xC0, 0x7C,
  0x03, 0xF0, 0x1E, 0x7C, 0x07, 0xE0, 0x1F, 0x00, 0xF3, 0xE0, 0x3F, 0x00,
  0xF8, 0x07, 0xFE, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0xF0, 0x0F, 0x80, 0x7E,
  0x01, 0xFF, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xF8, 0x07, 0xE0, 0x1F, 0x00,
  0x7F, 0x80, 0x3F, 0x00, 0xF8, 0x03, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0xC0, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xE0,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x03,
  0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xC0, 0x00, 0x3E, 0x01, 0xFF,
  0x00, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xE0, 0x1F, 0xF8, 0x00, 0x1F,
  0x80, 0x7F, 0xF0, 0x00, 0x7C, 0x03, 0xEF, 0xC0, 0x01, 0xF0, 0x0F, 0x9F,
  0x00, 0x0F, 0xC0, 0x3E, 0x7E, 0x00, 0x3F, 0x00, 0xF9, 0xF8, 0x00, 0xFC,
  0x03, 0xE3, 0xE0, 0x03, 0xE0, 0x1F, 0x8F, 0xC0, 0x1F, 0x80, 0x7E, 0x3F,
  0x00, 0x7E, 0x01, 0xF0, 0x7C, 0x01, 0xF8, 0x07, 0xC1, 0xF8, 0x07, 0xC0,
  0x1F, 0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x3F,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x3E, 0x01, 0xF8, 0x3E, 0x01,
  0xF8, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x1F, 0x80, 0x3F,
  0x1F, 0x80, 0x7C, 0x00, 0xFC, 0x7E, 0x01, 0xF0, 0x01, 0xF1, 0xF0, 0x0F,
  0xC0, 0x07, 0xE7, 0xC0, 0x3F, 0x00, 0x1F, 0x9F, 0x00, 0xF8, 0x00, 0x3E,
  0xFC, 0x03, 0xE0, 0x00, 0xFF, 0xF0, 0x0F, 0x80, 0x01, 0xFF, 0x80, 0x7E,
  0x00, 0x07, 0xFE, 0x01, 0xF8, 0x00, 0x1F, 0xF8, 0x07, 0xC0, 0x00, 0x3F,
  0xE0, 0x1F, 0x00, 0x00, 0xFF, 0x00, 0x7C, 0x00, 0x03, 0xFC, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x80, 0x3F,
  0xE0, 0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F,
  0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFC, 0x01,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00,
  0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07,
  0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x00, 0x3F, 0xC0,
  0xFC, 0x03, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xE1, 0xFF, 0x80, 0x3F, 0xE0, 0x0F,
  0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x07, 0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00,
  0x03, 0xF3, 0xF0, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x7F, 0x3F, 0x80,
  0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x01, 0xFE, 0x03, 0xFE, 0x01, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x0B, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xE0, 0x1F,
  0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFE,
  0x07, 0xE0, 0x07, 0xF0, 0x1F, 0x00, 0x7F, 0x80, 0xFF, 0xFF, 0xFC, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xF0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xF0, 0xFE,
  0x03, 0xF8, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x08, 0x00,
  0x0F, 0xE0, 0xE0, 0x03, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x00,
  0x40, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0x7C, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x7F, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x8F, 0x80, 0x00, 0x7E, 0x1F, 0x00, 0x01,
  0xF8, 0x3E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F,
  0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0xC0, 0x07, 0xE0, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0xF8, 0x07, 0xE0, 0x01,
  0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x3E,
  0x1F, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0xF8, 0xF8, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xBE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFB, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xE7,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xCF, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x1F,
  0x00, 0x07, 0xF8, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0xF0, 0x00, 0xFC, 0x7C,
  0x00, 0x3F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFF, 0xC0, 0x07, 0xE1, 0xF8,
  0x01, 0xFF, 0x80, 0x1F, 0x83, 0xF0, 0x07, 0xDF, 0x00, 0x3F, 0x07, 0xE0,
  0x0F, 0xBE, 0x00, 0xFC, 0x0F, 0xC0, 0x3E, 0x3C, 0x01, 0xF8, 0x1F, 0x80,
  0x7C, 0x78, 0x03, 0xE0, 0x3F, 0x01, 0xF8, 0xF8, 0x0F, 0xC0, 0x7E, 0x03,
  0xE1, 0xF0, 0x1F, 0x80, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E, 0x01, 0xF8, 0x1F,
  0x07, 0xC0, 0xFC, 0x03, 0xF0, 0x3E, 0x0F, 0x83, 0xF0, 0x07, 0xE0, 0xF8,
  0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x3E, 0x0F, 0x80, 0x1F, 0x87, 0xC0,
  0x7C, 0x3F, 0x00, 0x1F, 0x0F, 0x80, 0xF8, 0x7C, 0x00, 0x3E, 0x3E, 0x01,
  0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x03, 0xE3, 0xE0, 0x00, 0xF9, 0xF8, 0x07,
  0xCF, 0xC0, 0x01, 0xF3, 0xE0, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xC0, 0x1F,
  0x3E, 0x00, 0x07, 0xDF, 0x00, 0x3E, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x7D,
  0xF0, 0x00, 0x1F, 0xF8, 0x00, 0xFB, 0xE0, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x07, 0xFC,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x03, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x03, 0xE7, 0xF0, 0x00, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x00, 0xFE, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x0F,
  0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x03, 0xFB, 0xE0, 0x00, 0x3F, 0x9F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xFC, 0x1F, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0xFC, 0x07, 0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0xF8,
  0x07, 0xE0, 0x07, 0xC0, 0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x07, 0xC3, 0xF8, 0x00, 0x3E, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x3E, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07,
  0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07,
  0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x81, 0xF0,
  0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x1F, 0xFE, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x1F, 0xFC, 0x00,
  0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x07, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x79, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x03, 0xC3, 0xC0,
  0x00, 0xF8, 0x7C, 0x00, 0x1E, 0x07, 0x80, 0x07, 0xC0, 0xF8, 0x00, 0xF0,
  0x0F, 0x00, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0,
  0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x0F, 0x1F, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1E, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x7C, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xE0, 0xFC, 0x1F, 0x87, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF8,
  0x1E, 0x03, 0xC0, 0x00, 0x3F, 0x81, 0xF0, 0x0F, 0xFE, 0x1E, 0x01, 0xFF,
  0xF3, 0xE0, 0x3F, 0xFF, 0xBE, 0x07, 0xFF, 0xFB, 0xE0, 0xFF, 0x07, 0xFE,
  0x1F, 0xC0, 0x3F, 0xC1, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0,
  0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC,
  0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x07,
  0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F,
  0xC0, 0x3F, 0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xF1, 0xFF, 0xC0, 0x7F, 0xFF,
  0x7C, 0x07, 0xFF, 0xE7, 0xC0, 0x3F, 0xFC, 0x7C, 0x00, 0xFF, 0x07, 0xC0,
  0x01, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x7F, 0x00, 0x3F, 0x1F, 0xF8, 0x03, 0xF3, 0xFF, 0xC0, 0x3F, 0x7F, 0xFE,
  0x03, 0xEF, 0xFF, 0xE0, 0x3F, 0xE0, 0x7F, 0x07, 0xFC, 0x03, 0xF0, 0x7F,
  0x80, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x1F, 0x0F, 0xE0, 0x01,
  0xF0, 0xFE, 0x00, 0x1F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00,
  0x7F, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE3,
  0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF8, 0x03, 0xF8, 0x3F, 0xC0,
  0x7F, 0x07, 0xFF, 0x1F, 0xF0, 0x7D, 0xFF, 0xFE, 0x07, 0xCF, 0xFF, 0xC0,
  0x78, 0x7F, 0xF8, 0x0F, 0x83, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC1, 0xFE, 0x01, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x60, 0xFF,
  0x07, 0xC0, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xFF, 0x8F, 0x80, 0x1F, 0xFF,
  0x3E, 0x00, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0x80, 0xFF,
  0x81, 0xFC, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x1F, 0xC0,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x03, 0xF8,
  0x0F, 0xC0, 0x1F, 0xE0, 0x3F, 0x00, 0xFF, 0x80, 0xFE, 0x07, 0xFE, 0x03,
  0xFC, 0x7F, 0xF0, 0x07, 0xFF, 0xF7, 0xC0, 0x1F, 0xFF, 0x9F, 0x00, 0x3F,
  0xFC, 0x7C, 0x00, 0x3F, 0xC1, 0xE0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07,
  0xFD, 0xFE, 0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x3F, 0x1F, 0x80, 0x3F, 0x3F,
  0x00, 0x3F, 0x3F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x01, 0xFE, 0xFC,
  0x07, 0xFC, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x30, 0x7F, 0x81, 0xF0, 0x3F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x00, 0x20, 0x00, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x7C, 0x00, 0xFF,
  0xE1, 0xF0, 0x07, 0xFF, 0xCF, 0x80, 0x7F, 0xFF, 0xBE, 0x01, 0xFF, 0xFE,
  0xF8, 0x0F, 0xF0, 0x3F, 0xE0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x01, 0xFC,
  0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F,
  0x80, 0xFC, 0x00, 0xFE, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xE0,
  0x3F, 0x81, 0xFF, 0x80, 0xFF, 0x1F, 0x7C, 0x01, 0xFF, 0xFD, 0xF0, 0x07,
  0xFF, 0xEF, 0xC0, 0x0F, 0xFE, 0x3F, 0x00, 0x0F, 0xF0, 0xF8, 0x00, 0x04,
  0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x80, 0x01, 0xF8,
  0x03, 0x80, 0x1F, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x3F, 0x1F,
  0xFC, 0x03, 0xF3, 0xFF, 0xE0, 0x3F, 0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF0,
  0x3F, 0xF0, 0x7F, 0x07, 0xFC, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x38, 0x00, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x0F,
  0xC0, 0x1F, 0x80, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x0F,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x38, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x81, 0xF8, 0x03, 0xF8, 0x0F,
  0xC0, 0x3F, 0x80, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x01,
  0xF8, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F,
  0xDF, 0x80, 0x00, 0x7D, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0x80, 0x01, 0xFF, 0xFC, 0x00, 0x0F, 0xF7, 0xE0, 0x00, 0x7F, 0x1F, 0x80,
  0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFE, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x3F, 0x00,
  0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0x7F,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x00,
  0x01, 0xE0, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0x0F, 0xFC, 0x07, 0xFE, 0x00,
  0xF8, 0xFF, 0xF0, 0x7F, 0xF8, 0x07, 0xCF, 0xFF, 0x87, 0xFF, 0xE0, 0x3E,
  0xFF, 0xFE, 0x7F, 0xFF, 0x01, 0xFF, 0x03, 0xF7, 0x81, 0xF8, 0x1F, 0xF0,
  0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0x81, 0xF8, 0x01, 0xFC,
  0x00, 0x7C, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x1F, 0x80,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03,
  0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x07, 0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x01, 0xE0, 0x7F, 0x80, 0x3E, 0x1F, 0xFC, 0x03, 0xE3, 0xFF, 0xE0,
  0x3E, 0x7F, 0xFF, 0x03, 0xEF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0x07, 0xFE,
  0x03, 0xF0, 0x7F, 0xC0, 0x3F, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x00, 0x3F,
  0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07,
  0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x1F,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x03, 0xF8, 0x0F, 0xE1, 0xFC, 0x01, 0xF8, 0xFE, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0x9F, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x07, 0xEF, 0x80, 0x01, 0xFB,
  0xE0, 0x00, 0xFC, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07,
  0xE3, 0xF8, 0x03, 0xF8, 0x7E, 0x01, 0xFC, 0x1F, 0xF1, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x02, 0x00, 0x00, 0x00, 0x78, 0x1F, 0xC0, 0x03, 0xE1, 0xFF, 0x80, 0x0F,
  0x8F, 0xFF, 0x00, 0x3E, 0x7F, 0xFE, 0x00, 0xFB, 0xFF, 0xF8, 0x03, 0xFE,
  0x07, 0xF0, 0x1F, 0xF0, 0x0F, 0xC0, 0x7F, 0x80, 0x3F, 0x01, 0xFC, 0x00,
  0xFC, 0x07, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0, 0xFE, 0x00, 0x1F,
  0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80,
  0x0F, 0xC0, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F,
  0xE0, 0x7F, 0xF1, 0xFF, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xC0,
  0x1F, 0x1F, 0xFE, 0x00, 0x7C, 0x3F, 0xE0, 0x03, 0xF0, 0x08, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x81,
  0xF0, 0x0F, 0xFE, 0x1E, 0x01, 0xFF, 0xF3, 0xE0, 0x3F, 0xFF, 0xBE, 0x07,
  0xFF, 0xFB, 0xE0, 0xFF, 0x03, 0xFE, 0x1F, 0xC0, 0x3F, 0xC1, 0xF8, 0x01,
  0xFC, 0x3F, 0x80, 0x1F, 0xC3, 0xF0, 0x01, 0xFC, 0x7F, 0x00, 0x1F, 0xC7,
  0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00,
  0x1F, 0x8F, 0xC0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x0F, 0x80, 0x07, 0xF0, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFE, 0x07, 0xFE,
  0x0F, 0xF1, 0xF7, 0xC0, 0x7F, 0xFF, 0x7C, 0x07, 0xFF, 0xEF, 0xC0, 0x3F,
  0xF8, 0xFC, 0x00, 0xFF, 0x0F, 0x80, 0x01, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xE0, 0x7E, 0x07, 0xC3, 0xFC, 0x0F, 0x8F,
  0xF8, 0x1F, 0x3F, 0xE0, 0x3E, 0xFF, 0xC0, 0x7F, 0xF0, 0x81, 0xFF, 0x80,
  0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x03, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xDF, 0xC1, 0xFC, 0x01,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0xC0, 0x07, 0xF1, 0xF0, 0x1F, 0xE3, 0xFF, 0xFF,
  0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x00, 0x20, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x07, 0xE0, 0x01, 0xFF, 0xF9, 0xFF, 0xFF, 0x7F, 0xFF, 0xEF, 0xFF,
  0xFB, 0xFF, 0xFF, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x60, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xF0,
  0x07, 0xFE, 0x00, 0x08, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x0F, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xF8, 0x3F,
  0x00, 0x0F, 0x83, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01,
  0xFE, 0x0F, 0xC0, 0x3F, 0xE0, 0xFC, 0x07, 0xFE, 0x0F, 0xF1, 0xFF, 0xE0,
  0x7F, 0xFF, 0x7C, 0x07, 0xFF, 0xE7, 0xC0, 0x3F, 0xF8, 0x7C, 0x01, 0xFF,
  0x07, 0xC0, 0x01, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F, 0x3F, 0x00,
  0x1F, 0x8F, 0xC0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F,
  0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x81, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0,
  0x1F, 0x81, 0xF8, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x3F, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x9F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00,
  0x1E, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0xFC,
  0x01, 0xFE, 0x00, 0x7E, 0xFC, 0x01, 0xFE, 0x00, 0xFC, 0xFC, 0x03, 0xFE,
  0x00, 0xFC, 0xFC, 0x03, 0xDE, 0x01, 0xF8, 0xFC, 0x07, 0xDE, 0x01, 0xF8,
  0x7C, 0x07, 0xDE, 0x03, 0xF0, 0x7C, 0x07, 0x9E, 0x03, 0xF0, 0x7C, 0x0F,
  0x9E, 0x03, 0xE0, 0x7C, 0x0F, 0x1E, 0x07, 0xE0, 0x7C, 0x1F, 0x1F, 0x07,
  0xC0, 0x7C, 0x1F, 0x1F, 0x0F, 0xC0, 0x7C, 0x3E, 0x1F, 0x0F, 0xC0, 0x7C,
  0x3E, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x1F, 0x1F, 0x80, 0x7C, 0x7C, 0x1F,
  0x1F, 0x00, 0x7C, 0xF8, 0x1F, 0x3F, 0x00, 0x7C, 0xF8, 0x1F, 0x3E, 0x00,
  0x7C, 0xF0, 0x1F, 0x7E, 0x00, 0x7D, 0xF0, 0x1F, 0x7C, 0x00, 0x7D, 0xF0,
  0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x1F, 0xF8, 0x00, 0x7F, 0xE0, 0x1F, 0xF8,
  0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x7F, 0x00, 0x0F, 0x81,
  0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x3F,
  0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xCF, 0x80, 0x00,
  0x3F, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x01, 0xF8, 0x07, 0xF0, 0x01, 0xF8, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xF8,
  0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x03,
  0xE0, 0x7E, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x3E, 0x0F, 0xC0, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x00, 0xFC, 0xFC, 0x00,
  0x00, 0x1F, 0x3E, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80,
  0x03, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0x0E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00,
  0x07, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xF0,
  0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x5F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xE8, 0x00, 0x3F,
  0xE0,
};

const GFXglyph NotoSans_MediumItalic55pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 40, 15, 1, -39 },
  { 76, 18, 14, 23, 6, -39 },
  { 108, 35, 39, 36, 1, -39 },
  { 279, 27, 45, 30, 2, -42 },
  { 431, 39, 41, 45, 4, -40 },
  { 631, 34, 41, 38, 2, -40 },
  { 806, 8, 14, 13, 6, -39 },
  { 820, 19, 48, 17, 2, -39 },
  { 934, 19, 48, 17, -4, -39 },
  { 1048, 26, 26, 30, 5, -42 },
  { 1133, 26, 27, 31, 4, -33 },
  { 1221, 11, 13, 15, -2, -6 },
  { 1239, 15, 5, 17, 1, -17 },
  { 1249, 8, 8, 15, 1, -7 },
  { 1257, 28, 39, 21, -3, -39 },
  { 1394, 26, 41, 30, 3, -40 },
  { 1528, 18, 39, 30, 7, -39 },
  { 1616, 29, 40, 30, 0, -40 },
  { 1761, 28, 41, 30, 1, -40 },
  { 1905, 29, 39, 30, 0, -39 },
  { 2047, 28, 40, 30, 2, -39 },
  { 2187, 27, 41, 30, 3, -40 },
  { 2326, 27, 39, 30, 4, -39 },
  { 2458, 28, 41, 30, 2, -40 },
  { 2602, 26, 41, 30, 3, -40 },
  { 2736, 12, 31, 15, 1, -30 },
  { 2783, 16, 37, 15, -3, -30 },
  { 2857, 26, 28, 31, 4, -34 },
  { 2948, 25, 15, 31, 4, -27 },
  { 2995, 26, 28, 31, 4, -34 },
  { 3086, 22, 41, 24, 4, -40 },
  { 3199, 43, 44, 47, 3, -39 },
  { 3436, 32, 39, 32, -3, -39 },
  { 3592, 31, 39, 33, 2, -39 },
  { 3744, 31, 41, 33, 4, -40 },
  { 3903, 33, 39, 37, 2, -39 },
  { 4064, 29, 39, 29, 2, -39 },
  { 4206, 29, 39, 27, 2, -39 },
  { 4348, 33, 41, 38, 4, -40 },
  { 4518, 36, 39, 38, 2, -39 },
  { 4694, 23, 39, 19, -1, -39 },
  { 4807, 25, 50, 16, -9, -39 },
  { 4964, 35, 39, 32, 2, -39 },
  { 5135, 22, 39, 27, 2, -39 },
  { 5243, 45, 39, 47, 2, -39 },
  { 5463, 38, 39, 40, 2, -39 },
  { 5649, 34, 41, 40, 4, -40 },
  { 5824, 30, 39, 32, 2, -39 },
  { 5971, 34, 49, 40, 4, -40 },
  { 6180, 30, 39, 32, 2, -39 },
  { 6327, 28, 41, 28, 1, -40 },
  { 6471, 28, 39, 28, 5, -39 },
  { 6608, 34, 40, 37, 4, -39 },
  { 6778, 31, 39, 31, 5, -39 },
  { 6930, 47, 39, 48, 6, -39 },
  { 7160, 38, 39, 30, -3, -39 },
  { 7346, 29, 39, 29, 5, -39 },
  { 7488, 33, 39, 29, -1, -39 },
  { 7649, 22, 48, 17, -1, -39 },
  { 7781, 11, 39, 21, 6, -39 },
  { 7835, 22, 48, 17, -4, -39 },
  { 7967, 27, 26, 31, 2, -40 },
  { 8055, 23, 4, 22, -5, 5 },
  { 8067, 10, 9, 16, 8, -42 },
  { 8079, 28, 31, 32, 3, -30 },
  { 8188, 28, 43, 32, 1, -42 },
  { 8339, 23, 31, 25, 3, -30 },
  { 8429, 30, 43, 32, 3, -42 },
  { 8591, 24, 31, 28, 3, -30 },
  { 8684, 31, 55, 18, -6, -42 },
  { 8898, 30, 43, 32, 1, -30 },
  { 9060, 28, 42, 32, 1, -42 },
  { 9207, 15, 41, 15, 1, -41 },
  { 9284, 23, 54, 15, -7, -41 },
  { 9440, 29, 42, 28, 1, -42 },
  { 9593, 15, 42, 15, 1, -42 },
  { 9672, 45, 30, 49, 1, -30 },
  { 9841, 28, 30, 32, 1, -30 },
  { 9946, 26, 31, 31, 3, -30 },
  { 10047, 30, 43, 32, -1, -30 },
  { 10209, 28, 43, 32, 3, -30 },
  { 10360, 23, 30, 22, 1, -30 },
  { 10447, 23, 31, 24, 0, -30 },
  { 10537, 19, 37, 20, 2, -36 },
  { 10625, 28, 31, 32, 3, -30 },
  { 10734, 26, 30, 26, 3, -30 },
  { 10832, 40, 30, 41, 3, -30 },
  { 10982, 31, 30, 27, -2, -30 },
  { 11099, 34, 43, 27, -5, -30 },
  { 11282, 26, 30, 25, -1, -30 },
  { 11380, 22, 48, 19, 0, -39 },
  { 11512, 4, 55, 30, 14, -42 },
  { 11540, 21, 48, 19, -2, -39 },
  { 11666, 26, 7, 31, 4, -23 },
};

const GFXfont NotoSans_MediumItalic55pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic55pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic55pt7bGlyphs,
  0x20, 0x7E, 75
};

#endif // _NOTOSANS_MEDIUMITALIC55PT7B_H_
