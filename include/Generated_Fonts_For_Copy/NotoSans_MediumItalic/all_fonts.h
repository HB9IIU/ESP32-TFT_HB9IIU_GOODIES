#pragma once

// Auto-generated by fontMaker.py
// Source directory: /Users/danielstaempfli/AA_Coding/ESP32_Projects/ESP32-TFT_HB9IIU_GOODIES/include/Generated:Fonts_For_Copy/NotoSans_MediumItalic
// Headers: 67

#include "NotoSans_MediumItalic6pt7b.h"
#include "NotoSans_MediumItalic7pt7b.h"
#include "NotoSans_MediumItalic8pt7b.h"
#include "NotoSans_MediumItalic9pt7b.h"
#include "NotoSans_MediumItalic10pt7b.h"
#include "NotoSans_MediumItalic11pt7b.h"
#include "NotoSans_MediumItalic12pt7b.h"
#include "NotoSans_MediumItalic13pt7b.h"
#include "NotoSans_MediumItalic14pt7b.h"
#include "NotoSans_MediumItalic15pt7b.h"
#include "NotoSans_MediumItalic16pt7b.h"
#include "NotoSans_MediumItalic17pt7b.h"
#include "NotoSans_MediumItalic18pt7b.h"
#include "NotoSans_MediumItalic19pt7b.h"
#include "NotoSans_MediumItalic20pt7b.h"
#include "NotoSans_MediumItalic21pt7b.h"
#include "NotoSans_MediumItalic22pt7b.h"
#include "NotoSans_MediumItalic23pt7b.h"
#include "NotoSans_MediumItalic24pt7b.h"
#include "NotoSans_MediumItalic25pt7b.h"
#include "NotoSans_MediumItalic26pt7b.h"
#include "NotoSans_MediumItalic27pt7b.h"
#include "NotoSans_MediumItalic28pt7b.h"
#include "NotoSans_MediumItalic29pt7b.h"
#include "NotoSans_MediumItalic30pt7b.h"
#include "NotoSans_MediumItalic31pt7b.h"
#include "NotoSans_MediumItalic32pt7b.h"
#include "NotoSans_MediumItalic33pt7b.h"
#include "NotoSans_MediumItalic34pt7b.h"
#include "NotoSans_MediumItalic35pt7b.h"
#include "NotoSans_MediumItalic36pt7b.h"
#include "NotoSans_MediumItalic37pt7b.h"
#include "NotoSans_MediumItalic38pt7b.h"
#include "NotoSans_MediumItalic39pt7b.h"
#include "NotoSans_MediumItalic40pt7b.h"
#include "NotoSans_MediumItalic41pt7b.h"
#include "NotoSans_MediumItalic42pt7b.h"
#include "NotoSans_MediumItalic43pt7b.h"
#include "NotoSans_MediumItalic44pt7b.h"
#include "NotoSans_MediumItalic45pt7b.h"
#include "NotoSans_MediumItalic46pt7b.h"
#include "NotoSans_MediumItalic47pt7b.h"
#include "NotoSans_MediumItalic48pt7b.h"
#include "NotoSans_MediumItalic49pt7b.h"
#include "NotoSans_MediumItalic50pt7b.h"
#include "NotoSans_MediumItalic51pt7b.h"
#include "NotoSans_MediumItalic52pt7b.h"
#include "NotoSans_MediumItalic53pt7b.h"
#include "NotoSans_MediumItalic54pt7b.h"
#include "NotoSans_MediumItalic55pt7b.h"
#include "NotoSans_MediumItalic56pt7b.h"
#include "NotoSans_MediumItalic57pt7b.h"
#include "NotoSans_MediumItalic58pt7b.h"
#include "NotoSans_MediumItalic59pt7b.h"
#include "NotoSans_MediumItalic60pt7b.h"
#include "NotoSans_MediumItalic61pt7b.h"
#include "NotoSans_MediumItalic62pt7b.h"
#include "NotoSans_MediumItalic63pt7b.h"
#include "NotoSans_MediumItalic64pt7b.h"
#include "NotoSans_MediumItalic65pt7b.h"
#include "NotoSans_MediumItalic66pt7b.h"
#include "NotoSans_MediumItalic67pt7b.h"
#include "NotoSans_MediumItalic68pt7b.h"
#include "NotoSans_MediumItalic69pt7b.h"
#include "NotoSans_MediumItalic70pt7b.h"
#include "NotoSans_MediumItalic71pt7b.h"
#include "NotoSans_MediumItalic72pt7b.h"
