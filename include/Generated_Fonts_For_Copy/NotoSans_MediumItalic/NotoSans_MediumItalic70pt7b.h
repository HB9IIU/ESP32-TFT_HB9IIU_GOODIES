#ifndef _NOTOSANS_MEDIUMITALIC70PT7B_H_
#define _NOTOSANS_MEDIUMITALIC70PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 70pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic70pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F,
  0xC0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFE, 0x3F, 0x83, 0xFC, 0x7F, 0x07, 0xF1,
  0xFC, 0x0F, 0xE3, 0xF8, 0x1F, 0xC7, 0xF0, 0x3F, 0x0F, 0xE0, 0x7E, 0x1F,
  0x81, 0xFC, 0x3F, 0x03, 0xF8, 0x7E, 0x07, 0xE1, 0xF8, 0x0F, 0xC3, 0xF0,
  0x1F, 0x87, 0xE0, 0x3E, 0x0F, 0xC0, 0x7C, 0x1F, 0x01, 0xF8, 0x3E, 0x03,
  0xE0, 0x7C, 0x07, 0xC1, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00,
  0x00, 0x03, 0xE0, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x07,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x1F, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xE0,
  0x0F, 0x80, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00,
  0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x07,
  0xC0, 0x00, 0x00, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x78, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xF9, 0xF0, 0xF8, 0x03, 0xFC, 0x3E, 0x03, 0x00, 0x7F, 0x07, 0xC0, 0x00,
  0x1F, 0xC0, 0xF0, 0x00, 0x03, 0xF8, 0x3E, 0x00, 0x00, 0x7F, 0x07, 0xC0,
  0x00, 0x0F, 0xE0, 0xF8, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x00, 0x3F, 0x83,
  0xC0, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x00, 0x7F, 0x9F, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0x01, 0xF3, 0xFE, 0x00, 0x00, 0x3E, 0x3F, 0xC0, 0x00,
  0x07, 0x83, 0xF8, 0x00, 0x01, 0xF0, 0x7F, 0x00, 0x00, 0x3E, 0x0F, 0xE0,
  0x00, 0x07, 0xC1, 0xFC, 0x00, 0x00, 0xF0, 0x3F, 0x80, 0x00, 0x1E, 0x07,
  0xF0, 0x80, 0x07, 0xC1, 0xFE, 0x18, 0x00, 0xF8, 0x7F, 0x83, 0xE0, 0x1F,
  0x1F, 0xF0, 0x7F, 0xE3, 0xDF, 0xFC, 0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7F,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x7F,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x3F, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x1C,
  0x07, 0xE0, 0x1F, 0x83, 0xF0, 0xFF, 0xC3, 0xF0, 0x0F, 0xC3, 0xF0, 0xFF,
  0xF9, 0xF8, 0x0F, 0xE3, 0xF8, 0xFF, 0xFC, 0xFE, 0x07, 0xE1, 0xF8, 0xFF,
  0xFF, 0x3F, 0x07, 0xE1, 0xF8, 0xFF, 0xFF, 0x9F, 0xFF, 0xF1, 0xF8, 0xFF,
  0x0F, 0xEF, 0xFF, 0xF1, 0xFC, 0x7F, 0x03, 0xF3, 0xFF, 0xF0, 0xFC, 0x7F,
  0x01, 0xF8, 0xFF, 0xF0, 0xFC, 0x3F, 0x00, 0xFC, 0x3F, 0xF0, 0xFC, 0x1F,
  0x80, 0x7E, 0x07, 0x80, 0xFE, 0x1F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x0F,
  0xC0, 0x1F, 0x80, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x03,
  0xF0, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x80,
  0x1F, 0x80, 0x7E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0,
  0x01, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0,
  0x00, 0x07, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x3F,
  0xE0, 0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x0F,
  0xF8, 0x00, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x07, 0xF0, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0x07, 0xFE, 0x7F,
  0x80, 0x0F, 0xE0, 0xFF, 0x87, 0xFC, 0x00, 0xFE, 0x1F, 0xF0, 0x3F, 0xC0,
  0x1F, 0xC3, 0xFE, 0x01, 0xFE, 0x03, 0xFC, 0x3F, 0xC0, 0x1F, 0xF0, 0x3F,
  0x87, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0xFF, 0x07,
  0xF0, 0x00, 0x3F, 0xCF, 0xE0, 0xFF, 0x00, 0x03, 0xFF, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xFF, 0xC0, 0xFF, 0x00, 0x00, 0xFF, 0xF8, 0x0F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF0, 0x00, 0x07,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0xE0, 0x07, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x7F, 0xE0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xEF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x3F, 0xE0, 0x0F,
  0xFF, 0xFF, 0xC1, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xF0, 0x01, 0xFF,
  0xFC, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC7, 0xF1,
  0xFC, 0xFE, 0x3F, 0x8F, 0xE3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC7, 0xE1, 0xF8,
  0x7E, 0x1F, 0x87, 0xC1, 0xF0, 0x7C, 0x3E, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x30, 0x01, 0xF0, 0x00, 0x7C, 0x01,
  0xF0, 0x00, 0x7F, 0x01, 0xF0, 0x00, 0x7F, 0xC1, 0xF0, 0x00, 0xFF, 0xF3,
  0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0xFF, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x03, 0xF8, 0xF8, 0x00, 0x07, 0xF8, 0xF8, 0x00, 0x0F, 0xF0,
  0xFC, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x3F, 0xE0, 0x7E, 0x00, 0x1F, 0xC0,
  0x7E, 0x00, 0x0F, 0x80, 0x7F, 0x00, 0x07, 0x00, 0x3F, 0x00, 0x03, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x07, 0xF8, 0x0F,
  0xF0, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x03, 0xFC, 0x07, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x01, 0xFC, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFE,
  0xFF, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x1F, 0x0F, 0xE7, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x07, 0xFC, 0x01, 0xFF,
  0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFF, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x3F,
  0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x1F, 0xE0, 0x00,
  0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x80, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x07, 0xF9, 0xFE, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00,
  0x1F, 0xE7, 0xF0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x9F,
  0xE0, 0x00, 0x1F, 0xE3, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x7F,
  0x87, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00,
  0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF8, 0x03,
  0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0xFF, 0xFF, 0x03, 0xFF, 0xFC, 0x1F, 0xFF,
  0xF8, 0x7F, 0xF7, 0xF3, 0xFF, 0xCF, 0xE7, 0xFE, 0x3F, 0xC7, 0xF8, 0x7F,
  0x07, 0xC0, 0xFE, 0x0F, 0x01, 0xFC, 0x08, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x3F, 0x00, 0x0F, 0xF8, 0x00, 0xE0, 0x00, 0x3F, 0xC0, 0x02, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xFF, 0xFC,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x03, 0xFE, 0x00, 0x3C, 0x00, 0x1F, 0xF0,
  0x03, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0x03, 0xFE, 0x0E, 0x00, 0x00, 0x7F,
  0xE0, 0xFC, 0x00, 0x1F, 0xFC, 0x0F, 0xFF, 0xBF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03, 0xFC,
  0xFC, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE1, 0xFC,
  0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x03,
  0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x1E, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFE, 0x08, 0x00, 0x00,
  0x7F, 0xC0, 0xE0, 0x00, 0x0F, 0xFC, 0x0F, 0x80, 0x03, 0xFF, 0x80, 0xFF,
  0xEF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0x00, 0x03, 0xFC,
  0x3F, 0xFC, 0x00, 0x7F, 0x0F, 0xFF, 0xC0, 0x0F, 0xE7, 0xFF, 0xFC, 0x01,
  0xFD, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xC3, 0xFF,
  0x81, 0xFF, 0xE0, 0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0xFF, 0x07, 0xFC, 0x00,
  0x1F, 0xE1, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xE0, 0x00, 0x3F, 0x87, 0xF8,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x03, 0xFF, 0x00,
  0x7F, 0xFB, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xE1, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xF8, 0x7F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7F, 0x80,
  0x7F, 0x80, 0x07, 0xF8, 0x3F, 0xE0, 0x00, 0x7F, 0xDF, 0xF8, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x7F, 0xE1, 0xFF, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x07, 0xFC, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x3F,
  0x87, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0xC0, 0x01, 0xFE, 0x07, 0xFC,
  0x00, 0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x07, 0xFC, 0x07, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC7, 0xF8, 0x00, 0x0F, 0xF1, 0xFC, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0,
  0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0xFF, 0x1F,
  0xC0, 0x00, 0x7F, 0xC7, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F, 0xF8,
  0x7F, 0x80, 0x03, 0xFE, 0x1F, 0xE0, 0x01, 0xFF, 0x87, 0xFC, 0x01, 0xFF,
  0xE0, 0xFF, 0xC1, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0x7F, 0x00, 0xFF, 0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xCF, 0xF0, 0x01, 0xFF,
  0xC3, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFF, 0x00, 0xC0, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF,
  0xF0, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0x00, 0x18, 0x00, 0xFE, 0x01, 0xFE, 0x03, 0xFF, 0x03,
  0xFF, 0x03, 0xFF, 0x03, 0xFE, 0x03, 0xFE, 0x03, 0xFC, 0x01, 0xF8, 0x00,
  0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x00, 0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xC0, 0xFF, 0xC0, 0xFF, 0x80, 0x7F, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0xC0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xF0, 0x01, 0xFF,
  0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x60, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE1,
  0xF8, 0x03, 0xFE, 0x1C, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x07, 0xFF, 0x80, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0xFF, 0xE0,
  0x7E, 0x0F, 0xC0, 0x07, 0xFF, 0xFF, 0x00, 0xFC, 0x7E, 0x00, 0x7F, 0xFF,
  0xFC, 0x03, 0xF1, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xCF, 0xC0, 0x1F,
  0xF0, 0x0F, 0xC0, 0x3F, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFD, 0xF8,
  0x03, 0xF8, 0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x1F, 0xC0, 0x07, 0xE0, 0x0F,
  0xDF, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0xFC, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0x0F, 0xC0, 0x0F, 0xFF, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x01, 0xFB, 0xF0, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xEF,
  0xC0, 0x7E, 0x00, 0x3F, 0x80, 0x1F, 0xBF, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF3, 0xF0, 0x1F, 0x80, 0x1F,
  0xC0, 0x1F, 0x8F, 0xC0, 0x7E, 0x00, 0xFF, 0x00, 0xFE, 0x3F, 0x01, 0xF8,
  0x03, 0xFC, 0x03, 0xF0, 0xFC, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xC3, 0xF0,
  0x1F, 0xF1, 0xF7, 0xF1, 0xFE, 0x0F, 0xC0, 0x3F, 0xFF, 0xCF, 0xFF, 0xF0,
  0x3F, 0x00, 0xFF, 0xFE, 0x3F, 0xFF, 0x80, 0x7E, 0x01, 0xFF, 0xF0, 0x7F,
  0xFC, 0x01, 0xF8, 0x01, 0xFF, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x70, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xF7, 0xE0,
  0x00, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0x1F, 0xE0,
  0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00, 0x07, 0xF1, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x3F, 0xFF, 0x00, 0x3F,
  0x80, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x07,
  0xFC, 0x03, 0xF8, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x1F, 0xC0, 0x00,
  0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xFC, 0x00, 0xFF, 0x00, 0x07, 0xFC, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0,
  0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x01, 0xFE,
  0x07, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0,
  0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFF,
  0x81, 0xFE, 0x00, 0x07, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFC, 0x00, 0xFC, 0x00, 0xFF, 0xE0, 0x00,
  0x38, 0x01, 0xFF, 0xC0, 0x00, 0x08, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x04, 0x00, 0x1F, 0xFE, 0x00, 0x7C,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xFF,
  0xC0, 0x01, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00, 0x1F, 0xF0, 0x03, 0xF8,
  0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00,
  0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x01, 0xFE,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x3F,
  0xC0, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0,
  0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x03, 0xFC,
  0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x81, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x7F, 0x00, 0x00, 0x1F, 0xF0, 0x3F, 0xC0, 0x00,
  0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x01, 0xFF,
  0x80, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0xE0, 0x1F,
  0xE0, 0x00, 0x7F, 0xF0, 0x07, 0xF8, 0x00, 0xFF, 0xF8, 0x01, 0xFC, 0x0F,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x0E, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x80, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x03, 0xFF, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x8F, 0xF0, 0x00,
  0x3F, 0xFF, 0xE3, 0xFC, 0x00, 0x0F, 0xFF, 0xF8, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0x3F, 0xC0, 0x01, 0xFF, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC3,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xFC,
  0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0xC0, 0x00, 0x0F, 0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xFE, 0x00,
  0x00, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xFE, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x80, 0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F,
  0xF8, 0x00, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xE0,
  0x00, 0x01, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00,
  0x01, 0xFC, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xC3, 0xFE, 0x00, 0x00, 0x03,
  0xFC, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x07, 0xFB, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0xFF, 0xF7, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x87, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x0F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x07, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0x3F, 0xBF, 0x80, 0x1F, 0xBF, 0x80, 0x00, 0x1F, 0x9F, 0xC0, 0x1F, 0xDF,
  0xC0, 0x00, 0x1F, 0xDF, 0xC0, 0x0F, 0xE7, 0xE0, 0x00, 0x0F, 0xCF, 0xE0,
  0x07, 0xF3, 0xF0, 0x00, 0x0F, 0xE7, 0xF0, 0x03, 0xF9, 0xF8, 0x00, 0x07,
  0xE3, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xF3, 0xFC, 0x01, 0xFC, 0x7E,
  0x00, 0x03, 0xF1, 0xFC, 0x00, 0xFE, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x7F, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x3F, 0x8F, 0xC0, 0x01, 0xFC,
  0x7F, 0x80, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC1, 0xF8,
  0x00, 0xFC, 0x1F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x7E, 0x00, 0x7E, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x00, 0x7F, 0x07,
  0xF8, 0x03, 0xF8, 0x1F, 0x80, 0x3F, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xC0,
  0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x07, 0xE0, 0x1F, 0x80, 0xFE, 0x00, 0x7F,
  0x03, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x81, 0xF8, 0x0F, 0xC0, 0x7F,
  0x80, 0x3F, 0x80, 0xFE, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x87, 0xF0, 0x0F, 0xE0, 0x07, 0xF0,
  0x0F, 0xC3, 0xF0, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xE3, 0xF8, 0x07, 0xF8,
  0x03, 0xF8, 0x03, 0xF3, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x01, 0xF9, 0xF8,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFD, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7E, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x0F, 0xFE, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x07, 0xFF, 0x00,
  0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x01,
  0xFF, 0x80, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFE, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0xFF, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFD, 0xFC, 0x00, 0x01, 0xFC, 0x00,
  0xFD, 0xFC, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0xFF, 0x00, 0x03, 0xF8, 0x01,
  0xFC, 0x7F, 0x00, 0x03, 0xF8, 0x01, 0xF8, 0x7F, 0x00, 0x07, 0xF0, 0x03,
  0xF8, 0x7F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x03,
  0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x03, 0xF8, 0x3F, 0xC0, 0x0F, 0xF0, 0x03,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0xE0, 0x07,
  0xF0, 0x0F, 0xE0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x0F,
  0xE0, 0x03, 0xF8, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x1F,
  0xC0, 0x03, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0x01, 0xFE, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0xFE, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7F,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x07,
  0xFC, 0x00, 0x00, 0x3F, 0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0x1F, 0xE1, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE3, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE3, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF7, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE7,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00,
  0x03, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x03,
  0xFC, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF8,
  0xFF, 0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80,
  0x00, 0x03, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00,
  0x07, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xE0, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xF0, 0x3F, 0xFF,
  0x00, 0x1F, 0xC0, 0x07, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x03, 0xFC,
  0x00, 0x1F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0xFE, 0x00, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0xFF, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x7F, 0xC0,
  0x7F, 0x80, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x07, 0xF0, 0x0F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00,
  0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x7F, 0xF0, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xFF, 0x00, 0x00,
  0x7F, 0xC0, 0x7F, 0xE0, 0x00, 0x03, 0xFC, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0xE0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE1,
  0xFF, 0x00, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE3, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE7, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x01, 0xFE,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xEF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x00, 0x07, 0xFC, 0x07, 0xFC,
  0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x80,
  0x07, 0xFF, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xFF,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE, 0x00,
  0x3F, 0xFF, 0xFF, 0xF0, 0x01, 0xFC, 0x07, 0xFF, 0xC0, 0x0F, 0xE0, 0x03,
  0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x3F,
  0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0xFF, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0xFF, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01,
  0xFF, 0x01, 0xFC, 0x00, 0x1F, 0xF0, 0x1F, 0xE0, 0x03, 0xFF, 0x00, 0xFF,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF,
  0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x03,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x7F,
  0x00, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x03, 0xFC, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x03,
  0xFC, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x01, 0x80, 0x1F, 0xF0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x80, 0x00, 0x07, 0xFC, 0x0E, 0x00, 0x01, 0xFF, 0x80, 0xFC, 0x00,
  0x7F, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xE7,
  0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xC0,
  0x7F, 0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00,
  0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0,
  0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x00, 0x7F, 0x80, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x07, 0xF0,
  0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x00,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0xC0, 0x0F,
  0xF0, 0x00, 0x0F, 0xF0, 0x01, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x1F, 0xF8,
  0x03, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x7F,
  0x00, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x03, 0xFE, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xFC, 0x7F, 0x00, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x00,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0x3F,
  0xC0, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x3F,
  0x80, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0,
  0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x0F, 0xE1,
  0xFE, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x00, 0x0F,
  0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x0F, 0xEF, 0xE0,
  0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xF8, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x1F,
  0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0xFC, 0x00, 0x1F, 0xE0, 0x7F, 0x00,
  0x07, 0xEF, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0xFE, 0xFC, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFC,
  0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xF8, 0x07,
  0xF0, 0x03, 0xF8, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x0F, 0xC0,
  0x0F, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x7F, 0x0F, 0xC0, 0x1F, 0xE0, 0x07, 0xF0, 0x0F, 0xE0, 0xFC, 0x01, 0xFC,
  0x00, 0x7F, 0x00, 0xFE, 0x0F, 0xE0, 0x3F, 0xC0, 0x07, 0xF0, 0x1F, 0xC0,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x0F, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x1F, 0x80, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0x7F, 0x07,
  0xF0, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x7E, 0x1F, 0xE0,
  0x00, 0x7F, 0x0F, 0xE0, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF8, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x7F, 0x1F, 0x80, 0x07, 0xE3,
  0xF0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x3F, 0x3F,
  0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x7E, 0xFE, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x7F,
  0xC0, 0x00, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x8F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0xC0,
  0x00, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x1F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8,
  0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x03, 0xFC,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xFB,
  0xF8, 0x00, 0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x07, 0xFC, 0xFF, 0x00, 0x00,
  0x3F, 0xC3, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0xFE,
  0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x01, 0xFE,
  0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x07, 0xF0, 0x07, 0xF8, 0x00,
  0x3F, 0x80, 0x7F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x3F,
  0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x0F,
  0xE1, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0xFF, 0x00,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xF0, 0x1F, 0xC0, 0x7F,
  0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x0F, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x03,
  0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00,
  0x01, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x0F, 0xC7, 0xE0,
  0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x7F, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x00, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0x07,
  0xF8, 0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x0F, 0xE0, 0x3F, 0x01, 0xFC, 0x07,
  0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x00, 0x07, 0xFE, 0x03, 0xF0, 0x01,
  0xFF, 0xF0, 0x3F, 0x00, 0x3F, 0xFF, 0xC7, 0xF0, 0x07, 0xFF, 0xFC, 0x7E,
  0x00, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0x01,
  0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0xC0, 0xFF,
  0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0x07, 0xFC,
  0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0xC0,
  0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x7F, 0x80, 0x3F,
  0xFC, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFB, 0xFD, 0xF8, 0x03, 0xFF,
  0xFF, 0x9F, 0x80, 0x3F, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xFE, 0x3F, 0x80,
  0x0F, 0xFF, 0xC3, 0xF0, 0x00, 0x3F, 0xF0, 0x3F, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x01, 0xFE, 0x1F, 0xFE, 0x00, 0x1F, 0xC3, 0xFF, 0xF0, 0x01,
  0xFC, 0xFF, 0xFF, 0x80, 0x1F, 0xDF, 0xFF, 0xFC, 0x01, 0xFD, 0xFF, 0xFF,
  0xC0, 0x3F, 0xBE, 0x03, 0xFE, 0x03, 0xFF, 0xC0, 0x1F, 0xE0, 0x3F, 0xF8,
  0x01, 0xFE, 0x03, 0xFF, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0xFE, 0x07,
  0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0xFF, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x3F, 0xC1, 0xFC, 0x00,
  0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x3F, 0xE0, 0x01, 0xFE,
  0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x7F, 0xF8, 0x0F, 0xFC, 0x07, 0xFF, 0xE7,
  0xFF, 0x80, 0x7E, 0xFF, 0xFF, 0xF8, 0x0F, 0xE7, 0xFF, 0xFF, 0x00, 0xFC,
  0x3F, 0xFF, 0xC0, 0x0F, 0xC1, 0xFF, 0xF8, 0x00, 0xFC, 0x0F, 0xFE, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x08, 0x0F, 0xF8, 0x01, 0xE0, 0x3F, 0xFC, 0x7F, 0x80, 0x7F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFF,
  0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x07, 0xF0, 0x00, 0x7F, 0xFF, 0x1F, 0xE0,
  0x01, 0xFF, 0xFF, 0x3F, 0x80, 0x07, 0xFF, 0xFF, 0x7F, 0x00, 0x1F, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x01, 0xFF, 0x80, 0x3F, 0xF0,
  0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x1F, 0xE0,
  0x00, 0xFF, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x01, 0xFC,
  0x03, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xF0,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x1F,
  0xF0, 0x07, 0xF8, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0xC0, 0x0F,
  0xF0, 0x07, 0xFF, 0x80, 0x1F, 0xF0, 0x1F, 0xFE, 0x00, 0x3F, 0xFD, 0xFE,
  0xFC, 0x00, 0x3F, 0xFF, 0xF9, 0xF8, 0x00, 0x7F, 0xFF, 0xE3, 0xF0, 0x00,
  0x7F, 0xFF, 0x8F, 0xE0, 0x00, 0x7F, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0xF0,
  0x3F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFD, 0xFF, 0xC0, 0xFF, 0xC0, 0x7F, 0x83,
  0xFE, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x03, 0xF8, 0xFF, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x7F, 0x8F, 0xE0, 0x03, 0xFF, 0x1F, 0xC0, 0x1F, 0xFC, 0x7F, 0xBF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xFF, 0x03, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x10, 0x1F, 0xF0, 0x01, 0xE0,
  0x3F, 0xF8, 0x1F, 0xC0, 0x3F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00, 0x00, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE,
  0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x03, 0xFF, 0xBC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF,
  0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0xC7, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0xFE, 0x0F, 0xC0, 0x07, 0xFF, 0xF8,
  0xFE, 0x00, 0x7F, 0xFF, 0xC7, 0xE0, 0x07, 0xFF, 0xFF, 0x3F, 0x00, 0x7F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xE0, 0x0F, 0xFE,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x01, 0xFF, 0x01, 0xFE, 0x00,
  0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF8,
  0x3F, 0xC0, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x0F, 0xF8, 0x1F,
  0xE0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x07, 0xFC, 0x07, 0xF8, 0x00, 0x7F,
  0xE0, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0xFF, 0x00, 0x7F, 0xF8, 0x07, 0xFC,
  0x07, 0xFF, 0x80, 0x3F, 0xFD, 0xFD, 0xFC, 0x00, 0xFF, 0xFF, 0xEF, 0xE0,
  0x07, 0xFF, 0xFE, 0x7F, 0x00, 0x1F, 0xFF, 0xC7, 0xF8, 0x00, 0x7F, 0xFC,
  0x3F, 0x80, 0x00, 0xFF, 0xC1, 0xFC, 0x00, 0x00, 0xE0, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x02, 0x00, 0x00, 0xFF, 0x00,
  0x1C, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0x07, 0xFF, 0x80, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xE0,
  0x01, 0xFE, 0x1F, 0xFF, 0x00, 0x3F, 0x87, 0xFF, 0xF0, 0x07, 0xF1, 0xFF,
  0xFF, 0x00, 0xFE, 0xFF, 0xFF, 0xE0, 0x1F, 0xDF, 0xFF, 0xFE, 0x07, 0xF7,
  0xE0, 0x7F, 0xC0, 0xFF, 0xF0, 0x07, 0xF8, 0x1F, 0xFC, 0x00, 0xFF, 0x03,
  0xFF, 0x00, 0x0F, 0xE0, 0x7F, 0xC0, 0x01, 0xFC, 0x1F, 0xF8, 0x00, 0x3F,
  0x83, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xF0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00,
  0x7F, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0,
  0x00, 0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00,
  0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0x00, 0x07, 0xE0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF0, 0x03, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0,
  0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE,
  0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00,
  0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x03,
  0x0F, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x1F,
  0xC0, 0x1F, 0xE0, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC1,
  0xFE, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFE, 0x00, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x3F, 0x9F, 0xE0,
  0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xDF, 0xE0, 0x00, 0x0F, 0xFC, 0xFF, 0x00, 0x00, 0x7F, 0xC3,
  0xF8, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0xFF, 0x00, 0x01,
  0xFE, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xF0,
  0x07, 0xF8, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8,
  0x01, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xC0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07,
  0xF0, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x07, 0xFC,
  0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x1F, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xF8,
  0x7F, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xF8, 0xFF, 0xFF, 0x83, 0xFF, 0xFE,
  0x01, 0xF9, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x01, 0xFB, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0x03, 0xFB, 0xF0, 0x3F, 0xDF, 0x81, 0xFF, 0x03, 0xFF, 0xC0,
  0x3F, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0xFF, 0x03,
  0xFF, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00,
  0x7F, 0x07, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x07, 0xFC, 0x00, 0x1F,
  0xE0, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE,
  0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x01, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF,
  0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x01, 0xFE, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x00, 0x40, 0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xFC, 0x00,
  0xFE, 0x3F, 0xFF, 0xC0, 0x1F, 0x8F, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFF,
  0x80, 0xFE, 0xFF, 0xFF, 0xF8, 0x1F, 0xDF, 0x81, 0xFF, 0x03, 0xFF, 0xE0,
  0x1F, 0xE0, 0x7F, 0xF0, 0x03, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0x83, 0xFF,
  0x00, 0x07, 0xF0, 0x7F, 0xE0, 0x00, 0xFE, 0x0F, 0xF8, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x87, 0xF8,
  0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x87,
  0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x3F,
  0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00,
  0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xE0,
  0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x0F,
  0xF8, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8,
  0x7F, 0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x0F,
  0xF3, 0xF8, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00,
  0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x03, 0xF9, 0xFC, 0x00,
  0x00, 0xFE, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x1F, 0xEF, 0xF0,
  0x00, 0x07, 0xFB, 0xFC, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0xFF, 0x3F,
  0xC0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x07, 0xF8,
  0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x01, 0xFF, 0x07, 0xFC, 0x00, 0xFF,
  0x80, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xFD, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x0F, 0x81, 0xFF, 0xE0, 0x00, 0x1F, 0x87,
  0xFF, 0xF0, 0x00, 0x1F, 0x8F, 0xFF, 0xF8, 0x00, 0x1F, 0x9F, 0xFF, 0xFC,
  0x00, 0x1F, 0xBF, 0xFF, 0xFC, 0x00, 0x3F, 0xBE, 0x03, 0xFE, 0x00, 0x3F,
  0xFC, 0x01, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x01, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00,
  0x07, 0xF8, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x03, 0xFE, 0x00, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xFF,
  0x80, 0xFF, 0xC0, 0x07, 0xFF, 0xE7, 0xFF, 0x80, 0x07, 0xF7, 0xFF, 0xFF,
  0x80, 0x07, 0xF7, 0xFF, 0xFF, 0x00, 0x0F, 0xE3, 0xFF, 0xFC, 0x00, 0x0F,
  0xE1, 0xFF, 0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0xE0, 0x00, 0x0F, 0xE0, 0x1E,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xFE, 0x03, 0xF0, 0x01, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0xC3, 0xF0,
  0x07, 0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0x01, 0xFF, 0xE0, 0x7F, 0xE0, 0x0F, 0xFE, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0xFF, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0xC1,
  0xFE, 0x00, 0x07, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x07, 0xF8, 0x7F, 0x80,
  0x00, 0x7F, 0x87, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x0F,
  0xF0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0xFF, 0x00, 0x0F, 0xFC, 0x07, 0xF0, 0x01, 0xFF,
  0xC0, 0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xFB,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xBF, 0x80, 0x3F, 0xFF, 0xF3, 0xF8, 0x01,
  0xFF, 0xFE, 0x7F, 0x80, 0x0F, 0xFF, 0x87, 0xF0, 0x00, 0x3F, 0xF0, 0x7F,
  0x00, 0x00, 0x78, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0,
  0xFF, 0x80, 0x7F, 0x1F, 0xFC, 0x03, 0xF1, 0xFF, 0xE0, 0x1F, 0x9F, 0xFF,
  0x00, 0xFC, 0xFF, 0xF0, 0x0F, 0xEF, 0xFB, 0x80, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0x7F, 0xC0, 0x7F,
  0xC0, 0x0F, 0x01, 0xFE, 0x00, 0x0C, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFF, 0x0C, 0x00, 0x03, 0xFC, 0x3C, 0x00, 0x1F, 0xE0,
  0xFF, 0x03, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x7F, 0x80, 0x00, 0x7F, 0xE3, 0x80, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x80,
  0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x70, 0x00,
  0x07, 0xF8, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x1F, 0xE0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F,
  0xE0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00,
  0xFE, 0x0F, 0xF0, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC,
  0x1F, 0xC0, 0x00, 0x7F, 0x87, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03,
  0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x83, 0xF8, 0x00, 0x1F, 0xF0, 0x7F, 0x00,
  0x07, 0xFC, 0x0F, 0xE0, 0x01, 0xFF, 0x81, 0xFC, 0x00, 0x7F, 0xF0, 0x3F,
  0xC0, 0x1F, 0xFE, 0x07, 0xF8, 0x07, 0xDF, 0xC0, 0xFF, 0xEF, 0xFB, 0xF0,
  0x0F, 0xFF, 0xFE, 0x7E, 0x01, 0xFF, 0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0xE1,
  0xF8, 0x01, 0xFF, 0xF0, 0x3F, 0x00, 0x1F, 0xFC, 0x0F, 0xC0, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x0F, 0xF7,
  0xF0, 0x00, 0x07, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFF,
  0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xE1, 0xFC, 0x00, 0x0F,
  0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x0F, 0xF0, 0x0F, 0xE0,
  0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x0F, 0xE0, 0x1F, 0xE0, 0x01, 0xF8, 0x07, 0xF0, 0x00,
  0x7F, 0x03, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80,
  0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F, 0xC3, 0xF8,
  0x00, 0x07, 0xF1, 0xFE, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x3F,
  0x80, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x07,
  0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0xFF, 0x7F, 0x00, 0x07, 0xFC, 0x00, 0x1F, 0xCF, 0xE0,
  0x01, 0xFF, 0x80, 0x07, 0xF9, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0xFE, 0x3F,
  0x80, 0x0F, 0xFE, 0x00, 0x3F, 0xC7, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xF8,
  0xFE, 0x00, 0x7E, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xDF, 0x80, 0x3F,
  0xC1, 0xF8, 0x03, 0xF3, 0xF0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x7E, 0x01,
  0xFE, 0x07, 0xE0, 0x0F, 0xCF, 0xC0, 0x3F, 0x80, 0xFC, 0x03, 0xF1, 0xF8,
  0x0F, 0xF0, 0x1F, 0x80, 0x7E, 0x3F, 0x01, 0xFC, 0x03, 0xF0, 0x1F, 0x87,
  0xE0, 0x7F, 0x80, 0x7E, 0x03, 0xF0, 0xFC, 0x0F, 0xE0, 0x0F, 0xE0, 0xFC,
  0x1F, 0x81, 0xFC, 0x01, 0xFC, 0x1F, 0x83, 0xF0, 0x7F, 0x00, 0x3F, 0x87,
  0xF0, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0xFC, 0x0F, 0xC3, 0xF8, 0x00, 0xFE,
  0x3F, 0x81, 0xF8, 0x7F, 0x00, 0x1F, 0xC7, 0xE0, 0x3F, 0x1F, 0xE0, 0x03,
  0xF8, 0xFC, 0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0xFC, 0x7F, 0x00,
  0x0F, 0xE7, 0xE0, 0x1F, 0x9F, 0xC0, 0x01, 0xFD, 0xF8, 0x03, 0xF3, 0xF8,
  0x00, 0x3F, 0xBF, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xC0, 0x0F, 0xDF,
  0xC0, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x00, 0x1F, 0xBF, 0x00, 0x3F,
  0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0x3F, 0xC0, 0x0F,
  0xF8, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0xFF, 0x00, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x07, 0xF9, 0xFE, 0x00,
  0x00, 0x03, 0xFB, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x00, 0xFF, 0x07, 0xF8,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFC, 0x00, 0x03,
  0xFC, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01,
  0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0x00,
  0x7F, 0xC0, 0x00, 0x7F, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00,
  0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x01, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x1F,
  0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00,
  0x03, 0xF9, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x83, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFC,
  0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F,
  0xF8, 0x00, 0x3F, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00,
  0x3F, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x8F, 0xFE, 0x00, 0x00,
  0x5F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFE, 0xC0, 0x00, 0xFF, 0xFC, 0x40, 0x00, 0x0F, 0xF8, 0x00,
};

const GFXglyph NotoSans_MediumItalic70pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 19, 51, 19, 1, -50 },
  { 123, 23, 18, 29, 7, -50 },
  { 175, 44, 50, 45, 2, -50 },
  { 450, 35, 57, 39, 2, -53 },
  { 700, 49, 52, 57, 5, -51 },
  { 1019, 44, 52, 48, 2, -51 },
  { 1305, 10, 18, 16, 7, -50 },
  { 1328, 24, 61, 21, 3, -50 },
  { 1511, 24, 61, 21, -5, -50 },
  { 1694, 32, 32, 38, 7, -53 },
  { 1822, 33, 34, 40, 5, -42 },
  { 1963, 15, 17, 19, -3, -8 },
  { 1995, 18, 7, 22, 2, -22 },
  { 2011, 10, 10, 19, 1, -9 },
  { 2024, 35, 50, 26, -3, -50 },
  { 2243, 35, 52, 39, 3, -51 },
  { 2471, 23, 50, 39, 9, -50 },
  { 2615, 37, 51, 39, 0, -51 },
  { 2851, 36, 52, 39, 1, -51 },
  { 3085, 37, 50, 39, 0, -50 },
  { 3317, 36, 51, 39, 2, -50 },
  { 3547, 35, 52, 39, 4, -51 },
  { 3775, 35, 50, 39, 5, -50 },
  { 3994, 35, 52, 39, 3, -51 },
  { 4222, 34, 52, 39, 3, -51 },
  { 4443, 16, 40, 19, 1, -39 },
  { 4523, 21, 48, 19, -4, -39 },
  { 4649, 33, 35, 40, 5, -43 },
  { 4794, 32, 19, 40, 5, -34 },
  { 4870, 33, 35, 40, 5, -43 },
  { 5015, 28, 52, 31, 5, -51 },
  { 5197, 54, 56, 60, 4, -50 },
  { 5575, 41, 50, 41, -4, -50 },
  { 5832, 39, 50, 42, 3, -50 },
  { 6076, 40, 52, 42, 5, -51 },
  { 6336, 42, 50, 47, 3, -50 },
  { 6599, 36, 50, 37, 3, -50 },
  { 6824, 36, 50, 35, 3, -50 },
  { 7049, 42, 52, 48, 5, -51 },
  { 7322, 45, 50, 48, 3, -50 },
  { 7604, 30, 50, 24, -2, -50 },
  { 7792, 32, 64, 20, -11, -50 },
  { 8048, 44, 50, 40, 3, -50 },
  { 8323, 27, 50, 34, 3, -50 },
  { 8492, 57, 50, 60, 3, -50 },
  { 8849, 48, 50, 51, 3, -50 },
  { 9149, 44, 52, 51, 5, -51 },
  { 9435, 38, 50, 41, 3, -50 },
  { 9673, 44, 63, 51, 5, -51 },
  { 10020, 37, 50, 41, 3, -50 },
  { 10252, 36, 52, 36, 1, -51 },
  { 10486, 36, 50, 36, 6, -50 },
  { 10711, 43, 51, 48, 5, -50 },
  { 10986, 40, 50, 39, 6, -50 },
  { 11236, 60, 50, 61, 7, -50 },
  { 11611, 48, 50, 39, -4, -50 },
  { 11911, 37, 50, 37, 6, -50 },
  { 12143, 41, 50, 37, -1, -50 },
  { 12400, 28, 61, 21, -1, -50 },
  { 12614, 14, 50, 26, 8, -50 },
  { 12702, 27, 61, 21, -5, -50 },
  { 12908, 35, 32, 40, 2, -50 },
  { 13048, 28, 5, 28, -6, 6 },
  { 13066, 13, 12, 20, 10, -54 },
  { 13086, 36, 39, 40, 3, -38 },
  { 13262, 36, 54, 41, 2, -53 },
  { 13505, 30, 39, 32, 3, -38 },
  { 13652, 39, 54, 41, 3, -53 },
  { 13916, 31, 39, 36, 3, -38 },
  { 14068, 40, 71, 23, -8, -54 },
  { 14423, 37, 55, 41, 2, -38 },
  { 14678, 35, 53, 41, 2, -53 },
  { 14910, 18, 52, 19, 2, -52 },
  { 15027, 29, 69, 19, -9, -52 },
  { 15278, 37, 53, 36, 2, -53 },
  { 15524, 18, 53, 19, 2, -53 },
  { 15644, 56, 38, 62, 2, -38 },
  { 15910, 35, 39, 41, 2, -39 },
  { 16081, 34, 39, 40, 3, -38 },
  { 16247, 40, 55, 41, -2, -38 },
  { 16522, 36, 55, 41, 3, -38 },
  { 16770, 29, 38, 28, 2, -38 },
  { 16908, 30, 39, 31, 0, -38 },
  { 17055, 24, 47, 25, 3, -46 },
  { 17196, 35, 39, 41, 4, -38 },
  { 17367, 34, 38, 34, 3, -38 },
  { 17529, 51, 38, 52, 4, -38 },
  { 17772, 40, 38, 35, -3, -38 },
  { 17962, 43, 55, 34, -6, -38 },
  { 18258, 33, 38, 32, -1, -38 },
  { 18415, 27, 61, 25, 1, -50 },
  { 18621, 6, 70, 39, 17, -53 },
  { 18674, 27, 61, 25, -3, -50 },
  { 18880, 33, 10, 40, 5, -30 },
};

const GFXfont NotoSans_MediumItalic70pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic70pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic70pt7bGlyphs,
  0x20, 0x7E, 95
};

#endif // _NOTOSANS_MEDIUMITALIC70PT7B_H_
