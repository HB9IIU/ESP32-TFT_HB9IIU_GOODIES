#ifndef _NOTOSANS_MEDIUMITALIC56PT7B_H_
#define _NOTOSANS_MEDIUMITALIC56PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 56pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic56pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x7C, 0x01, 0xFC, 0x07, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0x00, 0x38, 0x00, 0x3F, 0x0F, 0xCF, 0x83, 0xF3, 0xE0,
  0xF9, 0xF8, 0x7E, 0x7E, 0x1F, 0x9F, 0x07, 0xC7, 0xC1, 0xF1, 0xF0, 0x7C,
  0x78, 0x1F, 0x1E, 0x07, 0x8F, 0x83, 0xE3, 0xE0, 0xF8, 0xF0, 0x3C, 0x3C,
  0x0F, 0x00, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0x80, 0x00,
  0x0F, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x3E, 0x00, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0xF0, 0x00, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x3C,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFE,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0xF8, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF8,
  0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x78,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x03, 0xF9, 0xE3, 0xC0,
  0x7E, 0x1E, 0x04, 0x07, 0xE1, 0xC0, 0x00, 0x7C, 0x3C, 0x00, 0x0F, 0xC3,
  0xC0, 0x00, 0xFC, 0x3C, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x7E, 0x38, 0x00,
  0x07, 0xF7, 0x80, 0x00, 0x7F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x0E, 0x7F, 0x00, 0x01, 0xE3, 0xF0, 0x00,
  0x1E, 0x1F, 0x80, 0x01, 0xE1, 0xF8, 0x00, 0x1E, 0x1F, 0x80, 0x01, 0xC1,
  0xF0, 0x00, 0x3C, 0x3F, 0x08, 0x03, 0xC3, 0xF0, 0xF0, 0x3C, 0xFE, 0x0F,
  0xFB, 0xFF, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xE0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF0,
  0x1F, 0xFC, 0x00, 0x07, 0xC0, 0x7F, 0xFC, 0x00, 0x1F, 0x01, 0xFF, 0xF8,
  0x00, 0x7C, 0x03, 0xF1, 0xF8, 0x00, 0xF8, 0x0F, 0xC1, 0xF0, 0x03, 0xE0,
  0x1F, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3E, 0x00, 0xF8, 0x0F,
  0x80, 0x7C, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x03, 0xE0, 0x3E, 0x07, 0xC0,
  0x0F, 0x80, 0x7C, 0x1F, 0x00, 0x1F, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x03,
  0xE0, 0xF8, 0x00, 0x7C, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x0F, 0x87, 0xC0,
  0x81, 0xF0, 0x3E, 0x1F, 0x1F, 0xE3, 0xE0, 0x7C, 0x7C, 0x7F, 0xF7, 0xC1,
  0xF1, 0xF1, 0xFF, 0xEF, 0xC7, 0xE3, 0xE7, 0xFF, 0xEF, 0xFF, 0x8F, 0x9F,
  0x87, 0xDF, 0xFE, 0x3E, 0x3E, 0x0F, 0x9F, 0xF8, 0xF8, 0xF8, 0x1F, 0x1F,
  0xE1, 0xF1, 0xF0, 0x3E, 0x04, 0x07, 0xC3, 0xE0, 0x7C, 0x00, 0x1F, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x3E, 0x03, 0xE0,
  0x03, 0xE0, 0x7C, 0x07, 0xC0, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x3E, 0x01,
  0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x01, 0xF0, 0x0F, 0x80, 0xF8,
  0x07, 0xC0, 0x0F, 0x03, 0xE0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x3E, 0x00,
  0x3E, 0x1F, 0x00, 0xF8, 0x00, 0x7F, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0xF8,
  0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x7C, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00,
  0x01, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE3, 0xFC,
  0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x0F, 0xC3, 0xFF, 0xF8, 0x01, 0xF8, 0xFF, 0x3F, 0x80, 0x7E,
  0x3F, 0x83, 0xF8, 0x0F, 0xCF, 0xE0, 0x3F, 0x03, 0xF1, 0xF8, 0x07, 0xF0,
  0xFC, 0x7F, 0x00, 0x7F, 0x1F, 0x8F, 0xC0, 0x07, 0xE7, 0xE1, 0xF8, 0x00,
  0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0xFF, 0x07, 0xE0, 0x00, 0xFF, 0xC0, 0xFC,
  0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0xFF, 0xC0,
  0x7F, 0x80, 0x3F, 0xFC, 0x07, 0xFE, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFB,
  0xF8, 0x0F, 0xFF, 0xFE, 0x3F, 0x80, 0xFF, 0xFF, 0x03, 0xF0, 0x07, 0xFF,
  0x80, 0x7F, 0x80, 0x04, 0x00, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x7E, 0x7E,
  0x7C, 0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0,
  0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x00, 0x08,
  0x03, 0xE0, 0x01, 0xC0, 0x7C, 0x00, 0x7E, 0x0F, 0x00, 0x0F, 0xF9, 0xE0,
  0x03, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x07, 0xF8, 0x3E, 0x01, 0xF7, 0x80,
  0x00, 0x7E, 0xF0, 0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE1, 0xE0, 0x01, 0xF8,
  0x3E, 0x00, 0x7F, 0x07, 0xC0, 0x03, 0xC0, 0xFC, 0x00, 0x30, 0x0F, 0x80,
  0x02, 0x01, 0xF8, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xE0, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07,
  0xE1, 0xF8, 0x3E, 0x07, 0xC1, 0xF0, 0x3E, 0x0F, 0x81, 0xE0, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xE7, 0xFF, 0xDF, 0xFF, 0x80, 0x3E,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x38, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xC0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xF8, 0x07, 0xFE, 0xFF, 0x80, 0xFE, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x0F,
  0xE0, 0x0F, 0xE1, 0xF8, 0x00, 0xFC, 0x7F, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFB, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x1F,
  0xBF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF8, 0x00, 0x1F, 0xBF, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x03, 0xFB,
  0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF9, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F,
  0xC0, 0x1F, 0xC1, 0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x07, 0xFD, 0xFF,
  0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFC, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x7F, 0xE0, 0x3F, 0xFC, 0x0F, 0xFF, 0x07, 0xFF, 0xE1, 0xFF,
  0xFC, 0xFF, 0x9F, 0x8F, 0xE3, 0xF1, 0xF0, 0xFC, 0x1C, 0x1F, 0x82, 0x03,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x3F, 0x80, 0x3C, 0x00, 0x7E, 0x00,
  0x60, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC3,
  0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0x60, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0x9F,
  0xF8, 0x07, 0xC0, 0x1F, 0xC0, 0x18, 0x00, 0x7E, 0x00, 0x80, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0xFF, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x1F, 0xE1, 0xE0, 0x01,
  0xFE, 0x0F, 0xF8, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0x3F, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x07, 0xC7,
  0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC1, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x00, 0xF8, 0x00,
  0x7C, 0x07, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFB, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7F, 0x08, 0x00, 0x0F, 0xF0, 0xE0, 0x01, 0xFE, 0x0F, 0xE1, 0xFF, 0xC0,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1F,
  0xFF, 0x00, 0x07, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0x9E, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x3F, 0x0F, 0xF0, 0x03, 0xF3, 0xFF, 0xC0, 0x3E, 0x7F, 0xFE,
  0x07, 0xEF, 0xFF, 0xF0, 0x7F, 0xF9, 0xFF, 0x07, 0xFC, 0x03, 0xF8, 0x7F,
  0x80, 0x3F, 0x87, 0xF0, 0x01, 0xF8, 0xFE, 0x00, 0x1F, 0x8F, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F,
  0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00,
  0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xF0, 0x1F, 0xC0,
  0x3F, 0xC7, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xF3, 0xFF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00,
  0xFF, 0x07, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x7E, 0x03, 0xF0,
  0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x7C, 0x07, 0xE0, 0x07,
  0xE0, 0x3F, 0x00, 0x3F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x01, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0xFF, 0xF0, 0x01, 0xFE, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x01,
  0xFC, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xF8, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0,
  0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xC0,
  0x00, 0x00, 0x00, 0x01, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0x3F, 0xE0, 0xFE, 0x03,
  0xF8, 0x7F, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF0,
  0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xF3, 0xF0, 0x01, 0xFC, 0xFC, 0x00, 0xFF, 0x3F, 0x80, 0x7F, 0xC7, 0xF8,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0x7E, 0x07, 0xFF, 0x9F, 0x80,
  0xFF, 0x87, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x02, 0x00, 0x7F, 0xC0, 0xF9,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x00,
  0xFF, 0xF8, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x3F, 0x07, 0xF0,
  0x7F, 0x0F, 0xF0, 0xFF, 0x07, 0xE0, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x07, 0xF0, 0xFF, 0x0F,
  0xF0, 0xFF, 0x0F, 0xE0, 0xFE, 0x03, 0x80, 0x00, 0x1E, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x40, 0x00, 0x00, 0x70, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00,
  0x00, 0x38, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F,
  0xF8, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x01, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x07, 0xFF, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00, 0x0F, 0xFE, 0x01, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFC, 0x3F, 0xFF, 0xF8, 0xFF, 0xBF, 0xE1, 0xC0, 0x1F,
  0xC4, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x01,
  0xFF, 0x80, 0x7F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x3F, 0x80,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xF8, 0x1F, 0x00, 0x00, 0x00, 0x1F,
  0x07, 0xC0, 0x03, 0xFE, 0x01, 0xF1, 0xF8, 0x03, 0xFF, 0xF8, 0x3E, 0x3E,
  0x01, 0xFF, 0xFE, 0x07, 0xCF, 0x80, 0x7F, 0xFF, 0xC0, 0x79, 0xF0, 0x1F,
  0xC0, 0xF8, 0x0F, 0x3C, 0x07, 0xE0, 0x1F, 0x01, 0xEF, 0x80, 0xF8, 0x07,
  0xC0, 0x3D, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xBC, 0x07, 0xC0, 0x1F, 0x00,
  0xFF, 0x81, 0xF0, 0x03, 0xE0, 0x3F, 0xF0, 0x3E, 0x00, 0xF8, 0x07, 0xFE,
  0x07, 0xC0, 0x1F, 0x00, 0xFF, 0xC0, 0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0x3E,
  0x00, 0xFC, 0x07, 0xDF, 0x07, 0xC0, 0x1F, 0x00, 0xFB, 0xE0, 0xF8, 0x07,
  0xE0, 0x3E, 0x7C, 0x1F, 0x00, 0xFC, 0x07, 0xCF, 0x81, 0xF0, 0x3F, 0x81,
  0xF1, 0xF0, 0x3E, 0x0F, 0xF8, 0x7E, 0x3E, 0x07, 0xFF, 0xDF, 0xFF, 0x87,
  0xC0, 0x7F, 0xF1, 0xFF, 0xE0, 0x7C, 0x07, 0xFC, 0x1F, 0xF8, 0x0F, 0x80,
  0x7F, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x70, 0x00,
  0x07, 0xFF, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0xFD, 0xF0,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x3F, 0x1F, 0x00, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x00, 0x03, 0xF0,
  0x0F, 0x80, 0x03, 0xF0, 0x07, 0xC0, 0x01, 0xF8, 0x03, 0xE0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x3F,
  0x00, 0x03, 0xE0, 0x3F, 0x80, 0x01, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x7F, 0xC0,
  0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0,
  0x01, 0xFC, 0x07, 0xE0, 0x1F, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xF0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFC,
  0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x3F, 0xC1,
  0xF8, 0x01, 0xFF, 0x83, 0xFF, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00,
  0x00, 0x04, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0x80, 0x3C, 0x03, 0xFE, 0x00, 0x04, 0x07, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xE0, 0x07, 0x00, 0x1F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x02, 0x80, 0x00, 0x00,
  0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x01, 0xFF,
  0x80, 0x1F, 0x80, 0x1F, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x1F, 0xC1,
  0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01,
  0xF8, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0xFC,
  0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x0F, 0xF0, 0x1F, 0x80, 0x0F, 0xF8, 0x07,
  0xE0, 0x1F, 0xFC, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x7C, 0x07, 0xFC, 0x00, 0x04,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x07,
  0xFF, 0xCF, 0xE0, 0x03, 0xFF, 0xE7, 0xE0, 0x03, 0xFF, 0xF3, 0xF0, 0x01,
  0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xFC, 0xFC, 0x00, 0x7F, 0xFC, 0x7E, 0x00,
  0x00, 0x7E, 0x3F, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x03, 0xF0, 0x7F, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x01, 0xF8, 0x0F,
  0xF0, 0x00, 0xFC, 0x07, 0xFC, 0x00, 0x7E, 0x01, 0xFF, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01,
  0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x3F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x80, 0x07, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x7F, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x30,
  0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xF8, 0x00,
  0x3F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0,
  0x1F, 0x80, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F,
  0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3E,
  0x03, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00,
  0x3F, 0x0F, 0xF0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00, 0xFD, 0xFC,
  0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFC, 0xFC, 0x00, 0x00,
  0x7F, 0x1F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x03, 0xF0, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x01,
  0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x03, 0xF8, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x0F, 0xF8, 0x00, 0x00, 0xFF, 0x80, 0x3F, 0xE0,
  0x00, 0x07, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x07, 0xFE, 0x00,
  0x00, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x7D, 0xE0, 0x00,
  0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x0F, 0xDF, 0x00, 0x03,
  0xEF, 0xC0, 0x3F, 0x7C, 0x00, 0x0F, 0xBF, 0x00, 0xF9, 0xF0, 0x00, 0x7C,
  0xFC, 0x03, 0xE7, 0xC0, 0x03, 0xF3, 0xE0, 0x0F, 0x9F, 0x00, 0x0F, 0x9F,
  0x80, 0x7E, 0x7C, 0x00, 0x7E, 0x7E, 0x01, 0xF9, 0xF0, 0x01, 0xF1, 0xF8,
  0x07, 0xE7, 0xC0, 0x0F, 0xC7, 0xE0, 0x1F, 0x0F, 0x00, 0x3E, 0x1F, 0x00,
  0x7C, 0x3E, 0x01, 0xF8, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xC3, 0xF0, 0x0F,
  0xC3, 0xE0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0xF8, 0x3E, 0x00, 0xF8,
  0x3E, 0x07, 0xC1, 0xF8, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xE0, 0x1F, 0x83,
  0xE0, 0xF8, 0x1F, 0x80, 0x7E, 0x0F, 0x83, 0xE0, 0x7E, 0x01, 0xF0, 0x1E,
  0x1F, 0x01, 0xF0, 0x07, 0xC0, 0x7C, 0xFC, 0x0F, 0xC0, 0x3F, 0x01, 0xF3,
  0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xDF, 0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x7C,
  0x03, 0xF0, 0x0F, 0x80, 0x7F, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xF0, 0x07,
  0xE0, 0x1F, 0x80, 0x7F, 0x80, 0x1F, 0x80, 0x7C, 0x00, 0xFE, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x3E, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x01,
  0xFE, 0x00, 0x00, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xF0, 0x07, 0xF8, 0x00,
  0x07, 0xE0, 0x0F, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0x80,
  0x7F, 0xE0, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0xC0,
  0x01, 0xF8, 0x07, 0xEF, 0x80, 0x03, 0xF0, 0x0F, 0xDF, 0x80, 0x07, 0xE0,
  0x1F, 0x3F, 0x00, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x3F, 0x00, 0x7C, 0x7E,
  0x00, 0x7E, 0x01, 0xF8, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0xFC, 0x01, 0xF0,
  0x07, 0xE1, 0xF8, 0x03, 0xE0, 0x0F, 0x81, 0xF0, 0x0F, 0xC0, 0x1F, 0x03,
  0xF0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x07, 0xC0, 0x7C,
  0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03, 0xE0, 0x1F, 0x83, 0xF0, 0x0F, 0xC0,
  0x1F, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x1F,
  0x00, 0x7C, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0x00, 0xFC, 0xFC, 0x03, 0xF0,
  0x00, 0xF9, 0xF8, 0x07, 0xE0, 0x01, 0xFB, 0xE0, 0x0F, 0xC0, 0x03, 0xF7,
  0xC0, 0x1F, 0x00, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x07, 0xFF, 0x00, 0xFC,
  0x00, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x1F,
  0xF0, 0x07, 0xC0, 0x00, 0x3F, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0xC0, 0x3F,
  0x00, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00,
  0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x07, 0xF8, 0x00, 0x3F,
  0x81, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xC0,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x1F, 0xDF, 0x80,
  0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x1F, 0xCF,
  0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE, 0x0F, 0xE0, 0x00,
  0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xE0, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x00, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFC,
  0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x07, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xF0, 0x1F,
  0x80, 0x3F, 0xC0, 0x7E, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x1F, 0xE0, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00,
  0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x1F, 0xDF, 0x80, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0x7E, 0x00,
  0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0xFE, 0x3F,
  0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x01, 0xFE,
  0x0F, 0xE0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x1F, 0xE0, 0x1F, 0xF0, 0x0F,
  0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x1F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7E,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00,
  0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF8,
  0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF,
  0xFE, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F,
  0xC0, 0x07, 0xE0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFE, 0x3F, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x20, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03,
  0xFC, 0x01, 0xE0, 0x3F, 0x80, 0x04, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x80, 0x00, 0xFE, 0x0F, 0x00, 0x3F, 0xE0, 0xFF, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x0D, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x0F, 0xC0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0xFE, 0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x01,
  0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x0F,
  0xE0, 0x0F, 0xE0, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFC, 0xFC, 0x00, 0x01, 0xFC, 0x7C, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x3E, 0x00, 0x3F,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1F, 0x07, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x1F, 0xBF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0x3F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0xFC,
  0x00, 0x7F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xF0, 0xFC,
  0x00, 0xFB, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0xFB, 0xE0, 0x07, 0xE0, 0xFC,
  0x01, 0xFB, 0xE0, 0x0F, 0xC0, 0xFC, 0x01, 0xF3, 0xE0, 0x0F, 0xC0, 0xFC,
  0x03, 0xF3, 0xE0, 0x0F, 0x80, 0xFC, 0x03, 0xE3, 0xE0, 0x1F, 0x80, 0xFC,
  0x03, 0xE3, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xC3, 0xE0, 0x3F, 0x00, 0xFC,
  0x07, 0xC3, 0xE0, 0x3F, 0x00, 0xFC, 0x0F, 0xC3, 0xE0, 0x7E, 0x00, 0xFC,
  0x0F, 0x83, 0xE0, 0x7E, 0x00, 0x7C, 0x1F, 0x83, 0xE0, 0xFC, 0x00, 0x7C,
  0x1F, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x3F, 0x03, 0xE0, 0xF8, 0x00, 0x7C,
  0x3E, 0x03, 0xE1, 0xF8, 0x00, 0x7C, 0x7E, 0x01, 0xE1, 0xF8, 0x00, 0x7C,
  0x7C, 0x01, 0xE3, 0xF0, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xF0, 0x00, 0x7C,
  0xF8, 0x01, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x01, 0xF7, 0xE0, 0x00, 0x7D,
  0xF0, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x00, 0x7D,
  0xF0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F,
  0xE0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x7E, 0x00, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x80, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xDF, 0x80, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0xFC,
  0x00, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x00, 0xFE,
  0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x03, 0xFD, 0xF0, 0x00, 0x0F, 0xE7, 0xE0,
  0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE0, 0xF8, 0x00,
  0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7F,
  0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x07, 0xE0, 0x7F, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xFC, 0x7F, 0x00, 0x03,
  0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x7D,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x0F, 0xFE, 0x00, 0x3F, 0xF8, 0x00, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xE0,
  0x07, 0xFF, 0x00, 0x1F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0xF8, 0x1F, 0x03,
  0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x7E, 0x0F, 0xC0, 0xF8,
  0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F,
  0x81, 0xF0, 0x3F, 0x07, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0,
  0xFC, 0x1F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xF0, 0x3E,
  0x07, 0xC0, 0xF8, 0x1F, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF,
  0x80, 0x0F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xC0, 0x07, 0xFF,
  0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x3D, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00,
  0x79, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x0F, 0x81, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C,
  0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x01, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0, 0xFE,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0x01, 0xFF, 0xF1, 0xF0, 0x3F, 0xFF,
  0x9F, 0x07, 0xFF, 0xFB, 0xE0, 0xFF, 0x87, 0xFE, 0x0F, 0xE0, 0x3F, 0xE1,
  0xFC, 0x01, 0xFE, 0x1F, 0x80, 0x1F, 0xE3, 0xF8, 0x00, 0xFC, 0x3F, 0x00,
  0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFF, 0x0F, 0xC0, 0x1F, 0xE0, 0xFC,
  0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF, 0x9F, 0xBE, 0x07, 0xFF, 0xF3,
  0xE0, 0x3F, 0xFE, 0x7C, 0x03, 0xFF, 0xC7, 0xC0, 0x0F, 0xF0, 0x7C, 0x00,
  0x10, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x81, 0xE0, 0x00, 0xF8, 0x7F, 0xC0, 0x0F, 0xC7, 0xFF, 0x00, 0x7E, 0x7F,
  0xFC, 0x03, 0xF7, 0xFF, 0xF0, 0x1F, 0x7C, 0x3F, 0x80, 0xFF, 0x80, 0xFE,
  0x0F, 0xF8, 0x07, 0xF0, 0x7F, 0x80, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x3F,
  0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFE, 0x1F,
  0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8, 0x7F, 0x00,
  0x3F, 0x83, 0xFC, 0x03, 0xFC, 0x1F, 0xE0, 0x3F, 0xC1, 0xFF, 0xE7, 0xFC,
  0x0F, 0xBF, 0xFF, 0xC0, 0x7C, 0xFF, 0xFC, 0x03, 0xC3, 0xFF, 0xC0, 0x3E,
  0x0F, 0xF8, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFF,
  0xFC, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0x07,
  0x83, 0xF8, 0x01, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0xC1, 0xFF, 0x0F,
  0x81, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xE0,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x3F, 0x00, 0x0F, 0xF8, 0x7E, 0x00, 0x7F, 0xFC,
  0xFC, 0x01, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0xFB, 0xE0, 0x1F, 0xF0, 0xFF,
  0xC0, 0x3F, 0x80, 0xFF, 0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE,
  0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0,
  0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3E, 0x07,
  0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x03, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F, 0xC0,
  0x1F, 0xE0, 0x1F, 0xC0, 0xFF, 0xC0, 0x3F, 0xE7, 0xEF, 0x80, 0x3F, 0xFF,
  0x9F, 0x00, 0x3F, 0xFE, 0x7C, 0x00, 0x7F, 0xF8, 0xF8, 0x00, 0x3F, 0xC1,
  0xF0, 0x00, 0x0C, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0xF8,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x0F, 0xF0, 0x7F,
  0x0F, 0xE0, 0x3F, 0x1F, 0xC0, 0x1F, 0x3F, 0x80, 0x1F, 0x3F, 0x00, 0x3F,
  0x7F, 0x00, 0x3F, 0x7E, 0x00, 0x7E, 0x7E, 0x01, 0xFE, 0xFE, 0x1F, 0xFC,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFC, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x08, 0x7F, 0x00, 0x30,
  0x7F, 0xC1, 0xF0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0,
  0x07, 0xFF, 0x80, 0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x06,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00,
  0x7F, 0xE1, 0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x3F, 0xFF, 0x9F, 0x01, 0xFF,
  0xFE, 0xFC, 0x0F, 0xF8, 0x7F, 0xE0, 0x3F, 0x80, 0x7F, 0x81, 0xFC, 0x01,
  0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F,
  0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00,
  0x1F, 0xC0, 0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x03, 0xFC, 0x0F, 0xC0, 0x1F,
  0xE0, 0x3F, 0x00, 0xFF, 0x80, 0xFE, 0x07, 0xFE, 0x03, 0xFE, 0x7F, 0xF8,
  0x07, 0xFF, 0xF7, 0xE0, 0x0F, 0xFF, 0x9F, 0x00, 0x3F, 0xFC, 0xFC, 0x00,
  0x3F, 0xC3, 0xF0, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x02, 0x00, 0x07, 0xF0, 0x0E, 0x00, 0x3F, 0x80, 0x3F, 0xCF, 0xFE,
  0x00, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x81, 0xE0, 0x00, 0xF8, 0x7F, 0xE0, 0x0F, 0xC7, 0xFF, 0x80, 0x7E,
  0x7F, 0xFE, 0x03, 0xF7, 0xFF, 0xF0, 0x1F, 0x7C, 0x3F, 0x80, 0xFF, 0x80,
  0xFE, 0x0F, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x1F, 0x83, 0xF8, 0x00, 0xFC,
  0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x0F, 0xC0, 0x00, 0x18, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0,
  0x0F, 0xE0, 0x1F, 0x80, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03,
  0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x18, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x03, 0x3F,
  0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x0F, 0xF0, 0x3F, 0x00, 0x7F, 0x00, 0xFC,
  0x03, 0xF8, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3E, 0x07,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFE, 0x7E, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F,
  0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF0,
  0x07, 0xE0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0xFC,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0x00, 0x0F,
  0x07, 0xFC, 0x03, 0xFF, 0x00, 0xF8, 0x7F, 0xF0, 0x3F, 0xFC, 0x07, 0xC7,
  0xFF, 0xC3, 0xFF, 0xE0, 0x3E, 0x7F, 0xFE, 0x3F, 0xFF, 0x81, 0xF7, 0xC3,
  0xF3, 0xE1, 0xFC, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xE0, 0xFF, 0x80, 0x7F,
  0xC0, 0x3F, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0xF8, 0x3F, 0x80, 0x1F, 0xE0,
  0x07, 0xC1, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC1, 0xF8, 0x00,
  0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x00, 0xFC,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x0F, 0x87, 0xFE, 0x00, 0xF8, 0x7F, 0xF8, 0x07,
  0xCF, 0xFF, 0xE0, 0x3E, 0x7F, 0xFF, 0x01, 0xF7, 0xE3, 0xFC, 0x1F, 0xFC,
  0x0F, 0xE0, 0xFF, 0x80, 0x3F, 0x07, 0xF8, 0x01, 0xF8, 0x3F, 0xC0, 0x0F,
  0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x07,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0x80,
  0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC3, 0xF8, 0x00, 0xFE, 0x00, 0x00, 0x03, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x1F,
  0xE1, 0xFE, 0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x3F, 0x80, 0x0F, 0xCF, 0xC0,
  0x03, 0xF7, 0xF0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xFF,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F,
  0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xFC, 0x00,
  0x1F, 0xBF, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xFE,
  0x00, 0xFE, 0x1F, 0xC0, 0x7F, 0x07, 0xFE, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x80,
  0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x7F, 0xC0, 0x03, 0xE1, 0xFF,
  0xC0, 0x07, 0xC7, 0xFF, 0xC0, 0x0F, 0x9F, 0xFF, 0xC0, 0x1F, 0x7C, 0x3F,
  0x80, 0x3F, 0xE0, 0x3F, 0x80, 0xFF, 0x80, 0x7F, 0x01, 0xFE, 0x00, 0x7E,
  0x03, 0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x03, 0xF0,
  0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x81,
  0xF0, 0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xF8, 0x1F,
  0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xF0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x3F, 0xC0, 0x7F, 0xF9, 0xFF, 0x00, 0xFD, 0xFF,
  0xFC, 0x01, 0xFB, 0xFF, 0xF0, 0x03, 0xF3, 0xFF, 0xC0, 0x07, 0xC3, 0xFE,
  0x00, 0x1F, 0x80, 0x40, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xFE, 0x1F, 0x01,
  0xFF, 0xF1, 0xF0, 0x3F, 0xFF, 0x9F, 0x07, 0xFF, 0xFB, 0xE0, 0xFF, 0x87,
  0xFE, 0x0F, 0xE0, 0x3F, 0xE1, 0xFC, 0x01, 0xFE, 0x3F, 0x80, 0x1F, 0xE3,
  0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0xFC, 0x7E, 0x00,
  0x0F, 0xC7, 0xE0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0x8F, 0xC0,
  0x03, 0xF0, 0xFC, 0x00, 0x7F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC, 0x00, 0xFF,
  0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x01, 0xFE, 0x0F, 0xE0, 0x7F, 0xE0, 0xFF,
  0x9F, 0xFE, 0x07, 0xFF, 0xF7, 0xE0, 0x3F, 0xFE, 0x7C, 0x03, 0xFF, 0xCF,
  0xC0, 0x0F, 0xF0, 0xFC, 0x00, 0x10, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3F, 0x01, 0xF0, 0xFE, 0x03, 0xE1, 0xFE, 0x03,
  0xE3, 0xFE, 0x03, 0xE7, 0xFE, 0x03, 0xEF, 0xFC, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xFE, 0x0F, 0xF0, 0x3E, 0x0F, 0xE0, 0x04, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x80,
  0x03, 0xF8, 0xE0, 0x03, 0xF0, 0xFC, 0x1F, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFF,
  0x18, 0x1F, 0xFE, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x40,
  0x00, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0,
  0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x00, 0x7C,
  0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F,
  0x87, 0xE0, 0x03, 0xF8, 0x7C, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xF0, 0xFC,
  0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xF0, 0xFC, 0x01, 0xFF, 0x0F, 0xC0, 0x1F,
  0xE0, 0xFE, 0x07, 0xFE, 0x0F, 0xF1, 0xFB, 0xE0, 0x7F, 0xFF, 0x3E, 0x07,
  0xFF, 0xE3, 0xE0, 0x3F, 0xFC, 0x7C, 0x01, 0xFF, 0x07, 0xC0, 0x01, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFB, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0x1F, 0xCF, 0xC0, 0x03, 0xF1, 0xF8, 0x00, 0xFE, 0x1F, 0x00,
  0x1F, 0x83, 0xE0, 0x07, 0xF0, 0x7C, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0x81,
  0xF8, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x81, 0xF8, 0x01, 0xF0, 0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07,
  0xC3, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3, 0xF0,
  0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xDF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x1F,
  0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x3F, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xBF, 0x00, 0x3F, 0xC0, 0x0F, 0xDF,
  0x80, 0x3F, 0xE0, 0x0F, 0xCF, 0xC0, 0x1F, 0xF0, 0x07, 0xE7, 0xE0, 0x1F,
  0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xFC, 0x03, 0xF0, 0xF8, 0x07, 0xBE, 0x03,
  0xF0, 0x7C, 0x07, 0xDF, 0x01, 0xF8, 0x3E, 0x03, 0xEF, 0x81, 0xF8, 0x1F,
  0x03, 0xE7, 0xC0, 0xFC, 0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x07, 0xC1, 0xF1,
  0xF0, 0x7E, 0x03, 0xE0, 0xF8, 0xF8, 0x3F, 0x01, 0xF0, 0xF8, 0x7C, 0x3F,
  0x00, 0xF8, 0x7C, 0x3E, 0x1F, 0x80, 0x7C, 0x7C, 0x1F, 0x1F, 0x80, 0x3E,
  0x3E, 0x0F, 0x8F, 0xC0, 0x1F, 0x1F, 0x03, 0xC7, 0xC0, 0x0F, 0x9F, 0x01,
  0xE7, 0xE0, 0x07, 0xCF, 0x80, 0xF3, 0xE0, 0x03, 0xEF, 0x80, 0x7B, 0xF0,
  0x01, 0xF7, 0xC0, 0x3D, 0xF0, 0x00, 0xFB, 0xC0, 0x1E, 0xF8, 0x00, 0x7F,
  0xE0, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0xFC,
  0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F,
  0x1F, 0x80, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0x7F, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0,
  0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00,
  0x1F, 0x80, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x1F, 0xC0,
  0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x81, 0xF8, 0x00,
  0x01, 0xF8, 0x7E, 0x00, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x07, 0xE3, 0xF0,
  0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x33, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFC, 0x07, 0xFF, 0xFF, 0x02, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x01, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0xF8, 0x00, 0x3F,
  0xE0, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x78, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xF0,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFF, 0xC0, 0x01, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x3F,
  0xE0, 0x03, 0xFF, 0x80, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x07,
  0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x07, 0x00, 0x00, 0x4F, 0xFC, 0x00, 0x1F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFA, 0x00, 0x07, 0xF8,
};

const GFXglyph NotoSans_MediumItalic56pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 41, 15, 1, -40 },
  { 78, 18, 14, 23, 6, -40 },
  { 110, 35, 40, 36, 2, -40 },
  { 285, 28, 46, 31, 2, -43 },
  { 446, 39, 42, 46, 4, -41 },
  { 651, 35, 42, 38, 2, -41 },
  { 835, 8, 14, 13, 6, -40 },
  { 849, 19, 49, 17, 2, -40 },
  { 966, 19, 49, 17, -4, -40 },
  { 1083, 27, 27, 31, 5, -43 },
  { 1175, 26, 27, 32, 4, -33 },
  { 1263, 11, 14, 15, -2, -7 },
  { 1283, 15, 6, 18, 1, -18 },
  { 1295, 8, 8, 15, 1, -7 },
  { 1303, 29, 40, 21, -3, -40 },
  { 1448, 27, 42, 31, 3, -41 },
  { 1590, 19, 40, 31, 7, -40 },
  { 1685, 30, 41, 31, 0, -41 },
  { 1839, 29, 42, 31, 1, -41 },
  { 1992, 30, 40, 31, 0, -40 },
  { 2142, 28, 41, 31, 2, -40 },
  { 2286, 28, 42, 31, 3, -41 },
  { 2433, 28, 40, 31, 4, -40 },
  { 2573, 29, 42, 31, 2, -41 },
  { 2726, 26, 42, 31, 3, -41 },
  { 2863, 12, 32, 15, 1, -31 },
  { 2911, 16, 38, 15, -3, -31 },
  { 2987, 26, 28, 32, 4, -34 },
  { 3078, 26, 16, 32, 4, -28 },
  { 3130, 26, 28, 32, 4, -34 },
  { 3221, 22, 42, 25, 4, -41 },
  { 3337, 43, 45, 48, 3, -40 },
  { 3579, 33, 40, 33, -3, -40 },
  { 3744, 31, 40, 34, 2, -40 },
  { 3899, 32, 42, 33, 4, -41 },
  { 4067, 34, 40, 38, 2, -40 },
  { 4237, 29, 40, 29, 2, -40 },
  { 4382, 29, 40, 28, 2, -40 },
  { 4527, 33, 42, 38, 4, -41 },
  { 4701, 37, 40, 38, 2, -40 },
  { 4886, 23, 40, 19, -1, -40 },
  { 5001, 26, 51, 16, -9, -40 },
  { 5167, 35, 40, 32, 2, -40 },
  { 5342, 22, 40, 27, 2, -40 },
  { 5452, 46, 40, 48, 2, -40 },
  { 5682, 39, 40, 40, 2, -40 },
  { 5877, 35, 42, 41, 4, -41 },
  { 6061, 31, 40, 32, 2, -40 },
  { 6216, 35, 51, 41, 4, -41 },
  { 6440, 30, 40, 33, 2, -40 },
  { 6590, 28, 42, 29, 1, -41 },
  { 6737, 28, 40, 29, 5, -40 },
  { 6877, 35, 41, 38, 4, -40 },
  { 7057, 32, 40, 32, 5, -40 },
  { 7217, 48, 40, 49, 6, -40 },
  { 7457, 38, 40, 31, -3, -40 },
  { 7647, 30, 40, 29, 5, -40 },
  { 7797, 33, 40, 30, -1, -40 },
  { 7962, 22, 49, 17, -1, -40 },
  { 8097, 11, 40, 21, 6, -40 },
  { 8152, 22, 49, 17, -4, -40 },
  { 8287, 28, 25, 32, 2, -40 },
  { 8375, 23, 4, 22, -5, 5 },
  { 8387, 10, 9, 16, 8, -43 },
  { 8399, 28, 32, 32, 3, -31 },
  { 8511, 29, 44, 33, 1, -43 },
  { 8671, 23, 32, 26, 3, -31 },
  { 8763, 31, 44, 33, 3, -43 },
  { 8934, 24, 32, 29, 3, -31 },
  { 9030, 31, 56, 19, -6, -43 },
  { 9247, 30, 44, 33, 1, -31 },
  { 9412, 29, 43, 33, 1, -43 },
  { 9568, 15, 42, 15, 1, -42 },
  { 9647, 23, 55, 15, -7, -42 },
  { 9806, 30, 43, 29, 1, -43 },
  { 9968, 15, 43, 15, 1, -43 },
  { 10049, 45, 31, 50, 1, -31 },
  { 10224, 29, 31, 33, 1, -31 },
  { 10337, 26, 32, 32, 3, -31 },
  { 10441, 31, 44, 33, -1, -31 },
  { 10612, 28, 44, 33, 3, -31 },
  { 10766, 24, 31, 23, 1, -31 },
  { 10859, 24, 32, 25, 0, -31 },
  { 10955, 18, 38, 20, 3, -37 },
  { 11041, 28, 31, 33, 3, -30 },
  { 11150, 27, 30, 27, 3, -30 },
  { 11252, 41, 30, 42, 3, -30 },
  { 11406, 32, 30, 28, -2, -30 },
  { 11526, 35, 43, 27, -5, -30 },
  { 11715, 26, 30, 25, -1, -30 },
  { 11813, 23, 49, 20, 0, -40 },
  { 11954, 5, 56, 31, 14, -43 },
  { 11989, 22, 49, 20, -2, -40 },
  { 12124, 26, 8, 32, 4, -24 },
};

const GFXfont NotoSans_MediumItalic56pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic56pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic56pt7bGlyphs,
  0x20, 0x7E, 76
};

#endif // _NOTOSANS_MEDIUMITALIC56PT7B_H_
