#ifndef _NOTOSANS_MEDIUMITALIC35PT7B_H_
#define _NOTOSANS_MEDIUMITALIC35PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 35pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic35pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x3C, 0x1E, 0x0F,
  0x07, 0x03, 0x83, 0xC1, 0xE0, 0xE0, 0x70, 0x38, 0x1C, 0x00, 0x00, 0x02,
  0x07, 0x83, 0xE1, 0xE0, 0xF0, 0x00, 0x79, 0xEE, 0x3D, 0xC7, 0x78, 0xEE,
  0x1D, 0xC7, 0x38, 0xE7, 0x1C, 0xC3, 0x80, 0x00, 0x70, 0x70, 0x01, 0xC3,
  0x80, 0x07, 0x0E, 0x00, 0x38, 0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00,
  0x1C, 0x1C, 0x0F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF0, 0x38,
  0x38, 0x00, 0xE1, 0xC0, 0x03, 0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60,
  0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xC0, 0xE1, 0xC0, 0x03,
  0x87, 0x00, 0x1C, 0x1C, 0x00, 0x70, 0x60, 0x01, 0xC3, 0x80, 0x06, 0x0E,
  0x00, 0x38, 0x78, 0x00, 0x00, 0x18, 0x00, 0x06, 0x00, 0x01, 0x80, 0x01,
  0xF0, 0x03, 0xFF, 0xC1, 0xFF, 0xE0, 0xFB, 0x78, 0x79, 0xC2, 0x1E, 0x70,
  0x07, 0x18, 0x01, 0xE6, 0x00, 0x79, 0x80, 0x0F, 0xE0, 0x03, 0xFC, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x73, 0xC0, 0x1C, 0xF0, 0x06,
  0x3C, 0x01, 0x8E, 0x30, 0x67, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xF0,
  0x00, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x06, 0x00, 0x00, 0x1F, 0x80,
  0x1E, 0x3F, 0xC0, 0x3C, 0x79, 0xC0, 0x38, 0x70, 0xE0, 0x70, 0x70, 0xE0,
  0xE0, 0xE0, 0xE1, 0xE0, 0xE0, 0xE1, 0xC0, 0xE1, 0xC3, 0x80, 0xE1, 0xC7,
  0x00, 0xE1, 0xCF, 0x00, 0xE3, 0xCE, 0x7E, 0xE3, 0x9C, 0xFE, 0xE7, 0xB9,
  0xEF, 0xFF, 0x7B, 0xC7, 0x7E, 0x73, 0x87, 0x00, 0xE3, 0x87, 0x01, 0xC7,
  0x07, 0x01, 0xC7, 0x07, 0x03, 0x87, 0x07, 0x07, 0x07, 0x0E, 0x0E, 0x07,
  0x0E, 0x0E, 0x07, 0x1E, 0x1C, 0x07, 0xBC, 0x38, 0x03, 0xF8, 0x70, 0x01,
  0xF0, 0x00, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x3F, 0xF8, 0x01, 0xE0, 0xF0,
  0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0x70, 0x38, 0x01, 0xE1, 0xE0, 0x07,
  0x8F, 0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xF0,
  0x00, 0x7F, 0xC0, 0xF3, 0xC7, 0x83, 0x9E, 0x0F, 0x1E, 0x70, 0x3C, 0xF3,
  0xC0, 0x7B, 0xCF, 0x00, 0xFE, 0x3C, 0x03, 0xF0, 0xF0, 0x0F, 0x83, 0xE0,
  0x7F, 0x07, 0xFF, 0xFE, 0x0F, 0xFE, 0x78, 0x1F, 0xE0, 0xF8, 0x7B, 0x9D,
  0xEE, 0x73, 0x9C, 0xC0, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x80,
  0x70, 0x0F, 0x01, 0xE0, 0x1E, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07,
  0x80, 0x70, 0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x0F,
  0x00, 0xF0, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x03, 0x80, 0x38, 0x03,
  0x80, 0x1C, 0x00, 0x01, 0xC0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0xF0, 0x07,
  0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07, 0x00, 0x70, 0x07,
  0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0E, 0x00, 0xE0, 0x1E, 0x01, 0xC0, 0x3C,
  0x03, 0xC0, 0x78, 0x07, 0x00, 0xF0, 0x0E, 0x01, 0xC0, 0x3C, 0x07, 0x80,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x78, 0x00, 0x38, 0x00, 0x1C, 0x06, 0x0E,
  0x03, 0xC6, 0x03, 0xFB, 0x00, 0x7F, 0xFF, 0x03, 0xFF, 0x81, 0xFF, 0xC1,
  0xF8, 0x03, 0xDC, 0x03, 0xC7, 0x03, 0xE3, 0x80, 0x61, 0xE0, 0x20, 0xF0,
  0x00, 0x20, 0x00, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0x70, 0x00, 0x38, 0x00,
  0x1C, 0x00, 0x0E, 0x00, 0x07, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xC0, 0x70, 0x00, 0x38, 0x00, 0x1C, 0x00, 0x0E, 0x00, 0x07, 0x00, 0x03,
  0x80, 0x01, 0xC0, 0x00, 0x0F, 0x1E, 0x1E, 0x1C, 0x3C, 0x38, 0x78, 0x70,
  0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0x27, 0xBF, 0xEF, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01,
  0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x01, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x03, 0xFF, 0x03, 0xFF,
  0xC3, 0xE1, 0xE1, 0xE0, 0x71, 0xE0, 0x3C, 0xF0, 0x1E, 0xF0, 0x0F, 0x78,
  0x07, 0xBC, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x77, 0x80, 0x7B,
  0xC0, 0x3D, 0xE0, 0x1E, 0xE0, 0x0F, 0x70, 0x0F, 0x3C, 0x07, 0x9E, 0x07,
  0x8F, 0x03, 0xC7, 0xC3, 0xC1, 0xFF, 0xC0, 0x7F, 0xC0, 0x1F, 0xC0, 0x00,
  0x00, 0xF0, 0x3F, 0x07, 0xE1, 0xFE, 0x3F, 0xEF, 0xDE, 0x71, 0xE2, 0x1C,
  0x03, 0xC0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0x80, 0x78, 0x07, 0x80, 0x78,
  0x07, 0x00, 0x70, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xE0, 0x1E, 0x01, 0xE0,
  0x1E, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xF0, 0x3F, 0xFF, 0x03, 0xC1, 0xE0,
  0x20, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x0E, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xFF, 0xC7, 0xFF, 0xF8, 0xFF,
  0xFF, 0x00, 0x03, 0xFE, 0x03, 0xFF, 0xC1, 0xFF, 0xF8, 0x38, 0x1E, 0x04,
  0x07, 0x80, 0x00, 0xF0, 0x00, 0x38, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x03, 0xE0,
  0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x38, 0x00,
  0x1E, 0x30, 0x0F, 0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00,
  0x77, 0x00, 0x1E, 0xE0, 0x07, 0xBC, 0x01, 0xE7, 0x80, 0x78, 0xF0, 0x0E,
  0x1C, 0x03, 0x83, 0x80, 0xF0, 0xF0, 0x3C, 0x1E, 0x0F, 0x03, 0x83, 0xC0,
  0x70, 0x7F, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38, 0x00, 0x03,
  0xFF, 0xC0, 0xFF, 0xF0, 0x7F, 0xF8, 0x1C, 0x00, 0x07, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0x80,
  0x7F, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E, 0x30, 0x1F,
  0x8F, 0xFF, 0xC3, 0xFF, 0xE0, 0x7F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0xFF,
  0xC0, 0xFF, 0xE0, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x38, 0x00, 0x3C, 0x78, 0x1E, 0xFF, 0x0E, 0xFF, 0xCF, 0xE3, 0xE7,
  0xC0, 0xF3, 0xE0, 0x3D, 0xE0, 0x1E, 0xF0, 0x0F, 0x78, 0x07, 0x3C, 0x03,
  0x9E, 0x03, 0xCF, 0x01, 0xE3, 0xC1, 0xE1, 0xFF, 0xE0, 0x7F, 0xE0, 0x1F,
  0xE0, 0x00, 0x3F, 0xFF, 0xCF, 0xFF, 0xF3, 0xFF, 0xFC, 0x00, 0x1E, 0x00,
  0x07, 0x00, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0xE0, 0x7F, 0xF8, 0x3E, 0x0F, 0x0F, 0x03, 0xC3, 0xC0,
  0xF0, 0xE0, 0x3C, 0x3C, 0x0F, 0x0F, 0x07, 0x81, 0xE3, 0xC0, 0x3F, 0xE0,
  0x07, 0xE0, 0x07, 0xF8, 0x07, 0xFF, 0x03, 0xE1, 0xE1, 0xE0, 0x3C, 0x78,
  0x0F, 0x1C, 0x03, 0xCF, 0x00, 0x73, 0xC0, 0x3C, 0x78, 0x0F, 0x1E, 0x07,
  0x87, 0xFF, 0xE0, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x0F, 0xFE,
  0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F, 0x78, 0x07, 0x78, 0x07, 0x78, 0x07,
  0x70, 0x07, 0x78, 0x0F, 0x78, 0x0F, 0x78, 0x1F, 0x7C, 0x3F, 0x3F, 0xFF,
  0x1F, 0xEE, 0x0F, 0x9E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x38,
  0x00, 0x78, 0x81, 0xF0, 0xFF, 0xE0, 0xFF, 0xC0, 0xFF, 0x00, 0x1E, 0x3C,
  0xF8, 0xF1, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x78,
  0xF9, 0xE3, 0xC0, 0x03, 0xC0, 0xF0, 0x7C, 0x0F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x1E,
  0x07, 0x83, 0xC0, 0xE0, 0x78, 0x1C, 0x07, 0x03, 0x80, 0x00, 0x01, 0x80,
  0x03, 0xC0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x00, 0x01, 0x80, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x78, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x7F, 0x00, 0xFE, 0x03,
  0xFC, 0x03, 0xF0, 0x01, 0xE0, 0x00, 0xC0, 0x00, 0x00, 0x1F, 0xE7, 0xFF,
  0x9F, 0xFE, 0xC0, 0xF0, 0x07, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0xF0,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x07, 0x00, 0x38,
  0x03, 0xC0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x78, 0x03, 0xE0, 0x1E, 0x00,
  0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC,
  0x01, 0xF0, 0x07, 0xC0, 0x78, 0x00, 0x38, 0x1C, 0x00, 0x03, 0x87, 0x00,
  0x00, 0x71, 0xE0, 0x7F, 0x07, 0x38, 0x3F, 0xF0, 0xEE, 0x0F, 0x1E, 0x1D,
  0xC3, 0xC1, 0xC3, 0xF0, 0x70, 0x70, 0x7E, 0x1C, 0x0E, 0x0F, 0xC3, 0x81,
  0xC1, 0xF8, 0xF0, 0x78, 0x3F, 0x1C, 0x0E, 0x0E, 0xE3, 0x81, 0xC1, 0xDC,
  0x78, 0x78, 0x73, 0x87, 0x1B, 0x1E, 0x70, 0xFF, 0x7F, 0x8E, 0x0F, 0xC7,
  0xC0, 0xE0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x20, 0x03, 0xFD, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x01, 0xDC, 0x00, 0x1E, 0xE0, 0x00, 0xE7, 0x00, 0x0F, 0x38, 0x00, 0x79,
  0xE0, 0x07, 0x8F, 0x00, 0x38, 0x78, 0x03, 0xC3, 0xC0, 0x1C, 0x0E, 0x01,
  0xE0, 0x70, 0x0F, 0xFF, 0x80, 0xFF, 0xFC, 0x07, 0xFF, 0xF0, 0x7F, 0xFF,
  0x87, 0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00, 0x79, 0xE0,
  0x01, 0xCF, 0x00, 0x0E, 0xF0, 0x00, 0x78, 0x07, 0xFF, 0x00, 0x7F, 0xFC,
  0x07, 0xFF, 0xE0, 0x78, 0x3E, 0x07, 0x01, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x0F, 0x0F, 0x01, 0xE0, 0xE0, 0x3E, 0x1F, 0xFF, 0xC1, 0xFF,
  0xF0, 0x1F, 0xFE, 0x01, 0xC3, 0xF8, 0x1C, 0x07, 0xC3, 0xC0, 0x3C, 0x3C,
  0x03, 0xC3, 0xC0, 0x3C, 0x38, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7,
  0x81, 0xF8, 0x7F, 0xFF, 0x07, 0xFF, 0xE0, 0xFF, 0xF0, 0x00, 0x00, 0x7F,
  0xE0, 0x1F, 0xFF, 0x03, 0xFF, 0xF0, 0x7E, 0x06, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x30, 0x3F, 0xFF, 0x00, 0xFF, 0xF0, 0x07, 0xFE,
  0x00, 0x07, 0xFE, 0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0x0F, 0xE0,
  0x70, 0x1F, 0x07, 0x80, 0x7C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00,
  0x78, 0x70, 0x03, 0xC7, 0x80, 0x1E, 0x3C, 0x00, 0xF1, 0xE0, 0x07, 0x8E,
  0x00, 0x3C, 0x70, 0x01, 0xE7, 0x80, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F,
  0x8E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0xFC, 0x3C, 0x1F, 0xC1, 0xFF,
  0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x7F, 0xFC, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0xFF, 0x03, 0xFF, 0xE0, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8,
  0x1F, 0xFF, 0x03, 0xC0, 0x00, 0x70, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0xFF, 0x81,
  0xFF, 0xE0, 0x3F, 0xFC, 0x07, 0xFF, 0x81, 0xE0, 0x00, 0x3C, 0x00, 0x07,
  0x80, 0x00, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x03, 0x80, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFE, 0x0F, 0xC0, 0x60, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x81, 0xFF, 0x78, 0x0F, 0xFB, 0xC0, 0x7F, 0xDE, 0x00,
  0x1C, 0xF0, 0x01, 0xE7, 0xC0, 0x0F, 0x1E, 0x00, 0x78, 0xF0, 0x03, 0x87,
  0xC0, 0x3C, 0x1F, 0x01, 0xE0, 0x7F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF,
  0x00, 0x07, 0x80, 0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C, 0x00,
  0xE0, 0x70, 0x03, 0xC1, 0xE0, 0x07, 0x83, 0xC0, 0x0F, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x38, 0x1C, 0x00, 0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0x83, 0xFF, 0xFE, 0x07, 0x00, 0x3C, 0x1E, 0x00, 0x78, 0x3C,
  0x00, 0xF0, 0x78, 0x01, 0xC0, 0xE0, 0x03, 0x83, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x3C, 0x1E, 0x00, 0x70, 0x38, 0x01, 0xE0, 0xF0, 0x03,
  0xC0, 0x07, 0xFE, 0x0F, 0xFC, 0x0F, 0xE0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x0F, 0xE0, 0x3F, 0xE0, 0xFF, 0xC0,
  0x00, 0x07, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E,
  0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x38, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x70, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x4F, 0xC0, 0x7F, 0x80,
  0x7F, 0x00, 0xFC, 0x00, 0x07, 0x80, 0x7C, 0x1E, 0x03, 0xE0, 0x78, 0x0F,
  0x01, 0xE0, 0x78, 0x07, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0xF0, 0x03,
  0xC7, 0x80, 0x0E, 0x3C, 0x00, 0x39, 0xE0, 0x01, 0xEF, 0x00, 0x07, 0xFC,
  0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xE7, 0x80, 0x0F, 0x0E, 0x00,
  0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0x81, 0xE0, 0x1E, 0x07, 0x80, 0x78,
  0x1F, 0x01, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x01, 0xE0, 0xF0, 0x07,
  0x80, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x3C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00,
  0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x07, 0xFF, 0xDF, 0xFF, 0xFF, 0xF8, 0x07, 0xE0, 0x01,
  0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x77, 0x07, 0xF0, 0x03, 0xF8, 0x3B, 0x80, 0x3B, 0xC1, 0xDC,
  0x03, 0xDC, 0x0E, 0xF0, 0x1C, 0xE0, 0x73, 0x81, 0xEF, 0x07, 0x9C, 0x0E,
  0x78, 0x3C, 0xE0, 0xF3, 0xC1, 0xC7, 0x07, 0x1C, 0x0E, 0x38, 0x78, 0xE0,
  0xF1, 0xC3, 0x8F, 0x07, 0x8E, 0x38, 0x78, 0x3C, 0x71, 0xC3, 0xC1, 0xC3,
  0x9C, 0x1C, 0x0E, 0x0E, 0xE1, 0xE0, 0xF0, 0x7E, 0x0F, 0x07, 0x83, 0xF0,
  0x78, 0x38, 0x1F, 0x03, 0xC1, 0xC0, 0xF8, 0x1C, 0x0E, 0x07, 0x81, 0xE0,
  0xF0, 0x3C, 0x0F, 0x00, 0x07, 0xC0, 0x07, 0x07, 0xC0, 0x07, 0x07, 0xE0,
  0x0F, 0x07, 0xE0, 0x0F, 0x07, 0xE0, 0x0E, 0x0F, 0xF0, 0x0E, 0x0E, 0xF0,
  0x0E, 0x0E, 0x70, 0x1E, 0x0E, 0x78, 0x1E, 0x0E, 0x78, 0x1C, 0x1E, 0x38,
  0x1C, 0x1E, 0x3C, 0x3C, 0x1C, 0x1C, 0x3C, 0x1C, 0x1C, 0x3C, 0x3C, 0x1E,
  0x38, 0x3C, 0x0E, 0x38, 0x3C, 0x0F, 0x78, 0x38, 0x0F, 0x78, 0x38, 0x07,
  0x78, 0x78, 0x07, 0xF0, 0x78, 0x07, 0xF0, 0x70, 0x03, 0xF0, 0x70, 0x03,
  0xF0, 0x70, 0x03, 0xE0, 0xF0, 0x01, 0xE0, 0x00, 0x7F, 0xC0, 0x07, 0xFF,
  0x80, 0x3F, 0xFF, 0x01, 0xF0, 0x3E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF3,
  0xE0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80,
  0x03, 0xDE, 0x00, 0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x1E, 0xF0, 0x00, 0x7B, 0xC0, 0x03, 0xE7, 0x80, 0x0F, 0x1E,
  0x00, 0x7C, 0x7C, 0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xF8, 0x03, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F, 0xFF, 0x03,
  0xC3, 0xF0, 0x70, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x38, 0x78, 0x07, 0x0F,
  0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x0F, 0x8F, 0x03, 0xE1, 0xFF, 0xF8, 0x3F,
  0xFE, 0x07, 0xFF, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0x80,
  0x00, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x07, 0xFF, 0x80, 0x3F, 0xFF,
  0x01, 0xF0, 0x7E, 0x0F, 0x80, 0x78, 0x7C, 0x01, 0xF3, 0xE0, 0x03, 0xCF,
  0x00, 0x0F, 0x3C, 0x00, 0x3D, 0xE0, 0x00, 0xF7, 0x80, 0x03, 0xDE, 0x00,
  0x0F, 0x78, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x1E,
  0xF0, 0x00, 0x7B, 0xC0, 0x01, 0xE7, 0x80, 0x0F, 0x1E, 0x00, 0x7C, 0x7C,
  0x03, 0xE0, 0xF8, 0x1F, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xF0, 0x1F,
  0xFF, 0x03, 0xC3, 0xF0, 0x70, 0x1E, 0x1E, 0x03, 0xC3, 0xC0, 0x78, 0x78,
  0x0F, 0x0F, 0x01, 0xE1, 0xC0, 0x3C, 0x78, 0x0F, 0x0F, 0x0F, 0xC1, 0xFF,
  0xF0, 0x3F, 0xFC, 0x07, 0xFE, 0x01, 0xE1, 0xE0, 0x3C, 0x3C, 0x07, 0x83,
  0xC0, 0xE0, 0x78, 0x3C, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x1E, 0x03,
  0xC3, 0x80, 0x3C, 0xF0, 0x07, 0x80, 0x01, 0xFF, 0x03, 0xFF, 0xC3, 0xFF,
  0xE1, 0xE0, 0x61, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x01, 0xF0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xC6, 0x03, 0xE3, 0xFF, 0xE1, 0xFF, 0xE0, 0x7F, 0xC0, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xF8, 0x07, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x78,
  0xF0, 0x03, 0xC7, 0x80, 0x1E, 0x38, 0x00, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1E, 0x78, 0x00, 0xE3, 0xC0, 0x0F,
  0x1E, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x00, 0x1C, 0x38, 0x01, 0xE1, 0xE0,
  0x0F, 0x0F, 0x00, 0xF0, 0x7C, 0x0F, 0x81, 0xFF, 0xF8, 0x07, 0xFF, 0x80,
  0x1F, 0xF0, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x1E, 0xF0, 0x01, 0xE7, 0x00,
  0x3C, 0x70, 0x03, 0xC7, 0x00, 0x78, 0x70, 0x07, 0x87, 0x80, 0xF0, 0x78,
  0x0E, 0x07, 0x81, 0xE0, 0x78, 0x1C, 0x07, 0x83, 0xC0, 0x78, 0x38, 0x03,
  0x87, 0x80, 0x38, 0x70, 0x03, 0x8F, 0x00, 0x38, 0xE0, 0x03, 0x9E, 0x00,
  0x39, 0xC0, 0x03, 0xBC, 0x00, 0x3B, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7F, 0x00, 0x78,
  0x03, 0xF8, 0x03, 0xC0, 0x3D, 0xC0, 0x3E, 0x01, 0xEE, 0x01, 0xF0, 0x0E,
  0x70, 0x1F, 0xC0, 0xF3, 0x80, 0xFE, 0x07, 0x9C, 0x0E, 0xF0, 0x78, 0xE0,
  0x73, 0x83, 0xC7, 0x07, 0x9C, 0x3C, 0x38, 0x38, 0xE1, 0xE1, 0xC3, 0xC7,
  0x0E, 0x0F, 0x1C, 0x38, 0xF0, 0x79, 0xE1, 0xC7, 0x03, 0xCE, 0x0E, 0x78,
  0x1E, 0x70, 0x73, 0xC0, 0xF7, 0x03, 0x9C, 0x07, 0xB8, 0x1D, 0xE0, 0x3F,
  0xC0, 0xEE, 0x01, 0xDC, 0x07, 0xF0, 0x0E, 0xE0, 0x3F, 0x00, 0x7E, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0x78, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x0F, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x3C, 0x01, 0xE0,
  0x78, 0x00, 0xE0, 0x78, 0x00, 0xF0, 0xF0, 0x00, 0xF1, 0xE0, 0x00, 0x73,
  0xC0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xEF,
  0x00, 0x01, 0xE7, 0x00, 0x03, 0xC7, 0x80, 0x07, 0x87, 0x80, 0x0F, 0x03,
  0x80, 0x0F, 0x03, 0xC0, 0x1E, 0x03, 0xC0, 0x3C, 0x01, 0xC0, 0x78, 0x01,
  0xE0, 0xF8, 0x01, 0xE0, 0xF0, 0x03, 0xEE, 0x00, 0xF9, 0xE0, 0x1E, 0x3C,
  0x07, 0x87, 0x81, 0xF0, 0x70, 0x3C, 0x0E, 0x0F, 0x01, 0xE1, 0xE0, 0x3C,
  0x78, 0x03, 0x9E, 0x00, 0x73, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x38,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xE0,
  0x00, 0x3C, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x1E,
  0x00, 0x01, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0xFF, 0xFF, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0xFE, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F,
  0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80,
  0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0E,
  0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0xE0, 0x7F, 0x03, 0xF8,
  0x00, 0xE1, 0xC3, 0x87, 0x8F, 0x0E, 0x1C, 0x38, 0x70, 0xE1, 0xE1, 0xC3,
  0x87, 0x0E, 0x1C, 0x3C, 0x78, 0x70, 0xE1, 0xC3, 0x87, 0x0F, 0x1E, 0x03,
  0xF8, 0x1F, 0xC1, 0xFE, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E,
  0x00, 0xE0, 0x07, 0x00, 0x38, 0x03, 0xC0, 0x1E, 0x00, 0xE0, 0x07, 0x00,
  0x78, 0x03, 0xC0, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C,
  0x00, 0xE0, 0x07, 0x00, 0x78, 0x03, 0xC0, 0x1C, 0x0F, 0xE0, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03,
  0xB8, 0x01, 0xCE, 0x00, 0x73, 0x80, 0x38, 0x70, 0x0E, 0x1C, 0x07, 0x03,
  0x81, 0xC0, 0xE0, 0xE0, 0x1C, 0x38, 0x07, 0x1C, 0x00, 0xE7, 0x00, 0x3B,
  0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0xF1, 0xC7, 0x8E, 0x1C,
  0x30, 0x03, 0xE1, 0xC3, 0xFC, 0xE1, 0xFF, 0xB8, 0xF8, 0x7E, 0x3C, 0x0F,
  0x9E, 0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF,
  0x00, 0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x0F, 0x8F, 0x07, 0xE3, 0xC3,
  0xF0, 0xFF, 0xDC, 0x1F, 0xE7, 0x03, 0xF1, 0xC0, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0E, 0x3E, 0x03, 0xBF, 0xC1, 0xFF, 0xF8, 0x7E, 0x1E, 0x1F,
  0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xF3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x07, 0x9E, 0x03, 0xC7, 0x80, 0xF1,
  0xF0, 0x78, 0xFF, 0xFE, 0x39, 0xFE, 0x0E, 0x3F, 0x00, 0x03, 0xFC, 0x3F,
  0xF1, 0xFF, 0xCF, 0x81, 0x3C, 0x01, 0xE0, 0x07, 0x80, 0x3C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x38, 0x00, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x3E,
  0x04, 0x7F, 0xF1, 0xFF, 0xC1, 0xFE, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x03, 0xE3, 0x81, 0xFE, 0x70, 0x7F, 0xEE, 0x1F, 0x0F, 0xC3,
  0xC0, 0xF8, 0xF0, 0x1E, 0x1E, 0x03, 0xC7, 0x80, 0x78, 0xF0, 0x0F, 0x1E,
  0x01, 0xE3, 0xC0, 0x38, 0x70, 0x0F, 0x0E, 0x01, 0xE1, 0xC0, 0x7C, 0x3C,
  0x1F, 0x07, 0x87, 0xE0, 0xFF, 0xDC, 0x0F, 0xF3, 0x80, 0xFC, 0x70, 0x00,
  0x03, 0xF8, 0x1F, 0xF8, 0x7F, 0xF9, 0xF0, 0xF3, 0xC1, 0xEF, 0x03, 0xDE,
  0x07, 0xF8, 0x3E, 0xFF, 0xF9, 0xFF, 0xE3, 0xFE, 0x07, 0x00, 0x0E, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x0C, 0x7F, 0xF8, 0x7F, 0xF0, 0x7F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xE2, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xFF, 0x80, 0x07, 0x00, 0x00, 0x70, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0xFF, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0xE0, 0xFF, 0xB8, 0x3F, 0xF7, 0x0F,
  0x87, 0xE1, 0xE0, 0x7C, 0x78, 0x0F, 0x0F, 0x01, 0xE3, 0xC0, 0x3C, 0x78,
  0x07, 0x8F, 0x00, 0xF1, 0xE0, 0x1C, 0x38, 0x07, 0x87, 0x00, 0xF0, 0xE0,
  0x3E, 0x1E, 0x0F, 0x83, 0xC3, 0xF0, 0x7F, 0xEE, 0x07, 0xFB, 0xC0, 0x7E,
  0x78, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x04, 0x03,
  0xC0, 0xFF, 0xF0, 0x1F, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x01,
  0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x0E, 0x3F, 0x03, 0x9F, 0xE1, 0xEF, 0xF8, 0x7F, 0x1F,
  0x1F, 0x03, 0xC7, 0x80, 0xF1, 0xE0, 0x38, 0xF0, 0x0E, 0x3C, 0x07, 0x8F,
  0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1C, 0x78, 0x07, 0x1E, 0x03, 0xC7, 0x80,
  0xF1, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F, 0x01, 0xE0, 0x03, 0x83,
  0xC1, 0xE0, 0xE0, 0x00, 0x00, 0x00, 0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1,
  0xC0, 0xE0, 0xF0, 0x78, 0x3C, 0x1C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xC1,
  0xE0, 0xF0, 0x78, 0x00, 0x00, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x70, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0xE0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00,
  0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80,
  0x1E, 0x00, 0x70, 0x01, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0, 0x3F, 0x80,
  0xFC, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x07, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0E, 0x03,
  0xC3, 0x81, 0xE1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x3C, 0x07, 0x1E, 0x03,
  0xCF, 0x00, 0xF7, 0x80, 0x3F, 0xC0, 0x0F, 0xF8, 0x03, 0xFE, 0x01, 0xF3,
  0xC0, 0x78, 0xF0, 0x1E, 0x1E, 0x07, 0x87, 0x81, 0xC1, 0xE0, 0xF0, 0x3C,
  0x3C, 0x0F, 0x0F, 0x01, 0xE0, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x70, 0x78,
  0x3C, 0x1E, 0x0F, 0x07, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0xE0, 0xF0, 0x78, 0x3C, 0x00,
  0x0E, 0x3E, 0x07, 0xC0, 0xEF, 0xF1, 0xFE, 0x1F, 0xFF, 0xBF, 0xF1, 0xD8,
  0x7F, 0x0F, 0x1F, 0x07, 0xE0, 0xF1, 0xE0, 0x7C, 0x0F, 0x1E, 0x07, 0xC0,
  0xF3, 0xC0, 0x78, 0x0F, 0x3C, 0x07, 0x80, 0xE3, 0xC0, 0x70, 0x0E, 0x38,
  0x07, 0x01, 0xE7, 0x80, 0xF0, 0x1E, 0x78, 0x0F, 0x01, 0xE7, 0x80, 0xF0,
  0x1C, 0x78, 0x0E, 0x03, 0xC7, 0x01, 0xE0, 0x3C, 0xF0, 0x1E, 0x03, 0xCF,
  0x01, 0xE0, 0x3C, 0xF0, 0x1E, 0x03, 0x80, 0x0E, 0x3F, 0x03, 0xBF, 0xE1,
  0xFF, 0xF8, 0x7F, 0x1F, 0x1F, 0x03, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C, 0xF0,
  0x1E, 0x3C, 0x07, 0x8F, 0x01, 0xE3, 0x80, 0x79, 0xE0, 0x1E, 0x78, 0x0F,
  0x1E, 0x03, 0xC7, 0x80, 0xF1, 0xC0, 0x3C, 0xF0, 0x0E, 0x3C, 0x07, 0x8F,
  0x01, 0xE0, 0x03, 0xF8, 0x0F, 0xFC, 0x1F, 0xFE, 0x3E, 0x1F, 0x3C, 0x0F,
  0x78, 0x0F, 0x78, 0x07, 0xF0, 0x07, 0xF0, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x1E, 0xF0, 0x3E, 0xF8, 0x7C, 0x7F, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x03, 0x8F, 0x80, 0x3B, 0xFC, 0x07, 0xFF, 0xE0,
  0x7E, 0x1E, 0x07, 0xC0, 0xF0, 0x78, 0x0F, 0x07, 0x80, 0xF0, 0xF0, 0x0F,
  0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0E, 0x01, 0xE1, 0xE0, 0x1E, 0x1E, 0x01,
  0xE1, 0xE0, 0x3C, 0x1E, 0x03, 0xC1, 0xF0, 0x78, 0x3F, 0xFF, 0x83, 0xDF,
  0xE0, 0x3C, 0xFC, 0x03, 0x80, 0x00, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0x70, 0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x03, 0xE1, 0xC3, 0xFE, 0xE1, 0xFF, 0xB8, 0xF8, 0x7E, 0x3C, 0x0F, 0x9E,
  0x03, 0xC7, 0x80, 0xF3, 0xC0, 0x3C, 0xF0, 0x0F, 0x3C, 0x03, 0xCF, 0x00,
  0xE3, 0x80, 0x78, 0xE0, 0x1E, 0x38, 0x0F, 0x8F, 0x07, 0xC3, 0xC3, 0xF0,
  0xFF, 0xDC, 0x1F, 0xEF, 0x03, 0xF3, 0xC0, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x70, 0x00, 0x3C, 0x00, 0x0F,
  0x00, 0x0E, 0x3C, 0x3B, 0xF1, 0xFF, 0xC7, 0xF0, 0x1F, 0x80, 0x7C, 0x01,
  0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x00, 0x07,
  0xF8, 0x1F, 0xFC, 0x7F, 0xF0, 0xF0, 0x23, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1E, 0x40, 0x3C, 0xFF, 0xF1, 0xFF, 0xE1, 0xFF, 0x00, 0x07,
  0x01, 0xC0, 0x38, 0x0F, 0x03, 0xFF, 0xFF, 0xFF, 0xF9, 0xE0, 0x3C, 0x07,
  0x80, 0xE0, 0x3C, 0x07, 0x80, 0xF0, 0x1C, 0x03, 0x80, 0xF0, 0x1E, 0x03,
  0xC0, 0x78, 0x0F, 0xF1, 0xFE, 0x1F, 0xC0, 0x1C, 0x03, 0xCF, 0x00, 0xE3,
  0xC0, 0x78, 0xF0, 0x1E, 0x38, 0x07, 0x8E, 0x01, 0xE7, 0x80, 0x71, 0xE0,
  0x3C, 0x78, 0x0F, 0x1C, 0x03, 0xCF, 0x00, 0xE3, 0xC0, 0x78, 0xF0, 0x1E,
  0x3C, 0x0F, 0x8F, 0x07, 0xE3, 0xC3, 0xF0, 0xFF, 0xDC, 0x1F, 0xE7, 0x03,
  0xF1, 0xC0, 0xE0, 0x0F, 0xF0, 0x07, 0xBC, 0x07, 0x9E, 0x03, 0xCF, 0x03,
  0xC7, 0x81, 0xE3, 0xC1, 0xE0, 0xE0, 0xF0, 0x70, 0xF0, 0x38, 0x78, 0x1C,
  0x78, 0x0E, 0x38, 0x07, 0x3C, 0x03, 0xDC, 0x01, 0xFE, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x3E, 0x07, 0xF8, 0x1F,
  0x03, 0xFC, 0x1F, 0x81, 0xDE, 0x0F, 0xC1, 0xEF, 0x06, 0xE0, 0xE7, 0x87,
  0x70, 0xF3, 0xC3, 0xB8, 0x71, 0xE3, 0x9C, 0x78, 0xF1, 0xCE, 0x3C, 0x79,
  0xC7, 0x3C, 0x3C, 0xE3, 0x9E, 0x0E, 0xE1, 0xCE, 0x07, 0x70, 0xEF, 0x03,
  0xB8, 0x77, 0x01, 0xF8, 0x3F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x0F, 0xC0,
  0x3E, 0x07, 0xC0, 0x1E, 0x03, 0xE0, 0x00, 0x0F, 0x01, 0xF0, 0xF0, 0x3E,
  0x07, 0x87, 0xC0, 0x78, 0x78, 0x03, 0x8F, 0x00, 0x3D, 0xE0, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x80, 0x07, 0xF8, 0x00, 0xF3, 0xC0, 0x1E, 0x3C, 0x03, 0xE1, 0xC0, 0x3C,
  0x1E, 0x07, 0x80, 0xE0, 0xF0, 0x0F, 0x00, 0x07, 0x00, 0x7C, 0x1E, 0x01,
  0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x3C, 0x07, 0x81, 0xE0, 0x1E, 0x07, 0x80,
  0x38, 0x3C, 0x00, 0xE0, 0xF0, 0x03, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x3C,
  0xF0, 0x00, 0xF3, 0xC0, 0x01, 0xDE, 0x00, 0x07, 0x70, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xFF,
  0x83, 0xFF, 0xC3, 0xFF, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7F, 0xFC, 0x3F, 0xFE,
  0x3F, 0xFE, 0x00, 0x00, 0x3C, 0x03, 0xF0, 0x0F, 0xC0, 0x78, 0x01, 0xC0,
  0x07, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x01, 0xE0,
  0x07, 0x00, 0xFC, 0x07, 0xC0, 0x3E, 0x00, 0xFC, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3C, 0x00, 0x30, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80,
  0x07, 0x80, 0x3E, 0x01, 0xF8, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03,
  0xE0, 0x0F, 0x03, 0xF8, 0x3E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x0E, 0x00, 0xF0, 0x07, 0x01, 0xF8, 0x0F, 0x80, 0x78,
  0x02, 0x00, 0x00, 0x1E, 0x00, 0xBF, 0xE0, 0xFF, 0xFF, 0xFC, 0x3F, 0xF8,
  0x07, 0xE0,
};

const GFXglyph NotoSans_MediumItalic35pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 9, 0, -1 },
  { 1, 9, 25, 9, 1, -25 },
  { 30, 11, 9, 14, 4, -25 },
  { 43, 22, 25, 23, 1, -25 },
  { 112, 18, 29, 19, 1, -27 },
  { 178, 24, 25, 29, 3, -25 },
  { 253, 22, 25, 24, 1, -25 },
  { 322, 5, 9, 8, 4, -25 },
  { 328, 12, 31, 11, 1, -25 },
  { 375, 12, 31, 11, -3, -25 },
  { 422, 17, 17, 19, 3, -27 },
  { 459, 17, 17, 20, 2, -21 },
  { 496, 8, 9, 9, -2, -4 },
  { 505, 9, 3, 11, 1, -11 },
  { 509, 5, 5, 9, 1, -5 },
  { 513, 18, 25, 13, -2, -25 },
  { 570, 17, 25, 19, 2, -25 },
  { 624, 12, 25, 19, 4, -25 },
  { 662, 19, 25, 19, 0, -25 },
  { 722, 18, 25, 19, 1, -25 },
  { 779, 19, 25, 19, 0, -25 },
  { 839, 18, 25, 19, 1, -25 },
  { 896, 17, 25, 19, 2, -25 },
  { 950, 18, 25, 19, 2, -25 },
  { 1007, 18, 25, 19, 1, -25 },
  { 1064, 16, 25, 19, 2, -25 },
  { 1114, 7, 19, 9, 1, -19 },
  { 1131, 10, 24, 9, -2, -19 },
  { 1161, 17, 17, 20, 2, -21 },
  { 1198, 17, 10, 20, 2, -17 },
  { 1220, 17, 17, 20, 2, -21 },
  { 1257, 13, 25, 15, 3, -25 },
  { 1298, 27, 28, 30, 2, -25 },
  { 1393, 21, 25, 20, -2, -25 },
  { 1459, 20, 25, 21, 1, -25 },
  { 1522, 20, 25, 21, 2, -25 },
  { 1585, 21, 25, 23, 1, -25 },
  { 1651, 19, 25, 18, 1, -25 },
  { 1711, 19, 25, 17, 1, -25 },
  { 1771, 21, 25, 24, 2, -25 },
  { 1837, 23, 25, 24, 1, -25 },
  { 1909, 15, 25, 12, -1, -25 },
  { 1956, 16, 32, 10, -6, -25 },
  { 2020, 22, 25, 20, 1, -25 },
  { 2089, 14, 25, 17, 1, -25 },
  { 2133, 29, 25, 30, 1, -25 },
  { 2224, 24, 25, 25, 1, -25 },
  { 2299, 22, 25, 25, 2, -25 },
  { 2368, 19, 25, 20, 1, -25 },
  { 2428, 22, 31, 25, 2, -25 },
  { 2514, 19, 25, 21, 1, -25 },
  { 2574, 17, 25, 18, 1, -25 },
  { 2628, 18, 25, 18, 3, -25 },
  { 2685, 21, 25, 24, 3, -25 },
  { 2751, 20, 25, 20, 3, -25 },
  { 2814, 29, 25, 30, 4, -25 },
  { 2905, 24, 25, 19, -2, -25 },
  { 2980, 19, 25, 18, 3, -25 },
  { 3040, 21, 25, 19, -1, -25 },
  { 3106, 13, 31, 11, 0, -25 },
  { 3157, 7, 25, 13, 4, -25 },
  { 3179, 13, 31, 11, -2, -25 },
  { 3230, 18, 16, 20, 1, -25 },
  { 3266, 14, 3, 14, -3, 3 },
  { 3272, 6, 6, 10, 5, -27 },
  { 3277, 18, 19, 20, 2, -19 },
  { 3320, 18, 27, 20, 1, -27 },
  { 3381, 14, 19, 16, 2, -19 },
  { 3415, 19, 27, 20, 2, -27 },
  { 3480, 15, 19, 18, 2, -19 },
  { 3516, 20, 35, 12, -4, -27 },
  { 3604, 19, 27, 20, 1, -19 },
  { 3669, 18, 27, 21, 1, -27 },
  { 3730, 9, 26, 9, 1, -26 },
  { 3760, 14, 34, 9, -4, -26 },
  { 3820, 18, 27, 18, 1, -27 },
  { 3881, 9, 27, 9, 1, -27 },
  { 3912, 28, 19, 31, 1, -19 },
  { 3979, 18, 19, 21, 1, -19 },
  { 4022, 16, 19, 20, 2, -19 },
  { 4060, 20, 27, 20, -1, -19 },
  { 4128, 18, 27, 20, 2, -19 },
  { 4189, 14, 19, 14, 1, -19 },
  { 4223, 15, 19, 16, 0, -19 },
  { 4259, 11, 23, 12, 2, -23 },
  { 4291, 18, 19, 21, 2, -19 },
  { 4334, 17, 19, 17, 2, -19 },
  { 4375, 25, 19, 26, 2, -19 },
  { 4435, 20, 19, 17, -1, -19 },
  { 4483, 22, 27, 17, -3, -19 },
  { 4558, 17, 19, 16, -1, -19 },
  { 4599, 14, 31, 12, 0, -25 },
  { 4654, 3, 35, 19, 9, -27 },
  { 4668, 13, 31, 12, -1, -25 },
  { 4719, 17, 5, 20, 2, -15 },
};

const GFXfont NotoSans_MediumItalic35pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic35pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic35pt7bGlyphs,
  0x20, 0x7E, 48
};

#endif // _NOTOSANS_MEDIUMITALIC35PT7B_H_
