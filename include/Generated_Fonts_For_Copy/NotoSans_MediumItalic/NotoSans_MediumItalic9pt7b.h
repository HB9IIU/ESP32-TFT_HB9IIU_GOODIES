#ifndef _NOTOSANS_MEDIUMITALIC9PT7B_H_
#define _NOTOSANS_MEDIUMITALIC9PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 9pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic9pt7bBitmaps[] PROGMEM = {
  0x00, 0x69, 0x21, 0x00, 0xB8, 0x29, 0xF2, 0xBE, 0x51, 0x40, 0x13, 0xD8,
  0xC3, 0x59, 0x88, 0x46, 0xAB, 0x37, 0xB5, 0x59, 0x80, 0x10, 0xA2, 0x8C,
  0x56, 0x67, 0xC0, 0xC0, 0x29, 0x49, 0x10, 0x24, 0x92, 0x70, 0x2A, 0x7A,
  0x4F, 0x44, 0xE0, 0xE0, 0x80, 0x12, 0x24, 0x88, 0x13, 0x52, 0x98, 0xC9,
  0xC0, 0x74, 0xA4, 0x80, 0x32, 0x42, 0x22, 0x23, 0xC0, 0x32, 0x42, 0x65,
  0x0B, 0xC0, 0x19, 0x95, 0x2F, 0x98, 0x7A, 0x1C, 0x21, 0x78, 0x34, 0x8E,
  0x9A, 0xE0, 0xF2, 0x24, 0x48, 0x13, 0x52, 0x65, 0x49, 0xC0, 0x22, 0xD2,
  0xB3, 0x0B, 0x80, 0x40, 0x80, 0x40, 0xA0, 0x12, 0xCC, 0x30, 0xFF, 0x8C,
  0x36, 0x80, 0x54, 0xA8, 0x20, 0x3E, 0xBD, 0x9D, 0x5B, 0x68, 0x0E, 0x00,
  0x18, 0x62, 0x8E, 0x47, 0x10, 0x7A, 0x5C, 0x94, 0xF8, 0x32, 0x61, 0x08,
  0x43, 0xC0, 0x79, 0x14, 0x51, 0x4B, 0xC0, 0x7A, 0x1C, 0x84, 0x78, 0x7A,
  0x1C, 0x84, 0x40, 0x32, 0x61, 0x59, 0x4B, 0xC0, 0x65, 0x17, 0xD2, 0x4A,
  0x20, 0x74, 0x44, 0x4C, 0x12, 0x22, 0x24, 0x48, 0x6D, 0x46, 0x14, 0x52,
  0x60, 0x64, 0x44, 0x4F, 0x63, 0x66, 0x66, 0x5A, 0x52, 0x94, 0x66, 0xC9,
  0x52, 0xA4, 0xD1, 0x00, 0x22, 0xE3, 0x18, 0xCF, 0xC0, 0x7A, 0x52, 0xE4,
  0x40, 0x22, 0xE3, 0x18, 0xCF, 0xC4, 0x10, 0x7A, 0x56, 0xE5, 0x4C, 0x32,
  0x50, 0xC1, 0x0B, 0xC0, 0xF4, 0x44, 0x48, 0xCC, 0x63, 0x29, 0x70, 0x9C,
  0xA9, 0x4C, 0x60, 0x93, 0xB2, 0xB4, 0xD4, 0xC8, 0x88, 0x4C, 0xC2, 0x14,
  0x52, 0x40, 0x9D, 0x18, 0x84, 0x40, 0x78, 0x88, 0xC4, 0x78, 0x69, 0x29,
  0x30, 0xAA, 0x50, 0x31, 0x22, 0x22, 0xC0, 0x22, 0x95, 0x10, 0xF0, 0x90,
  0x3A, 0x63, 0x27, 0x00, 0x22, 0x1C, 0x94, 0xAB, 0xC0, 0x34, 0x88, 0x70,
  0x08, 0x4E, 0x98, 0xC9, 0xC0, 0x35, 0xF8, 0x70, 0x18, 0x9C, 0x42, 0x11,
  0x08, 0xC0, 0x3A, 0x63, 0x27, 0x0B, 0x80, 0x22, 0x1E, 0x94, 0xAA, 0x40,
  0x61, 0x24, 0xA0, 0x30, 0x22, 0x22, 0x44, 0xC0, 0x22, 0x12, 0xA6, 0x52,
  0x40, 0x29, 0x24, 0xA0, 0x76, 0x95, 0x2A, 0x99, 0x20, 0x7A, 0x52, 0xA9,
  0x00, 0x32, 0x63, 0x27, 0x00, 0x72, 0x52, 0xAF, 0x42, 0x00, 0x3A, 0x63,
  0x27, 0x08, 0x40, 0x74, 0x44, 0x80, 0x74, 0x62, 0xE0, 0x5D, 0x24, 0xC0,
  0x4A, 0x53, 0x27, 0x00, 0x8A, 0x94, 0xC4, 0x00, 0xA7, 0xAE, 0xA4, 0x90,
  0x5A, 0x88, 0xC9, 0x00, 0x44, 0xA2, 0x8C, 0x20, 0x8C, 0x00, 0x72, 0x24,
  0xE0, 0x32, 0x48, 0x44, 0x40, 0xFF, 0x80, 0x65, 0x14, 0xA0, 0xF0,
};

const GFXglyph NotoSans_MediumItalic9pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 2, 0, -1 },
  { 1, 3, 6, 2, 0, -6 },
  { 4, 3, 2, 4, 1, -6 },
  { 5, 6, 6, 6, 0, -6 },
  { 10, 5, 8, 5, 0, -7 },
  { 15, 6, 7, 7, 1, -7 },
  { 21, 6, 7, 6, 0, -7 },
  { 27, 1, 2, 2, 1, -6 },
  { 28, 3, 7, 3, 0, -6 },
  { 31, 3, 7, 3, -1, -6 },
  { 34, 4, 4, 5, 1, -7 },
  { 36, 4, 4, 5, 1, -5 },
  { 38, 2, 2, 2, 0, -1 },
  { 39, 3, 1, 3, 0, -3 },
  { 40, 1, 1, 2, 0, -1 },
  { 41, 4, 6, 3, 0, -6 },
  { 44, 5, 7, 5, 0, -7 },
  { 49, 3, 6, 5, 1, -6 },
  { 52, 5, 7, 5, 0, -7 },
  { 57, 5, 7, 5, 0, -7 },
  { 62, 5, 6, 5, 0, -6 },
  { 66, 5, 6, 5, 0, -6 },
  { 70, 4, 7, 5, 1, -7 },
  { 74, 4, 6, 5, 1, -6 },
  { 77, 5, 7, 5, 0, -7 },
  { 82, 5, 7, 5, 0, -7 },
  { 87, 2, 5, 2, 0, -5 },
  { 89, 2, 6, 2, 0, -5 },
  { 91, 4, 5, 5, 1, -6 },
  { 94, 4, 2, 5, 1, -4 },
  { 95, 4, 5, 5, 1, -6 },
  { 98, 3, 7, 4, 1, -7 },
  { 101, 7, 7, 8, 0, -6 },
  { 108, 6, 6, 5, -1, -6 },
  { 113, 5, 6, 5, 0, -6 },
  { 117, 5, 7, 5, 1, -7 },
  { 122, 6, 6, 6, 0, -6 },
  { 127, 5, 6, 5, 0, -6 },
  { 131, 5, 6, 4, 0, -6 },
  { 135, 5, 7, 6, 1, -7 },
  { 140, 6, 6, 6, 0, -6 },
  { 145, 4, 6, 3, 0, -6 },
  { 148, 4, 8, 3, -1, -6 },
  { 152, 6, 6, 5, 0, -6 },
  { 157, 4, 6, 4, 0, -6 },
  { 160, 8, 6, 8, 0, -6 },
  { 166, 7, 6, 7, 0, -6 },
  { 172, 5, 7, 7, 1, -7 },
  { 177, 5, 6, 5, 0, -6 },
  { 181, 5, 9, 7, 1, -7 },
  { 187, 5, 6, 5, 0, -6 },
  { 191, 5, 7, 5, 0, -7 },
  { 196, 4, 6, 5, 1, -6 },
  { 199, 5, 6, 6, 1, -6 },
  { 203, 5, 6, 5, 1, -6 },
  { 207, 8, 6, 8, 1, -6 },
  { 213, 6, 6, 5, 0, -6 },
  { 218, 5, 6, 5, 1, -6 },
  { 222, 5, 6, 5, 0, -6 },
  { 226, 3, 7, 3, 0, -6 },
  { 229, 2, 6, 3, 1, -6 },
  { 231, 4, 7, 3, -1, -6 },
  { 235, 5, 4, 5, 0, -6 },
  { 238, 4, 1, 4, -1, 1 },
  { 239, 2, 2, 3, 1, -7 },
  { 240, 5, 5, 5, 0, -5 },
  { 244, 5, 7, 5, 0, -7 },
  { 249, 4, 5, 4, 0, -5 },
  { 252, 5, 7, 5, 0, -7 },
  { 257, 4, 5, 5, 0, -5 },
  { 260, 5, 9, 3, -1, -7 },
  { 266, 5, 7, 5, 0, -5 },
  { 271, 5, 7, 5, 0, -7 },
  { 276, 3, 7, 2, 0, -7 },
  { 279, 4, 9, 2, -1, -7 },
  { 284, 5, 7, 5, 0, -7 },
  { 289, 3, 7, 2, 0, -7 },
  { 292, 7, 5, 8, 0, -5 },
  { 297, 5, 5, 5, 0, -5 },
  { 301, 5, 5, 5, 0, -5 },
  { 305, 5, 7, 5, 0, -5 },
  { 310, 5, 7, 5, 0, -5 },
  { 315, 4, 5, 4, 0, -5 },
  { 318, 4, 5, 4, 0, -5 },
  { 321, 3, 6, 3, 0, -6 },
  { 324, 5, 5, 5, 0, -5 },
  { 328, 5, 5, 4, 0, -5 },
  { 332, 6, 5, 7, 1, -5 },
  { 336, 5, 5, 4, 0, -5 },
  { 340, 6, 7, 4, -1, -5 },
  { 346, 4, 5, 4, 0, -5 },
  { 349, 4, 7, 3, 0, -6 },
  { 353, 1, 9, 5, 2, -7 },
  { 355, 3, 7, 3, 0, -6 },
  { 358, 4, 1, 5, 1, -4 },
};

const GFXfont NotoSans_MediumItalic9pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic9pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic9pt7bGlyphs,
  0x20, 0x7E, 12
};

#endif // _NOTOSANS_MEDIUMITALIC9PT7B_H_
