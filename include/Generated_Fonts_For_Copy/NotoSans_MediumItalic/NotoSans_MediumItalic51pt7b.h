#ifndef _NOTOSANS_MEDIUMITALIC51PT7B_H_
#define _NOTOSANS_MEDIUMITALIC51PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 51pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic51pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0,
  0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x07, 0xE0, 0x3F, 0x80, 0xFE, 0x03, 0xF8,
  0x0F, 0xE0, 0x3F, 0x00, 0x30, 0x00, 0x3F, 0x1F, 0x9F, 0x0F, 0x8F, 0x87,
  0xC7, 0xC3, 0xE3, 0xC1, 0xE3, 0xE1, 0xF1, 0xF0, 0xF8, 0xF0, 0x7C, 0x78,
  0x3C, 0x3C, 0x1E, 0x1E, 0x0F, 0x0E, 0x07, 0x0F, 0x03, 0x80, 0x00, 0x03,
  0xC0, 0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07,
  0x80, 0xF0, 0x00, 0x07, 0x81, 0xF0, 0x00, 0x0F, 0x81, 0xE0, 0x00, 0x0F,
  0x01, 0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x03, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x3C, 0x07, 0x80, 0x00, 0x3C,
  0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x78,
  0x1F, 0x00, 0x00, 0xF8, 0x1E, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00, 0xF0,
  0x1E, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xE0, 0x78, 0x00, 0x03, 0xC0,
  0x78, 0x00, 0x03, 0xC0, 0xF8, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x07, 0x80,
  0xF0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x01,
  0xE0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x3C, 0x00, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x03, 0xF9, 0xC7, 0x83, 0xF1, 0xE0, 0x81, 0xF0, 0xE0, 0x00,
  0xF8, 0x70, 0x00, 0x7C, 0x38, 0x00, 0x3E, 0x3C, 0x00, 0x1F, 0x1E, 0x00,
  0x0F, 0xCE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xF0,
  0x00, 0x1F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F,
  0xF8, 0x00, 0x3C, 0xFC, 0x00, 0x1E, 0x3E, 0x00, 0x0E, 0x1F, 0x00, 0x07,
  0x0F, 0x80, 0x07, 0x87, 0xC0, 0x03, 0xC7, 0xE2, 0x01, 0xC3, 0xF1, 0xE0,
  0xE7, 0xF0, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF0, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x03, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x3F, 0xF8, 0x00, 0x7C, 0x0F,
  0xFF, 0x00, 0x0F, 0x03, 0xF1, 0xF0, 0x03, 0xC0, 0x7C, 0x3E, 0x00, 0xF8,
  0x1F, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x01,
  0xE0, 0x1F, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x1F, 0x00, 0x78, 0x0F,
  0x83, 0xC0, 0x0F, 0x01, 0xE0, 0xF8, 0x01, 0xE0, 0x3C, 0x3E, 0x00, 0x3C,
  0x0F, 0x8F, 0x80, 0x07, 0x81, 0xE1, 0xE3, 0xFC, 0xF0, 0x3C, 0x7C, 0xFF,
  0xDE, 0x0F, 0x9F, 0x3F, 0xFF, 0xE3, 0xE7, 0xCF, 0xFF, 0xFF, 0xF8, 0xF1,
  0xF0, 0xF7, 0xFF, 0x3E, 0x7C, 0x1E, 0x7F, 0x8F, 0x8F, 0x03, 0xC3, 0xC1,
  0xE3, 0xE0, 0x78, 0x00, 0x78, 0x7C, 0x0F, 0x00, 0x1F, 0x0F, 0x01, 0xE0,
  0x07, 0xC1, 0xE0, 0x3C, 0x00, 0xF0, 0x7C, 0x0F, 0x80, 0x3C, 0x0F, 0x81,
  0xF0, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0x80, 0x78, 0x07,
  0xC1, 0xF0, 0x1E, 0x00, 0xF8, 0x3C, 0x07, 0xC0, 0x1F, 0x0F, 0x81, 0xF0,
  0x01, 0xFF, 0xE0, 0x3C, 0x00, 0x3F, 0xFC, 0x0F, 0x00, 0x03, 0xFF, 0x03,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F,
  0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0x80, 0x01, 0xF0, 0x0F,
  0x80, 0x01, 0xF0, 0x1F, 0x80, 0x01, 0xF0, 0x3F, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0xFB, 0xF8, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0x80, 0x3F, 0x1F, 0xEF, 0x80, 0x3E, 0x3F, 0x8F, 0xC0,
  0x7E, 0x7F, 0x07, 0xE0, 0x7C, 0x7E, 0x03, 0xF0, 0xFC, 0xFC, 0x03, 0xF1,
  0xF8, 0xFC, 0x01, 0xF9, 0xF0, 0xF8, 0x00, 0xFF, 0xF0, 0xF8, 0x00, 0xFF,
  0xE0, 0xF8, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F,
  0x80, 0xFC, 0x00, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE7, 0xF0, 0x1F, 0xFF, 0xC3, 0xF0, 0x0F, 0xFF, 0x01,
  0xF8, 0x00, 0xC0, 0x00, 0x00, 0x3F, 0x3E, 0x3E, 0x3E, 0x3C, 0x7C, 0x7C,
  0x78, 0x78, 0x78, 0x78, 0x70, 0xF0, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1E,
  0x00, 0x40, 0x1E, 0x00, 0x70, 0x1E, 0x00, 0x7C, 0x1C, 0x00, 0xFF, 0x1C,
  0x00, 0xFF, 0xDC, 0x00, 0x1F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0x00, 0xFD, 0xFF, 0x01, 0xFE, 0x01, 0x07, 0xDE, 0x00, 0x0F, 0xCF,
  0x00, 0x1F, 0x8F, 0x00, 0x3F, 0x0F, 0x80, 0x7E, 0x0F, 0x80, 0x1E, 0x07,
  0x80, 0x0C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x02, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xE1,
  0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x81,
  0xE0, 0x7C, 0x0F, 0x00, 0x7F, 0xFD, 0xFF, 0xE7, 0xFF, 0xBF, 0xFE, 0xFF,
  0xF8, 0x18, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0xFF,
  0xFC, 0x01, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x7E, 0x0F, 0xE0,
  0x3F, 0x0F, 0xC0, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x3F, 0x00,
  0x1F, 0x3F, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00, 0x1F, 0x7E, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFC, 0x00, 0x3F, 0xFC, 0x00,
  0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x3E, 0xF8, 0x00,
  0x3E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7E, 0xF8, 0x00, 0x7C, 0xF8, 0x00,
  0xFC, 0xF8, 0x00, 0xFC, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xF8, 0xFC, 0x03,
  0xF0, 0xFC, 0x07, 0xE0, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x1F, 0xC0, 0x3F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF0, 0xFF, 0xF8, 0xFF,
  0x7D, 0xFF, 0x7E, 0x7E, 0x3E, 0x1E, 0x1F, 0x0C, 0x0F, 0x80, 0x0F, 0xC0,
  0x07, 0xE0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFC, 0x03, 0xF0, 0x1F, 0xC0,
  0x38, 0x01, 0xF8, 0x06, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0x78, 0x07, 0xF0, 0x18, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8,
  0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF,
  0xC0, 0x01, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F,
  0xC3, 0x00, 0x07, 0xF0, 0xF8, 0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7D, 0xF0,
  0x00, 0x1F, 0xBC, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xF9, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x0F, 0x8F, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC, 0x3E, 0x00,
  0x3F, 0x07, 0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x7C, 0x07,
  0xC0, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x01, 0xF8, 0x07, 0xE0, 0x7E,
  0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x03, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFE, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE,
  0x00, 0x40, 0x3F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x20, 0x00, 0x7F, 0x08, 0x00, 0x3F, 0x83, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x07, 0xFF,
  0xE0, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF0, 0x0F, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x7F, 0x00, 0xFC, 0xFF, 0xE0, 0x7E, 0xFF, 0xF8, 0x3E, 0xFF, 0xFC, 0x1F,
  0xF8, 0xFF, 0x0F, 0xF0, 0x1F, 0x8F, 0xE0, 0x07, 0xC7, 0xF0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xF8, 0x00, 0x7E, 0x7C, 0x00, 0x3F,
  0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xE0, 0x07,
  0xC3, 0xF0, 0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0x07, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x03,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFC,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x01, 0xFC, 0x7F, 0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x1F, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00, 0xFC, 0x1F,
  0x80, 0x3E, 0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0x3F, 0x87, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x1F, 0xFF, 0xC0, 0x0F, 0xF3, 0xF8, 0x07, 0xF0, 0x7E, 0x03, 0xF0,
  0x0F, 0xC1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0x8F,
  0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x7F, 0x01, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00,
  0x1C, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x3F, 0x00,
  0xFC, 0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0xCF, 0xC0,
  0x07, 0xE7, 0xE0, 0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0xF8,
  0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x87,
  0xE0, 0x7F, 0xC3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF0, 0x3F, 0xFD, 0xF0,
  0x0F, 0xF8, 0xF8, 0x01, 0xE0, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0x10,
  0x00, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFE, 0x1F, 0x81, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x1F, 0x87, 0xF0, 0xFE,
  0x1F, 0xC3, 0xF8, 0x7E, 0x07, 0x00, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8,
  0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF0,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0,
  0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xFE, 0x00,
  0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x03,
  0xFF, 0x80, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC7, 0xFF, 0xFC, 0x3F, 0xFF, 0xE3, 0xC0, 0x7E, 0x20, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x00, 0xFC, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xC7,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x07, 0xC0, 0x00,
  0x00, 0x7C, 0x1F, 0x00, 0x00, 0x00, 0x78, 0x7C, 0x01, 0xFF, 0xC0, 0xF8,
  0xF0, 0x0F, 0xFF, 0xC0, 0xF3, 0xE0, 0x3F, 0xFF, 0x81, 0xE7, 0x80, 0xFC,
  0x1F, 0x03, 0xDF, 0x03, 0xE0, 0x3E, 0x07, 0xBC, 0x0F, 0x80, 0x78, 0x0F,
  0xF8, 0x1F, 0x00, 0xF0, 0x1F, 0xF0, 0x7C, 0x03, 0xE0, 0x3F, 0xC0, 0xF0,
  0x07, 0x80, 0x7F, 0x81, 0xE0, 0x0F, 0x00, 0xFF, 0x07, 0xC0, 0x3E, 0x03,
  0xFE, 0x0F, 0x80, 0x7C, 0x07, 0xBC, 0x1F, 0x00, 0xF0, 0x0F, 0x78, 0x3E,
  0x03, 0xE0, 0x3E, 0xF0, 0x7C, 0x07, 0xC0, 0xF9, 0xE0, 0xF8, 0x1F, 0x81,
  0xE3, 0xC0, 0xF8, 0x77, 0x8F, 0xC7, 0x81, 0xFF, 0xEF, 0xFF, 0x0F, 0x81,
  0xFF, 0x9F, 0xFC, 0x1F, 0x01, 0xFE, 0x1F, 0xE0, 0x1E, 0x00, 0xE0, 0x07,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x01,
  0x80, 0x00, 0x7F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x03, 0xEF,
  0x00, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x0F, 0x8F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x07, 0xC3, 0xE0, 0x00, 0x3F, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xE0,
  0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8,
  0x0F, 0x80, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F,
  0xC0, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x0F, 0x8F, 0xC0,
  0x00, 0x3E, 0x3F, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x1F, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x01, 0xF0, 0x1F, 0xF0, 0x3F,
  0x00, 0x7F, 0x03, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x07, 0xE0, 0x7C, 0x00, 0xFE, 0x0F, 0xC0, 0x3F, 0xC0, 0xFF, 0xFF,
  0xF0, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x01,
  0xF8, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0x81, 0xF0, 0x01, 0xF8, 0x1F, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC,
  0x3E, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x87, 0xE0,
  0x03, 0xF8, 0x7C, 0x00, 0x7F, 0x07, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0xFE,
  0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFC, 0x03, 0xC0, 0x3F, 0xC0,
  0x01, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x80, 0x1F,
  0xF0, 0x7E, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0xFF,
  0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x30, 0x00, 0x00, 0x01, 0xFF,
  0xFC, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x1F, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0xFC, 0x00,
  0xFE, 0x01, 0xF0, 0x00, 0xFE, 0x03, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x07,
  0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F,
  0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xF0,
  0xFC, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x1F, 0x87,
  0xC0, 0x00, 0x7E, 0x0F, 0x80, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x07, 0xE0, 0xF8, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x00, 0x7F, 0xC0, 0x3F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x80, 0x7F, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0, 0x0F, 0xC0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0x80, 0xFF, 0x00,
  0x02, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xE3,
  0xF0, 0x07, 0xFF, 0xC7, 0xC0, 0x0F, 0xFF, 0x8F, 0x80, 0x1F, 0xFE, 0x3F,
  0x00, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xF0, 0xF8,
  0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC, 0x0F, 0xE0, 0x01, 0xF0, 0x1F, 0xE0,
  0x03, 0xE0, 0x1F, 0xF8, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x60,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x7C,
  0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x01, 0xF0, 0x1F,
  0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7E, 0x03,
  0xE0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x1F, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x03, 0xE0,
  0x3F, 0x00, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFE, 0x03, 0xF0, 0x00, 0x1F,
  0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xE0, 0x00,
  0x3E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00,
  0x0F, 0x80, 0x7C, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF,
  0xC0, 0x7F, 0xFE, 0x00, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x3F, 0xF8, 0x07, 0xFF, 0xE0,
  0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0x80,
  0x0F, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0x01,
  0xF0, 0x07, 0xE0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x1F, 0x80, 0x03,
  0xE0, 0x3F, 0x80, 0x03, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x07, 0xC3, 0xF8, 0x00, 0x07, 0xC7, 0xF0, 0x00, 0x07,
  0xCF, 0xE0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x0F,
  0xBF, 0x80, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0xC0, 0x00, 0x1F, 0xC7, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F,
  0x01, 0xF0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x7E,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00,
  0x07, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFE, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x00, 0x1F, 0xE0,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x07, 0xF8, 0x00, 0x03, 0xFE, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x00,
  0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0x7C, 0x03, 0xDF, 0x00, 0x07, 0xDF,
  0x01, 0xF3, 0xC0, 0x03, 0xEF, 0xC0, 0x7C, 0xF0, 0x00, 0xFB, 0xE0, 0x1F,
  0x3C, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x00, 0x1F, 0x3E, 0x01, 0xF3, 0xC0,
  0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x03, 0xC7, 0xE0, 0x3E, 0x3E, 0x01, 0xF1,
  0xF0, 0x0F, 0x8F, 0x80, 0x78, 0x7C, 0x03, 0xE3, 0xE0, 0x3E, 0x1F, 0x00,
  0xF8, 0xF8, 0x0F, 0x0F, 0xC0, 0x7C, 0x1E, 0x07, 0xC3, 0xF0, 0x1F, 0x07,
  0x83, 0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0xF8, 0x3E, 0x01, 0xF0, 0x78, 0x7C,
  0x0F, 0x80, 0xFC, 0x1E, 0x1F, 0x07, 0xE0, 0x3E, 0x07, 0xCF, 0x81, 0xF0,
  0x0F, 0x81, 0xF3, 0xE0, 0x7C, 0x03, 0xE0, 0x7D, 0xF0, 0x1F, 0x00, 0xF8,
  0x1F, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xFE, 0x03, 0xF0, 0x1F, 0x00, 0xFF,
  0x00, 0xF8, 0x07, 0xC0, 0x3F, 0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xE0, 0x0F,
  0x80, 0x7C, 0x03, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x0F,
  0x80, 0x3F, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x01, 0xFC,
  0x00, 0x03, 0xE0, 0x3F, 0x80, 0x00, 0x7C, 0x07, 0xF8, 0x00, 0x1F, 0x00,
  0xFF, 0x00, 0x03, 0xE0, 0x3F, 0xE0, 0x00, 0x7C, 0x07, 0xFE, 0x00, 0x0F,
  0x80, 0xFF, 0xC0, 0x03, 0xF0, 0x1F, 0xF8, 0x00, 0x7C, 0x03, 0xDF, 0x80,
  0x0F, 0x80, 0xF9, 0xF0, 0x01, 0xF0, 0x1F, 0x3E, 0x00, 0x3E, 0x03, 0xE3,
  0xE0, 0x0F, 0xC0, 0x7C, 0x7C, 0x01, 0xF0, 0x0F, 0x8F, 0xC0, 0x3E, 0x03,
  0xE0, 0xF8, 0x07, 0xC0, 0x7C, 0x1F, 0x00, 0xF8, 0x0F, 0x83, 0xF0, 0x3F,
  0x01, 0xF0, 0x3E, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xFC,
  0x1F, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC0,
  0x3F, 0x1F, 0x01, 0xF8, 0x03, 0xE3, 0xE0, 0x3E, 0x00, 0x7C, 0x7C, 0x07,
  0xC0, 0x07, 0xCF, 0x80, 0xF8, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0x1F, 0xFC,
  0x07, 0xC0, 0x01, 0xFF, 0x80, 0xF8, 0x00, 0x3F, 0xF0, 0x1F, 0x00, 0x07,
  0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0x7C, 0x00, 0x0F, 0xF0, 0x1F, 0x00,
  0x01, 0xFE, 0x03, 0xE0, 0x00, 0x1F, 0xC0, 0x7C, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE, 0x03, 0xFC,
  0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7F,
  0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F,
  0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00, 0x00, 0xFC,
  0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0, 0x7F, 0xC0,
  0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x1F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x01, 0xF0,
  0x3F, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xE0, 0x3E, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07,
  0xE0, 0xFC, 0x00, 0xFC, 0x0F, 0x80, 0x3F, 0xC0, 0xF8, 0x3F, 0xF8, 0x0F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFC,
  0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFE,
  0x03, 0xFC, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0,
  0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x3F, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x3F, 0x00,
  0x00, 0x1F, 0x7E, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x3F, 0x7C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFC, 0x7E, 0x00,
  0x00, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7F, 0x00,
  0x03, 0xF0, 0x3F, 0x80, 0x0F, 0xF0, 0x3F, 0xC0, 0x1F, 0xE0, 0x1F, 0xF0,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF,
  0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0xE0, 0x07, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0x03, 0xFC, 0x07,
  0xE0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0x83, 0xF0, 0x01, 0xF0, 0x7C,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x7E, 0x01, 0xFE,
  0x0F, 0x80, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFE, 0x00, 0x3E, 0x07, 0xC0, 0x07, 0xC0, 0xFC, 0x00,
  0xF8, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07,
  0xE0, 0x1F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x1F,
  0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x3E, 0x1F, 0x80, 0x07,
  0xE3, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x0F, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x80, 0xFE, 0x01, 0xC0, 0x7F, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x83, 0x00, 0x0F, 0xE0, 0xF8, 0x1F, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x30, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF,
  0xFE, 0x80, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xFC, 0x1F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xE0, 0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3F,
  0x0F, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xF8, 0x3F, 0x00, 0x01, 0xF0,
  0x7C, 0x00, 0x07, 0xE0, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0x7C, 0x1F, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x1F, 0x07, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0xFC, 0x3F, 0x00,
  0x01, 0xF0, 0x7E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x1F, 0x83, 0xE0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x01,
  0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0xE1, 0xFF,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x7E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00, 0xFC, 0xF8,
  0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03,
  0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0, 0x07, 0xE0, 0x7C, 0x00, 0x7E, 0x07,
  0xC0, 0x0F, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0x01,
  0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0xFC, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1,
  0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x3E, 0x3E, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x3E, 0x7C, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1E,
  0xF8, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xCF, 0xC0, 0x07, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0xFF, 0x80, 0x1F, 0x87, 0xC0, 0x0F, 0xF8, 0x01, 0xF0, 0x7C,
  0x01, 0xFF, 0x80, 0x3F, 0x07, 0xC0, 0x1E, 0xF8, 0x03, 0xE0, 0x7C, 0x03,
  0xEF, 0x80, 0x7E, 0x07, 0xC0, 0x3E, 0x78, 0x07, 0xC0, 0x7C, 0x07, 0xC7,
  0x80, 0x7C, 0x07, 0xC0, 0x7C, 0x78, 0x0F, 0xC0, 0x7C, 0x0F, 0x87, 0x80,
  0xF8, 0x07, 0xC0, 0xF8, 0x78, 0x1F, 0x80, 0x7C, 0x1F, 0x07, 0x81, 0xF0,
  0x07, 0xC1, 0xF0, 0x78, 0x3F, 0x00, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0x07,
  0xC3, 0xE0, 0x78, 0x3E, 0x00, 0x7C, 0x3E, 0x07, 0x87, 0xC0, 0x07, 0xC7,
  0xC0, 0x78, 0x7C, 0x00, 0x7C, 0x7C, 0x07, 0xCF, 0x80, 0x07, 0xCF, 0x80,
  0x7C, 0xF8, 0x00, 0x7C, 0xF8, 0x07, 0xCF, 0x80, 0x07, 0xDF, 0x00, 0x7D,
  0xF0, 0x00, 0x7D, 0xF0, 0x07, 0xDF, 0x00, 0x07, 0xDE, 0x00, 0x7F, 0xE0,
  0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0xC0, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x7F,
  0x80, 0x07, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x0F, 0xE0, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0xFC, 0x00,
  0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xF0,
  0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x03, 0xE7,
  0xE0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0x07, 0xCF,
  0x80, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7E, 0x1F, 0x00, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x07, 0xE0, 0x00,
  0x7C, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x07, 0xEF, 0xC0, 0x03, 0xF1, 0xF0, 0x00, 0xFC,
  0x7C, 0x00, 0x7E, 0x1F, 0x80, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0xF8, 0x07,
  0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x01, 0xF0, 0x7E, 0x00, 0x7C,
  0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC7, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x3E, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x1F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x01,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0x00,
  0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7C, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xFE,
  0x00, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x0F, 0x81, 0xE0, 0x78,
  0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x1F, 0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83,
  0xE0, 0xF8, 0x1E, 0x07, 0x81, 0xF0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C,
  0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0,
  0x00, 0x3F, 0xF0, 0x07, 0xFF, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1F, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x0F,
  0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xF3, 0xC0, 0x00, 0xF1, 0xF0, 0x00, 0xF8, 0x78,
  0x00, 0x78, 0x3E, 0x00, 0x7C, 0x0F, 0x00, 0x3C, 0x07, 0xC0, 0x3E, 0x01,
  0xE0, 0x1E, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x80,
  0x0F, 0x87, 0x80, 0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0x7B, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0x7F, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFC, 0x3F, 0x0F, 0x87, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0xF0, 0xF0, 0x1F, 0xFE, 0x7C, 0x0F, 0xFF, 0xDF, 0x07,
  0xFF, 0xF7, 0xC3, 0xF8, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x00, 0xFE,
  0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF1, 0xF8, 0x00,
  0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xF1, 0xF0,
  0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3,
  0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0x00, 0x7F, 0x07, 0xE0, 0x3F,
  0xC1, 0xFC, 0x3F, 0xF0, 0x7F, 0xFF, 0x78, 0x0F, 0xFF, 0x9E, 0x01, 0xFF,
  0xCF, 0x80, 0x3F, 0xC3, 0xE0, 0x01, 0x80, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x83, 0xE0,
  0x03, 0xE3, 0xFE, 0x00, 0xF9, 0xFF, 0xC0, 0x7E, 0xFF, 0xF8, 0x1F, 0x7D,
  0xFE, 0x07, 0xFC, 0x0F, 0xC1, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x7C, 0x3F,
  0x80, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3E, 0x00, 0x1F, 0x1F, 0x80, 0x07, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x00,
  0xFC, 0x7C, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0,
  0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x1F, 0xE0, 0x3F, 0x87,
  0xFC, 0x1F, 0xC1, 0xFF, 0xFF, 0xE0, 0x79, 0xFF, 0xF0, 0x1E, 0x3F, 0xF8,
  0x0F, 0x87, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x3F, 0x80, 0x21,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x04, 0x1F, 0xE0,
  0x70, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xC0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x0F,
  0xFC, 0x7C, 0x00, 0xFF, 0xF3, 0xE0, 0x0F, 0xFF, 0xDF, 0x00, 0xFF, 0xBE,
  0xF8, 0x0F, 0xE0, 0x7F, 0x80, 0x7E, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0,
  0x7F, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0x81, 0xF8,
  0x00, 0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0,
  0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x80, 0x7C,
  0x01, 0xFC, 0x03, 0xF0, 0x1F, 0xE0, 0x1F, 0xC3, 0xFF, 0x00, 0xFF, 0xFE,
  0xF0, 0x03, 0xFF, 0xE7, 0x80, 0x0F, 0xFE, 0x3C, 0x00, 0x3F, 0xC3, 0xE0,
  0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x7F, 0x8F, 0xE1, 0xFC, 0x0F, 0xC3, 0xF0, 0x0F,
  0x8F, 0xC0, 0x1F, 0x3F, 0x00, 0x7E, 0x7E, 0x00, 0xF8, 0xF8, 0x03, 0xF3,
  0xF0, 0x1F, 0xC7, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F,
  0xFF, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x08, 0x3F, 0x80,
  0x70, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFC,
  0x00, 0x07, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE3, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x02, 0x1F, 0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x10, 0x07, 0xFE, 0x1E, 0x00, 0xFF, 0xF1, 0xE0, 0x1F, 0xFF, 0xBE, 0x03,
  0xFF, 0xFB, 0xE0, 0x7F, 0x03, 0xFC, 0x07, 0xE0, 0x1F, 0xC0, 0xFC, 0x00,
  0xFC, 0x0F, 0xC0, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0x83,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x83, 0xE0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0xFE, 0x03, 0xE0,
  0x1F, 0xE0, 0x3F, 0x03, 0xFE, 0x03, 0xF8, 0x7B, 0xE0, 0x3F, 0xFF, 0x7C,
  0x01, 0xFF, 0xE7, 0xC0, 0x0F, 0xFC, 0x7C, 0x00, 0x7F, 0x8F, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xC0, 0x07, 0xF0, 0x0F,
  0x81, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x83, 0xF0, 0x03, 0xE3, 0xFF, 0x00,
  0xF9, 0xFF, 0xE0, 0x7E, 0xFF, 0xF8, 0x1F, 0x7E, 0xFF, 0x07, 0xFC, 0x0F,
  0xC1, 0xFE, 0x03, 0xF0, 0x7F, 0x00, 0x7C, 0x3F, 0x80, 0x1F, 0x0F, 0xE0,
  0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1F,
  0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x7E,
  0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x80, 0x0F, 0x87, 0xE0, 0x03, 0xE1, 0xF0,
  0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x0F, 0xC0, 0x07, 0xC0,
  0x00, 0x70, 0x03, 0xE0, 0x1F, 0xC0, 0x7E, 0x01, 0xF8, 0x03, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0x00, 0xF8, 0x03, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x47, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xF0,
  0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x10,
  0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF8, 0x0F, 0xC0, 0x3F, 0x03,
  0xF0, 0x07, 0xC0, 0xFC, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x0F, 0xC0, 0x07,
  0xE3, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x3F, 0x00, 0x03, 0xEF, 0xC0,
  0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F,
  0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x7E, 0x1F, 0x80,
  0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x3F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x80,
  0xF8, 0x01, 0xF8, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F,
  0x80, 0x3E, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x3F, 0x00, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07,
  0xC0, 0x1F, 0x00, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x00, 0xF8, 0x03,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03,
  0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xE1, 0xFF,
  0x01, 0xFF, 0x00, 0xF1, 0xFF, 0xC3, 0xFF, 0xC0, 0xF9, 0xFF, 0xE3, 0xFF,
  0xF0, 0x7D, 0xFF, 0xFB, 0xF7, 0xF8, 0x3F, 0xE0, 0xFD, 0xE0, 0xFC, 0x1F,
  0xE0, 0x3F, 0xE0, 0x3E, 0x0F, 0xE0, 0x1F, 0xE0, 0x1F, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0x87, 0xF0, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0x03,
  0xE1, 0xF8, 0x01, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0xFC,
  0x00, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x80, 0x1F,
  0x8F, 0xC0, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x3E, 0x00, 0x3E, 0x00, 0x7E, 0x1F, 0x00, 0x3F, 0x00, 0x3F, 0x1F, 0x80,
  0x1F, 0x80, 0x1F, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0xF0, 0xFF, 0xC0, 0x3C,
  0x7F, 0xF8, 0x1F, 0x3F, 0xFF, 0x07, 0xDF, 0xFF, 0xC1, 0xFF, 0x03, 0xF0,
  0x7F, 0x80, 0xFC, 0x3F, 0xC0, 0x1F, 0x0F, 0xE0, 0x07, 0xC3, 0xF8, 0x03,
  0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0x87, 0xE0,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x8F,
  0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00,
  0x7E, 0x1F, 0x00, 0x1F, 0x8F, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7F, 0x03, 0xF8, 0x7F, 0x00, 0xFC, 0x3F, 0x00, 0x3E,
  0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xCF, 0x80, 0x07, 0xEF, 0xC0, 0x03,
  0xF7, 0xC0, 0x01, 0xFB, 0xE0, 0x00, 0xFD, 0xF0, 0x00, 0x7D, 0xF8, 0x00,
  0x3E, 0xFC, 0x00, 0x3F, 0x7E, 0x00, 0x1F, 0xBF, 0x00, 0x0F, 0x9F, 0x80,
  0x0F, 0xC7, 0xC0, 0x07, 0xE3, 0xF0, 0x07, 0xE1, 0xF8, 0x07, 0xE0, 0x7F,
  0x0F, 0xF0, 0x3F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0x0F, 0xF8, 0x00, 0xF1,
  0xFF, 0xC0, 0x1F, 0x3F, 0xFE, 0x01, 0xF7, 0xDF, 0xE0, 0x1F, 0xF0, 0x3F,
  0x01, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0x1F, 0x03, 0xF8, 0x01, 0xF0, 0x3F,
  0x00, 0x1F, 0x03, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xE0, 0x01,
  0xF0, 0x7E, 0x00, 0x1F, 0x07, 0xC0, 0x03, 0xF0, 0x7C, 0x00, 0x3F, 0x07,
  0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x7C, 0x0F, 0xC0, 0x0F, 0xC0, 0xFC, 0x01, 0xFC, 0x1F, 0xE0, 0x3F, 0x81,
  0xFF, 0x07, 0xF0, 0x1F, 0x7F, 0xFE, 0x01, 0xF7, 0xFF, 0xE0, 0x1F, 0x3F,
  0xF8, 0x03, 0xF1, 0xFF, 0x00, 0x3F, 0x03, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0xF0, 0xF0, 0x1F, 0xFE, 0x3C, 0x0F, 0xFF, 0xDF,
  0x07, 0xFD, 0xFF, 0xC3, 0xF8, 0x1F, 0xE0, 0xFC, 0x03, 0xF8, 0x7E, 0x00,
  0xFE, 0x3F, 0x80, 0x1F, 0x8F, 0xC0, 0x07, 0xE3, 0xF0, 0x01, 0xF1, 0xF8,
  0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x1F, 0x80, 0x0F, 0xC7, 0xC0, 0x03, 0xE1,
  0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F, 0xC0, 0x07,
  0xE3, 0xF0, 0x03, 0xF0, 0xFC, 0x01, 0xFC, 0x1F, 0x00, 0x7F, 0x07, 0xE0,
  0x3F, 0xC1, 0xFC, 0x3D, 0xF0, 0x7F, 0xFE, 0xF8, 0x0F, 0xFF, 0x3E, 0x01,
  0xFF, 0x8F, 0x80, 0x3F, 0xC7, 0xE0, 0x01, 0x81, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x20, 0xF8,
  0x1E, 0x1F, 0xC0, 0xF1, 0xFE, 0x0F, 0x9F, 0xF0, 0x7D, 0xFF, 0x03, 0xFF,
  0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x0F, 0xE0,
  0xF8, 0x3F, 0x00, 0x40, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x0F,
  0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x88,
  0x00, 0x7E, 0x3C, 0x03, 0xF0, 0xFF, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x80, 0x00, 0x00, 0x70, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x04, 0xFF,
  0xFE, 0x7F, 0xFF, 0xBF, 0xFF, 0xEF, 0xFF, 0xF8, 0x3F, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x82, 0x07, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xF8, 0x07, 0xFE, 0x00,
  0x10, 0x00, 0x0F, 0x80, 0x0F, 0xC7, 0xE0, 0x03, 0xE1, 0xF8, 0x00, 0xF8,
  0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xE0,
  0x03, 0xE1, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7E, 0x1F, 0x00, 0x1F, 0x87,
  0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0xFC, 0x3E, 0x00, 0x3F,
  0x0F, 0x80, 0x1F, 0xC3, 0xE0, 0x0F, 0xE0, 0xF8, 0x07, 0xF8, 0x3F, 0x03,
  0xFE, 0x0F, 0xC1, 0xEF, 0x83, 0xFF, 0xF3, 0xE0, 0x7F, 0xFC, 0xF0, 0x1F,
  0xFC, 0x3C, 0x01, 0xFE, 0x0F, 0x00, 0x08, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xBE, 0x00, 0x1F, 0x9F, 0x00, 0x0F, 0x8F, 0x80, 0x0F, 0xC7, 0xC0, 0x07,
  0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xE0, 0xFC, 0x03, 0xF0, 0x3E, 0x01,
  0xF0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0xF8, 0x07, 0xC0, 0xFC, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x7E, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E,
  0x3F, 0x00, 0x0F, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xEF, 0x80, 0x01,
  0xF7, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xF8, 0x01,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xC0, 0x1F, 0xBE, 0x00, 0xFE, 0x00, 0xFD,
  0xF0, 0x0F, 0xF0, 0x07, 0xCF, 0x80, 0x7F, 0x80, 0x7E, 0x7C, 0x03, 0xFC,
  0x03, 0xE3, 0xE0, 0x3D, 0xE0, 0x3F, 0x1F, 0x01, 0xEF, 0x01, 0xF0, 0xF8,
  0x1F, 0x7C, 0x1F, 0x87, 0xC0, 0xF3, 0xE0, 0xF8, 0x3E, 0x0F, 0x9F, 0x0F,
  0xC1, 0xF0, 0x78, 0xF8, 0x7C, 0x07, 0x87, 0xC7, 0xC3, 0xE0, 0x3C, 0x3C,
  0x3E, 0x3E, 0x01, 0xE3, 0xE1, 0xF1, 0xF0, 0x0F, 0x1F, 0x0F, 0x9F, 0x80,
  0x78, 0xF0, 0x3C, 0xF8, 0x03, 0xCF, 0x81, 0xE7, 0xC0, 0x1E, 0x78, 0x0F,
  0x7C, 0x00, 0xF7, 0xC0, 0x7B, 0xE0, 0x07, 0xBC, 0x03, 0xFE, 0x00, 0x3D,
  0xE0, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x01, 0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0x80, 0x00, 0x3E, 0xFC, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x7E, 0x7C, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F,
  0x03, 0xF0, 0x03, 0xF0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x01,
  0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xE0, 0x01,
  0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x00, 0x1F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x7C, 0x03, 0xF0,
  0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0xFC, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0x3E, 0x3E, 0x00, 0x00, 0x7C, 0x7C, 0x00, 0x00,
  0xF9, 0xF0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x03,
  0xDF, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x02, 0x1F, 0xC0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xF8, 0x00,
  0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x07, 0xFC, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x1F,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x03, 0xFE, 0x00, 0x7F, 0x80, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0x80, 0x00, 0x02, 0x00,
  0x00, 0x9F, 0xF8, 0x00, 0xDF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x01, 0xFF, 0xFB, 0x00, 0x1F, 0xF9, 0x00, 0x00, 0xE0,
};

const GFXglyph NotoSans_MediumItalic51pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 14, 37, 14, 1, -36 },
  { 66, 17, 13, 21, 5, -36 },
  { 94, 32, 36, 33, 1, -36 },
  { 238, 25, 42, 28, 2, -39 },
  { 370, 35, 38, 42, 4, -37 },
  { 537, 32, 38, 35, 2, -37 },
  { 689, 8, 13, 12, 5, -36 },
  { 702, 17, 44, 16, 2, -36 },
  { 796, 18, 45, 16, -4, -37 },
  { 898, 24, 24, 28, 5, -39 },
  { 970, 24, 24, 29, 3, -30 },
  { 1042, 11, 13, 14, -2, -6 },
  { 1060, 14, 5, 16, 1, -16 },
  { 1069, 7, 8, 14, 1, -7 },
  { 1076, 25, 37, 19, -2, -37 },
  { 1192, 24, 38, 28, 3, -37 },
  { 1306, 17, 36, 28, 6, -36 },
  { 1383, 27, 37, 28, 0, -37 },
  { 1508, 26, 38, 28, 1, -37 },
  { 1632, 27, 36, 28, 0, -36 },
  { 1754, 26, 37, 28, 2, -36 },
  { 1875, 25, 38, 28, 3, -37 },
  { 1994, 26, 36, 28, 3, -36 },
  { 2111, 26, 38, 28, 2, -37 },
  { 2235, 25, 38, 28, 2, -37 },
  { 2354, 11, 29, 14, 1, -28 },
  { 2394, 15, 35, 14, -3, -28 },
  { 2460, 25, 25, 29, 3, -31 },
  { 2539, 23, 14, 29, 4, -25 },
  { 2580, 25, 25, 29, 3, -31 },
  { 2659, 20, 38, 22, 4, -37 },
  { 2754, 39, 41, 43, 3, -36 },
  { 2954, 30, 36, 30, -3, -36 },
  { 3089, 28, 36, 31, 2, -36 },
  { 3215, 30, 38, 30, 3, -37 },
  { 3358, 31, 36, 34, 2, -36 },
  { 3498, 27, 36, 27, 2, -36 },
  { 3620, 27, 36, 25, 2, -36 },
  { 3742, 31, 38, 35, 3, -37 },
  { 3890, 33, 36, 35, 2, -36 },
  { 4039, 21, 36, 17, -1, -36 },
  { 4134, 23, 46, 15, -8, -36 },
  { 4267, 32, 36, 29, 2, -36 },
  { 4411, 20, 36, 25, 2, -36 },
  { 4501, 42, 36, 44, 2, -36 },
  { 4690, 35, 36, 37, 2, -36 },
  { 4848, 32, 38, 37, 3, -37 },
  { 5000, 28, 36, 30, 2, -36 },
  { 5126, 32, 46, 37, 3, -37 },
  { 5310, 27, 36, 30, 2, -36 },
  { 5432, 26, 38, 26, 1, -37 },
  { 5556, 26, 36, 26, 4, -36 },
  { 5673, 31, 37, 35, 4, -36 },
  { 5817, 28, 36, 29, 5, -36 },
  { 5943, 44, 36, 44, 5, -36 },
  { 6141, 35, 36, 28, -3, -36 },
  { 6299, 26, 36, 27, 5, -36 },
  { 6416, 30, 36, 27, -1, -36 },
  { 6551, 20, 44, 15, -1, -36 },
  { 6661, 10, 37, 19, 6, -37 },
  { 6708, 20, 44, 15, -4, -36 },
  { 6818, 25, 24, 29, 2, -37 },
  { 6893, 21, 3, 20, -5, 5 },
  { 6901, 9, 8, 15, 7, -39 },
  { 6910, 26, 29, 29, 2, -28 },
  { 7005, 26, 40, 30, 1, -39 },
  { 7135, 22, 29, 24, 2, -28 },
  { 7215, 29, 40, 30, 2, -39 },
  { 7360, 23, 29, 26, 2, -28 },
  { 7444, 29, 51, 17, -6, -39 },
  { 7629, 28, 40, 30, 1, -28 },
  { 7769, 26, 39, 30, 1, -39 },
  { 7896, 14, 38, 14, 1, -38 },
  { 7963, 21, 50, 14, -6, -38 },
  { 8095, 27, 39, 26, 1, -39 },
  { 8227, 14, 39, 14, 1, -39 },
  { 8296, 41, 28, 45, 1, -28 },
  { 8440, 26, 28, 30, 1, -28 },
  { 8531, 25, 28, 29, 2, -28 },
  { 8619, 28, 40, 30, -1, -28 },
  { 8759, 26, 40, 30, 2, -28 },
  { 8889, 21, 28, 21, 1, -28 },
  { 8963, 22, 29, 23, 0, -28 },
  { 9043, 18, 35, 18, 2, -34 },
  { 9122, 26, 28, 30, 3, -27 },
  { 9213, 25, 27, 24, 2, -27 },
  { 9298, 37, 27, 38, 3, -27 },
  { 9423, 29, 27, 25, -2, -27 },
  { 9521, 31, 39, 25, -4, -27 },
  { 9673, 24, 27, 23, -1, -27 },
  { 9754, 21, 44, 18, 0, -36 },
  { 9870, 4, 51, 28, 13, -39 },
  { 9896, 20, 44, 18, -2, -36 },
  { 10006, 25, 8, 29, 3, -22 },
};

const GFXfont NotoSans_MediumItalic51pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic51pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic51pt7bGlyphs,
  0x20, 0x7E, 69
};

#endif // _NOTOSANS_MEDIUMITALIC51PT7B_H_
