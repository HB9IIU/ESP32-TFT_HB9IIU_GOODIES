#ifndef _NOTOSANS_MEDIUMITALIC45PT7B_H_
#define _NOTOSANS_MEDIUMITALIC45PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 45pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic45pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x07, 0xE0, 0x7E, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x38, 0x07, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F,
  0x80, 0x20, 0x00, 0x7C, 0x7D, 0xF1, 0xF7, 0x87, 0xDE, 0x1E, 0x78, 0x79,
  0xE1, 0xEF, 0x0F, 0x3C, 0x3C, 0xF0, 0xF3, 0x83, 0x8E, 0x0E, 0x00, 0x00,
  0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01, 0xE0,
  0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xC0, 0xF0, 0x00, 0x3C, 0x0F, 0x00,
  0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x0F, 0x03, 0xC0,
  0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x1E,
  0x07, 0x00, 0x01, 0xE0, 0xF0, 0x0F, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF,
  0xCF, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0xC0, 0x38, 0x1E, 0x00, 0x07,
  0x81, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x03, 0xC0, 0x00, 0xF0, 0x38,
  0x00, 0x0F, 0x03, 0x80, 0x00, 0xE0, 0x78, 0x00, 0x0E, 0x07, 0x80, 0x01,
  0xE0, 0xF0, 0x00, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x07, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0xFF, 0xFF, 0x03,
  0xFF, 0xFE, 0x07, 0xC7, 0x08, 0x1F, 0x1C, 0x00, 0x3E, 0x38, 0x00, 0x7C,
  0x70, 0x00, 0xF8, 0xE0, 0x01, 0xF1, 0xC0, 0x01, 0xF7, 0x00, 0x03, 0xFE,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x01, 0xFF,
  0x00, 0x03, 0xBF, 0x00, 0x07, 0x3E, 0x00, 0x0E, 0x3C, 0x00, 0x38, 0x78,
  0x00, 0x70, 0xF0, 0x00, 0xE3, 0xE3, 0x01, 0xC7, 0xC7, 0xC3, 0xBF, 0x0F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x03, 0xFC, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x7C, 0x0F, 0xF8,
  0x00, 0x78, 0x1F, 0xFC, 0x00, 0xF0, 0x1E, 0x3C, 0x01, 0xE0, 0x3C, 0x1E,
  0x03, 0xE0, 0x3C, 0x1E, 0x03, 0xC0, 0x78, 0x1E, 0x07, 0x80, 0x78, 0x1E,
  0x0F, 0x00, 0x78, 0x3C, 0x0F, 0x00, 0x70, 0x3C, 0x1E, 0x00, 0xF0, 0x3C,
  0x3C, 0x00, 0xF0, 0x3C, 0x78, 0x00, 0xF0, 0x3C, 0x78, 0xE0, 0xF0, 0x78,
  0xF3, 0xFC, 0xF0, 0x79, 0xE7, 0xFE, 0x78, 0xF3, 0xCF, 0xFE, 0x7F, 0xE3,
  0xCF, 0x1F, 0x7F, 0xE7, 0x9E, 0x0F, 0x3F, 0x8F, 0x1E, 0x0F, 0x04, 0x1E,
  0x3C, 0x0F, 0x00, 0x1E, 0x3C, 0x0F, 0x00, 0x3C, 0x3C, 0x0F, 0x00, 0x78,
  0x3C, 0x1E, 0x00, 0xF0, 0x3C, 0x1E, 0x00, 0xF0, 0x38, 0x1E, 0x01, 0xE0,
  0x78, 0x1E, 0x03, 0xC0, 0x78, 0x3C, 0x07, 0x80, 0x3C, 0x3C, 0x07, 0x80,
  0x3C, 0x78, 0x0F, 0x00, 0x3F, 0xF8, 0x1E, 0x00, 0x1F, 0xF0, 0x3E, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xF8, 0x1F, 0x00,
  0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x0F,
  0x01, 0xF0, 0x00, 0x78, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x3F,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xC3, 0xF7, 0xC0, 0x7C, 0x3E,
  0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x3E, 0x3E, 0x03, 0xE1, 0xF1, 0xF0, 0x0F,
  0x9F, 0x0F, 0x00, 0x7F, 0xF0, 0xF8, 0x01, 0xFF, 0x87, 0xC0, 0x07, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x3F,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0x7E, 0x03, 0xFF, 0xF1, 0xF8, 0x0F, 0xFE,
  0x07, 0xE0, 0x7D, 0xF7, 0x9E, 0x79, 0xEF, 0x3C, 0xF3, 0x8E, 0x00, 0x00,
  0x3E, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x01, 0xF0,
  0x03, 0xC0, 0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x0F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03,
  0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x00, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07,
  0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF8, 0x03,
  0xE0, 0x07, 0x80, 0x1F, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x02, 0x03, 0xC0, 0x38, 0x1C, 0x01, 0xF0, 0xE0, 0x0F, 0xE7, 0x00,
  0xFF, 0xF1, 0xF8, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE, 0x03, 0xF7, 0xF0, 0x3F,
  0x80, 0x03, 0xDE, 0x00, 0x3E, 0x70, 0x03, 0xE3, 0xC0, 0x3E, 0x1E, 0x00,
  0xE0, 0x78, 0x03, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x70, 0x00, 0x03, 0x80, 0x00, 0x1C, 0x00, 0x00, 0xE0, 0x00, 0x07, 0x00,
  0x00, 0x38, 0x00, 0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x07, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x38, 0x00,
  0x01, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0x80, 0x00, 0x1C,
  0x00, 0x00, 0xE0, 0x00, 0x07, 0x00, 0x00, 0x38, 0x00, 0x0F, 0xC3, 0xE1,
  0xF0, 0x7C, 0x1E, 0x0F, 0x83, 0xC1, 0xF0, 0x78, 0x1C, 0x0F, 0x00, 0x7F,
  0xF7, 0xFF, 0xFF, 0xEF, 0xFE, 0x39, 0xFF, 0xFF, 0xFF, 0xE6, 0x00, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xFF, 0x00, 0xFF, 0xFC, 0x03, 0xFB, 0xF8, 0x1F, 0x83, 0xE0,
  0xFC, 0x07, 0xC3, 0xE0, 0x1F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF3, 0xE0,
  0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x07,
  0xDF, 0x00, 0x1F, 0x7C, 0x00, 0x7D, 0xE0, 0x01, 0xFF, 0x80, 0x0F, 0xBE,
  0x00, 0x3E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x1F, 0x3E, 0x00,
  0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x0F, 0x87, 0x80, 0x3E, 0x1F, 0x01, 0xF0,
  0x7E, 0x0F, 0xC0, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x07, 0xFF, 0x80, 0x0F,
  0xF8, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x0F, 0xF0, 0x3F, 0xE1, 0xFF, 0xCF,
  0xFF, 0x3F, 0xDE, 0x7E, 0x7C, 0x70, 0xF8, 0xC1, 0xF0, 0x03, 0xC0, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x1E, 0x00, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07,
  0x80, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x0F, 0x80, 0x00, 0x03, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x07, 0xFD, 0xFE, 0x03, 0xE0, 0x3E, 0x01, 0x80, 0x3F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x00, 0x06, 0x00, 0x01, 0xFF, 0xC0, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x7F, 0x1F, 0xC0, 0x70, 0x0F, 0xC0, 0x80,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x0F, 0xF8,
  0x00, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x08, 0x7F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC4, 0x00,
  0x1F, 0x8E, 0x00, 0x7E, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF,
  0x80, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xBC, 0x00, 0x0F, 0xBC, 0x00, 0x1F, 0x3C, 0x00, 0x3E, 0x7C, 0x00, 0x3C,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF8, 0x03, 0xE0,
  0xF8, 0x07, 0xC0, 0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01,
  0xF0, 0x3E, 0x01, 0xF0, 0x7C, 0x01, 0xE0, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07,
  0xFF, 0xF8, 0x04, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE2, 0x00, 0x0F, 0xC7, 0x00, 0x7F,
  0x0F, 0xFF, 0xFC, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0xFE, 0x01,
  0xFF, 0x18, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x01,
  0xF1, 0xFC, 0x07, 0xDF, 0xFC, 0x1E, 0xFF, 0xF0, 0xFF, 0xDF, 0xE3, 0xF8,
  0x0F, 0x8F, 0xC0, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xC0, 0x07,
  0xCF, 0x00, 0x1F, 0x3C, 0x00, 0x78, 0xF0, 0x03, 0xE3, 0xC0, 0x0F, 0x8F,
  0x80, 0x3E, 0x3E, 0x01, 0xF0, 0xFC, 0x0F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF,
  0xF0, 0x0F, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x7F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0xFF, 0xC0, 0x07, 0xFF, 0xE0,
  0x1F, 0xFF, 0xC0, 0x7F, 0x1F, 0xC0, 0xF8, 0x0F, 0x81, 0xE0, 0x0F, 0x07,
  0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x3C,
  0x03, 0xE0, 0x7C, 0x1F, 0x80, 0x7C, 0x7E, 0x00, 0x7F, 0xF8, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0x3F, 0x01, 0xF8, 0x3F,
  0x07, 0xE0, 0x3E, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x8F,
  0xC0, 0x7E, 0x0F, 0xE3, 0xFC, 0x0F, 0xFF, 0xF0, 0x0F, 0xFF, 0xC0, 0x0F,
  0xFE, 0x00, 0x00, 0x0C, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0xFE, 0x01, 0xFF,
  0xFC, 0x0F, 0xF3, 0xF0, 0x3E, 0x07, 0xE1, 0xF0, 0x0F, 0x87, 0x80, 0x1E,
  0x3E, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xC0, 0x07, 0xCF, 0x00, 0x1F, 0x3C,
  0x00, 0x7C, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0x8F, 0x80, 0x7E, 0x3F, 0x03,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xEF, 0x83, 0xFF, 0x3C, 0x03, 0xF9, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x80, 0x3F, 0x03, 0xFF, 0xF8,
  0x0F, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0x83, 0xF0,
  0xFC, 0x7F, 0x1F, 0x83, 0xE0, 0x60, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x7C, 0x3F,
  0x0F, 0xC3, 0xF0, 0xF8, 0x18, 0x00, 0x00, 0xF0, 0x0F, 0xC0, 0x7E, 0x07,
  0xF0, 0x3F, 0x00, 0xF8, 0x03, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF0,
  0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x08,
  0x00, 0x00, 0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x80, 0x0F,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x80,
  0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x1C, 0x00, 0x00, 0x20, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x06, 0x00, 0x00, 0x3C,
  0x00, 0x01, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0,
  0x03, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x01, 0xFE, 0x00, 0x0F, 0xC0,
  0x00, 0x70, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x03, 0xFF, 0x83,
  0xFF, 0xF0, 0xFF, 0xFE, 0x3F, 0x3F, 0x8E, 0x03, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF,
  0xF0, 0x00, 0x3F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x01, 0xF0, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x3C, 0x00, 0x00, 0x1E, 0x0F,
  0x00, 0x00, 0x01, 0xE3, 0xE0, 0x1F, 0xF8, 0x3C, 0x78, 0x0F, 0xFF, 0x87,
  0x9E, 0x03, 0xFF, 0xE0, 0xF3, 0xC0, 0xF8, 0x3C, 0x1E, 0x70, 0x3C, 0x07,
  0x81, 0xDE, 0x0F, 0x80, 0xE0, 0x3B, 0xC1, 0xE0, 0x3C, 0x0F, 0x78, 0x78,
  0x07, 0x81, 0xEE, 0x0F, 0x00, 0xF0, 0x3F, 0xC1, 0xE0, 0x3C, 0x07, 0xF8,
  0x3C, 0x07, 0x80, 0xEF, 0x07, 0x80, 0xF0, 0x3D, 0xE0, 0xF0, 0x3E, 0x07,
  0xBC, 0x1E, 0x0F, 0xC1, 0xE7, 0x83, 0xE3, 0xF8, 0x78, 0x78, 0x7F, 0xF7,
  0xFF, 0x0F, 0x07, 0xFC, 0xFF, 0x81, 0xE0, 0x7F, 0x0F, 0xE0, 0x3E, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x0C, 0x00, 0x07, 0xFC, 0x1F, 0x80,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1E, 0xF0, 0x00, 0x03, 0xDE, 0x00, 0x00,
  0xFB, 0xC0, 0x00, 0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF1, 0xE0,
  0x00, 0x3E, 0x3C, 0x00, 0x0F, 0x87, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x07, 0x80,
  0x1F, 0x00, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF0, 0x3E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x0F, 0x80, 0x01,
  0xE3, 0xE0, 0x00, 0x3C, 0x7C, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0x1F, 0x03, 0xFF, 0xF0, 0x01, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xE0, 0x7C, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0x3E,
  0x0F, 0x80, 0x1F, 0x07, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0x83, 0xE0, 0x07,
  0xC1, 0xF0, 0x07, 0xE0, 0xF8, 0x07, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0x81, 0xFC, 0x07, 0x80,
  0x3F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF0,
  0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F,
  0x00, 0x3F, 0x0F, 0x00, 0x7F, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x60, 0x00, 0x07, 0xFF,
  0xC0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0xFE,
  0x00, 0xC0, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x30, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7C, 0x07, 0xF8, 0x0F,
  0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x07, 0x80, 0x07,
  0xC1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0xF8,
  0x00, 0x3E, 0x1E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xF8, 0x00, 0x1F,
  0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x1F, 0x00,
  0x03, 0xE3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xE3,
  0xE0, 0x01, 0xF8, 0x7C, 0x00, 0x7F, 0x0F, 0x80, 0x1F, 0xC1, 0xF0, 0x0F,
  0xF0, 0x3C, 0x07, 0xFC, 0x0F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC,
  0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xFF, 0xFE, 0x07, 0xFF,
  0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00,
  0x70, 0x00, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xF0, 0x03, 0x81, 0xFC, 0x00, 0x10, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x9F, 0x00, 0x7F, 0xF3, 0xE0,
  0x0F, 0xFE, 0x7C, 0x01, 0xFF, 0xCF, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x3E,
  0x3E, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x0F, 0x80,
  0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x3F, 0x80, 0x1F, 0x03, 0xF8, 0x03, 0xE0,
  0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0xF8, 0x00,
  0x3C, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF8,
  0x1F, 0xFF, 0xFF, 0xC0, 0xF8, 0x00, 0x3C, 0x07, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x80, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8,
  0x1F, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x0F, 0x80, 0x01, 0xFF,
  0xE0, 0x7F, 0xFC, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x01, 0xFC, 0x01, 0xFF, 0xF0, 0x3F, 0xFC, 0x07,
  0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0xC7, 0xF0, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0, 0x03,
  0xF0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0xC0, 0x3C, 0x01, 0xF8, 0x07,
  0xC0, 0x3F, 0x00, 0x7C, 0x07, 0xE0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x1F,
  0x80, 0x07, 0x83, 0xF0, 0x00, 0xF8, 0x7E, 0x00, 0x0F, 0x8F, 0xC0, 0x00,
  0xF9, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFD, 0xF0, 0x00,
  0x1F, 0x9F, 0x00, 0x03, 0xE1, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0,
  0xF8, 0x00, 0x3C, 0x07, 0xC0, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xE0,
  0x07, 0xC0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0xF8,
  0x01, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03, 0xF8, 0x00,
  0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC, 0x07,
  0xF0, 0x00, 0x3F, 0xE0, 0x7F, 0xC0, 0x01, 0xFF, 0x03, 0xDE, 0x00, 0x1F,
  0xF0, 0x1E, 0xF0, 0x00, 0xF7, 0x80, 0xF7, 0x80, 0x0F, 0xFC, 0x07, 0xBC,
  0x00, 0x7B, 0xE0, 0x7D, 0xE0, 0x07, 0xDF, 0x03, 0xEF, 0x00, 0x3C, 0xF0,
  0x1E, 0x78, 0x03, 0xCF, 0x80, 0xF3, 0xC0, 0x1E, 0x7C, 0x07, 0x9E, 0x01,
  0xE3, 0xE0, 0x7C, 0x78, 0x0F, 0x1E, 0x03, 0xE3, 0xC0, 0xF0, 0xF0, 0x1E,
  0x1E, 0x07, 0x8F, 0x80, 0xF0, 0xF0, 0x78, 0x7C, 0x0F, 0x87, 0x87, 0xC3,
  0xE0, 0x7C, 0x3C, 0x3C, 0x1E, 0x03, 0xE1, 0xE3, 0xE0, 0xF0, 0x1E, 0x0F,
  0x1E, 0x0F, 0x80, 0xF0, 0x79, 0xF0, 0x7C, 0x0F, 0x81, 0xCF, 0x03, 0xE0,
  0x7C, 0x0F, 0xF0, 0x1E, 0x03, 0xC0, 0x7F, 0x80, 0xF0, 0x1E, 0x03, 0xF8,
  0x0F, 0x80, 0xF0, 0x1F, 0xC0, 0x7C, 0x0F, 0x80, 0xFC, 0x03, 0xE0, 0x7C,
  0x07, 0xE0, 0x1E, 0x03, 0xC0, 0x3E, 0x01, 0xF0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x78, 0x0F, 0xE0, 0x00,
  0xF0, 0x1F, 0xC0, 0x03, 0xE0, 0x7F, 0x80, 0x07, 0xC0, 0xFF, 0x80, 0x0F,
  0x81, 0xFF, 0x00, 0x1E, 0x03, 0xDE, 0x00, 0x3C, 0x07, 0xBE, 0x00, 0xF8,
  0x1F, 0x3C, 0x01, 0xF0, 0x3E, 0x7C, 0x03, 0xC0, 0x78, 0xF8, 0x07, 0x80,
  0xF0, 0xF0, 0x1F, 0x01, 0xE1, 0xF0, 0x3E, 0x07, 0xC3, 0xE0, 0x7C, 0x0F,
  0x83, 0xC0, 0xF0, 0x1E, 0x07, 0xC1, 0xE0, 0x3C, 0x0F, 0x87, 0xC0, 0xF8,
  0x0F, 0x0F, 0x81, 0xF0, 0x1F, 0x1F, 0x03, 0xE0, 0x3E, 0x3C, 0x07, 0x80,
  0x3C, 0x78, 0x0F, 0x00, 0x7D, 0xF0, 0x3E, 0x00, 0x7B, 0xE0, 0x7C, 0x00,
  0xFF, 0xC0, 0xF0, 0x01, 0xFF, 0x01, 0xE0, 0x01, 0xFE, 0x03, 0xC0, 0x03,
  0xFC, 0x0F, 0x80, 0x07, 0xF8, 0x1F, 0x00, 0x07, 0xE0, 0x3C, 0x00, 0x0F,
  0xC0, 0x78, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F,
  0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03,
  0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00,
  0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xEF, 0x80, 0x00, 0x7C, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8,
  0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x1F, 0x0F, 0x80, 0x3F, 0x0F, 0x00, 0x3E, 0x1F, 0x00, 0xFE, 0x1F, 0x07,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFC,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x7F, 0x00, 0xFC, 0x0F, 0xE0,
  0x07, 0xE0, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x03, 0xF1, 0xF0, 0x00, 0x1F,
  0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xC0,
  0x00, 0x1F, 0x7C, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3E, 0xF8,
  0x00, 0x03, 0xEF, 0x80, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xEF, 0x80, 0x00,
  0x7C, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0xFE, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFF,
  0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0xC0,
  0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80,
  0x3E, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x7E, 0x1F, 0x01, 0xFC, 0x1F, 0xFF,
  0xF8, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0x00, 0x3E, 0x0F,
  0x80, 0x3E, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3C, 0x07, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x78, 0x01,
  0xF0, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00,
  0xFC, 0x00, 0x07, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFF, 0xC0, 0xFC, 0x03, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x84, 0x00, 0x3F, 0x0E, 0x00, 0xFC,
  0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x00, 0x7F, 0xF8, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80,
  0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE1, 0xF0, 0x00, 0x3E,
  0x1F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC1, 0xE0,
  0x00, 0x7C, 0x3E, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F,
  0x83, 0xE0, 0x00, 0xF8, 0x3C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x3E, 0x07,
  0xC0, 0x07, 0xC0, 0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0xFF,
  0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0xF8, 0x00, 0x0F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xDF, 0x00, 0x07,
  0xE7, 0x80, 0x03, 0xE3, 0xC0, 0x03, 0xF1, 0xE0, 0x01, 0xF0, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0xF8, 0x1F, 0x00, 0x7C, 0x0F, 0x80,
  0x7C, 0x07, 0xC0, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x1F, 0x00, 0x78,
  0x1F, 0x00, 0x3C, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x07, 0xC0, 0x07,
  0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x01, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00,
  0x3D, 0xF0, 0x00, 0x1E, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xE0,
  0x03, 0xEF, 0x00, 0x1F, 0x80, 0x0F, 0xBC, 0x00, 0x7E, 0x00, 0x7C, 0xF0,
  0x03, 0xF8, 0x01, 0xF3, 0xC0, 0x0F, 0xE0, 0x07, 0xCF, 0x00, 0x7F, 0x80,
  0x3E, 0x3C, 0x01, 0xFE, 0x00, 0xF8, 0xF0, 0x0F, 0xF8, 0x07, 0xC3, 0xC0,
  0x3D, 0xE0, 0x1F, 0x0F, 0x00, 0xF3, 0xC0, 0xF8, 0x3E, 0x07, 0x8F, 0x03,
  0xE0, 0xF8, 0x1E, 0x3C, 0x0F, 0x03, 0xE0, 0xF0, 0xF0, 0x7C, 0x0F, 0x83,
  0xC3, 0xC1, 0xE0, 0x3E, 0x1F, 0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x3C, 0x3E,
  0x03, 0xE3, 0xE0, 0xF1, 0xF0, 0x0F, 0x8F, 0x03, 0xC7, 0xC0, 0x3E, 0x7C,
  0x0F, 0x1E, 0x00, 0xF9, 0xE0, 0x3C, 0xF8, 0x03, 0xE7, 0x80, 0xF3, 0xC0,
  0x0F, 0xBC, 0x03, 0xDF, 0x00, 0x1E, 0xF0, 0x0F, 0x78, 0x00, 0x7F, 0x80,
  0x3D, 0xE0, 0x01, 0xFE, 0x00, 0xFF, 0x80, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x7C, 0x03, 0xC0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x00, 0x07,
  0xC0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x78,
  0xF8, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x1F,
  0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0x80, 0x3F, 0x00, 0x3E,
  0x01, 0xF8, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0,
  0xF8, 0x00, 0x3F, 0x78, 0x00, 0x7E, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF8, 0x3C, 0x01, 0xF0, 0x3C, 0x03, 0xE0, 0x3E, 0x07, 0xE0,
  0x3E, 0x07, 0xC0, 0x1E, 0x0F, 0x80, 0x1E, 0x1F, 0x80, 0x1F, 0x1F, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x3C, 0x00, 0x0F, 0x7C, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x02, 0x07, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC0,
  0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x0F, 0xF8, 0x03, 0xFE, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E,
  0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03,
  0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xF0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x1F,
  0xF0, 0x0F, 0xFC, 0x00, 0xF0, 0x78, 0x3C, 0x1F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x78, 0x3E, 0x1F, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x0F,
  0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3E, 0x0F, 0x07, 0x83, 0xC1, 0xE0,
  0xF0, 0x7C, 0x3E, 0x0F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x3F,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x0F, 0xF8, 0x0F, 0xFC, 0x07, 0xFC,
  0x03, 0xFE, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x1E, 0xE0, 0x00, 0x39, 0xE0, 0x00,
  0xF3, 0xC0, 0x01, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x1E, 0x07, 0x80, 0x3C,
  0x0F, 0x00, 0xF0, 0x0F, 0x01, 0xE0, 0x1E, 0x07, 0x80, 0x3C, 0x0F, 0x00,
  0x3C, 0x3C, 0x00, 0x78, 0x78, 0x00, 0x79, 0xE0, 0x00, 0xF7, 0xC0, 0x00,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0xF8, 0xF8, 0x7C, 0x3C,
  0x1E, 0x1E, 0x0F, 0x00, 0x3C, 0x00, 0x03, 0xFE, 0x3C, 0x0F, 0xFE, 0x78,
  0x3F, 0xFD, 0xF0, 0xFE, 0x3F, 0xC3, 0xF0, 0x3F, 0x87, 0xC0, 0x3F, 0x1F,
  0x80, 0x7E, 0x3E, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0,
  0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00,
  0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07, 0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0x7F,
  0x07, 0xC1, 0xFE, 0x0F, 0xEF, 0xBC, 0x1F, 0xFE, 0xF8, 0x1F, 0xF9, 0xE0,
  0x1F, 0xC3, 0xC0, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0x80, 0x1F, 0x1F, 0xC0, 0x3E,
  0xFF, 0xC0, 0x7B, 0xFF, 0xC1, 0xFF, 0x1F, 0x83, 0xFC, 0x1F, 0x87, 0xF0,
  0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8, 0x01,
  0xF1, 0xF0, 0x03, 0xE3, 0xC0, 0x07, 0xC7, 0x80, 0x0F, 0x9F, 0x00, 0x3E,
  0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE3, 0xF0, 0x07, 0xC7,
  0xE0, 0x1F, 0x8F, 0xE0, 0x7E, 0x1F, 0xFF, 0xF8, 0x3D, 0xFF, 0xE0, 0xF1,
  0xFF, 0x81, 0xE1, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0xFC, 0x0F, 0xFF,
  0x83, 0xFF, 0xE0, 0xFE, 0x1C, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x30, 0xFF, 0xFE, 0x0F, 0xFF, 0xC0,
  0xFF, 0xF8, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x1C, 0x1F,
  0x00, 0x7F, 0xCF, 0x80, 0x7F, 0xF7, 0xC0, 0x7F, 0xFB, 0xE0, 0x7F, 0x1F,
  0xE0, 0x7E, 0x07, 0xF0, 0x3E, 0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00,
  0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0x87, 0xC0,
  0x07, 0xC3, 0xE0, 0x03, 0xC1, 0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x7C,
  0x01, 0xF8, 0x3E, 0x00, 0xFC, 0x1F, 0x00, 0xFC, 0x0F, 0x80, 0xFE, 0x03,
  0xE0, 0xFF, 0x01, 0xFD, 0xF7, 0x80, 0xFF, 0xF7, 0x80, 0x3F, 0xF3, 0xC0,
  0x0F, 0xF1, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0,
  0x7F, 0xFE, 0x0F, 0xC3, 0xF1, 0xF8, 0x1F, 0x1F, 0x01, 0xF3, 0xE0, 0x1F,
  0x3E, 0x01, 0xF7, 0xC0, 0x3E, 0x7C, 0x1F, 0xE7, 0xFF, 0xFC, 0xFF, 0xFF,
  0x0F, 0xFF, 0xC0, 0xFF, 0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0x87, 0xF9, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xF8, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x60, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00,
  0x8F, 0xC0, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0xFF, 0x8F, 0x01, 0xFF,
  0xCF, 0x03, 0xFF, 0xDF, 0x07, 0xF1, 0xFE, 0x0F, 0xC0, 0xFE, 0x0F, 0x80,
  0x7E, 0x1F, 0x80, 0x7E, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x78, 0x7C, 0x00,
  0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x03,
  0xF0, 0x7C, 0x07, 0xF0, 0x7E, 0x0F, 0xF0, 0x3F, 0xBF, 0xF0, 0x3F, 0xFD,
  0xF0, 0x1F, 0xF9, 0xE0, 0x0F, 0xE3, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x80, 0x0F,
  0x80, 0xF0, 0x3F, 0x80, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x83, 0xC0, 0x1F, 0x1F, 0xE0,
  0x3C, 0xFF, 0xE0, 0x7B, 0xFF, 0xC1, 0xFF, 0x8F, 0xC3, 0xFC, 0x0F, 0x87,
  0xF0, 0x1F, 0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0xF8, 0xF8,
  0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3C, 0x00, 0xF8,
  0xF8, 0x01, 0xF1, 0xF0, 0x03, 0xC0, 0x01, 0xE0, 0x3F, 0x03, 0xF0, 0x3E,
  0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF8, 0x04, 0x7E, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01,
  0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x01, 0x07,
  0xC0, 0x3E, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xF0, 0x0F,
  0x83, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0x3F, 0xBE, 0x00, 0x3F, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3C,
  0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0x80, 0x7C, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x78, 0x07, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0x01,
  0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0x80, 0xF8,
  0x0F, 0x80, 0x00, 0x01, 0xC0, 0x07, 0x00, 0x78, 0xFF, 0x03, 0xFC, 0x07,
  0x9F, 0xF8, 0x7F, 0xE0, 0x7B, 0xFF, 0xCF, 0xFF, 0x0F, 0xF8, 0xFD, 0xE3,
  0xF0, 0xFF, 0x07, 0xFC, 0x1F, 0x0F, 0xE0, 0x3F, 0x80, 0xF0, 0xFC, 0x03,
  0xF0, 0x0F, 0x0F, 0x80, 0x7E, 0x01, 0xF1, 0xF8, 0x07, 0xE0, 0x1F, 0x1F,
  0x00, 0x7C, 0x01, 0xF1, 0xF0, 0x07, 0xC0, 0x1F, 0x1F, 0x00, 0x78, 0x01,
  0xE1, 0xE0, 0x0F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xE0, 0x0F,
  0x80, 0x3E, 0x3E, 0x00, 0xF8, 0x03, 0xE3, 0xC0, 0x0F, 0x00, 0x3C, 0x7C,
  0x01, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF0, 0x07,
  0xC7, 0xC0, 0x1F, 0x00, 0x7C, 0x78, 0x01, 0xE0, 0x07, 0x8F, 0x80, 0x3E,
  0x00, 0xF8, 0xF8, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xE0, 0x0F, 0x1F,
  0xF0, 0x1E, 0x7F, 0xF0, 0x3D, 0xFF, 0xE0, 0xFF, 0xCF, 0xE1, 0xFE, 0x07,
  0xC3, 0xF8, 0x0F, 0x87, 0xE0, 0x1F, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C,
  0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC7, 0xC0, 0x0F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF0,
  0x03, 0xE3, 0xE0, 0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1E, 0x00,
  0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF0, 0x00, 0x18, 0x00, 0x03, 0xFE,
  0x00, 0x3F, 0xFE, 0x01, 0xFF, 0xFC, 0x0F, 0xE3, 0xF0, 0x7E, 0x07, 0xE3,
  0xF0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0x79, 0xF0, 0x01, 0xF7, 0xC0,
  0x07, 0xDE, 0x00, 0x1E, 0xF8, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F,
  0xBE, 0x00, 0x3E, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x3F, 0x1F,
  0x00, 0xF8, 0x7E, 0x07, 0xC1, 0xFF, 0xFF, 0x03, 0xFF, 0xF8, 0x07, 0xFF,
  0xC0, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x70, 0x00, 0xF1, 0xFE, 0x00, 0x79,
  0xFF, 0x80, 0x3D, 0xFF, 0xE0, 0x3F, 0xE3, 0xF0, 0x1F, 0xE0, 0xFC, 0x0F,
  0xE0, 0x3E, 0x07, 0xE0, 0x1F, 0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF0, 0x78, 0x00, 0xF8, 0x3C, 0x00, 0x7C,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x1F,
  0x03, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFF, 0xFF,
  0xC0, 0x7B, 0xFF, 0xC0, 0x7C, 0xFF, 0xC0, 0x3E, 0x3F, 0xC0, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0x03, 0xFE, 0x3C, 0x0F, 0xFE, 0x78, 0x3F, 0xFD, 0xF0, 0xFE, 0x3F, 0xC3,
  0xF0, 0x3F, 0x87, 0xC0, 0x3F, 0x1F, 0x00, 0x7E, 0x3E, 0x00, 0xF8, 0xF8,
  0x01, 0xF1, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xCF, 0x80, 0x0F, 0x9F, 0x00,
  0x1E, 0x3E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x03, 0xF1, 0xF0, 0x07,
  0xE3, 0xE0, 0x1F, 0x87, 0xC0, 0x7F, 0x07, 0xC1, 0xFE, 0x0F, 0xEF, 0xFC,
  0x1F, 0xFE, 0xF0, 0x1F, 0xF9, 0xE0, 0x1F, 0xC7, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x01, 0xE0, 0xF1, 0xF8, 0x1E, 0x7F,
  0x03, 0xDF, 0xE0, 0xFF, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x00,
  0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x7F, 0xF8, 0x1F, 0xFF,
  0x87, 0xFF, 0xF0, 0xFC, 0x1C, 0x3E, 0x00, 0x87, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0,
  0x03, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xCC, 0x01, 0xF1, 0xF1, 0xFE, 0x3F, 0xFF, 0x87,
  0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x00, 0x1E,
  0x00, 0x78, 0x01, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x1E, 0x00,
  0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00,
  0x3C, 0x00, 0x78, 0x00, 0xF8, 0x01, 0xFB, 0x83, 0xFF, 0x07, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0x80, 0x3E, 0x1E, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xE1, 0xF0, 0x03, 0xC3, 0xE0, 0x0F, 0x87, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0x78, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xE0, 0x07,
  0xC7, 0xC0, 0x0F, 0x8F, 0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3C, 0x01, 0xF8,
  0x78, 0x03, 0xF1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x83, 0xE0, 0xFF, 0x07,
  0xFF, 0xDE, 0x0F, 0xFF, 0x3C, 0x0F, 0xFC, 0xF0, 0x0F, 0xE1, 0xE0, 0xF8,
  0x00, 0xFF, 0xE0, 0x03, 0xE7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x03,
  0xE1, 0xE0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7C, 0x0F, 0x81,
  0xF0, 0x3E, 0x07, 0xC1, 0xF0, 0x0F, 0x07, 0xC0, 0x3C, 0x3E, 0x00, 0xF0,
  0xF0, 0x03, 0xC7, 0xC0, 0x0F, 0x1E, 0x00, 0x3C, 0xF8, 0x00, 0xF3, 0xC0,
  0x03, 0xDF, 0x00, 0x07, 0x78, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x0F, 0xC0,
  0x1E, 0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x1F, 0xC0, 0x3E, 0xF0, 0x1F, 0xC0,
  0x7C, 0xF0, 0x1D, 0xE0, 0x7C, 0xF0, 0x3D, 0xE0, 0xF8, 0xF0, 0x3D, 0xE0,
  0xF8, 0xF0, 0x79, 0xE1, 0xF0, 0xF0, 0x79, 0xE1, 0xF0, 0xF0, 0xF1, 0xE1,
  0xE0, 0xF0, 0xF1, 0xE3, 0xE0, 0xF1, 0xE1, 0xE3, 0xC0, 0xF1, 0xE1, 0xE7,
  0xC0, 0xF3, 0xC1, 0xE7, 0x80, 0xF3, 0xC1, 0xE7, 0x80, 0xF3, 0x81, 0xEF,
  0x00, 0xF7, 0x81, 0xEF, 0x00, 0xF7, 0x81, 0xFF, 0x00, 0xFF, 0x01, 0xFE,
  0x00, 0xFF, 0x01, 0xFE, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x7C, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x0F, 0xC0, 0xF8, 0x07, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xC1, 0xF8, 0x00, 0xF0, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x0F, 0x9F, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xDF, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0xF8, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x1F, 0x01,
  0xF0, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x03,
  0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x3E, 0x01, 0xE0, 0x07, 0xC0, 0x1E, 0x00,
  0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x1F, 0x00,
  0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x00, 0xF0,
  0x7C, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0xF0, 0xF8, 0x00, 0x0F, 0x8F, 0x80,
  0x00, 0xF9, 0xF0, 0x00, 0x07, 0x9E, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFE, 0x00, 0x03,
  0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF0, 0x00, 0x07, 0xC0, 0x07, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xF0, 0x01,
  0xF0, 0x00, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x7F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x7F,
  0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x03, 0xFC, 0x00, 0x3E, 0x00, 0x3F, 0x80, 0x3F, 0xE0, 0x0F, 0x80,
  0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0,
  0x00, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0x80, 0x00,
  0x1F, 0x80, 0x0B, 0xFF, 0x80, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFC, 0x07,
  0xFF, 0xC0, 0x0F, 0xF0,
};

const GFXglyph NotoSans_MediumItalic45pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 12, 33, 12, 1, -32 },
  { 51, 14, 11, 18, 5, -32 },
  { 71, 28, 32, 29, 1, -32 },
  { 183, 23, 37, 25, 1, -34 },
  { 290, 32, 33, 37, 3, -33 },
  { 422, 29, 33, 31, 1, -33 },
  { 542, 6, 11, 10, 5, -32 },
  { 551, 15, 39, 14, 2, -32 },
  { 625, 15, 39, 14, -3, -32 },
  { 699, 21, 21, 25, 4, -34 },
  { 755, 21, 22, 26, 3, -27 },
  { 813, 10, 11, 12, -2, -5 },
  { 827, 12, 4, 14, 1, -14 },
  { 833, 6, 7, 12, 1, -6 },
  { 839, 23, 32, 17, -2, -32 },
  { 931, 22, 33, 25, 2, -33 },
  { 1022, 15, 32, 25, 6, -32 },
  { 1082, 24, 33, 25, 0, -33 },
  { 1181, 23, 33, 25, 1, -33 },
  { 1276, 24, 32, 25, 0, -32 },
  { 1372, 23, 32, 25, 1, -32 },
  { 1464, 22, 33, 25, 3, -33 },
  { 1555, 23, 32, 25, 3, -32 },
  { 1647, 23, 33, 25, 2, -33 },
  { 1742, 22, 33, 25, 2, -33 },
  { 1833, 10, 26, 12, 1, -25 },
  { 1866, 13, 31, 12, -2, -25 },
  { 1917, 21, 23, 26, 3, -28 },
  { 1978, 21, 12, 26, 3, -22 },
  { 2010, 21, 23, 26, 3, -28 },
  { 2071, 18, 34, 20, 3, -33 },
  { 2148, 35, 36, 38, 2, -32 },
  { 2306, 27, 32, 26, -3, -32 },
  { 2414, 25, 32, 27, 2, -32 },
  { 2514, 26, 33, 27, 3, -33 },
  { 2622, 27, 32, 30, 2, -32 },
  { 2730, 23, 32, 24, 2, -32 },
  { 2822, 23, 32, 22, 2, -32 },
  { 2914, 27, 33, 31, 3, -33 },
  { 3026, 29, 32, 31, 2, -32 },
  { 3142, 19, 32, 15, -1, -32 },
  { 3218, 20, 41, 13, -7, -32 },
  { 3321, 28, 32, 26, 2, -32 },
  { 3433, 17, 32, 22, 2, -32 },
  { 3501, 37, 32, 38, 2, -32 },
  { 3649, 31, 32, 32, 2, -32 },
  { 3773, 28, 33, 33, 3, -33 },
  { 3889, 24, 32, 26, 2, -32 },
  { 3985, 28, 41, 33, 3, -33 },
  { 4129, 24, 32, 26, 2, -32 },
  { 4225, 23, 33, 23, 1, -33 },
  { 4320, 23, 32, 23, 4, -32 },
  { 4412, 28, 32, 31, 3, -32 },
  { 4524, 25, 32, 25, 4, -32 },
  { 4624, 38, 32, 39, 5, -32 },
  { 4776, 30, 32, 25, -2, -32 },
  { 4896, 24, 32, 24, 4, -32 },
  { 4992, 27, 32, 24, -1, -32 },
  { 5100, 18, 39, 14, -1, -32 },
  { 5188, 9, 32, 17, 5, -32 },
  { 5224, 17, 39, 14, -3, -32 },
  { 5307, 23, 20, 25, 1, -32 },
  { 5365, 18, 3, 18, -4, 4 },
  { 5372, 8, 7, 13, 7, -34 },
  { 5379, 23, 25, 26, 2, -25 },
  { 5451, 23, 34, 26, 1, -34 },
  { 5549, 19, 25, 21, 2, -25 },
  { 5609, 25, 34, 26, 2, -34 },
  { 5716, 20, 25, 23, 2, -25 },
  { 5779, 25, 45, 15, -5, -34 },
  { 5920, 24, 36, 26, 1, -25 },
  { 6028, 23, 34, 26, 1, -34 },
  { 6126, 12, 33, 12, 1, -33 },
  { 6176, 19, 44, 12, -6, -33 },
  { 6281, 24, 34, 23, 1, -34 },
  { 6383, 12, 34, 12, 1, -34 },
  { 6434, 36, 25, 40, 1, -25 },
  { 6547, 23, 25, 26, 1, -25 },
  { 6619, 22, 25, 26, 2, -25 },
  { 6688, 25, 36, 26, -1, -25 },
  { 6801, 23, 36, 26, 2, -25 },
  { 6905, 19, 25, 18, 1, -25 },
  { 6965, 19, 25, 20, 0, -25 },
  { 7025, 15, 30, 16, 2, -30 },
  { 7082, 23, 24, 26, 2, -24 },
  { 7151, 22, 24, 22, 2, -24 },
  { 7217, 32, 24, 33, 3, -24 },
  { 7313, 26, 24, 22, -2, -24 },
  { 7391, 28, 35, 22, -4, -24 },
  { 7514, 21, 24, 20, -1, -24 },
  { 7577, 18, 39, 16, 0, -32 },
  { 7665, 4, 45, 25, 11, -34 },
  { 7688, 18, 39, 16, -2, -32 },
  { 7776, 21, 6, 26, 3, -19 },
};

const GFXfont NotoSans_MediumItalic45pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic45pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic45pt7bGlyphs,
  0x20, 0x7E, 61
};

#endif // _NOTOSANS_MEDIUMITALIC45PT7B_H_
