#ifndef _NOTOSANS_MEDIUMITALIC54PT7B_H_
#define _NOTOSANS_MEDIUMITALIC54PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 54pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic54pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F,
  0x00, 0x7E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80,
  0x3F, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x1F,
  0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00,
  0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF8, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x1C, 0x00, 0x3E, 0x1F, 0xBF, 0x0F, 0xDF, 0x87, 0xEF, 0xC3,
  0xE7, 0xC1, 0xF3, 0xE0, 0xF9, 0xF0, 0xF8, 0xF0, 0x7C, 0x78, 0x3E, 0x7C,
  0x1E, 0x3E, 0x0F, 0x1E, 0x07, 0x8F, 0x03, 0xC7, 0x83, 0xC0, 0x00, 0x01,
  0xE0, 0x3E, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00,
  0x0F, 0x80, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00,
  0x00, 0x7C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0,
  0x00, 0x03, 0xE0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF,
  0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x00,
  0x7C, 0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00,
  0x03, 0xE0, 0x3C, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF,
  0x87, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xE0, 0x3E,
  0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xC0, 0x00, 0x0F, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x7C, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00, 0x7C,
  0x07, 0x80, 0x00, 0x1E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x03,
  0xE0, 0x3C, 0x00, 0x00, 0xF0, 0x1F, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x3F, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0xFF, 0x79, 0xF0, 0x1F, 0x8F, 0x06, 0x03, 0xE1, 0xE0,
  0x00, 0xFC, 0x38, 0x00, 0x1F, 0x87, 0x00, 0x03, 0xF1, 0xE0, 0x00, 0x7E,
  0x3C, 0x00, 0x0F, 0xC7, 0x80, 0x00, 0xFC, 0xE0, 0x00, 0x1F, 0xFC, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x03, 0xCF, 0xC0,
  0x00, 0x78, 0xFC, 0x00, 0x0E, 0x1F, 0x80, 0x03, 0xC3, 0xF0, 0x00, 0x78,
  0x7E, 0x00, 0x0F, 0x0F, 0x84, 0x01, 0xC3, 0xF0, 0xC0, 0x38, 0xFE, 0x1F,
  0x8F, 0x7F, 0x83, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF0, 0x1F, 0xF8, 0x00, 0x0F, 0x80, 0xFF,
  0xF0, 0x00, 0x7C, 0x07, 0xFF, 0xC0, 0x03, 0xE0, 0x1F, 0x1F, 0x80, 0x0F,
  0x80, 0xF8, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x1F, 0x03,
  0xE0, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x7C, 0x01, 0xF0, 0x3E, 0x03, 0xE0,
  0x07, 0x80, 0xF8, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x0F,
  0x83, 0xE0, 0x03, 0xE0, 0x3C, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0xF8, 0x00,
  0x3E, 0x07, 0xC3, 0xC0, 0xC0, 0xF8, 0x1E, 0x1F, 0x1F, 0xE3, 0xE0, 0xF8,
  0xF9, 0xFF, 0xCF, 0x83, 0xE7, 0xCF, 0xFF, 0xBF, 0x1F, 0x1E, 0x3F, 0x7E,
  0x7F, 0xF8, 0xF9, 0xF0, 0x7D, 0xFF, 0xC7, 0xC7, 0xC1, 0xF3, 0xFE, 0x3E,
  0x3E, 0x07, 0xC3, 0xF0, 0xF0, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xC0, 0x7C,
  0x00, 0x3E, 0x1F, 0x01, 0xF0, 0x01, 0xF0, 0x7C, 0x07, 0xC0, 0x07, 0xC1,
  0xF0, 0x1E, 0x00, 0x3E, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x1E, 0x03, 0xE0,
  0x0F, 0x80, 0x78, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x3C, 0x01, 0xF0, 0x07,
  0x81, 0xF0, 0x0F, 0x80, 0x1E, 0x07, 0x80, 0x7C, 0x00, 0x7C, 0x3E, 0x01,
  0xF0, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x03, 0xFF, 0xC0, 0x7C, 0x00, 0x0F,
  0xFE, 0x03, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0xC0, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x0F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0xF8, 0x1F, 0x80, 0x00, 0x3E, 0x0F, 0xE0, 0x00, 0x0F,
  0xCF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x07, 0xFF, 0xC0, 0x0F, 0xC3, 0xFB, 0xF8, 0x07, 0xE1, 0xFC, 0x7E, 0x01,
  0xF8, 0xFC, 0x0F, 0xC0, 0xFC, 0x7E, 0x03, 0xF8, 0x3F, 0x1F, 0x80, 0x7E,
  0x1F, 0x8F, 0xC0, 0x0F, 0xCF, 0xC3, 0xF0, 0x03, 0xFF, 0xF0, 0xFC, 0x00,
  0x7F, 0xF8, 0x3F, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x01, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x00, 0xFC, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x3F, 0xF8, 0x07,
  0xF8, 0x7F, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xF1, 0xF8,
  0x07, 0xFF, 0xF8, 0x3F, 0x00, 0x7F, 0xF0, 0x0F, 0xE0, 0x03, 0x80, 0x00,
  0x00, 0x3E, 0xFD, 0xFB, 0xF7, 0xCF, 0x9F, 0x3C, 0x79, 0xF3, 0xE7, 0x8F,
  0x1E, 0x00, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03,
  0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0x07, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00,
  0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x01,
  0x00, 0x78, 0x00, 0xE0, 0x3C, 0x00, 0xFC, 0x1E, 0x00, 0x7F, 0x8E, 0x00,
  0x7F, 0xF7, 0x00, 0x0F, 0xFF, 0xBF, 0xE0, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xF8, 0x03, 0xFF, 0xFC, 0x03, 0xFC, 0x3E, 0x03, 0xFE, 0x00, 0x03, 0xEF,
  0x00, 0x03, 0xE3, 0xC0, 0x07, 0xE1, 0xE0, 0x07, 0xF0, 0xF8, 0x03, 0xF0,
  0x7C, 0x00, 0x70, 0x1F, 0x00, 0x18, 0x0F, 0x80, 0x08, 0x07, 0xE0, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE1, 0xF8, 0x3F, 0x0F, 0xC1, 0xF8, 0x3E, 0x0F, 0xC1, 0xF0,
  0x3E, 0x0F, 0x81, 0xF0, 0x7C, 0x0F, 0x00, 0x7F, 0xFD, 0xFF, 0xF7, 0xFF,
  0xDF, 0xFF, 0xFF, 0xF8, 0x3C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x38, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x07, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x00, 0xFE, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0x3F, 0x80,
  0x7E, 0x0F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF1, 0xF8, 0x00, 0xFC, 0xFC,
  0x00, 0x3F, 0x3F, 0x00, 0x0F, 0xCF, 0xC0, 0x03, 0xF7, 0xE0, 0x00, 0xFD,
  0xF8, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xDF, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0xFF, 0xF0, 0x00, 0x3E, 0xFC, 0x00, 0x1F, 0xBF, 0x00, 0x07, 0xEF, 0xC0,
  0x01, 0xFB, 0xF0, 0x00, 0x7E, 0xF8, 0x00, 0x3F, 0x3E, 0x00, 0x0F, 0xCF,
  0x80, 0x03, 0xF3, 0xF0, 0x01, 0xFC, 0xF8, 0x00, 0x7E, 0x3F, 0x00, 0x1F,
  0x8F, 0xC0, 0x0F, 0xC3, 0xF0, 0x07, 0xF0, 0xFC, 0x01, 0xF8, 0x1F, 0x80,
  0xFE, 0x07, 0xF8, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07,
  0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x07, 0xE0, 0x07, 0xF8, 0x03, 0xFE, 0x03, 0xFF, 0x81, 0xFF, 0xE1, 0xFF,
  0xF0, 0xFF, 0x7C, 0xFF, 0xBF, 0x3F, 0xCF, 0xC7, 0xC3, 0xF0, 0xC0, 0xF8,
  0x20, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x7C, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0xFE, 0x07, 0xF8, 0x03,
  0xC0, 0x0F, 0xC0, 0x08, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x0F,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83, 0xFF, 0xFF, 0xFC, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0xFE, 0x00, 0xC0, 0x07, 0xE0,
  0x08, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x80, 0x00, 0x7F, 0x0E, 0x00, 0x0F, 0xE0, 0xFE, 0x0F,
  0xFE, 0x0F, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFE, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x06, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xFC,
  0x00, 0x01, 0xFB, 0xE0, 0x00, 0x0F, 0x9F, 0x00, 0x00, 0xF9, 0xF0, 0x00,
  0x0F, 0xCF, 0x80, 0x00, 0xFC, 0x7C, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0xFC,
  0x3F, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x07, 0xE0, 0xFC,
  0x00, 0x7E, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x01, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xFC, 0x03, 0xE0, 0x07, 0xE0, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xEF, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0x80, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x0F,
  0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF,
  0x00, 0x40, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x80, 0x00, 0xFE, 0x18, 0x00, 0x7F, 0x83,
  0xF0, 0x3F, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x05, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xFF,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0xFF, 0x80, 0x3E, 0x7F, 0xF8, 0x0F, 0xDF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8,
  0x3F, 0xF0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x00, 0x7E, 0x3F, 0x80,
  0x0F, 0xC7, 0xF0, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x1F, 0x80, 0x03, 0xE3,
  0xF0, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1, 0xF8, 0x00,
  0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0xFC, 0x0F,
  0xE0, 0x3F, 0x80, 0xFE, 0x1F, 0xE0, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x01, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xE0, 0x1F, 0xF7, 0xFE, 0x03, 0xF0, 0x1F, 0xC0, 0xFC, 0x01, 0xF8, 0x1F,
  0x80, 0x1F, 0x03, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x80, 0x0F,
  0x81, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x80, 0xFE,
  0x07, 0xE0, 0x0F, 0xE3, 0xF8, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xF7,
  0xF8, 0x07, 0xF0, 0x3F, 0x81, 0xFC, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xE1, 0xF0, 0x00, 0x7C, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01, 0xF8, 0xFE,
  0x00, 0x3F, 0x0F, 0xE0, 0x0F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0xFE, 0x01,
  0xFC, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0x7C, 0x00, 0x1F, 0x3F, 0x00, 0x07, 0xCF, 0xC0, 0x01, 0xF3,
  0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xCF, 0xC0, 0x07,
  0xF1, 0xF8, 0x03, 0xFC, 0x7F, 0x03, 0xFF, 0x1F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFB, 0xE0, 0x7F, 0xFD, 0xF8, 0x0F, 0xFE, 0x7E, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xFC, 0x0F, 0x07, 0xFE, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x08, 0x00, 0x00,
  0x01, 0xC0, 0x7E, 0x07, 0xF0, 0xFF, 0x0F, 0xF0, 0xFE, 0x07, 0xE0, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x7E, 0x0F, 0xE0, 0xFE, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x70, 0x00, 0x00,
  0x1C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x07,
  0xFC, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xC0, 0x00,
  0x00, 0x20, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFC,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0, 0x00, 0xFF, 0xC0, 0x03, 0xFF, 0x80,
  0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x70, 0x00,
  0x00, 0x20, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFE, 0x0F, 0xFF,
  0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x1F, 0x01, 0xFC, 0x40, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x80,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xC0,
  0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x7F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x3F, 0xC0, 0x3E, 0x1F, 0x00, 0x7F, 0xFE, 0x07, 0x87, 0xC0,
  0x3F, 0xFF, 0x81, 0xF3, 0xE0, 0x3F, 0xFF, 0xE0, 0x7C, 0xF0, 0x1F, 0xC0,
  0xF8, 0x1F, 0x7C, 0x07, 0xC0, 0x3C, 0x07, 0xDF, 0x03, 0xE0, 0x1F, 0x01,
  0xF7, 0x80, 0xF0, 0x07, 0xC0, 0x7F, 0xE0, 0x7C, 0x01, 0xF0, 0x1F, 0xF8,
  0x1E, 0x00, 0x78, 0x07, 0xBE, 0x0F, 0x80, 0x3E, 0x01, 0xEF, 0x03, 0xE0,
  0x0F, 0x80, 0xFB, 0xC0, 0xF8, 0x03, 0xC0, 0x3E, 0xF0, 0x3E, 0x01, 0xF0,
  0x0F, 0x3C, 0x0F, 0x80, 0x7C, 0x07, 0xCF, 0x03, 0xE0, 0x3F, 0x01, 0xF3,
  0xC0, 0xF8, 0x0F, 0xC0, 0xF8, 0xF8, 0x3E, 0x07, 0xF0, 0x7C, 0x3E, 0x0F,
  0xEF, 0xBF, 0xFF, 0x0F, 0x81, 0xFF, 0xE7, 0xFF, 0x83, 0xE0, 0x3F, 0xF1,
  0xFF, 0xC0, 0x7C, 0x07, 0xF0, 0x3F, 0xC0, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xC0, 0x00, 0x1F, 0xF8, 0x07, 0xF0, 0x00, 0x03, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x7D,
  0xF0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x03, 0xE1,
  0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x0F, 0xC0,
  0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3F, 0x00,
  0xF8, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xF0, 0x00,
  0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x7E, 0x3F, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00,
  0x3E, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8,
  0x07, 0xE0, 0x7F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x7C, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x3F, 0x03, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x7E, 0x00,
  0x3F, 0x81, 0xF8, 0x01, 0xFC, 0x07, 0xC0, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00,
  0x3E, 0x01, 0xFF, 0x01, 0xF8, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0,
  0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00,
  0x7E, 0x0F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x01, 0xFF,
  0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x1F, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFC, 0x01, 0xE0, 0x3F, 0xC0, 0x01, 0x01, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0xFF, 0x00, 0x18, 0x03, 0xFF, 0xDF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01,
  0x40, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xC0, 0xFF, 0xE0, 0x07, 0xE0, 0x0F, 0xF0, 0x03, 0xE0, 0x01, 0xFC, 0x03,
  0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x07, 0xE0, 0x3E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x01, 0xF8,
  0x1F, 0x80, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x3F,
  0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7C, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00,
  0xFC, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00,
  0x7F, 0x07, 0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x3F, 0x83, 0xF0, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0x7C, 0x00,
  0x3F, 0xC0, 0x7E, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0x80, 0x7F, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x1F,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0xFE, 0x01, 0xFF, 0x80, 0x7E, 0x03, 0xFE, 0x00, 0x0C, 0x07, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0xFC, 0xFC, 0x00, 0x7F,
  0xFC, 0xFC, 0x00, 0x7F, 0xFC, 0xFC, 0x00, 0xFF, 0xF8, 0xFC, 0x00, 0xFF,
  0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01, 0xF8, 0xFC, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x01, 0xF0, 0xFC, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xE0, 0x7F, 0x00, 0x07,
  0xE0, 0x7F, 0x80, 0x07, 0xE0, 0x3F, 0xC0, 0x07, 0xE0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xC0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0A, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x03, 0xF0, 0x0F, 0x80, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x0F, 0xC0, 0x3E, 0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0xFC, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x1F, 0x80, 0x7C, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x7E,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x01, 0xF0, 0x0F, 0xC0, 0x00,
  0x3E, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x07, 0xC0,
  0x00, 0x3F, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x3F, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xFC, 0x03, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0xEF, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00,
  0xFF, 0xC0, 0x00, 0x1C, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F,
  0x00, 0x0F, 0xE0, 0x0F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x07, 0xC0, 0x3F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x03, 0xE0, 0xFE,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x9F,
  0xC0, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x01, 0xF7, 0xF0, 0x00, 0x00, 0xFF,
  0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0xF8, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x7F, 0x0F, 0xC0, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF0, 0x1F, 0x80,
  0x00, 0xFC, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xFE,
  0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xC0, 0x00,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xF0, 0x1F, 0xF0, 0x00, 0x03, 0xFF, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x1F, 0xF8, 0x00, 0x07, 0xFE, 0x01, 0xFF, 0x80, 0x00,
  0xFF, 0xE0, 0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x03, 0xEF, 0x80, 0x01, 0xFF,
  0xE0, 0x3E, 0xF8, 0x00, 0x1F, 0x7C, 0x03, 0xEF, 0x80, 0x03, 0xE7, 0xC0,
  0x3E, 0xF8, 0x00, 0x3E, 0xFC, 0x03, 0xE7, 0x80, 0x07, 0xCF, 0xC0, 0x7E,
  0x78, 0x00, 0x7C, 0xFC, 0x07, 0xC7, 0x80, 0x0F, 0x8F, 0x80, 0x7C, 0x7C,
  0x00, 0xF8, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x1F, 0x80, 0xFC, 0x7C, 0x01,
  0xF1, 0xF8, 0x0F, 0xC7, 0xC0, 0x3E, 0x1F, 0x00, 0xF8, 0x7C, 0x03, 0xE1,
  0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x3F, 0x00, 0xF8, 0x7C, 0x07, 0xC3, 0xF0,
  0x1F, 0x83, 0xC0, 0xF8, 0x3F, 0x01, 0xF8, 0x3C, 0x1F, 0x03, 0xE0, 0x1F,
  0x03, 0xC1, 0xF0, 0x3E, 0x01, 0xF0, 0x3E, 0x3E, 0x07, 0xE0, 0x1F, 0x03,
  0xE3, 0xE0, 0x7E, 0x03, 0xF0, 0x3E, 0x7C, 0x07, 0xE0, 0x3F, 0x03, 0xE7,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xEF, 0x80,
  0xFC, 0x03, 0xE0, 0x1F, 0xF0, 0x0F, 0xC0, 0x7E, 0x01, 0xFF, 0x00, 0xFC,
  0x07, 0xC0, 0x1F, 0xE0, 0x0F, 0x80, 0x7C, 0x01, 0xFE, 0x00, 0xF8, 0x07,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0,
  0x1F, 0x80, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xF8, 0x07, 0xF0, 0x00, 0x07, 0xC0, 0x3F, 0x80, 0x00, 0x7E,
  0x03, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xF0, 0x00, 0x1F, 0x00, 0xFF, 0x80,
  0x00, 0xF8, 0x07, 0xFE, 0x00, 0x07, 0xC0, 0x3F, 0xF0, 0x00, 0x7E, 0x03,
  0xEF, 0x80, 0x03, 0xF0, 0x1F, 0x7E, 0x00, 0x1F, 0x00, 0xFB, 0xF0, 0x00,
  0xF8, 0x07, 0xCF, 0x80, 0x0F, 0xC0, 0x3E, 0x7E, 0x00, 0x7E, 0x03, 0xF1,
  0xF0, 0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0x1F, 0x00, 0xF8, 0x7E, 0x00, 0xF8,
  0x07, 0xC1, 0xF0, 0x0F, 0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x7E,
  0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0xF8, 0x07,
  0xC0, 0x7E, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x7E, 0x03, 0xF0, 0x0F, 0xC3,
  0xE0, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x07, 0xC0,
  0x0F, 0xCF, 0xC0, 0x7E, 0x00, 0x3E, 0x7E, 0x03, 0xF0, 0x01, 0xFB, 0xE0,
  0x1F, 0x00, 0x0F, 0xDF, 0x00, 0xF8, 0x00, 0x3E, 0xF8, 0x07, 0xC0, 0x01,
  0xFF, 0xC0, 0x7E, 0x00, 0x0F, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0xE0, 0x1F,
  0x00, 0x01, 0xFF, 0x00, 0xF8, 0x00, 0x0F, 0xF8, 0x0F, 0xC0, 0x00, 0x3F,
  0xC0, 0x7E, 0x00, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0,
  0x1F, 0xE0, 0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00,
  0x00, 0x1F, 0xDF, 0x80, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F,
  0x80, 0x0F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x0F, 0xFF, 0x7F, 0xF8, 0x03,
  0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0x00, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0x0F, 0xE0, 0x3E, 0x00,
  0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3E,
  0x07, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00,
  0x3F, 0x83, 0xF0, 0x07, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFE, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xF8, 0x1F, 0xF0, 0x1F, 0xF0, 0x03, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC7,
  0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F,
  0x7E, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0x7E, 0x00, 0x00, 0x3F, 0xBF, 0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x0F, 0xE3, 0xF8, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x0F, 0xF0, 0x1F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0xF8, 0x07, 0xE0,
  0x1F, 0xE0, 0x3E, 0x00, 0x7F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F,
  0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3E, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x7E, 0x07, 0xE0,
  0x07, 0xF0, 0x3E, 0x00, 0xFF, 0x03, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x03,
  0xF0, 0x3E, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0xFC, 0x0F, 0xC0, 0x07, 0xC0,
  0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFC, 0x01, 0xF8, 0x07, 0xC0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03,
  0xF0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xC0,
  0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFC, 0x07, 0xF8, 0x0F, 0x80, 0xFE, 0x00, 0x20, 0x3F, 0x80,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x80, 0x00,
  0xFE, 0x1C, 0x00, 0x7F, 0x83, 0xFC, 0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFC, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3E, 0x00,
  0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x03, 0xE0, 0x00, 0x1F, 0x83, 0xF0,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x03, 0xF0, 0x7E,
  0x00, 0x01, 0xF0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x3F, 0x07, 0xC0, 0x00, 0x3F, 0x07,
  0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x7E, 0x0F, 0xC0, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x3F, 0xC0, 0x1F, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x50, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E,
  0x1F, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x3F, 0x07,
  0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0x80, 0xFC,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x01,
  0xF1, 0xF8, 0x00, 0x07, 0xCF, 0xC0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x7E, 0x00, 0x07,
  0xEF, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0xBE, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF3, 0xE0, 0x01, 0xFF, 0x00, 0x1F, 0x8F,
  0x80, 0x07, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x3F, 0xF0, 0x01, 0xF0, 0xF8,
  0x00, 0xFF, 0xC0, 0x0F, 0xC3, 0xE0, 0x03, 0xDF, 0x00, 0x3F, 0x0F, 0x80,
  0x1F, 0x7C, 0x01, 0xF8, 0x3E, 0x00, 0x7D, 0xF0, 0x07, 0xE0, 0xF8, 0x03,
  0xE7, 0xC0, 0x3F, 0x03, 0xE0, 0x0F, 0x9F, 0x00, 0xFC, 0x0F, 0x80, 0x7C,
  0x7C, 0x03, 0xE0, 0x3E, 0x01, 0xF1, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x87,
  0xC0, 0x7C, 0x03, 0xF0, 0x3E, 0x1F, 0x03, 0xF0, 0x0F, 0xC1, 0xF8, 0x7C,
  0x0F, 0xC0, 0x3F, 0x07, 0xC1, 0xF0, 0x7E, 0x00, 0xFC, 0x3F, 0x07, 0xC1,
  0xF8, 0x03, 0xF0, 0xF8, 0x1F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x7C, 0x3F,
  0x00, 0x3F, 0x1F, 0x01, 0xF0, 0xF8, 0x00, 0xFC, 0x7C, 0x03, 0xC7, 0xE0,
  0x03, 0xF3, 0xE0, 0x0F, 0x1F, 0x00, 0x07, 0xCF, 0x80, 0x3C, 0x7C, 0x00,
  0x1F, 0x7C, 0x00, 0xF3, 0xE0, 0x00, 0x7D, 0xF0, 0x03, 0xCF, 0x80, 0x01,
  0xF7, 0xC0, 0x0F, 0x7E, 0x00, 0x07, 0xFE, 0x00, 0x3D, 0xF0, 0x00, 0x1E,
  0xF8, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x01, 0xFF,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0,
  0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x0F, 0xE0, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x7E,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x01,
  0xF3, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x01, 0xFB, 0xE0,
  0x00, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x0F,
  0xC3, 0xE0, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x00, 0xFE, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0xFC,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE7, 0xC0, 0x00,
  0xFC, 0x7E, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x03,
  0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x01,
  0xF8, 0x01, 0xF0, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0x87, 0xE0, 0x00, 0xF8, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0xFD,
  0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x03, 0xFF, 0x80, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0xF8, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81,
  0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0x7C,
  0x0F, 0x81, 0xF0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x3E, 0x07,
  0xC0, 0xF8, 0x1F, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0xF8, 0x1F, 0x03, 0xE0,
  0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x3F, 0xF8, 0x01, 0xFF, 0xC0, 0x0F, 0xFE,
  0x00, 0xFF, 0xF0, 0x07, 0xFF, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0xFF, 0xE0, 0x07,
  0xFF, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x1F, 0xFC, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xDF,
  0x00, 0x00, 0xF9, 0xE0, 0x00, 0x1E, 0x3E, 0x00, 0x07, 0xC3, 0xC0, 0x00,
  0xF0, 0x7C, 0x00, 0x3E, 0x07, 0x80, 0x07, 0x80, 0xF8, 0x01, 0xF0, 0x1F,
  0x00, 0x3C, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x01, 0xE0, 0x03, 0xC0, 0x7C,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0x83, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x0F,
  0x1F, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE0, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F,
  0x1F, 0x87, 0xC1, 0xF0, 0xF8, 0x3E, 0x0F, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xF8, 0x7C, 0x07, 0xFF, 0x8F, 0x81, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0x7C,
  0x1F, 0xE1, 0xFF, 0x87, 0xF8, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x00, 0x7F,
  0x87, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xFC, 0x1F, 0xE3, 0xEF, 0x81, 0xFF,
  0xFD, 0xF0, 0x3F, 0xFF, 0x3E, 0x03, 0xFF, 0x87, 0x80, 0x3F, 0xE1, 0xF0,
  0x00, 0xC0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x01, 0x80, 0x03, 0xF0,
  0xFF, 0x00, 0x3F, 0x3F, 0xF8, 0x03, 0xE7, 0xFF, 0xC0, 0x3E, 0xFF, 0xFE,
  0x03, 0xFF, 0x0F, 0xE0, 0x7F, 0xC0, 0x7E, 0x07, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x3F, 0x1F,
  0x80, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF0, 0x00,
  0x7E, 0x1F, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0xC3,
  0xF8, 0x01, 0xF8, 0x3F, 0x80, 0x3F, 0x87, 0xFC, 0x07, 0xF0, 0x7F, 0xE1,
  0xFE, 0x07, 0xDF, 0xFF, 0xE0, 0x7C, 0xFF, 0xFC, 0x07, 0x87, 0xFF, 0x00,
  0xF8, 0x3F, 0xE0, 0x00, 0x00, 0x40, 0x00, 0x00, 0x07, 0x00, 0x01, 0xFF,
  0xF0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x3F, 0xE0, 0xE1,
  0xFE, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x41, 0xFE, 0x0F, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x02, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3E, 0x00, 0x01, 0x80, 0xF8, 0x00, 0x7F, 0xC7, 0xE0, 0x07, 0xFF,
  0x9F, 0x80, 0x3F, 0xFF, 0x7E, 0x01, 0xFF, 0xFD, 0xF0, 0x0F, 0xF0, 0xFF,
  0xC0, 0x7F, 0x00, 0xFF, 0x01, 0xF8, 0x03, 0xFC, 0x0F, 0xE0, 0x07, 0xE0,
  0x3F, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xF8, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0xC0,
  0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xC0, 0xF8, 0x00, 0x3F, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0x80, 0x07, 0xE0, 0x3E, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0xFE,
  0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xC0, 0x3F, 0xC0, 0x3F, 0x01, 0xFF, 0x00,
  0xFF, 0x1F, 0x7C, 0x01, 0xFF, 0xFD, 0xF0, 0x07, 0xFF, 0xE7, 0x80, 0x0F,
  0xFE, 0x1E, 0x00, 0x1F, 0xF0, 0xF8, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x07, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x7F,
  0xFF, 0xE1, 0xFE, 0x0F, 0xC7, 0xF0, 0x0F, 0x8F, 0xC0, 0x1F, 0x3F, 0x00,
  0x3E, 0x7E, 0x00, 0xFD, 0xF8, 0x01, 0xFB, 0xF0, 0x07, 0xE7, 0xC0, 0x3F,
  0xDF, 0xFF, 0xFF, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xE0, 0xFF, 0xFF, 0x01,
  0xFF, 0xC0, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x30, 0xFF,
  0x03, 0xE1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0x81, 0xFF, 0xFE, 0x00, 0xFF,
  0xF0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xF1,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x03, 0x80, 0x00, 0x00, 0xFF, 0x87, 0xC0, 0x1F, 0xFE, 0x3E, 0x01, 0xFF,
  0xF9, 0xF0, 0x1F, 0xFF, 0xDF, 0x01, 0xFE, 0x1F, 0xF8, 0x1F, 0xE0, 0x3F,
  0xC0, 0xFE, 0x01, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0x3F, 0x07,
  0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E, 0x1F, 0x80,
  0x03, 0xE0, 0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x7E, 0x0F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x3F, 0x03,
  0xE0, 0x03, 0xF8, 0x1F, 0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xFE, 0x07, 0xE0,
  0x1F, 0xE0, 0x3F, 0x01, 0xFF, 0x01, 0xFE, 0x3E, 0xF8, 0x07, 0xFF, 0xEF,
  0xC0, 0x3F, 0xFE, 0x7C, 0x00, 0xFF, 0xE3, 0xE0, 0x01, 0xFE, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x08, 0x00, 0x3F,
  0x80, 0x78, 0x03, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x01, 0x80, 0x03, 0xF0, 0xFF, 0x80, 0x3F, 0x3F, 0xFC,
  0x03, 0xE7, 0xFF, 0xE0, 0x3E, 0xFF, 0xFE, 0x03, 0xFF, 0x0F, 0xE0, 0x7F,
  0xE0, 0x7F, 0x07, 0xF8, 0x03, 0xF0, 0x7F, 0x80, 0x3F, 0x07, 0xF0, 0x03,
  0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x07, 0xE0, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x7C, 0x1F, 0x80, 0x0F, 0xC1, 0xF0, 0x00, 0xFC, 0x1F, 0x00, 0x0F, 0xC3,
  0xF0, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x3E, 0x00,
  0x1F, 0x87, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xF0,
  0x7E, 0x00, 0x3F, 0x07, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF0, 0x0F, 0xC0,
  0x3F, 0x00, 0xFC, 0x03, 0xF0, 0x0F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x03,
  0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x3F, 0x81, 0xF8,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x7C, 0x03, 0xF0, 0x07, 0xE0, 0x3F,
  0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x7C, 0x3F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFE, 0xFC, 0x00, 0x0F, 0xE7, 0xE0, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8,
  0x1F, 0x80, 0x0F, 0x80, 0x7E, 0x00, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0x1F,
  0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xF8, 0x0F, 0x80, 0x0F, 0xC0,
  0xFC, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7C, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xE0,
  0x07, 0xC0, 0x1F, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x18,
  0x00, 0x1C, 0x00, 0x3E, 0x0F, 0xF0, 0x0F, 0xF8, 0x03, 0xE3, 0xFF, 0x81,
  0xFF, 0xC0, 0x3E, 0x7F, 0xFC, 0x3F, 0xFE, 0x03, 0xEF, 0xFF, 0xC7, 0xFF,
  0xE0, 0x3F, 0xF0, 0xFC, 0xF8, 0x7F, 0x07, 0xFC, 0x07, 0xFE, 0x03, 0xF0,
  0x7F, 0x80, 0x7F, 0xC0, 0x3F, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF0, 0x7F,
  0x00, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0xFE, 0x00,
  0x7E, 0x00, 0x3E, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0xFC, 0x00, 0x7E,
  0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x00,
  0x7E, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x00, 0xFC,
  0x1F, 0x00, 0x0F, 0x80, 0x0F, 0xC1, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x3F,
  0x00, 0x1F, 0x80, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x3F, 0x00,
  0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F,
  0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x7E, 0x00, 0x3F, 0x00,
  0x1F, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7E, 0x00, 0x3F,
  0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x3E, 0x0F,
  0xF8, 0x03, 0xE3, 0xFF, 0xC0, 0x3E, 0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xE0,
  0x7F, 0xF8, 0xFF, 0x07, 0xFE, 0x07, 0xF0, 0x7F, 0xC0, 0x3F, 0x07, 0xF8,
  0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0xFE, 0x00, 0x7E,
  0x0F, 0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07, 0xE1, 0xF8,
  0x00, 0x7E, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0x3F,
  0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x87, 0xE0, 0x01,
  0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x0F,
  0xC0, 0x03, 0xF0, 0x00, 0x02, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0x87, 0xF8, 0x7F, 0x00,
  0xFC, 0x3F, 0x00, 0x3F, 0x3F, 0x00, 0x1F, 0xBF, 0x80, 0x0F, 0xDF, 0x80,
  0x07, 0xEF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xF0,
  0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0xDF, 0x00, 0x07, 0xEF, 0x80, 0x03, 0xF7, 0xC0, 0x03, 0xF3,
  0xF0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x3F, 0xC3, 0xFC,
  0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x03, 0xE0, 0xFF, 0x00, 0x0F, 0x8F, 0xFE,
  0x00, 0x3E, 0x7F, 0xFC, 0x00, 0xFB, 0xFF, 0xF8, 0x03, 0xFF, 0x0F, 0xE0,
  0x1F, 0xF0, 0x1F, 0x80, 0x7F, 0x80, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x07,
  0xF0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC1, 0xF8, 0x00,
  0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x07, 0xE0, 0x7C, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F,
  0xE1, 0xFE, 0x01, 0xF7, 0xFF, 0xF8, 0x07, 0xCF, 0xFF, 0xC0, 0x1F, 0x1F,
  0xFC, 0x00, 0xFC, 0x3F, 0xE0, 0x03, 0xF0, 0x10, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F,
  0xF8, 0x3C, 0x07, 0xFF, 0x8F, 0x81, 0xFF, 0xF9, 0xF0, 0x7F, 0xFF, 0xFC,
  0x1F, 0xE1, 0xFF, 0x87, 0xF0, 0x0F, 0xF0, 0xFE, 0x01, 0xFE, 0x3F, 0x80,
  0x1F, 0xC7, 0xE0, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x01, 0xF9, 0xF8, 0x00, 0x3E, 0x3F, 0x00, 0x07, 0xC7, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xF8, 0x7C,
  0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xE1, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x7F,
  0x87, 0xE0, 0x1F, 0xE0, 0xFC, 0x07, 0xFC, 0x1F, 0xE3, 0xEF, 0x81, 0xFF,
  0xFB, 0xF0, 0x3F, 0xFE, 0x7C, 0x03, 0xFF, 0x8F, 0x80, 0x3F, 0xE3, 0xF0,
  0x00, 0x40, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x07, 0xC3, 0xF8, 0x0F, 0x8F, 0xF0, 0x1F, 0x3F, 0xE0, 0x3E, 0xFF, 0xC0,
  0x7F, 0xFF, 0x81, 0xFF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x80, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0,
  0x7F, 0xFF, 0xC1, 0xFC, 0x07, 0x83, 0xF0, 0x02, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xE0, 0x00, 0x7F,
  0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0xC0, 0x07, 0xF1,
  0xF0, 0x1F, 0xC3, 0xFF, 0xFF, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x07,
  0xFF, 0xC0, 0x00, 0x20, 0x00, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xCF, 0xFF, 0xF9, 0xFF, 0xFF, 0x43, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x60, 0x7F, 0xFC,
  0x07, 0xFF, 0x80, 0xFF, 0xF0, 0x07, 0xFC, 0x00, 0x08, 0x00, 0x0F, 0xC0,
  0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF1,
  0xF8, 0x00, 0x7C, 0x3F, 0x00, 0x1F, 0x87, 0xE0, 0x03, 0xF0, 0xF8, 0x00,
  0x7E, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x01, 0xF0, 0xFC, 0x00, 0x7E, 0x1F,
  0x00, 0x0F, 0xC3, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0xC3, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE3, 0xF0,
  0x01, 0xF8, 0x7E, 0x00, 0x7F, 0x0F, 0xC0, 0x0F, 0xE1, 0xF8, 0x03, 0xFC,
  0x3F, 0x00, 0xFF, 0x07, 0xE0, 0x3F, 0xE0, 0xFE, 0x1F, 0x7C, 0x0F, 0xFF,
  0xCF, 0x81, 0xFF, 0xF1, 0xF0, 0x1F, 0xFC, 0x3C, 0x01, 0xFF, 0x07, 0x80,
  0x02, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xEF, 0xC0,
  0x03, 0xF3, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x7E, 0x3F, 0x00, 0x1F, 0x8F,
  0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7C,
  0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x07, 0xE0, 0x1F, 0x83,
  0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0x3E, 0x1F, 0x80, 0x0F,
  0x8F, 0xC0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E, 0x7E, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xF0,
  0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xF8, 0x03, 0xF7, 0xE0, 0x0F, 0xF0, 0x07, 0xEF, 0xC0,
  0x3F, 0xE0, 0x1F, 0x9F, 0x80, 0x7B, 0xC0, 0x3F, 0x3F, 0x01, 0xF7, 0x80,
  0xFC, 0x7E, 0x03, 0xCF, 0x01, 0xF8, 0x7C, 0x0F, 0x9E, 0x03, 0xE0, 0xF8,
  0x1F, 0x7C, 0x0F, 0xC1, 0xF0, 0x3C, 0xF8, 0x1F, 0x03, 0xE0, 0xF9, 0xF0,
  0x7E, 0x07, 0xC1, 0xE3, 0xE0, 0xF8, 0x0F, 0x87, 0xC3, 0xC3, 0xF0, 0x1F,
  0x0F, 0x07, 0x87, 0xE0, 0x3E, 0x3E, 0x0F, 0x0F, 0x80, 0x7C, 0x7C, 0x1E,
  0x3F, 0x00, 0xF9, 0xF0, 0x3C, 0x7C, 0x01, 0xF3, 0xE0, 0x79, 0xF8, 0x03,
  0xE7, 0x80, 0xF3, 0xE0, 0x07, 0xDF, 0x01, 0xE7, 0xC0, 0x0F, 0xBC, 0x03,
  0xDF, 0x00, 0x1F, 0xF8, 0x07, 0xBE, 0x00, 0x3F, 0xE0, 0x0F, 0x78, 0x00,
  0x7F, 0xC0, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00,
  0x7F, 0x80, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x0F,
  0xE0, 0x07, 0xE0, 0x3F, 0x80, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0x81, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x1F, 0x8F, 0x80, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xC0,
  0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00,
  0xF8, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x1F, 0xC0, 0x3E,
  0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x0F, 0xC0,
  0x01, 0xF0, 0x03, 0xF0, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x0F, 0x80, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x03, 0xE0, 0xFC, 0x00, 0x00, 0xF8,
  0x3E, 0x00, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x03,
  0xE3, 0xF0, 0x00, 0x00, 0x78, 0xF8, 0x00, 0x00, 0x1F, 0x7E, 0x00, 0x00,
  0x07, 0xDF, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0xFF, 0xFC, 0x1F, 0xFF, 0xFC, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x0C, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x00, 0x7F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFE,
  0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x0A, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x40,
  0x00, 0x03, 0xF0, 0x00, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00,
  0xFF, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x80, 0x03, 0xF0,
  0x00, 0x10, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xBF, 0xF8, 0x00, 0x7F, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFE, 0x00,
  0x3F, 0xF9, 0x00, 0x01, 0xF0,
};

const GFXglyph NotoSans_MediumItalic54pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 14, 0, -1 },
  { 1, 15, 40, 15, 1, -39 },
  { 76, 17, 14, 22, 6, -39 },
  { 106, 34, 39, 35, 1, -39 },
  { 272, 27, 44, 30, 2, -41 },
  { 421, 38, 40, 44, 4, -39 },
  { 611, 34, 40, 37, 2, -39 },
  { 781, 7, 14, 12, 6, -39 },
  { 794, 19, 48, 16, 2, -39 },
  { 908, 18, 48, 16, -4, -39 },
  { 1016, 25, 25, 30, 5, -41 },
  { 1095, 25, 26, 31, 4, -32 },
  { 1177, 11, 13, 14, -2, -6 },
  { 1195, 14, 5, 17, 1, -17 },
  { 1204, 7, 8, 14, 1, -7 },
  { 1211, 27, 39, 20, -2, -39 },
  { 1343, 26, 40, 30, 3, -39 },
  { 1473, 18, 39, 30, 7, -39 },
  { 1561, 29, 39, 30, 0, -39 },
  { 1703, 28, 40, 30, 1, -39 },
  { 1843, 29, 39, 30, 0, -39 },
  { 1985, 27, 40, 30, 2, -39 },
  { 2120, 27, 40, 30, 3, -39 },
  { 2255, 27, 39, 30, 4, -39 },
  { 2387, 27, 40, 30, 2, -39 },
  { 2522, 26, 40, 30, 2, -39 },
  { 2652, 12, 31, 14, 1, -30 },
  { 2699, 16, 37, 14, -3, -30 },
  { 2773, 25, 27, 31, 4, -33 },
  { 2858, 25, 16, 31, 4, -27 },
  { 2908, 25, 27, 31, 4, -33 },
  { 2993, 21, 40, 24, 4, -39 },
  { 3098, 42, 44, 46, 3, -39 },
  { 3329, 32, 39, 31, -3, -39 },
  { 3485, 30, 39, 33, 2, -39 },
  { 3632, 30, 40, 32, 4, -39 },
  { 3782, 33, 39, 36, 2, -39 },
  { 3943, 28, 39, 28, 2, -39 },
  { 4080, 28, 39, 27, 2, -39 },
  { 4217, 32, 40, 37, 4, -39 },
  { 4377, 35, 39, 37, 2, -39 },
  { 4548, 22, 39, 18, -1, -39 },
  { 4656, 24, 50, 16, -8, -39 },
  { 4806, 34, 39, 31, 2, -39 },
  { 4972, 21, 39, 26, 2, -39 },
  { 5075, 44, 39, 46, 2, -39 },
  { 5290, 37, 39, 39, 2, -39 },
  { 5471, 33, 40, 39, 4, -39 },
  { 5636, 29, 39, 31, 2, -39 },
  { 5778, 33, 48, 39, 4, -39 },
  { 5976, 29, 39, 32, 2, -39 },
  { 6118, 27, 40, 28, 1, -39 },
  { 6253, 27, 39, 28, 5, -39 },
  { 6385, 33, 40, 37, 4, -39 },
  { 6550, 30, 39, 30, 5, -39 },
  { 6697, 46, 39, 47, 6, -39 },
  { 6922, 37, 39, 30, -3, -39 },
  { 7103, 28, 39, 28, 5, -39 },
  { 7240, 32, 39, 29, -1, -39 },
  { 7396, 21, 48, 16, -1, -39 },
  { 7522, 11, 39, 20, 6, -39 },
  { 7576, 21, 48, 16, -4, -39 },
  { 7702, 27, 25, 31, 2, -39 },
  { 7787, 22, 4, 21, -5, 5 },
  { 7798, 9, 8, 16, 8, -41 },
  { 7807, 27, 31, 31, 3, -30 },
  { 7912, 28, 42, 32, 1, -41 },
  { 8059, 22, 31, 25, 3, -30 },
  { 8145, 30, 42, 31, 3, -41 },
  { 8303, 23, 31, 28, 3, -30 },
  { 8393, 31, 54, 18, -6, -41 },
  { 8603, 29, 43, 32, 1, -30 },
  { 8759, 28, 41, 32, 1, -41 },
  { 8903, 14, 40, 15, 1, -40 },
  { 8973, 22, 53, 15, -7, -40 },
  { 9119, 29, 41, 28, 1, -41 },
  { 9268, 15, 41, 15, 1, -41 },
  { 9345, 44, 30, 48, 1, -30 },
  { 9510, 28, 30, 32, 1, -30 },
  { 9615, 25, 30, 31, 3, -30 },
  { 9709, 30, 43, 32, -1, -30 },
  { 9871, 27, 43, 31, 3, -30 },
  { 10017, 23, 30, 22, 1, -30 },
  { 10104, 23, 31, 24, 0, -30 },
  { 10194, 19, 37, 19, 2, -36 },
  { 10282, 27, 30, 32, 3, -29 },
  { 10384, 26, 29, 26, 3, -29 },
  { 10479, 39, 29, 40, 3, -29 },
  { 10621, 31, 29, 27, -2, -29 },
  { 10734, 34, 42, 26, -5, -29 },
  { 10913, 25, 29, 24, -1, -29 },
  { 11004, 22, 48, 19, 0, -39 },
  { 11136, 5, 54, 30, 13, -41 },
  { 11170, 21, 48, 19, -2, -39 },
  { 11296, 25, 8, 31, 4, -23 },
};

const GFXfont NotoSans_MediumItalic54pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic54pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic54pt7bGlyphs,
  0x20, 0x7E, 74
};

#endif // _NOTOSANS_MEDIUMITALIC54PT7B_H_
