#ifndef _NOTOSANS_MEDIUMITALIC59PT7B_H_
#define _NOTOSANS_MEDIUMITALIC59PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 59pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic59pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0C, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x3C, 0x00, 0x3F, 0x87, 0xE7, 0xE0, 0xFC, 0xFC, 0x1F, 0x1F, 0x87,
  0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x9F, 0x83, 0xE3, 0xE0, 0x7C, 0x7C, 0x0F,
  0x8F, 0x81, 0xE1, 0xF0, 0x7C, 0x3C, 0x0F, 0x87, 0x81, 0xF1, 0xF0, 0x3C,
  0x3C, 0x07, 0x80, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x3E,
  0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF,
  0xC3, 0xFF, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x0F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x07, 0xFF,
  0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x07, 0x80,
  0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x3E,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xBC, 0xFC, 0x07, 0xF1,
  0xE0, 0xC0, 0x7F, 0x0F, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x87, 0x80,
  0x00, 0xFC, 0x3C, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x3F, 0x0E, 0x00, 0x01,
  0xFC, 0xF0, 0x00, 0x0F, 0xF7, 0x80, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1E, 0x7F, 0x80,
  0x00, 0xF1, 0xFC, 0x00, 0x07, 0x87, 0xE0, 0x00, 0x3C, 0x3F, 0x00, 0x01,
  0xE1, 0xF8, 0x00, 0x1E, 0x0F, 0xC0, 0x00, 0xF0, 0x7E, 0x20, 0x07, 0x87,
  0xE1, 0x80, 0x3C, 0x7F, 0x0F, 0x83, 0xCF, 0xF8, 0x7F, 0xFF, 0xFF, 0x83,
  0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF0, 0x00, 0x7F,
  0xFC, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0x80, 0x3F,
  0xF8, 0x00, 0x07, 0xC0, 0x1F, 0xFF, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xC0,
  0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x00, 0xFC, 0x01, 0xF0, 0x3E, 0x00, 0x3E,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x0F,
  0x80, 0xF8, 0x03, 0xE0, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x01, 0xF8, 0x1F,
  0x00, 0x07, 0xC0, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x07, 0xC0, 0x00,
  0xF8, 0x07, 0xC3, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0xF8, 0x3E, 0x0F, 0x80,
  0xF8, 0x7C, 0x7F, 0xE3, 0xE0, 0x3E, 0x3E, 0x3F, 0xFC, 0xFC, 0x1F, 0x1F,
  0x9F, 0xFF, 0x9F, 0x0F, 0xC7, 0xCF, 0xFF, 0xE7, 0xFF, 0xE3, 0xE3, 0xF0,
  0xF9, 0xFF, 0xF1, 0xF1, 0xF8, 0x3F, 0x3F, 0xF8, 0xFC, 0x7C, 0x0F, 0xC7,
  0xFC, 0x3E, 0x3F, 0x01, 0xF0, 0x38, 0x1F, 0x0F, 0x80, 0xFC, 0x00, 0x0F,
  0x83, 0xE0, 0x3F, 0x00, 0x07, 0xE0, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x7E,
  0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x07, 0xC0, 0x3E,
  0x00, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x07,
  0xC0, 0x1F, 0x01, 0xF0, 0x03, 0xF0, 0x07, 0xC0, 0x7C, 0x01, 0xF8, 0x01,
  0xF0, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x8F,
  0xC0, 0x1F, 0x80, 0x03, 0xFF, 0xF0, 0x07, 0xC0, 0x00, 0xFF, 0xF8, 0x03,
  0xE0, 0x00, 0x1F, 0xFC, 0x01, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0xC0,
  0x00, 0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x7E, 0x7F, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0x80,
  0x07, 0xE0, 0xFF, 0xFE, 0x00, 0x7E, 0x1F, 0xF3, 0xF8, 0x03, 0xF1, 0xFE,
  0x0F, 0xE0, 0x3F, 0x0F, 0xE0, 0x7F, 0x01, 0xF8, 0xFE, 0x01, 0xFC, 0x1F,
  0x87, 0xE0, 0x07, 0xF1, 0xFC, 0x7F, 0x00, 0x1F, 0xCF, 0xC3, 0xF0, 0x00,
  0xFE, 0xFC, 0x1F, 0x80, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xFE, 0x07,
  0xE0, 0x00, 0x7F, 0xE0, 0x3F, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x1F,
  0xF0, 0x0F, 0xF0, 0x01, 0xFF, 0xC0, 0x3F, 0xC0, 0x3F, 0xFE, 0x01, 0xFF,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xCF, 0xE0, 0x1F, 0xFF, 0xFC, 0x7F,
  0x80, 0x7F, 0xFF, 0x81, 0xFC, 0x01, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x68,
  0x00, 0x00, 0x00, 0x3F, 0x9F, 0x8F, 0xC7, 0xE3, 0xE1, 0xF1, 0xF8, 0xF8,
  0x7C, 0x3E, 0x1F, 0x0F, 0x07, 0x87, 0xC3, 0xC0, 0x00, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x0F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x18, 0x03, 0xE0, 0x03,
  0xC0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0xF1, 0xE0, 0x03, 0xFF, 0xBC,
  0x00, 0x3F, 0xFF, 0x83, 0xF0, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xF8, 0x03, 0xFB, 0xFF, 0x01, 0xFF, 0x80, 0x60, 0x7E, 0xF0,
  0x00, 0x1F, 0x9F, 0x00, 0x07, 0xE3, 0xE0, 0x01, 0xFC, 0x3E, 0x00, 0xFF,
  0x07, 0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xF8, 0x1F, 0x80, 0x0E, 0x01, 0xF0,
  0x00, 0x80, 0x3F, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x80, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x01,
  0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xE0, 0x3F,
  0x03, 0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x3E, 0x03,
  0xE0, 0x00, 0x3F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE,
  0xFF, 0xFE, 0x0C, 0x3F, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xDF, 0xF0, 0x0F,
  0xF0, 0x3F, 0x80, 0x7F, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF0, 0x7F, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xF1, 0xFC, 0x00, 0x3F,
  0x8F, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x7F, 0x3F,
  0x00, 0x03, 0xFB, 0xF8, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x0F,
  0xDF, 0xC0, 0x00, 0xFE, 0xFE, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x3F, 0x3F,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0xFE, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF8, 0xFC, 0x00, 0x3F,
  0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x80, 0x1F, 0xC0, 0xFC, 0x00, 0xFE, 0x07,
  0xF0, 0x0F, 0xE0, 0x3F, 0xC1, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0x00, 0x3F,
  0xE0, 0x07, 0xFE, 0x01, 0xFF, 0xE0, 0x3F, 0xFE, 0x0F, 0xFF, 0xE3, 0xFF,
  0xFC, 0xFF, 0xEF, 0xC7, 0xF8, 0xFC, 0x3F, 0x0F, 0xC3, 0xC1, 0xF8, 0x18,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F,
  0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x80, 0x3F, 0x80, 0x7F, 0x80, 0x3C, 0x00, 0x7F, 0x00, 0x70, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0,
  0x0F, 0x80, 0x3F, 0xC0, 0x38, 0x00, 0x7F, 0x00, 0x40, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x20, 0x00, 0x07, 0xF0, 0xC0, 0x00, 0x3F, 0xC3, 0xE0, 0x03, 0xFE, 0x0F,
  0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x3D, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x01, 0xF9,
  0xF0, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x3F, 0x1F,
  0x80, 0x00, 0xFC, 0x3E, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xFC, 0x01,
  0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x03, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0,
  0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80,
  0x0C, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x08, 0x00, 0x03, 0xF8, 0x30, 0x00, 0x1F, 0xE0, 0xF0, 0x01, 0xFF, 0x03,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xE4, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x03,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0xFF, 0xFB, 0xE0, 0x07, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x81, 0xF0, 0x00, 0xFE, 0x3F, 0xF0, 0x03, 0xF3, 0xFF, 0xF0, 0x0F, 0xDF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0x07, 0xFE, 0x01,
  0xFC, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x3F,
  0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE3,
  0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03, 0xF0, 0xFE,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0xFE, 0x03, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFE, 0x3F,
  0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFE, 0x3F, 0xE0, 0x1F, 0xE0, 0x3F,
  0xC0, 0x7F, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x0F,
  0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0xFC, 0x01, 0xFC,
  0x0F, 0xF0, 0x03, 0xFC, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0,
  0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xF0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x03,
  0xF8, 0x01, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x03,
  0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x3F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xF0, 0x00,
  0x3F, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFC, 0x07, 0xF0, 0x1F, 0xE0, 0xFE, 0x00, 0xFE, 0x1F,
  0xC0, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00,
  0x3F, 0x3F, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x03, 0xF3,
  0xF0, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F, 0x00,
  0x0F, 0xF3, 0xF0, 0x00, 0xFF, 0x3F, 0x80, 0x1F, 0xE3, 0xFC, 0x07, 0xFE,
  0x1F, 0xF9, 0xFF, 0xE1, 0xFF, 0xFF, 0x7E, 0x0F, 0xFF, 0xEF, 0xE0, 0x7F,
  0xFC, 0xFC, 0x01, 0xFF, 0x8F, 0xC0, 0x01, 0x80, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF8, 0x08, 0x01, 0xFF, 0x80, 0xFF, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x00, 0xFF, 0xF8,
  0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x60, 0x1F, 0x80, 0xFE, 0x0F, 0xF0,
  0x7F, 0x83, 0xFC, 0x1F, 0xC0, 0xFE, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x0F,
  0xC0, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xC0,
  0x00, 0x00, 0x06, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0x7F, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xC0, 0x07, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x0F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xF8,
  0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x30, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFC, 0x00,
  0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x1F, 0xFF, 0x03, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC,
  0x7F, 0xFF, 0xF9, 0xFF, 0xFF, 0xF3, 0xC0, 0x1F, 0xCC, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x02,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x81, 0xF0, 0x00, 0x3E, 0x00, 0x3E, 0x0F,
  0xC0, 0x0F, 0xFF, 0x80, 0xF8, 0x3E, 0x00, 0xFF, 0xFF, 0x83, 0xF1, 0xF0,
  0x07, 0xFF, 0xFC, 0x07, 0xCF, 0xC0, 0x3F, 0xEF, 0xF0, 0x1F, 0x3E, 0x01,
  0xFC, 0x07, 0xC0, 0x7C, 0xF8, 0x0F, 0xC0, 0x3E, 0x01, 0xF7, 0xC0, 0x7E,
  0x00, 0xF8, 0x07, 0xDF, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x7C, 0x0F, 0xC0,
  0x1F, 0x80, 0x7D, 0xF0, 0x3E, 0x00, 0x7C, 0x01, 0xFF, 0x80, 0xF8, 0x01,
  0xF0, 0x07, 0xBE, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0xF8, 0x1F, 0x00, 0x3F,
  0x00, 0xFB, 0xE0, 0x7C, 0x00, 0xF8, 0x03, 0xEF, 0x81, 0xF0, 0x03, 0xE0,
  0x1F, 0x3E, 0x07, 0xC0, 0x1F, 0x80, 0x7C, 0xF8, 0x1F, 0x00, 0xFE, 0x03,
  0xE3, 0xE0, 0x7E, 0x03, 0xF8, 0x1F, 0x8F, 0x81, 0xF8, 0x1F, 0xE0, 0xFC,
  0x3E, 0x03, 0xF9, 0xF7, 0xCF, 0xF0, 0xFC, 0x0F, 0xFF, 0x9F, 0xFF, 0x81,
  0xF0, 0x1F, 0xFC, 0x3F, 0xFC, 0x07, 0xC0, 0x3F, 0xE0, 0xFF, 0xC0, 0x1F,
  0x80, 0x3E, 0x00, 0xFC, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0x3F, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x00, 0xFD, 0xF0, 0x00, 0x00, 0x3E, 0x7C, 0x00,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xF1, 0xF8,
  0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x01, 0xF8,
  0x0F, 0x80, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x3F, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0x80, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x01, 0xF8, 0x7F, 0x00, 0x00, 0x7E, 0x1F, 0x80, 0x00, 0x1F, 0xCF, 0xE0,
  0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x3F, 0xFE,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xE0, 0x1F, 0xF8, 0x03, 0xF0, 0x01,
  0xFE, 0x03, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xE0,
  0x01, 0xFC, 0x03, 0xF0, 0x01, 0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x0F, 0xF0, 0x0F,
  0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x01, 0xFE, 0x0F, 0xC0, 0x01, 0xFE, 0x07, 0xE0, 0x01, 0xFF,
  0x07, 0xF0, 0x07, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFC, 0x01, 0xF0, 0x07, 0xFC, 0x00, 0x08,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x40, 0x07, 0xFE, 0x00, 0xF0, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0x80, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x7F, 0xF8,
  0x00, 0xFC, 0x00, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFC, 0x01, 0xFC, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x1F,
  0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x0F, 0xE0, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x03, 0xF8,
  0x1F, 0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x00, 0x01,
  0xFE, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x3F, 0x00, 0x0F, 0xFC, 0x03, 0xF0,
  0x03, 0xFF, 0x80, 0x7F, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x7F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xF8, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x0C, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07,
  0xE0, 0x01, 0xFF, 0xF9, 0xFC, 0x00, 0x3F, 0xFF, 0x3F, 0x80, 0x07, 0xFF,
  0xE7, 0xF0, 0x01, 0xFF, 0xFC, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xC0, 0x07,
  0xFF, 0xE3, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x3F, 0x8F, 0xE0,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0xFC, 0x3F, 0x80, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F,
  0x81, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xE0, 0x00, 0x7E, 0x03, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0xF0, 0x07, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0x80,
  0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00,
  0x1F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x04, 0x0F, 0xF8, 0x00, 0xFF, 0xFE,
  0x00, 0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x0F,
  0xFC, 0x00, 0x00, 0x10, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x07, 0xF8,
  0x03, 0xF0, 0x00, 0x7F, 0x80, 0x1F, 0x80, 0x07, 0xF8, 0x01, 0xFC, 0x00,
  0x7F, 0x80, 0x0F, 0xC0, 0x07, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x03,
  0xF0, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00,
  0x0F, 0xC3, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0xC0, 0x00, 0x03, 0xF3, 0xFC,
  0x00, 0x00, 0x3F, 0xBF, 0xC0, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x0F,
  0xDF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0x3F, 0x00, 0x00, 0x0F, 0xF1,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00,
  0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F,
  0x80, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF0,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0xDF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x3F, 0xE0, 0x00, 0x01, 0xFF, 0x80,
  0x3F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x7F, 0xF0,
  0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x01, 0xFF, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0xFF, 0xF0, 0x00, 0x1F, 0xBF,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x3E, 0x7C, 0x00, 0x0F, 0xDF,
  0x80, 0x3F, 0x3E, 0x00, 0x0F, 0xCF, 0xC0, 0x1F, 0x9F, 0x00, 0x07, 0xE7,
  0xE0, 0x0F, 0xCF, 0x80, 0x07, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x03, 0xE3,
  0xF0, 0x03, 0xE3, 0xE0, 0x03, 0xF1, 0xF8, 0x03, 0xF1, 0xF0, 0x01, 0xF0,
  0xFC, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xF8,
  0x7E, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x3F, 0x00, 0x7E, 0x0F, 0x80, 0x7C,
  0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x7E, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x3E,
  0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x1F,
  0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x3F, 0x1F,
  0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x8F, 0x80, 0xFE, 0x00, 0xFC, 0x07, 0xCF,
  0xC0, 0x7E, 0x00, 0x7C, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF7,
  0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFB, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x3F, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x07,
  0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x3E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x3F,
  0xC0, 0x00, 0x0F, 0xC0, 0x3F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xF0, 0x00,
  0x07, 0xE0, 0x0F, 0xFC, 0x00, 0x03, 0xF0, 0x07, 0xFE, 0x00, 0x01, 0xF8,
  0x03, 0xFF, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0xC0, 0x00, 0xFC, 0x01, 0xFF,
  0xE0, 0x00, 0x7E, 0x00, 0xFB, 0xF0, 0x00, 0x3F, 0x00, 0x7C, 0xFC, 0x00,
  0x1F, 0x80, 0x3E, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x3F, 0x80, 0x0F, 0xC0,
  0x1F, 0x8F, 0xC0, 0x07, 0xE0, 0x0F, 0xC7, 0xE0, 0x03, 0xF0, 0x07, 0xC3,
  0xF8, 0x01, 0xF8, 0x03, 0xE0, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x7E, 0x00,
  0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x0F, 0xC0, 0x3F, 0x00,
  0x7E, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x3F, 0x00,
  0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x83,
  0xF0, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x07, 0xE0, 0x07, 0xF1, 0xF8, 0x03,
  0xF0, 0x01, 0xF8, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x7E, 0x00, 0xFC, 0x00,
  0x3F, 0x3F, 0x00, 0x7C, 0x00, 0x1F, 0x9F, 0x00, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x3F, 0x00, 0x03, 0xFF, 0xC0, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x0F,
  0xC0, 0x00, 0xFF, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x07, 0xE0, 0x00,
  0x1F, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xFE,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF8, 0x07, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF,
  0xFE, 0x00, 0xFC, 0x07, 0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x01, 0xFC, 0x00,
  0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00,
  0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00,
  0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xFE, 0x07, 0xE0, 0x07,
  0xFC, 0x07, 0xE0, 0x7F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFE, 0x01,
  0xFF, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x3F,
  0xC0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x0F,
  0xE1, 0xFC, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00,
  0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x03, 0xFB,
  0xF8, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF8,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7E, 0xFE, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x01, 0xFD, 0xFC, 0x00,
  0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x7F,
  0x00, 0x03, 0xFC, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE,
  0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFC, 0x07, 0xFE, 0x00,
  0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03,
  0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x07,
  0xE0, 0x07, 0xFC, 0x07, 0xE0, 0x3F, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x3F,
  0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0, 0x7F,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xE0,
  0x0F, 0x00, 0xFF, 0x00, 0x04, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x20, 0x00,
  0x0F, 0xE0, 0xC0, 0x00, 0xFF, 0x03, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFD,
  0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03,
  0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xE0,
  0x3F, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x1F,
  0xC0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x03, 0xFE,
  0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xDF, 0x80, 0x00,
  0x0F, 0xE7, 0xE0, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00,
  0x00, 0xFE, 0x1F, 0x80, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x07, 0xF0, 0x7E, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x0F, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x0F, 0xC0, 0x03, 0xF0, 0x07,
  0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x07, 0xC0,
  0x3F, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x1F,
  0x83, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00,
  0x7E, 0x1F, 0x80, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x00, 0xF9, 0xFC, 0x00, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0x0F, 0xBF, 0x00,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x00, 0xFB, 0xE0, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x3F,
  0x00, 0x03, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xFF, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFE,
  0x3F, 0x00, 0x0F, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xFF, 0x80, 0x1F,
  0xC3, 0xF0, 0x01, 0xF7, 0xE0, 0x07, 0xE0, 0x7C, 0x00, 0xFD, 0xF8, 0x03,
  0xF8, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x8F, 0x80,
  0x3F, 0x01, 0xF8, 0x07, 0xC3, 0xE0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0xF8,
  0x07, 0xE0, 0x1F, 0x80, 0xFC, 0x3E, 0x03, 0xF0, 0x07, 0xE0, 0x7E, 0x0F,
  0x80, 0xFC, 0x01, 0xF8, 0x1F, 0x83, 0xE0, 0x7F, 0x00, 0x7E, 0x07, 0xC0,
  0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x3E, 0x07, 0xE0, 0x07, 0xE0, 0xF8,
  0x0F, 0x83, 0xF0, 0x01, 0xF8, 0x7E, 0x03, 0xE0, 0xFC, 0x00, 0x7E, 0x1F,
  0x00, 0xF8, 0x7E, 0x00, 0x1F, 0x8F, 0xC0, 0x3E, 0x1F, 0x80, 0x07, 0xE3,
  0xE0, 0x0F, 0x8F, 0xC0, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xF0, 0x00, 0x7E,
  0x7E, 0x00, 0xF8, 0xFC, 0x00, 0x1F, 0x9F, 0x00, 0x3E, 0x7E, 0x00, 0x07,
  0xEF, 0xC0, 0x0F, 0x9F, 0x80, 0x01, 0xFB, 0xE0, 0x03, 0xE7, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00,
  0x07, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0x80, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x01, 0xF9, 0xFC,
  0x00, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xEF, 0xC0,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x00,
  0x3F, 0x87, 0xE0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00,
  0x03, 0xF8, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0xFC, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F,
  0xC3, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07,
  0xE3, 0xF0, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x1F,
  0x7E, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xFC, 0x01, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xE0, 0x00, 0xFC,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF8, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x01,
  0xF0, 0x1F, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF,
  0xE0, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C,
  0xF8, 0x00, 0x03, 0xE3, 0xE0, 0x00, 0x3E, 0x1F, 0x00, 0x01, 0xF0, 0x7C,
  0x00, 0x1F, 0x03, 0xE0, 0x00, 0xF8, 0x1F, 0x80, 0x0F, 0x80, 0x7C, 0x00,
  0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x00, 0x7C, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x1F, 0x80, 0x01,
  0xF0, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x07, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFF, 0xFF, 0xFE, 0xFC, 0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xC0,
  0xF8, 0x1F, 0x07, 0xC0, 0x00, 0x1F, 0xE0, 0x7C, 0x01, 0xFF, 0xC1, 0xF0,
  0x1F, 0xFF, 0x8F, 0x80, 0xFF, 0xFF, 0x3E, 0x07, 0xFF, 0xFF, 0xF8, 0x1F,
  0xE0, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01,
  0xFC, 0x7F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E,
  0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F,
  0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xF7,
  0xC0, 0x7F, 0xFF, 0x9F, 0x00, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xE3, 0xF0,
  0x03, 0xFE, 0x0F, 0x80, 0x00, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x07, 0xF8, 0x00, 0x7E, 0x3F, 0xF8, 0x00, 0xFC, 0xFF, 0xF8, 0x03, 0xF3,
  0xFF, 0xF8, 0x07, 0xEF, 0xFF, 0xF0, 0x0F, 0xFE, 0x0F, 0xF0, 0x1F, 0xF0,
  0x0F, 0xE0, 0x3F, 0xC0, 0x0F, 0xC0, 0xFF, 0x80, 0x1F, 0xC1, 0xFE, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x01,
  0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0xFE,
  0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE1,
  0xFC, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x01, 0xFC, 0x0F,
  0xF0, 0x07, 0xF8, 0x1F, 0xF0, 0x1F, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFD,
  0xFF, 0xFE, 0x01, 0xF1, 0xFF, 0xF8, 0x03, 0xE1, 0xFF, 0xE0, 0x0F, 0x81,
  0xFF, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x7F,
  0xC0, 0x30, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x80, 0x04, 0x1F, 0xE0, 0x1C, 0x0F, 0xFF, 0xFE, 0x03, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xC0, 0x07, 0xFF, 0x80, 0x00,
  0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0x07,
  0xE0, 0x01, 0xFF, 0xC3, 0xF0, 0x03, 0xFF, 0xF3, 0xF0, 0x03, 0xFF, 0xFD,
  0xF8, 0x03, 0xFF, 0xFF, 0xFC, 0x03, 0xFE, 0x07, 0xFE, 0x01, 0xFE, 0x01,
  0xFF, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x80,
  0x03, 0xF0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x07, 0xF8, 0x07,
  0xE0, 0x07, 0xFC, 0x03, 0xF8, 0x07, 0xFE, 0x01, 0xFE, 0x07, 0xFE, 0x00,
  0x7F, 0xFF, 0xDF, 0x00, 0x3F, 0xFF, 0xCF, 0x80, 0x0F, 0xFF, 0xC7, 0xC0,
  0x03, 0xFF, 0xC7, 0xC0, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0x04, 0x00, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFE, 0x07, 0xF0, 0xFE, 0x01, 0xFC,
  0x7F, 0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xCF, 0xE0, 0x07, 0xF3, 0xF0, 0x01,
  0xF9, 0xFC, 0x00, 0xFE, 0x7E, 0x00, 0xFF, 0x1F, 0x83, 0xFF, 0xCF, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x0F,
  0xF4, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x01, 0x07, 0xF8, 0x03, 0xC1, 0xFF, 0x87, 0xF0, 0x3F, 0xFF, 0xFC, 0x07,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0x80, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x03,
  0xFC, 0x08, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00,
  0x7F, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x04, 0x3F, 0x80, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x1F, 0x00, 0x1F, 0xFE,
  0x1F, 0x00, 0x7F, 0xFE, 0x3F, 0x00, 0xFF, 0xFF, 0x3E, 0x01, 0xFF, 0xFF,
  0xFE, 0x03, 0xFE, 0x07, 0xFE, 0x03, 0xFC, 0x03, 0xFE, 0x07, 0xF8, 0x03,
  0xFC, 0x07, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03,
  0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x0F,
  0xE0, 0x3F, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x3F, 0xE0, 0x3F, 0x80, 0x7F,
  0xE0, 0x3F, 0xC0, 0xFF, 0xC0, 0x1F, 0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xEF,
  0xC0, 0x0F, 0xFF, 0xCF, 0xC0, 0x07, 0xFF, 0x1F, 0x80, 0x03, 0xFE, 0x1F,
  0x80, 0x00, 0x20, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0xC0, 0x01, 0xFE, 0x00, 0xF8, 0x03, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0xFF, 0x00, 0x1F, 0x8F, 0xFF, 0x00, 0x7E, 0x7F, 0xFE, 0x03, 0xF3, 0xFF,
  0xF8, 0x0F, 0xDF, 0xFF, 0xF0, 0x3F, 0xF8, 0x1F, 0xC0, 0xFF, 0xC0, 0x3F,
  0x03, 0xFE, 0x00, 0xFC, 0x1F, 0xF0, 0x03, 0xF0, 0x7F, 0x80, 0x0F, 0xC1,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00,
  0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x01, 0xFC,
  0x3F, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1C,
  0x00, 0x3E, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0,
  0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x08, 0x3F, 0x80, 0x07,
  0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0xFF,
  0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0,
  0x03, 0xF0, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80,
  0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xC0, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x1F, 0xF7, 0xF0, 0x00,
  0x1F, 0xE3, 0xF0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x1F, 0x81, 0xF8, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x1F, 0x80,
  0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0,
  0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0,
  0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x01, 0xF0, 0xFF, 0xE0, 0x3F, 0xFC, 0x01, 0xF1,
  0xFF, 0xF0, 0x7F, 0xFE, 0x01, 0xF3, 0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xF7,
  0xFF, 0xF9, 0xFF, 0xFE, 0x03, 0xFF, 0x83, 0xFB, 0xE0, 0x7F, 0x03, 0xFF,
  0x01, 0xFF, 0xC0, 0x7F, 0x03, 0xFE, 0x01, 0xFF, 0x80, 0x3F, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x3F, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0x07, 0xF0,
  0x01, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xFC, 0x00, 0x7F, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0xC0,
  0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80,
  0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x3F, 0x00,
  0x0F, 0xC0, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0x00,
  0x02, 0x00, 0x03, 0xE0, 0x7F, 0xC0, 0x07, 0xC3, 0xFF, 0xC0, 0x0F, 0x8F,
  0xFF, 0xC0, 0x3F, 0x3F, 0xFF, 0xC0, 0x7E, 0xFF, 0xFF, 0x80, 0xFF, 0xF0,
  0x7F, 0x01, 0xFF, 0x80, 0x7E, 0x03, 0xFE, 0x00, 0xFE, 0x0F, 0xF8, 0x01,
  0xF8, 0x1F, 0xE0, 0x03, 0xF0, 0x3F, 0xC0, 0x07, 0xE0, 0x7F, 0x00, 0x0F,
  0xC1, 0xFE, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0xE0,
  0xFE, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00,
  0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x07, 0xFF,
  0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0,
  0xFF, 0x81, 0xFC, 0x0F, 0xE0, 0x0F, 0xE1, 0xFC, 0x00, 0x7E, 0x3F, 0x80,
  0x07, 0xE3, 0xF8, 0x00, 0x7F, 0x3F, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x3F,
  0x7E, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07,
  0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFC, 0xFC,
  0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x3F, 0x87, 0xF0, 0x07,
  0xF0, 0x7F, 0x81, 0xFF, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x30,
  0x00, 0x00, 0x00, 0x7C, 0x0F, 0xF0, 0x00, 0x3E, 0x1F, 0xFC, 0x00, 0x1F,
  0x1F, 0xFF, 0x00, 0x0F, 0x9F, 0xFF, 0xC0, 0x0F, 0xDF, 0xFF, 0xE0, 0x07,
  0xFF, 0x07, 0xF8, 0x03, 0xFE, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x01,
  0xFF, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC,
  0x0F, 0xC0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x3F,
  0x01, 0xF8, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x07,
  0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x07, 0xF8, 0x03,
  0xFC, 0x03, 0xFE, 0x03, 0xFC, 0x03, 0xF7, 0xFF, 0xFC, 0x01, 0xFB, 0xFF,
  0xFC, 0x00, 0xFC, 0xFF, 0xFC, 0x00, 0x7E, 0x3F, 0xFC, 0x00, 0x3F, 0x0F,
  0xF8, 0x00, 0x3F, 0x80, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x7C, 0x01, 0xFF, 0xE1, 0xF0, 0x1F, 0xFF, 0xCF, 0x80,
  0xFF, 0xFF, 0x3E, 0x07, 0xFF, 0xFE, 0xF8, 0x3F, 0xE0, 0x7F, 0xE0, 0xFF,
  0x00, 0xFF, 0x87, 0xF8, 0x03, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0xFE, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8,
  0xFE, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xFC, 0x3F,
  0x00, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFE, 0x0F, 0xC0,
  0x03, 0xF8, 0x3F, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0xFF, 0x83, 0xF8, 0x07,
  0xFE, 0x0F, 0xF0, 0x3F, 0xF0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xBF,
  0x00, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xC7, 0xE0, 0x03, 0xFE, 0x1F, 0x80,
  0x00, 0x80, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x3F, 0x80, 0xF8, 0x7F, 0xC0,
  0x7C, 0x7F, 0xC0, 0x7E, 0x7F, 0xE0, 0x3F, 0x7F, 0xF0, 0x1F, 0xFF, 0x98,
  0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF,
  0xF0, 0x3F, 0x80, 0x78, 0x3F, 0x80, 0x08, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFC, 0x40, 0x00, 0xFE, 0x38, 0x00, 0xFE, 0x1F, 0xE3, 0xFF,
  0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x00, 0x7F, 0xFE,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0xFF,
  0xFF, 0x7F, 0xFF, 0xEF, 0xFF, 0xFE, 0xFF, 0xFF, 0xEF, 0xFF, 0xFE, 0x0F,
  0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x7F,
  0xFC, 0x03, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x38, 0x00, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0xFE, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x87,
  0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0xFC, 0x00,
  0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x7F, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0,
  0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0xFF, 0x0F, 0xE0, 0x03, 0xF8, 0x3F,
  0x80, 0x1F, 0xE0, 0xFE, 0x00, 0xFF, 0x83, 0xF8, 0x07, 0xFE, 0x0F, 0xE0,
  0x3D, 0xF8, 0x1F, 0xFF, 0xF7, 0xC0, 0x7F, 0xFF, 0x9F, 0x00, 0xFF, 0xFC,
  0x7C, 0x03, 0xFF, 0xE1, 0xF0, 0x03, 0xFE, 0x0F, 0x80, 0x01, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xEF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x3F, 0x87, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7F, 0x07, 0xE0, 0x07, 0xE0,
  0x7E, 0x00, 0xFE, 0x07, 0xE0, 0x0F, 0xC0, 0x7E, 0x01, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x3E, 0x03, 0xF8, 0x03, 0xE0, 0x3F, 0x00, 0x3F, 0x07, 0xF0,
  0x03, 0xF0, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x01, 0xF3, 0xF0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xFF, 0x80,
  0x07, 0xF0, 0x01, 0xFD, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0xC0, 0x0F, 0xE7, 0xC0, 0x0F, 0xF8, 0x01, 0xF8, 0xF8, 0x01, 0xFF, 0x00,
  0x7F, 0x1F, 0x80, 0x7D, 0xE0, 0x0F, 0xC3, 0xF0, 0x0F, 0xBC, 0x01, 0xF8,
  0x7E, 0x03, 0xE7, 0x80, 0x7E, 0x0F, 0xC0, 0x7C, 0xF0, 0x0F, 0xC1, 0xF8,
  0x1F, 0xBE, 0x03, 0xF0, 0x3F, 0x03, 0xE7, 0xC0, 0x7E, 0x07, 0xE0, 0x7C,
  0xF8, 0x1F, 0xC0, 0xFC, 0x1F, 0x1F, 0x03, 0xF0, 0x1F, 0x83, 0xE1, 0xF0,
  0xFE, 0x03, 0xF0, 0xF8, 0x3E, 0x1F, 0x80, 0x7E, 0x1F, 0x07, 0xC3, 0xF0,
  0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x01, 0xF8, 0xF8, 0x1F, 0x1F, 0x80, 0x3F,
  0x3F, 0x03, 0xE7, 0xE0, 0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x00, 0xFC, 0xF8,
  0x0F, 0x9F, 0x00, 0x1F, 0xBE, 0x01, 0xF7, 0xE0, 0x03, 0xF7, 0xC0, 0x3E,
  0xF8, 0x00, 0x7F, 0xF0, 0x07, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0,
  0x00, 0xFF, 0x80, 0x1F, 0xF8, 0x00, 0x1F, 0xF0, 0x03, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x80, 0x0F, 0xF8, 0x00, 0x0F, 0xF0,
  0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80,
  0x1F, 0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x03, 0xF0, 0x1F, 0xC0, 0x01, 0xFC,
  0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x0F,
  0xCF, 0xE0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x07, 0xF7, 0xF0, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x03, 0xF0, 0xFE, 0x00,
  0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xE0,
  0x03, 0xF8, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x0F,
  0xC0, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x03,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x01,
  0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF1, 0xF8, 0x00,
  0x00, 0x1F, 0x3F, 0x00, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xBE,
  0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xC0, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xFF, 0x00,
  0x07, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x0F, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x01, 0xFE,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x13, 0xFF, 0xC0, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xC8, 0x00, 0x0F, 0xF8,
};

const GFXglyph NotoSans_MediumItalic59pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 16, 43, 16, 1, -42 },
  { 87, 19, 15, 24, 6, -42 },
  { 123, 37, 42, 38, 2, -42 },
  { 318, 29, 48, 33, 2, -45 },
  { 492, 42, 44, 48, 4, -43 },
  { 723, 37, 44, 40, 2, -43 },
  { 927, 9, 15, 14, 6, -42 },
  { 944, 20, 51, 18, 2, -42 },
  { 1072, 20, 51, 18, -4, -42 },
  { 1200, 27, 28, 32, 6, -45 },
  { 1295, 28, 28, 34, 4, -35 },
  { 1393, 13, 15, 16, -3, -7 },
  { 1418, 16, 6, 19, 1, -19 },
  { 1430, 8, 9, 16, 1, -8 },
  { 1439, 30, 42, 22, -3, -42 },
  { 1597, 29, 44, 33, 3, -43 },
  { 1757, 20, 42, 33, 7, -42 },
  { 1862, 31, 43, 33, 0, -43 },
  { 2029, 30, 44, 33, 1, -43 },
  { 2194, 31, 42, 33, 0, -42 },
  { 2357, 30, 43, 33, 2, -42 },
  { 2519, 30, 44, 33, 3, -43 },
  { 2684, 30, 42, 33, 4, -42 },
  { 2842, 30, 44, 33, 2, -43 },
  { 3007, 28, 44, 33, 3, -43 },
  { 3161, 13, 34, 16, 1, -33 },
  { 3217, 17, 41, 16, -3, -33 },
  { 3305, 28, 29, 34, 4, -36 },
  { 3407, 28, 16, 34, 4, -29 },
  { 3463, 28, 29, 34, 4, -36 },
  { 3565, 22, 44, 26, 5, -43 },
  { 3686, 46, 47, 50, 3, -42 },
  { 3957, 34, 42, 34, -3, -42 },
  { 4136, 33, 42, 36, 2, -42 },
  { 4310, 34, 44, 35, 4, -43 },
  { 4497, 36, 42, 40, 2, -42 },
  { 4686, 31, 42, 31, 2, -42 },
  { 4849, 31, 42, 29, 2, -42 },
  { 5012, 35, 44, 40, 4, -43 },
  { 5205, 39, 42, 40, 2, -42 },
  { 5410, 24, 42, 20, -1, -42 },
  { 5536, 27, 54, 17, -9, -42 },
  { 5719, 37, 42, 34, 2, -42 },
  { 5914, 23, 42, 29, 2, -42 },
  { 6035, 49, 42, 50, 2, -42 },
  { 6293, 41, 42, 43, 2, -42 },
  { 6509, 37, 44, 43, 4, -43 },
  { 6713, 32, 42, 34, 2, -42 },
  { 6881, 37, 53, 43, 4, -43 },
  { 7127, 32, 42, 35, 2, -42 },
  { 7295, 30, 44, 30, 1, -43 },
  { 7460, 30, 42, 30, 5, -42 },
  { 7618, 37, 43, 40, 4, -42 },
  { 7817, 34, 42, 33, 5, -42 },
  { 7996, 50, 42, 51, 6, -42 },
  { 8259, 40, 42, 33, -3, -42 },
  { 8469, 31, 42, 31, 5, -42 },
  { 8632, 35, 42, 31, -1, -42 },
  { 8816, 23, 51, 18, -1, -42 },
  { 8963, 12, 42, 22, 6, -42 },
  { 9026, 23, 51, 18, -4, -42 },
  { 9173, 29, 26, 33, 2, -42 },
  { 9268, 24, 4, 23, -5, 5 },
  { 9280, 10, 9, 17, 9, -45 },
  { 9292, 30, 33, 34, 3, -32 },
  { 9416, 31, 46, 34, 1, -45 },
  { 9595, 25, 33, 27, 3, -32 },
  { 9699, 33, 46, 34, 3, -45 },
  { 9889, 26, 33, 30, 3, -32 },
  { 9997, 33, 59, 20, -6, -45 },
  { 10241, 32, 46, 34, 1, -32 },
  { 10425, 30, 45, 35, 1, -45 },
  { 10594, 16, 44, 16, 1, -44 },
  { 10682, 25, 58, 16, -8, -44 },
  { 10864, 32, 45, 31, 1, -45 },
  { 11044, 16, 45, 16, 1, -45 },
  { 11134, 48, 32, 52, 1, -32 },
  { 11326, 31, 33, 35, 1, -33 },
  { 11454, 28, 33, 34, 3, -32 },
  { 11570, 33, 46, 34, -1, -32 },
  { 11760, 30, 46, 34, 3, -32 },
  { 11933, 25, 32, 24, 1, -32 },
  { 12033, 25, 33, 26, 0, -32 },
  { 12137, 20, 40, 21, 3, -39 },
  { 12237, 30, 33, 35, 3, -32 },
  { 12361, 28, 32, 28, 3, -32 },
  { 12473, 43, 32, 44, 3, -32 },
  { 12645, 33, 32, 29, -2, -32 },
  { 12777, 36, 46, 28, -5, -32 },
  { 12984, 28, 32, 27, -1, -32 },
  { 13096, 24, 51, 21, 0, -42 },
  { 13249, 5, 59, 33, 15, -45 },
  { 13286, 23, 51, 21, -2, -42 },
  { 13433, 28, 8, 34, 4, -25 },
};

const GFXfont NotoSans_MediumItalic59pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic59pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic59pt7bGlyphs,
  0x20, 0x7E, 80
};

#endif // _NOTOSANS_MEDIUMITALIC59PT7B_H_
