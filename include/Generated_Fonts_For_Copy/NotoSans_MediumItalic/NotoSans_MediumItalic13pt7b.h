#ifndef _NOTOSANS_MEDIUMITALIC13PT7B_H_
#define _NOTOSANS_MEDIUMITALIC13PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 13pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic13pt7bBitmaps[] PROGMEM = {
  0x00, 0x32, 0x26, 0x64, 0x04, 0xC0, 0x5A, 0xA4, 0x0B, 0x12, 0x7F, 0x12,
  0x34, 0xFF, 0x24, 0x28, 0x48, 0x08, 0x38, 0xAB, 0x43, 0x03, 0x85, 0x0A,
  0xFC, 0x40, 0x80, 0x71, 0xC9, 0x25, 0x12, 0xAE, 0xA8, 0xA4, 0x92, 0x4B,
  0xC7, 0x00, 0x1E, 0x19, 0x0D, 0x83, 0x83, 0x9A, 0x4B, 0x19, 0x8C, 0x7B,
  0x00, 0x58, 0x19, 0x88, 0x84, 0x21, 0x18, 0x42, 0x18, 0x31, 0x11, 0x11,
  0x13, 0x26, 0xC0, 0x1A, 0x4F, 0x0F, 0x71, 0x20, 0x20, 0x82, 0x3F, 0x20,
  0x82, 0x00, 0x2D, 0x60, 0xF0, 0x70, 0x06, 0x08, 0x20, 0xC1, 0x06, 0x08,
  0x30, 0xC0, 0x79, 0x3C, 0x61, 0x8E, 0x38, 0xA6, 0xF0, 0x3F, 0xA2, 0x26,
  0x44, 0x40, 0x3E, 0x4C, 0x18, 0x20, 0xC3, 0x08, 0x20, 0xFC, 0x3E, 0x0C,
  0x18, 0x63, 0x80, 0x81, 0x46, 0xF8, 0x06, 0x1C, 0x51, 0xA6, 0x59, 0xBF,
  0x84, 0x08, 0x3E, 0x40, 0x81, 0xC4, 0xC0, 0x81, 0x46, 0xF8, 0x3D, 0x84,
  0x3E, 0xCA, 0x38, 0xA2, 0x70, 0xFC, 0x30, 0x86, 0x10, 0x86, 0x10, 0xC0,
  0x7D, 0x14, 0x5E, 0x72, 0x28, 0xA2, 0xF0, 0x7B, 0x38, 0xE3, 0xDD, 0xA0,
  0x84, 0xE0, 0x6C, 0x00, 0xB0, 0x33, 0x00, 0x02, 0x64, 0xC0, 0x04, 0x66,
  0x20, 0x70, 0x30, 0x40, 0xFC, 0x0F, 0xC0, 0x81, 0x81, 0x83, 0x3B, 0x08,
  0x00, 0xF8, 0x42, 0x26, 0x20, 0x18, 0xC0, 0x1F, 0x18, 0x24, 0xE6, 0x49,
  0xA2, 0x69, 0xAA, 0x6A, 0x6C, 0xC0, 0x1F, 0x80, 0x06, 0x0E, 0x0A, 0x1A,
  0x12, 0x3E, 0x23, 0x63, 0xC3, 0x3E, 0x23, 0x23, 0x26, 0x7C, 0x62, 0x42,
  0x46, 0xFC, 0x3E, 0xC1, 0x06, 0x08, 0x10, 0x20, 0x62, 0x7C, 0x3E, 0x23,
  0x21, 0x21, 0x61, 0x63, 0x43, 0x46, 0xF8, 0x3E, 0x40, 0x81, 0x07, 0xCC,
  0x10, 0x20, 0xFC, 0x3E, 0x40, 0x81, 0x07, 0xCC, 0x10, 0x20, 0xC0, 0x3F,
  0x60, 0x40, 0xC0, 0x8E, 0x82, 0x86, 0xC4, 0x7C, 0x31, 0x90, 0xC8, 0x44,
  0x27, 0xF3, 0x19, 0x0C, 0x84, 0xC2, 0x00, 0x39, 0x8C, 0x42, 0x31, 0x88,
  0xE0, 0x0C, 0x30, 0x82, 0x18, 0x61, 0x04, 0x10, 0xCE, 0x30, 0x33, 0x93,
  0x0B, 0x07, 0x07, 0x83, 0x41, 0x30, 0x88, 0xC6, 0x00, 0x30, 0x82, 0x08,
  0x61, 0x84, 0x11, 0xF8, 0x30, 0x67, 0x1C, 0xE3, 0x94, 0xA6, 0x94, 0x94,
  0x93, 0xB2, 0x66, 0xCC, 0x80, 0x30, 0x9C, 0x4A, 0x25, 0x36, 0xD2, 0x29,
  0x14, 0x8E, 0xC3, 0x00, 0x3E, 0x63, 0xC3, 0xC1, 0x83, 0x83, 0x82, 0xC6,
  0x7C, 0x3E, 0x22, 0x23, 0x22, 0x7E, 0x60, 0x40, 0x40, 0xC0, 0x3E, 0x63,
  0xC3, 0xC1, 0x83, 0x83, 0x82, 0xC6, 0x7C, 0x08, 0x0E, 0x3E, 0x44, 0x89,
  0x17, 0xCD, 0x13, 0x22, 0xC6, 0x3E, 0xC1, 0x81, 0x81, 0x81, 0x83, 0x46,
  0xF8, 0xFE, 0x60, 0xC1, 0x02, 0x04, 0x18, 0x30, 0x40, 0x63, 0x43, 0x42,
  0x42, 0xC2, 0x86, 0x86, 0xCC, 0x78, 0xC3, 0xC6, 0xC4, 0x4C, 0x48, 0x50,
  0x50, 0x60, 0x60, 0xC6, 0x39, 0xCF, 0x29, 0x6D, 0x65, 0x28, 0xA5, 0x18,
  0xC3, 0x18, 0x42, 0x00, 0x31, 0x89, 0x86, 0x81, 0x80, 0xC0, 0xA0, 0xD8,
  0xCC, 0xC2, 0x00, 0xC6, 0x99, 0x22, 0x87, 0x04, 0x18, 0x30, 0x40, 0x3F,
  0x06, 0x0C, 0x08, 0x10, 0x30, 0x60, 0xC0, 0xFC, 0x39, 0x08, 0xC4, 0x21,
  0x08, 0xC4, 0x38, 0xC9, 0x24, 0x99, 0x20, 0x38, 0x46, 0x21, 0x08, 0xC4,
  0x21, 0x38, 0x18, 0x30, 0xB1, 0x24, 0x58, 0x40, 0xF8, 0xD0, 0x77, 0x38,
  0xE3, 0x8A, 0x6E, 0x80, 0x30, 0x40, 0x81, 0x67, 0x6C, 0x51, 0xA3, 0x45,
  0xF0, 0x7E, 0x21, 0x08, 0x43, 0xC0, 0x06, 0x0C, 0x13, 0xAC, 0xD1, 0xA3,
  0x44, 0x99, 0xD0, 0x7E, 0x63, 0xE8, 0x47, 0xC0, 0x0E, 0x30, 0x61, 0xE1,
  0x02, 0x0C, 0x10, 0x20, 0x41, 0x83, 0x0C, 0x00, 0x3A, 0xCD, 0x1A, 0x34,
  0x49, 0x9D, 0x06, 0x89, 0xF0, 0x30, 0x40, 0x81, 0x77, 0x6C, 0xD1, 0xA2,
  0x45, 0x88, 0x33, 0x02, 0x66, 0x44, 0x4C, 0x0C, 0x30, 0x02, 0x18, 0x61,
  0x04, 0x10, 0xC3, 0x08, 0xE0, 0x30, 0x40, 0x81, 0x36, 0xCF, 0x1C, 0x2C,
  0x49, 0x98, 0x33, 0x22, 0x66, 0x44, 0x4C, 0x3D, 0xCE, 0xED, 0x99, 0xA2,
  0x24, 0x44, 0x88, 0xB3, 0x30, 0x3E, 0xED, 0x9A, 0x34, 0x48, 0xB3, 0x00,
  0x7B, 0x38, 0xE3, 0x8A, 0x6F, 0x00, 0x3C, 0xCD, 0x8A, 0x34, 0x68, 0xBE,
  0x60, 0x81, 0x00, 0x77, 0x38, 0xE3, 0x8A, 0x6E, 0x86, 0x10, 0x40, 0x3D,
  0xC6, 0x10, 0x41, 0x0C, 0x00, 0x7D, 0x06, 0x0C, 0x1A, 0x6F, 0x00, 0x24,
  0xF4, 0xC8, 0x88, 0xE0, 0x47, 0x1C, 0xE3, 0x8A, 0x6E, 0x80, 0x8E, 0x29,
  0xA4, 0xA2, 0x8C, 0x00, 0x98, 0xCC, 0xA6, 0x55, 0x6A, 0xA6, 0x73, 0x30,
  0x33, 0x16, 0x1C, 0x18, 0x18, 0x24, 0xC6, 0x23, 0x22, 0x26, 0x24, 0x38,
  0x38, 0x10, 0x30, 0x20, 0xC0, 0x7C, 0x21, 0x0C, 0x63, 0x0F, 0x80, 0x18,
  0x8C, 0x46, 0x61, 0x8C, 0x42, 0x18, 0xFF, 0xF8, 0x38, 0x61, 0x84, 0x10,
  0x31, 0x08, 0x20, 0x8C, 0x00, 0x47, 0xF0,
};

const GFXglyph NotoSans_MediumItalic13pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 3, 0, -1 },
  { 1, 4, 9, 4, 0, -9 },
  { 6, 5, 3, 5, 1, -9 },
  { 8, 8, 9, 8, 0, -9 },
  { 17, 7, 11, 7, 0, -10 },
  { 27, 9, 9, 11, 1, -9 },
  { 38, 9, 9, 9, 0, -9 },
  { 49, 2, 3, 3, 1, -9 },
  { 50, 5, 11, 4, 0, -9 },
  { 57, 4, 11, 4, -1, -9 },
  { 63, 6, 6, 7, 1, -10 },
  { 68, 6, 7, 7, 1, -8 },
  { 74, 3, 4, 3, -1, -2 },
  { 76, 4, 1, 4, 0, -4 },
  { 77, 2, 2, 3, 0, -2 },
  { 78, 7, 9, 5, -1, -9 },
  { 86, 6, 9, 7, 1, -9 },
  { 93, 4, 9, 7, 2, -9 },
  { 98, 7, 9, 7, 0, -9 },
  { 106, 7, 9, 7, 0, -9 },
  { 114, 7, 9, 7, 0, -9 },
  { 122, 7, 9, 7, 0, -9 },
  { 130, 6, 9, 7, 1, -9 },
  { 137, 6, 9, 7, 1, -9 },
  { 144, 6, 9, 7, 1, -9 },
  { 151, 6, 9, 7, 1, -9 },
  { 158, 3, 7, 3, 0, -7 },
  { 161, 4, 9, 3, -1, -7 },
  { 166, 6, 7, 7, 1, -8 },
  { 172, 6, 3, 7, 1, -6 },
  { 175, 6, 7, 7, 1, -8 },
  { 181, 5, 9, 6, 1, -9 },
  { 187, 10, 10, 11, 1, -9 },
  { 200, 8, 9, 8, -1, -9 },
  { 209, 8, 9, 8, 0, -9 },
  { 218, 7, 9, 8, 1, -9 },
  { 226, 8, 9, 9, 0, -9 },
  { 235, 7, 9, 7, 0, -9 },
  { 243, 7, 9, 6, 0, -9 },
  { 251, 8, 9, 9, 1, -9 },
  { 260, 9, 9, 9, 0, -9 },
  { 271, 5, 9, 4, 0, -9 },
  { 277, 6, 12, 4, -2, -9 },
  { 286, 9, 9, 8, 0, -9 },
  { 297, 6, 9, 6, 0, -9 },
  { 304, 11, 9, 11, 0, -9 },
  { 317, 9, 9, 9, 0, -9 },
  { 328, 8, 9, 9, 1, -9 },
  { 337, 8, 9, 8, 0, -9 },
  { 346, 8, 11, 9, 1, -9 },
  { 357, 7, 9, 8, 0, -9 },
  { 365, 7, 9, 7, 0, -9 },
  { 373, 7, 9, 7, 1, -9 },
  { 381, 8, 9, 9, 1, -9 },
  { 390, 8, 9, 7, 1, -9 },
  { 399, 11, 9, 11, 1, -9 },
  { 412, 9, 9, 7, -1, -9 },
  { 423, 7, 9, 7, 1, -9 },
  { 431, 8, 9, 7, 0, -9 },
  { 440, 5, 11, 4, 0, -9 },
  { 447, 3, 9, 5, 1, -9 },
  { 451, 5, 11, 4, -1, -9 },
  { 458, 7, 6, 7, 0, -9 },
  { 464, 5, 1, 5, -1, 1 },
  { 465, 2, 2, 4, 2, -10 },
  { 466, 6, 7, 7, 1, -7 },
  { 472, 7, 10, 8, 0, -10 },
  { 481, 5, 7, 6, 1, -7 },
  { 486, 7, 10, 8, 1, -10 },
  { 495, 5, 7, 7, 1, -7 },
  { 500, 7, 13, 4, -1, -10 },
  { 512, 7, 10, 8, 0, -7 },
  { 521, 7, 10, 8, 0, -10 },
  { 530, 4, 10, 4, 0, -10 },
  { 535, 6, 13, 4, -2, -10 },
  { 545, 7, 10, 7, 0, -10 },
  { 554, 4, 10, 4, 0, -10 },
  { 559, 11, 7, 11, 0, -7 },
  { 569, 7, 7, 8, 0, -7 },
  { 576, 6, 7, 7, 1, -7 },
  { 582, 7, 10, 8, 0, -7 },
  { 591, 6, 10, 8, 1, -7 },
  { 599, 6, 7, 5, 0, -7 },
  { 605, 6, 7, 6, 0, -7 },
  { 611, 4, 9, 5, 1, -9 },
  { 616, 6, 7, 8, 1, -7 },
  { 622, 6, 7, 6, 1, -7 },
  { 628, 9, 7, 10, 1, -7 },
  { 636, 8, 7, 6, -1, -7 },
  { 643, 8, 10, 6, -1, -7 },
  { 653, 6, 7, 6, 0, -7 },
  { 659, 5, 11, 5, 0, -9 },
  { 666, 1, 13, 7, 3, -10 },
  { 668, 6, 11, 5, -1, -9 },
  { 677, 6, 2, 7, 1, -6 },
};

const GFXfont NotoSans_MediumItalic13pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic13pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic13pt7bGlyphs,
  0x20, 0x7E, 18
};

#endif // _NOTOSANS_MEDIUMITALIC13PT7B_H_
