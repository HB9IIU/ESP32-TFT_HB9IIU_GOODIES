#ifndef _NOTOSANS_MEDIUMITALIC58PT7B_H_
#define _NOTOSANS_MEDIUMITALIC58PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 58pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic58pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03,
  0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x3E, 0x00, 0x7F,
  0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x38,
  0x00, 0x3F, 0x0F, 0xE7, 0xE1, 0xF8, 0xFC, 0x3F, 0x1F, 0x07, 0xE7, 0xE0,
  0xF8, 0xFC, 0x1F, 0x1F, 0x03, 0xE3, 0xE0, 0xFC, 0x7C, 0x1F, 0x0F, 0x83,
  0xE1, 0xE0, 0x7C, 0x3C, 0x0F, 0x0F, 0x81, 0xE1, 0xE0, 0x3C, 0x3C, 0x07,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x1E, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00,
  0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x00, 0x7C, 0x07,
  0xC0, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0xF8, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x3E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3C,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x00, 0x78, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x78,
  0x00, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x1E, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x3E, 0x00, 0x00, 0x7C, 0x03, 0xC0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0x80, 0x78, 0x00, 0x00,
  0xF8, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0xF0, 0x0F, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x01,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x07, 0x80,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0xFE, 0x38, 0x78, 0x0F, 0xE3,
  0xC0, 0x40, 0x7E, 0x1E, 0x00, 0x03, 0xF0, 0xF0, 0x00, 0x1F, 0x07, 0x80,
  0x00, 0xF8, 0x38, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x3F, 0x1E, 0x00, 0x01,
  0xFC, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xDF, 0xE0, 0x00, 0x1E, 0x7F, 0x00,
  0x00, 0xF1, 0xF8, 0x00, 0x07, 0x07, 0xE0, 0x00, 0x78, 0x3F, 0x00, 0x03,
  0xC1, 0xF8, 0x00, 0x1E, 0x1F, 0x80, 0x00, 0xF0, 0xFC, 0x30, 0x07, 0x0F,
  0xE1, 0xF0, 0x78, 0xFE, 0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3E, 0x01, 0xFF, 0xE0, 0x00, 0x3E,
  0x01, 0xFF, 0xF8, 0x00, 0x3E, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0x00, 0xFC,
  0x3E, 0x00, 0x1F, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x07, 0xC0,
  0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x0F, 0x80,
  0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0x07, 0xC0,
  0x7C, 0x0F, 0xC0, 0x03, 0xE0, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x07,
  0xC0, 0x01, 0xF0, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x0F, 0x87, 0xE0, 0x00,
  0x7C, 0x07, 0xC3, 0xE1, 0xFE, 0x3E, 0x07, 0xE3, 0xE3, 0xFF, 0x9F, 0x03,
  0xE3, 0xE3, 0xFF, 0xE7, 0xC3, 0xF1, 0xF3, 0xFF, 0xF3, 0xF7, 0xF1, 0xF3,
  0xF8, 0xF9, 0xFF, 0xF1, 0xF1, 0xF0, 0x7E, 0x7F, 0xF1, 0xF9, 0xF8, 0x1F,
  0x1F, 0xF0, 0xF8, 0xF8, 0x0F, 0x87, 0xE0, 0xF8, 0x7C, 0x07, 0xC0, 0x00,
  0xF8, 0x7E, 0x03, 0xE0, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x00, 0x7C, 0x1F,
  0x01, 0xF8, 0x00, 0x7C, 0x0F, 0x80, 0xF8, 0x00, 0x7C, 0x07, 0xC0, 0x7C,
  0x00, 0x7E, 0x07, 0xE0, 0x3E, 0x00, 0x3E, 0x03, 0xF0, 0x1F, 0x00, 0x3E,
  0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3F, 0x00, 0x7E,
  0x0F, 0xC0, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x1F, 0x00, 0x0F, 0x87, 0xE0,
  0x1F, 0x00, 0x07, 0xFF, 0xE0, 0x1F, 0x80, 0x01, 0xFF, 0xE0, 0x0F, 0x80,
  0x00, 0xFF, 0xE0, 0x0F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x01,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x1F, 0x80, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00,
  0xFC, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0xFC, 0x1F, 0xE0, 0x00, 0x07, 0xE3,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x03, 0xF0, 0xFF, 0x3F,
  0x00, 0x7E, 0x1F, 0xC3, 0xF8, 0x07, 0xE3, 0xF8, 0x1F, 0xC0, 0xFE, 0x7F,
  0x00, 0xFE, 0x0F, 0xC7, 0xE0, 0x0F, 0xE1, 0xF8, 0xFE, 0x00, 0x7F, 0x3F,
  0x8F, 0xC0, 0x03, 0xFF, 0xF0, 0xFC, 0x00, 0x3F, 0xFE, 0x0F, 0xC0, 0x01,
  0xFF, 0xE0, 0xFC, 0x00, 0x0F, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x01, 0xFF, 0x80, 0x7F, 0x80, 0x7F, 0xFC,
  0x07, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0xFE, 0x03, 0xFF, 0xFF,
  0xC7, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0x80, 0x7F, 0xFC, 0x03, 0xFC, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C,
  0x7C, 0x7C, 0x78, 0x78, 0xF8, 0xF0, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7C,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00,
  0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xA0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x18, 0x03,
  0xE0, 0x03, 0xC0, 0x78, 0x00, 0xFE, 0x0F, 0x00, 0x1F, 0xF1, 0xE0, 0x03,
  0xFF, 0xB8, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xF8, 0x3E, 0x01, 0xFF, 0x80, 0x00,
  0x7C, 0xF0, 0x00, 0x3F, 0x9E, 0x00, 0x0F, 0xE3, 0xE0, 0x03, 0xF8, 0x7C,
  0x00, 0xFE, 0x07, 0xC0, 0x07, 0xC0, 0xF8, 0x00, 0x70, 0x1F, 0x80, 0x04,
  0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xF8, 0x1F, 0x81, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x00, 0x7F,
  0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x08, 0x3E, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFE, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xC0, 0x1F, 0xE1, 0xFE, 0x03, 0xF8, 0x0F, 0xE0, 0x7F, 0x00, 0x7E,
  0x07, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF1, 0xFC,
  0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0x7E,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0x7E, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x7F, 0xFE, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00,
  0x1F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8,
  0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFE, 0x07, 0xE0,
  0x1F, 0xE0, 0x7F, 0x03, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xF0,
  0x01, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xC0, 0x7F, 0xFC, 0x1F, 0xFF, 0xC3, 0xFE, 0xFC, 0xFF,
  0xCF, 0xC7, 0xF1, 0xF8, 0x3E, 0x1F, 0x83, 0x81, 0xF8, 0x10, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xF1, 0xFF, 0x80, 0x3F, 0x00,
  0x7F, 0x00, 0x38, 0x00, 0x7F, 0x00, 0x20, 0x00, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x07, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF8,
  0x07, 0xF8, 0x3F, 0xE0, 0x0F, 0x00, 0x3F, 0x80, 0x30, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xFC, 0x30, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0xFF, 0x83,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0x7C, 0x00, 0x00, 0xFD, 0xF8, 0x00, 0x01,
  0xFB, 0xF0, 0x00, 0x07, 0xE7, 0xC0, 0x00, 0x1F, 0x9F, 0x80, 0x00, 0x7E,
  0x3F, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0xC3,
  0xF0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03, 0xF0, 0x1F,
  0x80, 0x0F, 0xC0, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFE, 0x01, 0xF8,
  0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80,
  0x7E, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x7E, 0x03, 0xFF, 0xFF, 0xFF, 0xF7,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF,
  0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x60, 0x00,
  0x07, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFE, 0x00, 0x7C, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFC, 0x20, 0x00, 0x1F, 0xC1, 0xE0, 0x03, 0xFE,
  0x0F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x07, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xFF, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x3F, 0xF0, 0x18, 0x03, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF8,
  0x01, 0xF8, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x07,
  0xFF, 0xFF, 0xF8, 0x3F, 0xF0, 0x1F, 0xE1, 0xFF, 0x00, 0x7F, 0x0F, 0xF0,
  0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x80, 0x03,
  0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE3,
  0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x83, 0xF0,
  0x01, 0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x0F,
  0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x00,
  0x07, 0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x04, 0x00, 0x00, 0x1F,
  0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF,
  0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x03, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x03,
  0xF8, 0x1F, 0xE0, 0x1F, 0xC0, 0x3F, 0x80, 0x7E, 0x00, 0x7E, 0x03, 0xF0,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x7E, 0x03, 0xF0, 0x01, 0xF8, 0x0F, 0xC0, 0x0F, 0xE0, 0x1F, 0x80, 0x3F,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xFD, 0xFE, 0x00,
  0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFE, 0x3F, 0xC0, 0x1F, 0xE0,
  0x7F, 0x80, 0xFE, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03,
  0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0xFE, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x3F, 0x07,
  0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x80, 0x3F, 0x80, 0xFF,
  0xC7, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xA0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0,
  0x3F, 0xFF, 0xF8, 0x0F, 0xF0, 0x7F, 0x83, 0xFC, 0x07, 0xF0, 0x7E, 0x00,
  0x7F, 0x1F, 0xC0, 0x07, 0xE3, 0xF0, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xCF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x3F, 0x3F, 0x00, 0x07, 0xE7, 0xE0, 0x01, 0xFC, 0xFC,
  0x00, 0x3F, 0x9F, 0x80, 0x0F, 0xF3, 0xF8, 0x03, 0xFE, 0x3F, 0xC1, 0xFF,
  0xC7, 0xFF, 0xFF, 0xF0, 0x7F, 0xFF, 0x7E, 0x07, 0xFF, 0xCF, 0xC0, 0x7F,
  0xF1, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x08,
  0x01, 0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC,
  0x00, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x18, 0x00, 0x00, 0x00,
  0x01, 0xF0, 0x1F, 0x81, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xF8, 0x1F, 0xC0,
  0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x08, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F,
  0x83, 0xF8, 0x1F, 0xC0, 0x38, 0x00, 0x00, 0x1F, 0x00, 0x1F, 0x80, 0x1F,
  0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xC0, 0x07, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x0C,
  0x00, 0x00, 0x07, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00,
  0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x40, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x18, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x1F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F,
  0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF,
  0x00, 0x07, 0xFF, 0x00, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xC0, 0x01, 0xFF,
  0xE0, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x78, 0x00, 0x00, 0x0C, 0x00, 0x00, 0x01, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xFF,
  0xFF, 0xC7, 0xF0, 0x7F, 0x87, 0x00, 0x3F, 0x88, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x00,
  0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x10, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x1F,
  0xC0, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x00, 0x00, 0x7C, 0x1F, 0x80, 0x0F, 0xFC, 0x03, 0xE0, 0xF8,
  0x01, 0xFF, 0xFC, 0x0F, 0x8F, 0x80, 0x3F, 0xFF, 0xE0, 0x7C, 0x7C, 0x03,
  0xFF, 0xFE, 0x03, 0xE7, 0xC0, 0x3F, 0x81, 0xF0, 0x1F, 0x3E, 0x03, 0xF0,
  0x0F, 0x80, 0xFB, 0xE0, 0x3F, 0x00, 0x7C, 0x07, 0xDF, 0x01, 0xF0, 0x07,
  0xC0, 0x3E, 0xF8, 0x1F, 0x80, 0x3E, 0x01, 0xF7, 0xC0, 0xF8, 0x01, 0xF0,
  0x0F, 0xFC, 0x07, 0xC0, 0x0F, 0x80, 0x7F, 0xE0, 0x7C, 0x00, 0xF8, 0x03,
  0xFF, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0xF8, 0x1F, 0x00, 0x3E, 0x01, 0xF7,
  0xC0, 0xF8, 0x03, 0xF0, 0x0F, 0xBE, 0x07, 0xC0, 0x1F, 0x00, 0xF9, 0xF0,
  0x3E, 0x01, 0xF8, 0x07, 0xCF, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0x7C, 0x0F,
  0xC0, 0xFE, 0x07, 0xE3, 0xE0, 0x7F, 0x1F, 0xF8, 0xFE, 0x1F, 0x01, 0xFF,
  0xF7, 0xFF, 0xE0, 0x7C, 0x0F, 0xFF, 0x1F, 0xFE, 0x03, 0xE0, 0x3F, 0xF0,
  0x7F, 0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x10, 0x00,
  0x07, 0xF8, 0x00, 0x07, 0x00, 0x00, 0x1F, 0xF8, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x00, 0x1F, 0x1F, 0x00, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x07, 0xE1,
  0xF0, 0x00, 0x01, 0xF8, 0x7C, 0x00, 0x00, 0xFC, 0x1F, 0x00, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x03,
  0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x3E, 0x00, 0x0F, 0xC0, 0x0F, 0x80, 0x03, 0xF0, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x1F, 0x80,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE1, 0xFC,
  0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x1F, 0x8F,
  0xC0, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x01, 0xFB, 0xF8, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xF8, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7E,
  0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x03, 0xF0, 0x1F,
  0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xF8, 0x07, 0xE0, 0x03, 0xF8, 0x07,
  0xE0, 0x07, 0xF8, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x3F, 0x00, 0x3F, 0xC0, 0x1F, 0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x03, 0xF8,
  0x0F, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x03,
  0xFC, 0x0F, 0xC0, 0x03, 0xFC, 0x0F, 0xC0, 0x0F, 0xFE, 0x07, 0xFF, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xC7, 0xF8, 0x07, 0xFE, 0x00, 0x38,
  0x07, 0xFC, 0x00, 0x04, 0x07, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x08, 0x03,
  0xFF, 0x00, 0x38, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x00, 0xD0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF0, 0x01, 0xF8, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xE0,
  0x0F, 0xC0, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x00, 0x03,
  0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x00,
  0x00, 0xFE, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x00, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00,
  0xFE, 0x1F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00,
  0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x07, 0xF0,
  0x3F, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x0F,
  0xF0, 0x3F, 0x00, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFF, 0x00, 0xFC, 0x00,
  0xFF, 0xC0, 0x3F, 0x01, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF,
  0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xF9, 0xFF, 0x00, 0x7F, 0xE0, 0x01,
  0xE0, 0x1F, 0xF0, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x03,
  0xFF, 0xF9, 0xFC, 0x00, 0x7F, 0xFE, 0x3F, 0x80, 0x0F, 0xFF, 0xC7, 0xF0,
  0x01, 0xFF, 0xF8, 0xFE, 0x00, 0x3F, 0xFF, 0x1F, 0xC0, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x01, 0xF8, 0x7F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x3F, 0x81, 0xFE,
  0x00, 0x07, 0xE0, 0x1F, 0xE0, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x3F, 0x80,
  0x3F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0x16,
  0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x3F,
  0x80, 0x7F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x00,
  0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x0F,
  0xE0, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFF,
  0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x1F, 0xC0, 0x08, 0x1F, 0xF0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x07, 0xF0,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF8, 0x00, 0x01, 0xF8,
  0x7F, 0x80, 0x00, 0x0F, 0xC7, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x80, 0x00,
  0x07, 0xE7, 0xF8, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x01, 0xFB, 0xF8,
  0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xEF, 0xE0, 0x00, 0x01, 0xFE, 0x3F, 0x00,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x3F, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xC0,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x01,
  0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x9F, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFF,
  0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE,
  0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x7C,
  0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xFC,
  0x01, 0xF7, 0xC0, 0x00, 0x7E, 0xFC, 0x01, 0xF7, 0xC0, 0x00, 0x7C, 0xF8,
  0x03, 0xF7, 0xE0, 0x00, 0xFD, 0xF8, 0x03, 0xF3, 0xE0, 0x00, 0xF9, 0xF8,
  0x03, 0xF3, 0xE0, 0x01, 0xF9, 0xF8, 0x03, 0xE3, 0xE0, 0x01, 0xF1, 0xF8,
  0x07, 0xE3, 0xE0, 0x03, 0xE3, 0xF0, 0x07, 0xE3, 0xE0, 0x07, 0xE3, 0xF0,
  0x07, 0xE3, 0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xE0, 0x0F, 0xC3, 0xF0,
  0x07, 0xC3, 0xE0, 0x0F, 0x83, 0xF0, 0x0F, 0xC3, 0xF0, 0x1F, 0x87, 0xE0,
  0x0F, 0xC1, 0xF0, 0x1F, 0x07, 0xE0, 0x0F, 0xC1, 0xF0, 0x3F, 0x07, 0xE0,
  0x0F, 0xC1, 0xF0, 0x3E, 0x07, 0xE0, 0x0F, 0x81, 0xF0, 0x7E, 0x0F, 0xC0,
  0x1F, 0x81, 0xF0, 0x7C, 0x0F, 0xC0, 0x1F, 0x81, 0xF0, 0xFC, 0x0F, 0xC0,
  0x1F, 0x81, 0xF0, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF1, 0xF8, 0x0F, 0xC0,
  0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xFB, 0xE0, 0x1F, 0x80,
  0x3F, 0x00, 0xFB, 0xE0, 0x1F, 0x80, 0x3F, 0x00, 0xFF, 0xC0, 0x1F, 0x80,
  0x3E, 0x00, 0xFF, 0xC0, 0x1F, 0x80, 0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFF, 0x80, 0x3F, 0x00, 0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x00,
  0x7E, 0x00, 0xFF, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFC, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x00, 0xFF,
  0x80, 0x00, 0x3F, 0x00, 0xFF, 0x80, 0x00, 0x7E, 0x00, 0xFF, 0x80, 0x00,
  0x7E, 0x00, 0xFF, 0xC0, 0x00, 0x7E, 0x01, 0xFF, 0xC0, 0x00, 0x7E, 0x01,
  0xFF, 0xE0, 0x00, 0x7E, 0x01, 0xF7, 0xE0, 0x00, 0xFC, 0x01, 0xF7, 0xE0,
  0x00, 0xFC, 0x01, 0xF3, 0xF0, 0x00, 0xFC, 0x03, 0xF3, 0xF0, 0x00, 0xFC,
  0x03, 0xF3, 0xF0, 0x00, 0xF8, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x03, 0xE1,
  0xF8, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0xFC, 0x01,
  0xF8, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x03, 0xF0, 0x07,
  0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x3F,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x07, 0xE0,
  0x0F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x80, 0x1F, 0x87, 0xE0, 0x1F, 0x80,
  0x1F, 0x87, 0xC0, 0x1F, 0x80, 0x0F, 0xCF, 0xC0, 0x1F, 0x00, 0x0F, 0xCF,
  0xC0, 0x1F, 0x00, 0x0F, 0xCF, 0xC0, 0x3F, 0x00, 0x07, 0xEF, 0xC0, 0x3F,
  0x00, 0x07, 0xEF, 0x80, 0x3F, 0x00, 0x03, 0xEF, 0x80, 0x3E, 0x00, 0x03,
  0xFF, 0x80, 0x7E, 0x00, 0x03, 0xFF, 0x80, 0x7E, 0x00, 0x01, 0xFF, 0x80,
  0x7E, 0x00, 0x01, 0xFF, 0x00, 0x7E, 0x00, 0x01, 0xFF, 0x00, 0x7C, 0x00,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0xFC, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F,
  0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x0F, 0xFE, 0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00,
  0x3F, 0x7F, 0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x01, 0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01,
  0x40, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFC, 0x03, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07,
  0xE0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xFC, 0x07, 0xE0, 0x1F, 0xF8, 0x0F,
  0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0x3F, 0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xC0, 0x01, 0xFC, 0x07,
  0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07,
  0xE1, 0xFC, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x07, 0xF3, 0xF8, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x00, 0x3F, 0x7F,
  0x00, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x03,
  0xF7, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0xFE,
  0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F,
  0xEF, 0xE0, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x01, 0xFC, 0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0x7F,
  0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFE,
  0x03, 0xFC, 0x00, 0x7F, 0xC0, 0x3F, 0xF0, 0x1F, 0xF8, 0x01, 0xFF, 0xFF,
  0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF,
  0xC0, 0x1F, 0x80, 0x7F, 0xC0, 0x7F, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F,
  0x01, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8,
  0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x7E, 0x07, 0xF0, 0x01, 0xFC, 0x0F,
  0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x7F, 0xE0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x03, 0xF0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0xC0, 0x3F, 0x00, 0x1F,
  0x80, 0x7E, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x7E,
  0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC,
  0x7F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFE, 0x00,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0x00, 0xFE,
  0x00, 0x04, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x30, 0x00, 0x3F, 0xC0, 0xF8,
  0x01, 0xFF, 0x03, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07, 0xE0,
  0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x01, 0xF8, 0x1F, 0x80,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x00, 0x3F, 0x81,
  0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x3F, 0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x07, 0xFC, 0x03, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0xD0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x0F, 0xE1, 0xF8, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x07,
  0xF0, 0x7E, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xF8, 0x07, 0xC0, 0x01, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x0F, 0xC0, 0x1F, 0x80, 0x07, 0xE0,
  0x1F, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0xF8, 0x0F, 0xC0, 0x00, 0x7C,
  0x07, 0xE0, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x03, 0xF1, 0xF8, 0x00, 0x01,
  0xF8, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00,
  0x1F, 0x7E, 0x00, 0x00, 0x0F, 0xBF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x0F,
  0xDF, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFF, 0x00, 0x07,
  0xE7, 0xE0, 0x00, 0xFF, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0xFF, 0xC0, 0x03,
  0xF1, 0xF8, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x3F, 0xF0, 0x01,
  0xF8, 0x7E, 0x00, 0x3E, 0xF8, 0x00, 0xFC, 0x3F, 0x00, 0x1F, 0x7C, 0x00,
  0xFE, 0x1F, 0x80, 0x1F, 0x3E, 0x00, 0x7E, 0x0F, 0xC0, 0x0F, 0x9F, 0x00,
  0x7F, 0x07, 0xE0, 0x0F, 0xCF, 0x80, 0x3F, 0x01, 0xF0, 0x07, 0xC7, 0xC0,
  0x1F, 0x80, 0xF8, 0x07, 0xE3, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE1, 0xF0,
  0x0F, 0xC0, 0x3E, 0x03, 0xF0, 0xF8, 0x0F, 0xC0, 0x1F, 0x01, 0xF0, 0x7C,
  0x07, 0xE0, 0x0F, 0x81, 0xF8, 0x3E, 0x07, 0xF0, 0x07, 0xC0, 0xFC, 0x1F,
  0x83, 0xF0, 0x03, 0xE0, 0xFC, 0x0F, 0xC1, 0xF8, 0x01, 0xF0, 0x7E, 0x07,
  0xE1, 0xF8, 0x00, 0xFC, 0x3E, 0x03, 0xF0, 0xFC, 0x00, 0x7E, 0x3F, 0x00,
  0xF8, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x7C, 0x7E, 0x00, 0x1F, 0x9F, 0x80,
  0x3E, 0x3E, 0x00, 0x0F, 0xCF, 0x80, 0x1F, 0x3F, 0x00, 0x07, 0xEF, 0xC0,
  0x0F, 0x9F, 0x00, 0x03, 0xE7, 0xC0, 0x07, 0xDF, 0x80, 0x01, 0xF3, 0xE0,
  0x03, 0xEF, 0xC0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x00, 0x7D, 0xF0,
  0x00, 0xFF, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8,
  0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00,
  0x3F, 0x00, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00, 0x00,
  0x01, 0xFB, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x00, 0x3F, 0x87,
  0xE0, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xF8,
  0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x1F,
  0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0xFC,
  0x00, 0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80,
  0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0xFE, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0xFC, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F,
  0x00, 0x03, 0xF0, 0xFE, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x40, 0x7F, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFC, 0x00, 0x7F,
  0xF8, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C,
  0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E,
  0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1F, 0x01, 0xF8, 0x1F,
  0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0xFC, 0x0F,
  0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7E, 0x07, 0xE0, 0x3E, 0x03,
  0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0xFE, 0x00,
  0x7F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x7F,
  0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x07, 0xFE,
  0x00, 0x00, 0x7C, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x3E, 0x1F, 0x00,
  0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x03, 0xC0, 0x00, 0xF8, 0x1F, 0x00, 0x0F,
  0x80, 0xF8, 0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x03, 0xE0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x0F, 0x80, 0x03, 0xF0, 0xF8, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x7C, 0x7C,
  0x00, 0x01, 0xF7, 0xE0, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0xFE, 0x0F,
  0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x1F, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xFF, 0x07, 0xC0, 0x3F, 0xFE, 0x3E, 0x03, 0xFF,
  0xF1, 0xF0, 0x3F, 0xFF, 0xDF, 0x83, 0xFE, 0x3F, 0xF8, 0x3F, 0xC0, 0x7F,
  0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1, 0xFC, 0x00, 0x7F, 0x8F,
  0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x0F,
  0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x01, 0xFE, 0x1F, 0x80,
  0x0F, 0xF0, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x0F, 0xF8, 0x3F, 0xC0, 0xFF,
  0xC0, 0xFF, 0xBF, 0xFE, 0x07, 0xFF, 0xFB, 0xF0, 0x1F, 0xFF, 0x9F, 0x00,
  0x7F, 0xF0, 0xF8, 0x01, 0xFF, 0x07, 0xC0, 0x00, 0x80, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x1F, 0x00,
  0x07, 0xE1, 0xFF, 0x00, 0x1F, 0x9F, 0xFE, 0x00, 0xFC, 0xFF, 0xFC, 0x03,
  0xF7, 0xFF, 0xF8, 0x0F, 0xFF, 0x1F, 0xE0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF,
  0x80, 0x7F, 0x07, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x03,
  0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC,
  0x3E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFE, 0x1F,
  0x80, 0x03, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xE0, 0xFF, 0x00, 0x7F, 0x03, 0xFE, 0x03,
  0xFC, 0x1F, 0xFF, 0x7F, 0xE0, 0x7C, 0xFF, 0xFF, 0x01, 0xF3, 0xFF, 0xF8,
  0x07, 0xC7, 0xFF, 0xC0, 0x3E, 0x07, 0xFC, 0x00, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFF, 0x00, 0xFF, 0xFF, 0x01, 0xFF, 0xFF,
  0x03, 0xFF, 0xFE, 0x07, 0xFE, 0x3E, 0x0F, 0xF0, 0x02, 0x1F, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x10, 0x7F, 0x80, 0x70, 0x7F, 0xF7, 0xF0,
  0x3F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x7F, 0xE1, 0xF8, 0x00,
  0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xF9, 0xF8, 0x03, 0xFF, 0xFD, 0xF8, 0x07,
  0xFC, 0x7F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F,
  0xC0, 0x0F, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80, 0x07, 0xE0, 0x7F,
  0x00, 0x07, 0xE0, 0x7F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x0F, 0xC0, 0xFC,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x1F, 0x80, 0xFC,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x7F, 0x80, 0xFC,
  0x00, 0x7F, 0x80, 0xFC, 0x00, 0xFF, 0x00, 0xFE, 0x01, 0xFF, 0x00, 0xFF,
  0x03, 0xFF, 0x00, 0x7F, 0xDF, 0xFF, 0x00, 0x7F, 0xFF, 0xBE, 0x00, 0x3F,
  0xFF, 0x3E, 0x00, 0x1F, 0xFC, 0x3E, 0x00, 0x0F, 0xF8, 0x3E, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x3F, 0xFF,
  0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x3F, 0xC1, 0xFC, 0x3F, 0x80,
  0x7E, 0x3F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x9F, 0xC0, 0x0F, 0xCF, 0xC0,
  0x07, 0xEF, 0xE0, 0x07, 0xF7, 0xE0, 0x0F, 0xF3, 0xF0, 0x1F, 0xF3, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x04,
  0x1F, 0xC0, 0x0E, 0x0F, 0xFC, 0x3F, 0x03, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0x80, 0x00, 0x5C, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x87, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x7C, 0x00,
  0xFF, 0xF8, 0xF8, 0x07, 0xFF, 0xF1, 0xF0, 0x1F, 0xFF, 0xF7, 0xE0, 0x3F,
  0xE3, 0xFF, 0x80, 0xFF, 0x01, 0xFF, 0x03, 0xFC, 0x01, 0xFE, 0x07, 0xF0,
  0x03, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00,
  0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x07,
  0xE0, 0xFC, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF8, 0x1F, 0x80, 0x0F, 0xF0,
  0x3F, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x00,
  0xFF, 0xBF, 0x7E, 0x01, 0xFF, 0xFC, 0xF8, 0x01, 0xFF, 0xF3, 0xF0, 0x01,
  0xFF, 0xC7, 0xE0, 0x01, 0xFF, 0x0F, 0xC0, 0x00, 0x60, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x20, 0x00, 0x3F, 0x80, 0x60, 0x00,
  0xFE, 0x00, 0xFC, 0x07, 0xFC, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xF8, 0x1F, 0x00, 0x07, 0xE1, 0xFF, 0x80, 0x1F, 0x9F, 0xFF, 0x00, 0xFC,
  0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF8, 0x0F, 0xFF, 0x0F, 0xE0, 0x3F, 0xF0,
  0x1F, 0xC0, 0xFF, 0x80, 0x7F, 0x07, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x03,
  0xF0, 0x7F, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xF8,
  0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x83, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x00,
  0x3C, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7E, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x87, 0xF0,
  0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x20, 0x3F, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x07, 0xE0,
  0x3F, 0x80, 0x0F, 0xC0, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E, 0x0F,
  0xE0, 0x00, 0xFC, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x07, 0xCF, 0xE0, 0x00, 0x1F, 0xBF, 0x80, 0x00, 0x3F, 0x7F, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x07, 0xFD, 0xF8, 0x00, 0x0F, 0xF3, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x01, 0xF8, 0x0F, 0xE0, 0x03,
  0xF0, 0x0F, 0xC0, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01,
  0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F,
  0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0xFF, 0x80, 0x3F, 0xE0, 0x07,
  0xC7, 0xFF, 0x81, 0xFF, 0xE0, 0x0F, 0x9F, 0xFF, 0x87, 0xFF, 0xE0, 0x3F,
  0x7F, 0xFF, 0x1F, 0xFF, 0xC0, 0x7D, 0xF8, 0xFE, 0x7E, 0x3F, 0xC0, 0xFB,
  0xC0, 0xFF, 0xF0, 0x3F, 0x81, 0xFF, 0x00, 0xFF, 0xC0, 0x3F, 0x07, 0xFC,
  0x01, 0xFF, 0x00, 0x7E, 0x0F, 0xF0, 0x03, 0xFC, 0x00, 0xFC, 0x1F, 0xC0,
  0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00,
  0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x03,
  0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x7E, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF8,
  0x00, 0xFE, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC0,
  0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x00,
  0x0F, 0xC3, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0x01,
  0xF8, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x07,
  0xC1, 0xFF, 0x80, 0x1F, 0x1F, 0xFF, 0x00, 0xFC, 0xFF, 0xFE, 0x03, 0xF7,
  0xFF, 0xF8, 0x0F, 0xFF, 0x9F, 0xF0, 0x3F, 0xF0, 0x1F, 0xC0, 0xFF, 0x80,
  0x7F, 0x07, 0xFC, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xF0, 0x7F, 0x80, 0x1F,
  0xC1, 0xFC, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0,
  0xFE, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x7F,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80,
  0x07, 0xF0, 0x7E, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x7E, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0xFE,
  0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x7F, 0x07,
  0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07,
  0xFF, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xF8,
  0x0F, 0xF8, 0xFF, 0x83, 0xFC, 0x07, 0xF0, 0xFE, 0x00, 0x7F, 0x1F, 0xC0,
  0x0F, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xBF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF0, 0x00, 0x3F, 0xFE,
  0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x3F, 0xBF, 0x00, 0x07,
  0xE7, 0xE0, 0x01, 0xFC, 0xFE, 0x00, 0x3F, 0x0F, 0xC0, 0x0F, 0xE1, 0xFC,
  0x07, 0xF8, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0,
  0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x30, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x1F, 0xF0, 0x00, 0x7C, 0x7F, 0xF8, 0x00,
  0x7C, 0xFF, 0xFC, 0x00, 0xFD, 0xFF, 0xFE, 0x00, 0xFB, 0xF1, 0xFE, 0x00,
  0xFF, 0xC0, 0x7F, 0x00, 0xFF, 0x80, 0x7F, 0x01, 0xFF, 0x00, 0x3F, 0x01,
  0xFE, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xE0, 0x00, 0x7E, 0x07,
  0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFE, 0x07,
  0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF8, 0x0F,
  0xF0, 0x03, 0xF8, 0x0F, 0xF0, 0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xF0, 0x1F,
  0xFF, 0x7F, 0xE0, 0x1F, 0xBF, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0x80, 0x1F,
  0x8F, 0xFF, 0x00, 0x1F, 0x87, 0xFC, 0x00, 0x3F, 0x00, 0xE0, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xFF, 0x87, 0xC0, 0x3F,
  0xFE, 0x3E, 0x03, 0xFF, 0xF9, 0xF0, 0x3F, 0xFF, 0xDF, 0x83, 0xFE, 0x3F,
  0xF8, 0x3F, 0xC0, 0x7F, 0xC3, 0xFC, 0x01, 0xFE, 0x1F, 0xC0, 0x0F, 0xF1,
  0xFC, 0x00, 0x7F, 0x8F, 0xE0, 0x01, 0xF8, 0xFE, 0x00, 0x0F, 0xC7, 0xF0,
  0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0xC0, 0x01,
  0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x07, 0xF1,
  0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0,
  0x01, 0xFE, 0x1F, 0x80, 0x0F, 0xF0, 0xFC, 0x00, 0xFF, 0x07, 0xF0, 0x0F,
  0xF8, 0x3F, 0xC0, 0xFF, 0xC0, 0xFF, 0xBF, 0x7E, 0x07, 0xFF, 0xF3, 0xE0,
  0x1F, 0xFF, 0x3F, 0x00, 0x7F, 0xF1, 0xF8, 0x01, 0xFF, 0x0F, 0xC0, 0x00,
  0x80, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0xFF, 0x01, 0xF1, 0xFF, 0x03,
  0xF3, 0xFF, 0x03, 0xF7, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x03,
  0xFE, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0x80, 0xF0, 0x3F, 0x80, 0x18,
  0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x40, 0x00, 0xFC, 0x38,
  0x00, 0xFE, 0x1F, 0xC3, 0xFF, 0x0F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x01, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xF7, 0x81, 0xFF, 0xF0, 0x3F, 0xFE, 0x03,
  0xFF, 0xC0, 0x3F, 0xF0, 0x00, 0xE0, 0x00, 0x07, 0xE0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7E, 0x0F, 0xC0,
  0x03, 0xF8, 0x3F, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7E, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E,
  0x0F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0, 0x7E, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFE, 0x00,
  0x3F, 0x83, 0xF0, 0x01, 0xFE, 0x0F, 0xC0, 0x07, 0xF8, 0x3F, 0x00, 0x3F,
  0xC0, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x0F, 0x7C, 0x07, 0xFF, 0xFB, 0xF0,
  0x1F, 0xFF, 0xCF, 0xC0, 0x7F, 0xFF, 0x3E, 0x00, 0xFF, 0xF0, 0xF8, 0x00,
  0xFF, 0x83, 0xE0, 0x00, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0xFE, 0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x01, 0xFC, 0xFC, 0x00, 0x1F,
  0x87, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0xFC, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x3F, 0x00, 0x3E, 0x03, 0xF0, 0x03,
  0xE0, 0x7E, 0x00, 0x3E, 0x0F, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x1F,
  0xC0, 0x03, 0xF1, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x03, 0xF3, 0xF0, 0x00,
  0x1F, 0x3F, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x0F, 0xFF, 0x00, 0x1F, 0xE0, 0x07, 0xFF, 0xC0, 0x07, 0xF8, 0x01, 0xF9,
  0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x7C, 0x00, 0xFF, 0x80, 0x3F, 0x1F, 0x00,
  0x7F, 0xE0, 0x0F, 0xC7, 0xC0, 0x1F, 0xF8, 0x07, 0xE1, 0xF0, 0x0F, 0xBE,
  0x01, 0xF8, 0x7C, 0x03, 0xEF, 0x80, 0xFC, 0x1F, 0x01, 0xF3, 0xE0, 0x3F,
  0x07, 0xC0, 0x7C, 0xF8, 0x1F, 0x81, 0xF0, 0x3F, 0x3E, 0x07, 0xE0, 0x7C,
  0x0F, 0x8F, 0x83, 0xF8, 0x1F, 0x83, 0xE3, 0xE0, 0xFC, 0x07, 0xE1, 0xF0,
  0xF8, 0x3F, 0x01, 0xF8, 0x7C, 0x3E, 0x1F, 0x80, 0x7E, 0x3E, 0x0F, 0x87,
  0xE0, 0x1F, 0x8F, 0x83, 0xE3, 0xF0, 0x07, 0xE7, 0xC0, 0xF8, 0xFC, 0x01,
  0xF9, 0xF0, 0x3E, 0x7E, 0x00, 0x7E, 0xF8, 0x0F, 0x9F, 0x80, 0x1F, 0xBE,
  0x03, 0xE7, 0xC0, 0x07, 0xEF, 0x80, 0xFB, 0xF0, 0x01, 0xF7, 0xC0, 0x1E,
  0xF8, 0x00, 0x7D, 0xF0, 0x07, 0xBE, 0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xC0, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x07, 0xE0, 0x3F, 0x80,
  0x03, 0xF0, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7E, 0x1F, 0x80,
  0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x07, 0xFF, 0xC0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x07, 0xE1,
  0xF8, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x07, 0xF0,
  0x1F, 0x80, 0x07, 0xF0, 0x07, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x07, 0xE0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x1F, 0x0F, 0xC0,
  0x00, 0x01, 0xF1, 0xF8, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0x01, 0xF3,
  0xF0, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x00,
  0x1F, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x08, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0xC1,
  0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xFE, 0x00, 0x0F, 0xFE, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xFE, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00, 0x7F, 0x80, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00,
  0x01, 0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F,
  0xE0, 0x00, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x02, 0x00, 0x00, 0x27,
  0xFE, 0x00, 0x05, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xF4, 0x00, 0x1F, 0xFC, 0x80,
  0x00, 0x1C, 0x00,
};

const GFXglyph NotoSans_MediumItalic58pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 16, 42, 16, 1, -41 },
  { 85, 19, 15, 24, 6, -41 },
  { 121, 36, 41, 37, 2, -41 },
  { 306, 29, 47, 32, 2, -44 },
  { 477, 41, 43, 47, 4, -42 },
  { 698, 36, 43, 40, 2, -42 },
  { 892, 8, 15, 13, 6, -41 },
  { 907, 20, 50, 18, 2, -41 },
  { 1032, 19, 51, 18, -4, -42 },
  { 1154, 27, 27, 32, 6, -44 },
  { 1246, 27, 29, 33, 4, -35 },
  { 1344, 13, 14, 15, -3, -7 },
  { 1367, 16, 5, 18, 1, -18 },
  { 1377, 8, 9, 15, 1, -8 },
  { 1386, 30, 42, 22, -3, -42 },
  { 1544, 28, 43, 32, 3, -42 },
  { 1695, 20, 41, 32, 7, -41 },
  { 1798, 31, 42, 32, 0, -42 },
  { 1961, 30, 43, 32, 1, -42 },
  { 2123, 31, 41, 32, 0, -41 },
  { 2282, 29, 42, 32, 2, -41 },
  { 2435, 29, 43, 32, 3, -42 },
  { 2591, 29, 41, 32, 4, -41 },
  { 2740, 30, 43, 32, 2, -42 },
  { 2902, 27, 43, 32, 3, -42 },
  { 3048, 13, 33, 15, 1, -32 },
  { 3102, 17, 39, 15, -3, -32 },
  { 3185, 27, 30, 33, 4, -36 },
  { 3287, 27, 16, 33, 4, -28 },
  { 3341, 27, 30, 33, 4, -36 },
  { 3443, 23, 43, 25, 4, -42 },
  { 3567, 45, 46, 49, 3, -41 },
  { 3826, 34, 41, 34, -3, -41 },
  { 4001, 33, 41, 35, 2, -41 },
  { 4171, 33, 43, 35, 4, -42 },
  { 4349, 35, 41, 39, 2, -41 },
  { 4529, 31, 41, 30, 2, -41 },
  { 4688, 30, 41, 29, 2, -41 },
  { 4842, 35, 43, 40, 4, -42 },
  { 5031, 38, 41, 40, 2, -41 },
  { 5226, 24, 41, 20, -1, -41 },
  { 5349, 26, 52, 17, -9, -41 },
  { 5518, 37, 41, 33, 2, -41 },
  { 5708, 23, 41, 28, 2, -41 },
  { 5826, 48, 41, 49, 2, -41 },
  { 6072, 40, 41, 42, 2, -41 },
  { 6277, 36, 43, 42, 4, -42 },
  { 6471, 32, 41, 34, 2, -41 },
  { 6635, 36, 52, 42, 4, -42 },
  { 6869, 31, 41, 34, 2, -41 },
  { 7028, 30, 43, 30, 1, -42 },
  { 7190, 29, 41, 30, 5, -41 },
  { 7339, 36, 42, 40, 4, -41 },
  { 7528, 33, 41, 33, 5, -41 },
  { 7698, 49, 41, 50, 6, -41 },
  { 7950, 40, 41, 32, -3, -41 },
  { 8155, 31, 41, 30, 5, -41 },
  { 8314, 34, 41, 31, -1, -41 },
  { 8489, 23, 50, 18, -1, -41 },
  { 8633, 12, 42, 22, 6, -42 },
  { 8696, 23, 50, 18, -4, -41 },
  { 8840, 29, 27, 33, 2, -42 },
  { 8938, 24, 4, 23, -5, 5 },
  { 8950, 11, 9, 17, 8, -44 },
  { 8963, 29, 33, 33, 3, -32 },
  { 9083, 30, 45, 34, 1, -44 },
  { 9252, 24, 33, 27, 3, -32 },
  { 9351, 32, 45, 34, 3, -44 },
  { 9531, 25, 33, 30, 3, -32 },
  { 9635, 32, 58, 19, -6, -44 },
  { 9867, 31, 46, 34, 1, -32 },
  { 10046, 30, 44, 34, 1, -44 },
  { 10211, 16, 43, 16, 1, -43 },
  { 10297, 24, 57, 16, -7, -43 },
  { 10468, 31, 44, 30, 1, -44 },
  { 10639, 16, 44, 16, 1, -44 },
  { 10727, 47, 32, 51, 1, -32 },
  { 10915, 30, 32, 34, 1, -32 },
  { 11035, 27, 33, 33, 3, -32 },
  { 11147, 32, 46, 34, -1, -32 },
  { 11331, 29, 46, 34, 3, -32 },
  { 11498, 24, 32, 23, 1, -32 },
  { 11594, 25, 33, 26, 0, -32 },
  { 11698, 19, 39, 21, 3, -38 },
  { 11791, 30, 32, 34, 3, -31 },
  { 11911, 28, 31, 28, 3, -31 },
  { 12020, 42, 31, 43, 3, -31 },
  { 12183, 33, 31, 29, -2, -31 },
  { 12311, 36, 45, 28, -5, -31 },
  { 12514, 27, 31, 26, -1, -31 },
  { 12619, 24, 50, 20, 0, -41 },
  { 12769, 5, 58, 32, 14, -44 },
  { 12806, 22, 50, 20, -2, -41 },
  { 12944, 27, 9, 33, 4, -25 },
};

const GFXfont NotoSans_MediumItalic58pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic58pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic58pt7bGlyphs,
  0x20, 0x7E, 79
};

#endif // _NOTOSANS_MEDIUMITALIC58PT7B_H_
