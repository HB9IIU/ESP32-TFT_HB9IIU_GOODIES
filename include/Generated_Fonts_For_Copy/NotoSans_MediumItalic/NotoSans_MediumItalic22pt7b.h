#ifndef _NOTOSANS_MEDIUMITALIC22PT7B_H_
#define _NOTOSANS_MEDIUMITALIC22PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 22pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic22pt7bBitmaps[] PROGMEM = {
  0x00, 0x0C, 0x71, 0xC7, 0x18, 0x63, 0x8E, 0x30, 0xC3, 0x00, 0x01, 0x8E,
  0x38, 0x66, 0xCD, 0x9B, 0x24, 0xD9, 0x80, 0x06, 0x30, 0x31, 0x81, 0x88,
  0x08, 0xC0, 0xC6, 0x3F, 0xFD, 0xFF, 0xE3, 0x18, 0x18, 0xC0, 0xC4, 0x3F,
  0xFC, 0x63, 0x03, 0x10, 0x11, 0x81, 0x8C, 0x0C, 0x60, 0x01, 0x00, 0x60,
  0x3F, 0x0F, 0xF3, 0x24, 0x6C, 0x0D, 0x81, 0xE0, 0x3E, 0x01, 0xF0, 0x3E,
  0x06, 0xC0, 0x99, 0x17, 0x3F, 0xC3, 0xF0, 0x18, 0x02, 0x00, 0x38, 0x0C,
  0xF8, 0x33, 0x98, 0x46, 0x31, 0x8C, 0x66, 0x19, 0x98, 0x33, 0x36, 0x66,
  0xDF, 0xFB, 0x66, 0xEC, 0xCC, 0x1B, 0x18, 0x66, 0x31, 0x8C, 0x66, 0x19,
  0x8C, 0x3F, 0x70, 0x3C, 0x07, 0x80, 0x3F, 0x01, 0xCE, 0x06, 0x18, 0x18,
  0xE0, 0x67, 0x01, 0xF8, 0x07, 0x80, 0x3E, 0x1D, 0x9C, 0x6E, 0x3B, 0x30,
  0x7C, 0xC1, 0xE3, 0x87, 0x8F, 0xFE, 0x1F, 0x8E, 0x6D, 0xB5, 0x80, 0x06,
  0x18, 0x70, 0xC3, 0x06, 0x18, 0x30, 0xE1, 0x83, 0x06, 0x0C, 0x18, 0x30,
  0x60, 0xC0, 0xC1, 0x80, 0x0C, 0x06, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x07, 0x06, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x30, 0xE0, 0x06,
  0x01, 0x88, 0x63, 0x90, 0x7C, 0xC3, 0xF1, 0xE0, 0xD8, 0x66, 0x08, 0xC0,
  0x20, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x0F, 0xFF, 0xFF, 0xC1, 0x80, 0x30,
  0x06, 0x00, 0xC0, 0x18, 0x00, 0x39, 0x9C, 0xC6, 0x60, 0x7F, 0xF0, 0x7F,
  0x80, 0x00, 0x60, 0x18, 0x03, 0x00, 0xC0, 0x38, 0x06, 0x01, 0xC0, 0x30,
  0x0C, 0x01, 0x80, 0x60, 0x0C, 0x03, 0x00, 0xE0, 0x18, 0x07, 0x00, 0x07,
  0x83, 0xF8, 0xE3, 0x18, 0x77, 0x0E, 0xC1, 0xD8, 0x3F, 0x07, 0xE0, 0xFC,
  0x1B, 0x03, 0x60, 0xEE, 0x19, 0xC7, 0x1F, 0xC1, 0xF0, 0x06, 0x3C, 0xFF,
  0xEC, 0xC1, 0x87, 0x0E, 0x18, 0x30, 0x61, 0xC3, 0x06, 0x0C, 0x38, 0x07,
  0xC1, 0xFE, 0x18, 0x61, 0x07, 0x00, 0x70, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0x80, 0x70, 0x0E, 0x01, 0xC0, 0x38, 0x07, 0x00, 0xFF, 0xCF, 0xFC, 0x07,
  0xC1, 0xFE, 0x18, 0x60, 0x07, 0x00, 0x70, 0x06, 0x00, 0xC0, 0xF8, 0x0F,
  0x80, 0x1C, 0x00, 0xC0, 0x0E, 0x00, 0xC8, 0x1C, 0xFF, 0x87, 0xF0, 0x00,
  0x70, 0x0E, 0x01, 0xE0, 0x3E, 0x03, 0x60, 0x6E, 0x0C, 0xC1, 0x8C, 0x30,
  0xC7, 0x1C, 0xE1, 0x8F, 0xFF, 0xFF, 0xE0, 0x18, 0x03, 0x80, 0x30, 0x1F,
  0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0F, 0x83, 0xFC, 0x23, 0x80,
  0x38, 0x07, 0x00, 0xE0, 0x19, 0x07, 0x3F, 0xC7, 0xF0, 0x03, 0xE1, 0xFC,
  0x70, 0x1C, 0x03, 0x00, 0xE0, 0x19, 0xC3, 0xFC, 0x71, 0xDC, 0x1B, 0x83,
  0x70, 0x6E, 0x1C, 0xC3, 0x1F, 0xE1, 0xF0, 0x3F, 0xF7, 0xFE, 0x00, 0xE0,
  0x0C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x30, 0x06, 0x00, 0xE0, 0x0C, 0x01,
  0xC0, 0x18, 0x03, 0x80, 0x70, 0x0E, 0x00, 0x07, 0x83, 0xF8, 0xE3, 0x98,
  0x33, 0x06, 0x71, 0x87, 0x70, 0x78, 0x3F, 0x0E, 0x33, 0x87, 0x60, 0x6C,
  0x1D, 0xC3, 0x1F, 0xE1, 0xF8, 0x0F, 0x03, 0xF8, 0xE3, 0x38, 0x66, 0x0E,
  0xC1, 0xD8, 0x33, 0x0E, 0x7F, 0xC7, 0xD8, 0x07, 0x00, 0xC0, 0x38, 0x0E,
  0x3F, 0x87, 0xE0, 0x19, 0xCE, 0x00, 0x00, 0x00, 0x03, 0x39, 0xC0, 0x0C,
  0x71, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xE3, 0x1C, 0x63, 0x0C, 0x00, 0x00,
  0x60, 0x3C, 0x1E, 0x0F, 0x07, 0x01, 0xC0, 0x0F, 0x00, 0x78, 0x03, 0xE0,
  0x1C, 0x00, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x80, 0x1C, 0x01, 0xC1, 0xF0, 0xF0, 0x78, 0x1C,
  0x02, 0x00, 0x00, 0x3C, 0xFF, 0x47, 0x03, 0x03, 0x07, 0x0E, 0x1C, 0x38,
  0x70, 0x60, 0x00, 0x00, 0xC0, 0xE0, 0xC0, 0x00, 0xF0, 0x03, 0xFF, 0x03,
  0x81, 0xC3, 0x00, 0x63, 0x00, 0x1B, 0x0F, 0xCD, 0x8C, 0x66, 0x8C, 0x63,
  0xC6, 0x31, 0xE6, 0x18, 0xF3, 0x0C, 0x79, 0x8E, 0x6C, 0x7B, 0xE3, 0x18,
  0xE1, 0x80, 0x00, 0x60, 0x10, 0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x00, 0xE0,
  0x07, 0x00, 0x78, 0x07, 0xC0, 0x36, 0x03, 0xB0, 0x19, 0xC1, 0xCE, 0x0C,
  0x30, 0xFF, 0x87, 0xFC, 0x70, 0x63, 0x03, 0x38, 0x19, 0x80, 0xDC, 0x07,
  0x1F, 0x81, 0xFE, 0x18, 0x73, 0x83, 0x38, 0x33, 0x07, 0x30, 0xE3, 0xFC,
  0x7F, 0xC7, 0x0E, 0x60, 0x66, 0x06, 0x60, 0xEE, 0x1C, 0xFF, 0xCF, 0xF0,
  0x03, 0xF0, 0x7F, 0xC7, 0x84, 0x70, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x38, 0x10, 0xFF,
  0x03, 0xF8, 0x1F, 0x80, 0xFF, 0x06, 0x3C, 0x70, 0x73, 0x83, 0x98, 0x0C,
  0xC0, 0x66, 0x03, 0x70, 0x3B, 0x81, 0xD8, 0x0C, 0xC0, 0xE6, 0x0E, 0x70,
  0xF3, 0xFE, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x80, 0x60,
  0x0C, 0x11, 0xFC, 0x7F, 0x8E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x3F,
  0xC7, 0xF8, 0x1F, 0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C, 0x01,
  0xFC, 0x7F, 0x8E, 0x01, 0x80, 0x30, 0x06, 0x01, 0xC0, 0x30, 0x06, 0x00,
  0x03, 0xF0, 0x3F, 0xF1, 0xE1, 0x8F, 0x00, 0x38, 0x01, 0xC0, 0x07, 0x00,
  0x18, 0x00, 0x61, 0xF9, 0x87, 0xCE, 0x03, 0x18, 0x0C, 0x70, 0x71, 0xC1,
  0xC3, 0xFE, 0x07, 0xF8, 0x1C, 0x0C, 0x60, 0x31, 0x81, 0xCE, 0x07, 0x38,
  0x18, 0xC0, 0x63, 0x01, 0x8F, 0xFE, 0x7F, 0xF1, 0xC0, 0xC6, 0x03, 0x18,
  0x1C, 0x60, 0x73, 0x81, 0x8E, 0x06, 0x30, 0x18, 0x0F, 0xC3, 0xE0, 0x60,
  0x18, 0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x07, 0xC3, 0xF8, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xC0,
  0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03, 0x80, 0xE0, 0x30,
  0x0C, 0x07, 0x0F, 0x83, 0xC0, 0x18, 0x1C, 0x60, 0xE1, 0x87, 0x0E, 0x38,
  0x39, 0xC0, 0xCE, 0x03, 0x70, 0x0F, 0x80, 0x7E, 0x01, 0xDC, 0x06, 0x30,
  0x18, 0xE0, 0x61, 0x83, 0x87, 0x0C, 0x1C, 0x30, 0x38, 0x18, 0x18, 0x18,
  0x38, 0x38, 0x30, 0x30, 0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xFF,
  0xFF, 0x1C, 0x03, 0xC7, 0x00, 0xF1, 0xE0, 0x78, 0xD8, 0x1E, 0x36, 0x0D,
  0x8D, 0x83, 0x63, 0x61, 0xB8, 0xD8, 0x6C, 0x76, 0x33, 0x19, 0x9C, 0xC6,
  0x66, 0x71, 0x8B, 0x18, 0x63, 0xC6, 0x30, 0xE1, 0x8C, 0x38, 0x63, 0x0C,
  0x38, 0x1C, 0x06, 0x38, 0x0C, 0x70, 0x39, 0xB0, 0x63, 0x60, 0xC6, 0xE1,
  0x8C, 0xC7, 0x19, 0x8C, 0x73, 0x98, 0xC3, 0x31, 0x86, 0x63, 0x0F, 0xC6,
  0x0F, 0x18, 0x1E, 0x30, 0x1C, 0x60, 0x38, 0x03, 0xE0, 0x3F, 0xE1, 0xE3,
  0x8E, 0x07, 0x30, 0x0D, 0xC0, 0x37, 0x00, 0xD8, 0x03, 0x60, 0x0D, 0x80,
  0x7E, 0x01, 0xD8, 0x06, 0x70, 0x39, 0xC1, 0xC3, 0xFE, 0x07, 0xF0, 0x1F,
  0x81, 0xFE, 0x18, 0xE3, 0x87, 0x38, 0x73, 0x07, 0x30, 0x63, 0x0E, 0x7F,
  0xC7, 0xF0, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0x03,
  0xE0, 0x3F, 0xE1, 0xE3, 0x8E, 0x07, 0x30, 0x0D, 0xC0, 0x37, 0x00, 0xD8,
  0x03, 0x60, 0x0D, 0x80, 0x7E, 0x01, 0xD8, 0x06, 0x70, 0x39, 0xC1, 0xC3,
  0xFE, 0x07, 0xE0, 0x01, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x1F, 0x81,
  0xFE, 0x18, 0xE3, 0x87, 0x38, 0x73, 0x07, 0x30, 0x63, 0x1E, 0x7F, 0x87,
  0xF0, 0x63, 0x06, 0x38, 0x61, 0x8E, 0x1C, 0xC1, 0xCC, 0x0E, 0x07, 0xC0,
  0xFF, 0x1C, 0x23, 0x80, 0x38, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x07, 0x80,
  0x38, 0x01, 0xC0, 0x1C, 0x01, 0xC8, 0x1C, 0xFF, 0x87, 0xF0, 0xFF, 0xFF,
  0xFC, 0x30, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0xE0, 0x1C, 0x03, 0x00, 0x60, 0x0C, 0x03, 0x80, 0x30, 0x19, 0x80, 0xDC,
  0x0E, 0xE0, 0x76, 0x03, 0x30, 0x19, 0x80, 0xDC, 0x0E, 0xE0, 0x66, 0x03,
  0x30, 0x19, 0x81, 0xCC, 0x0C, 0x70, 0xE3, 0xFE, 0x0F, 0xE0, 0xC0, 0x3C,
  0x07, 0xE0, 0x6E, 0x0E, 0xE0, 0xC6, 0x1C, 0x61, 0x86, 0x38, 0x63, 0x06,
  0x70, 0x66, 0x06, 0xE0, 0x6C, 0x07, 0x80, 0x78, 0x03, 0x00, 0xE0, 0xE0,
  0x7C, 0x1C, 0x1B, 0x87, 0x83, 0x70, 0xF0, 0xEE, 0x1E, 0x19, 0xC6, 0xC7,
  0x38, 0xD8, 0xC3, 0x33, 0x38, 0x66, 0x66, 0x0D, 0x8C, 0xC1, 0xB1, 0xB0,
  0x3C, 0x36, 0x07, 0x86, 0xC0, 0xE0, 0xF0, 0x1C, 0x1E, 0x03, 0x83, 0x80,
  0x1C, 0x0E, 0x18, 0x38, 0x38, 0x60, 0x31, 0x80, 0x67, 0x00, 0xFC, 0x00,
  0xF0, 0x01, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x3B, 0x00, 0xE6, 0x03, 0x8E,
  0x06, 0x0C, 0x1C, 0x18, 0x70, 0x38, 0xC0, 0x7E, 0x0E, 0x60, 0xC6, 0x18,
  0x63, 0x87, 0x30, 0x36, 0x03, 0xE0, 0x3C, 0x03, 0x80, 0x38, 0x03, 0x80,
  0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0x80, 0x1C, 0x01,
  0xC0, 0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x06, 0x00, 0x60, 0x07, 0x00,
  0x70, 0x07, 0x00, 0x30, 0x03, 0xFF, 0x1F, 0xF8, 0x0F, 0x0F, 0x18, 0x18,
  0x18, 0x18, 0x18, 0x30, 0x30, 0x30, 0x30, 0x70, 0x60, 0x60, 0x60, 0x60,
  0xE0, 0xC8, 0xF0, 0xC3, 0x18, 0xC6, 0x31, 0x8E, 0x31, 0x8C, 0x63, 0x18,
  0x63, 0x0F, 0x87, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0C, 0x06, 0x03,
  0x01, 0x80, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x1C, 0x0C, 0x3E, 0x00, 0x04,
  0x01, 0xC0, 0x38, 0x0D, 0x81, 0xB0, 0x63, 0x0C, 0x63, 0x04, 0x60, 0xD8,
  0x1C, 0xFF, 0x80, 0xE6, 0x31, 0x0F, 0x67, 0xEC, 0xC7, 0xB8, 0x76, 0x0D,
  0xC1, 0xB8, 0x36, 0x0E, 0xC1, 0xDC, 0x71, 0xFE, 0x3E, 0xC0, 0x18, 0x03,
  0x00, 0x60, 0x1C, 0x03, 0x80, 0x67, 0x0F, 0xF1, 0xC7, 0x70, 0xEE, 0x1D,
  0x83, 0xB0, 0x76, 0x0D, 0xC3, 0xB8, 0x67, 0xFC, 0xDF, 0x00, 0x0F, 0x9F,
  0xCC, 0x0E, 0x06, 0x07, 0x03, 0x01, 0x80, 0xC0, 0x70, 0x1F, 0xC7, 0xE0,
  0x00, 0x30, 0x03, 0x00, 0x30, 0x07, 0x00, 0x60, 0xF6, 0x3F, 0x63, 0x0E,
  0x70, 0xE6, 0x0C, 0xE0, 0xCE, 0x0C, 0xC1, 0xCC, 0x18, 0xE3, 0x8F, 0xF8,
  0x7D, 0x80, 0x0F, 0x8F, 0xE3, 0x1D, 0x87, 0x61, 0xBF, 0xCF, 0xE3, 0x00,
  0xC0, 0x38, 0x27, 0xF0, 0xFC, 0x00, 0xF0, 0x1F, 0x03, 0x80, 0x30, 0x03,
  0x00, 0xFC, 0x1F, 0xC0, 0x60, 0x06, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x0C,
  0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x01, 0x80, 0x18, 0x03, 0x80, 0xF0,
  0x0E, 0x00, 0x07, 0xB1, 0xFB, 0x18, 0x73, 0x87, 0x30, 0x67, 0x06, 0x70,
  0x66, 0x0E, 0x60, 0xC7, 0x1C, 0x7E, 0xC3, 0xCC, 0x01, 0xC0, 0x18, 0x83,
  0x8F, 0xF0, 0xFE, 0x00, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x67,
  0x8F, 0xF1, 0xC7, 0x70, 0xEE, 0x1D, 0x83, 0x30, 0x66, 0x0D, 0xC3, 0xB0,
  0x66, 0x0C, 0xC1, 0x80, 0x18, 0xC0, 0x03, 0x18, 0xCE, 0x63, 0x18, 0xCE,
  0x63, 0x18, 0x01, 0x80, 0xC0, 0x00, 0x00, 0x30, 0x18, 0x0C, 0x0E, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x1C, 0x0E, 0x06, 0x1F,
  0x0F, 0x00, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x00, 0x61, 0xCC, 0x71,
  0x9C, 0x77, 0x0D, 0xC1, 0xF0, 0x3F, 0x0E, 0x61, 0xCC, 0x31, 0xC6, 0x18,
  0xC3, 0x80, 0x18, 0xC6, 0x73, 0x98, 0xC6, 0x73, 0x18, 0xCE, 0x73, 0x18,
  0xC0, 0x33, 0x8F, 0x1F, 0xEF, 0xCE, 0x3C, 0x6E, 0x1C, 0x37, 0x0E, 0x1B,
  0x06, 0x0D, 0x83, 0x0E, 0xC3, 0x86, 0xE1, 0x83, 0x60, 0xC1, 0xB0, 0x61,
  0xD8, 0x70, 0xE0, 0x19, 0xE1, 0xFE, 0x1C, 0x73, 0x87, 0x38, 0x73, 0x06,
  0x30, 0x67, 0x06, 0x70, 0xE6, 0x0E, 0x60, 0xCE, 0x0C, 0x0F, 0x07, 0xF9,
  0xC3, 0x30, 0x66, 0x0F, 0xC1, 0xB0, 0x36, 0x06, 0xC1, 0xDC, 0x71, 0xFC,
  0x1F, 0x00, 0x0C, 0xE0, 0x7F, 0x83, 0x8E, 0x38, 0x71, 0xC3, 0x8C, 0x1C,
  0x60, 0xE3, 0x06, 0x38, 0x71, 0xC3, 0x0F, 0xF8, 0x6F, 0x87, 0x00, 0x38,
  0x01, 0x80, 0x0C, 0x00, 0xE0, 0x00, 0x0F, 0x67, 0xFC, 0xC3, 0xB8, 0x76,
  0x0D, 0xC1, 0xB8, 0x36, 0x0E, 0xC1, 0x9C, 0x73, 0xFE, 0x3C, 0xC0, 0x38,
  0x06, 0x00, 0xC0, 0x18, 0x07, 0x00, 0x33, 0x9F, 0x8E, 0x0E, 0x07, 0x03,
  0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x00, 0x1F, 0x9F, 0xCC, 0x2E,
  0x03, 0x81, 0xE0, 0x3C, 0x0E, 0x03, 0x41, 0xBF, 0xDF, 0xC0, 0x08, 0x30,
  0xE3, 0xFF, 0xE6, 0x1C, 0x38, 0x60, 0xC1, 0x87, 0x0E, 0x1F, 0x1E, 0x00,
  0x30, 0x66, 0x0D, 0xC1, 0xB8, 0x76, 0x0C, 0xC1, 0x98, 0x37, 0x0E, 0xE1,
  0xDC, 0x73, 0xFE, 0x3C, 0xC0, 0xC0, 0xF8, 0x3B, 0x86, 0x71, 0xC6, 0x30,
  0xCE, 0x19, 0x83, 0x70, 0x6C, 0x0F, 0x81, 0xE0, 0x3C, 0x00, 0xE1, 0x83,
  0xE3, 0x87, 0xE3, 0xC6, 0xE6, 0xCE, 0xE6, 0xCC, 0x6C, 0xDC, 0x6C, 0xD8,
  0x68, 0xD8, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xE0, 0x70, 0xE0, 0x18, 0x38,
  0xE3, 0x83, 0x38, 0x1B, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xE0, 0x1D,
  0x81, 0xCC, 0x1C, 0x71, 0xC1, 0x80, 0x18, 0x1C, 0x70, 0x61, 0xC3, 0x03,
  0x1C, 0x0C, 0x60, 0x33, 0x80, 0xCC, 0x03, 0x70, 0x0D, 0x80, 0x36, 0x00,
  0x70, 0x01, 0xC0, 0x06, 0x00, 0x30, 0x01, 0xC0, 0x3E, 0x00, 0xF0, 0x00,
  0x3F, 0xCF, 0xF0, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0, 0xE0, 0x30, 0x18,
  0x0F, 0xF3, 0xFC, 0x01, 0x83, 0xC1, 0x81, 0x80, 0xC0, 0x60, 0x30, 0x30,
  0x38, 0x78, 0x3C, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x70, 0x18, 0x0E,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0C, 0x0F, 0x01, 0x80, 0xC0,
  0x60, 0x30, 0x18, 0x18, 0x06, 0x03, 0xC1, 0xC1, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x38, 0x38, 0x3C, 0x00, 0x7C, 0x3F, 0xFE, 0x0F, 0x00,
};

const GFXglyph NotoSans_MediumItalic22pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 6, 16, 6, 0, -16 },
  { 13, 7, 6, 9, 2, -16 },
  { 19, 13, 16, 14, 1, -16 },
  { 45, 11, 18, 12, 1, -17 },
  { 70, 15, 16, 18, 2, -16 },
  { 100, 14, 16, 15, 1, -16 },
  { 128, 3, 6, 5, 2, -16 },
  { 131, 7, 19, 7, 1, -16 },
  { 148, 8, 19, 7, -2, -16 },
  { 167, 10, 11, 12, 2, -17 },
  { 181, 11, 11, 13, 1, -13 },
  { 197, 5, 6, 6, -1, -3 },
  { 201, 6, 2, 7, 0, -7 },
  { 203, 3, 3, 6, 0, -3 },
  { 205, 11, 16, 8, -1, -16 },
  { 227, 11, 16, 12, 1, -16 },
  { 249, 7, 16, 12, 3, -16 },
  { 263, 12, 16, 12, 0, -16 },
  { 287, 12, 16, 12, 0, -16 },
  { 311, 12, 16, 12, 0, -16 },
  { 335, 11, 16, 12, 1, -16 },
  { 357, 11, 16, 12, 1, -16 },
  { 379, 12, 16, 12, 1, -16 },
  { 403, 11, 16, 12, 1, -16 },
  { 425, 11, 16, 12, 1, -16 },
  { 447, 5, 12, 6, 0, -12 },
  { 455, 6, 15, 6, -1, -12 },
  { 467, 11, 11, 13, 1, -13 },
  { 483, 10, 6, 13, 2, -11 },
  { 491, 11, 11, 13, 1, -13 },
  { 507, 8, 16, 10, 2, -16 },
  { 523, 17, 18, 19, 1, -16 },
  { 562, 13, 16, 13, -1, -16 },
  { 588, 12, 16, 13, 1, -16 },
  { 612, 13, 16, 13, 1, -16 },
  { 638, 13, 16, 15, 1, -16 },
  { 664, 11, 16, 12, 1, -16 },
  { 686, 11, 16, 11, 1, -16 },
  { 708, 14, 16, 15, 1, -16 },
  { 736, 14, 16, 15, 1, -16 },
  { 764, 10, 16, 8, -1, -16 },
  { 784, 10, 20, 6, -3, -16 },
  { 809, 14, 16, 13, 1, -16 },
  { 837, 8, 16, 11, 1, -16 },
  { 853, 18, 16, 19, 1, -16 },
  { 889, 15, 16, 16, 1, -16 },
  { 919, 14, 16, 16, 1, -16 },
  { 947, 12, 16, 13, 1, -16 },
  { 971, 14, 20, 16, 1, -16 },
  { 1006, 12, 16, 13, 1, -16 },
  { 1030, 12, 16, 11, 0, -16 },
  { 1054, 11, 16, 11, 2, -16 },
  { 1076, 13, 16, 15, 2, -16 },
  { 1102, 12, 16, 12, 2, -16 },
  { 1126, 19, 16, 19, 2, -16 },
  { 1164, 15, 16, 12, -1, -16 },
  { 1194, 12, 16, 12, 2, -16 },
  { 1218, 13, 16, 12, 0, -16 },
  { 1244, 8, 19, 7, 0, -16 },
  { 1263, 5, 16, 8, 2, -16 },
  { 1273, 9, 19, 7, -2, -16 },
  { 1295, 11, 10, 12, 1, -16 },
  { 1309, 9, 1, 9, -2, 2 },
  { 1311, 4, 4, 6, 3, -17 },
  { 1313, 11, 12, 13, 1, -12 },
  { 1330, 11, 17, 13, 1, -17 },
  { 1354, 9, 12, 10, 1, -12 },
  { 1368, 12, 17, 13, 1, -17 },
  { 1394, 10, 12, 11, 1, -12 },
  { 1409, 12, 22, 7, -2, -17 },
  { 1442, 12, 17, 13, 0, -12 },
  { 1468, 11, 17, 13, 1, -17 },
  { 1492, 5, 16, 6, 1, -16 },
  { 1502, 9, 21, 6, -3, -16 },
  { 1526, 11, 17, 11, 1, -17 },
  { 1550, 5, 17, 6, 1, -17 },
  { 1561, 17, 12, 19, 1, -12 },
  { 1587, 12, 12, 13, 0, -12 },
  { 1605, 11, 12, 13, 1, -12 },
  { 1622, 13, 17, 13, -1, -12 },
  { 1650, 11, 17, 13, 1, -12 },
  { 1674, 9, 12, 9, 1, -12 },
  { 1688, 9, 12, 10, 0, -12 },
  { 1702, 7, 15, 8, 1, -15 },
  { 1716, 11, 12, 13, 1, -12 },
  { 1733, 11, 12, 11, 1, -12 },
  { 1750, 16, 12, 16, 1, -12 },
  { 1774, 13, 12, 11, -1, -12 },
  { 1794, 14, 17, 11, -2, -12 },
  { 1824, 10, 12, 10, 0, -12 },
  { 1839, 9, 19, 8, 0, -16 },
  { 1861, 2, 22, 12, 5, -17 },
  { 1867, 9, 19, 8, -1, -16 },
  { 1889, 11, 3, 13, 1, -9 },
};

const GFXfont NotoSans_MediumItalic22pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic22pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic22pt7bGlyphs,
  0x20, 0x7E, 30
};

#endif // _NOTOSANS_MEDIUMITALIC22PT7B_H_
