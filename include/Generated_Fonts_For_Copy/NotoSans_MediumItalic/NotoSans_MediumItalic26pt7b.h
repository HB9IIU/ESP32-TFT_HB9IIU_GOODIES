#ifndef _NOTOSANS_MEDIUMITALIC26PT7B_H_
#define _NOTOSANS_MEDIUMITALIC26PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 26pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic26pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x1C, 0x38, 0x71, 0xC3, 0x87, 0x0E, 0x18, 0x30, 0xE1, 0xC3,
  0x06, 0x00, 0x00, 0x71, 0xE1, 0xC0, 0x67, 0x67, 0xE7, 0xE6, 0xC6, 0xC6,
  0xCC, 0x01, 0x8C, 0x03, 0x8C, 0x03, 0x0C, 0x03, 0x18, 0x03, 0x18, 0x06,
  0x18, 0x7F, 0xFF, 0x7F, 0xFF, 0x0E, 0x30, 0x0C, 0x30, 0x0C, 0x60, 0x0C,
  0x62, 0xFF, 0xFC, 0xFF, 0xFC, 0x18, 0xC0, 0x30, 0xC0, 0x30, 0xC0, 0x31,
  0x80, 0x71, 0x80, 0x00, 0xC0, 0x04, 0x00, 0x70, 0x1F, 0xF1, 0xFF, 0x1C,
  0xC8, 0xE4, 0x07, 0x60, 0x3B, 0x00, 0xF8, 0x03, 0xE0, 0x07, 0xC0, 0x6E,
  0x03, 0x30, 0x19, 0x90, 0x9C, 0xFF, 0xE7, 0xFC, 0x0F, 0x80, 0x18, 0x00,
  0x80, 0x0C, 0x00, 0x1C, 0x01, 0x8F, 0xC0, 0xC7, 0x70, 0x71, 0x8C, 0x38,
  0xE3, 0x0C, 0x30, 0xC6, 0x0C, 0x33, 0x83, 0x1D, 0xC0, 0xC6, 0x6F, 0xBB,
  0xB7, 0xFF, 0xDD, 0x8C, 0xEE, 0xE3, 0x03, 0x30, 0xC1, 0x8C, 0x30, 0xE3,
  0x1C, 0x30, 0xC6, 0x18, 0x33, 0x8C, 0x0F, 0xC7, 0x01, 0xE0, 0x01, 0xC0,
  0x07, 0xF0, 0x0F, 0x78, 0x0C, 0x38, 0x1C, 0x38, 0x1C, 0x38, 0x0C, 0x70,
  0x0F, 0xE0, 0x07, 0x80, 0x1F, 0x00, 0x3F, 0x87, 0x71, 0xC6, 0xE1, 0xCE,
  0xE0, 0xFC, 0xE0, 0x78, 0xE0, 0x70, 0xF1, 0xF8, 0x7F, 0xDC, 0x3F, 0x1E,
  0x6F, 0xFD, 0xB0, 0x03, 0x83, 0x81, 0x81, 0x81, 0xC0, 0xC0, 0xE0, 0x60,
  0x70, 0x30, 0x18, 0x1C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x38,
  0x1C, 0x06, 0x03, 0x00, 0xC0, 0x06, 0x03, 0x80, 0xC0, 0x60, 0x38, 0x1C,
  0x0E, 0x07, 0x03, 0x81, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x1C, 0x0E, 0x0E,
  0x07, 0x07, 0x03, 0x03, 0x83, 0x83, 0x80, 0x06, 0x00, 0x70, 0x06, 0x0C,
  0x60, 0xF6, 0x07, 0xFF, 0x0F, 0xF1, 0xE1, 0x36, 0x0F, 0x30, 0x63, 0x02,
  0x38, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x06, 0x0F, 0xFF, 0xFF, 0xF0,
  0x60, 0x06, 0x00, 0x60, 0x06, 0x00, 0x60, 0x39, 0xDC, 0xE6, 0x60, 0xFF,
  0xF0, 0x7F, 0x70, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0, 0x0E, 0x00,
  0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0x80, 0x1C, 0x01, 0xC0,
  0x0E, 0x00, 0xE0, 0x07, 0x00, 0x70, 0x03, 0x00, 0x38, 0x00, 0x03, 0xC0,
  0x7F, 0x87, 0xFC, 0x38, 0x73, 0x83, 0x9C, 0x1D, 0xC0, 0xEE, 0x07, 0x70,
  0x3B, 0x01, 0xF8, 0x0F, 0xC0, 0xEE, 0x07, 0x70, 0x3B, 0x83, 0x8C, 0x1C,
  0x71, 0xC3, 0xFC, 0x0F, 0xC0, 0x03, 0x83, 0xC7, 0xC7, 0xEF, 0x73, 0x38,
  0x1C, 0x0C, 0x0E, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0xE0, 0x70, 0x38, 0x18,
  0x1C, 0x0E, 0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xFF, 0x83, 0x07, 0x00, 0x1C,
  0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x70, 0x03, 0xC0, 0x1E, 0x00, 0xF0,
  0x07, 0x80, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0xFF, 0xCF, 0xFF,
  0x00, 0x03, 0xE0, 0x3F, 0xE1, 0xF7, 0x82, 0x07, 0x00, 0x1C, 0x00, 0x70,
  0x03, 0x80, 0x1E, 0x07, 0xE0, 0x3E, 0x00, 0xFE, 0x00, 0x1C, 0x00, 0x70,
  0x00, 0xC0, 0x07, 0x00, 0x1C, 0xC0, 0xF3, 0xFF, 0x87, 0xF8, 0x00, 0x00,
  0x1C, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x01, 0xF8, 0x0E, 0xE0, 0x33, 0x01,
  0xCC, 0x0E, 0x70, 0x71, 0xC3, 0x87, 0x1C, 0x18, 0x60, 0x63, 0xFF, 0xFF,
  0xFF, 0x80, 0x38, 0x00, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x0F, 0xF8, 0x7F,
  0xC3, 0xFE, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0, 0x07, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x38, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0x80, 0x1C, 0xC1,
  0xE7, 0xFE, 0x3F, 0xC0, 0x00, 0xF8, 0x1F, 0xC1, 0xF6, 0x1C, 0x01, 0xC0,
  0x1C, 0x00, 0xE0, 0x0E, 0x78, 0x77, 0xE3, 0xFF, 0x9C, 0x1C, 0xE0, 0xEE,
  0x07, 0x70, 0x39, 0x81, 0xCE, 0x1C, 0x71, 0xE1, 0xFE, 0x07, 0xE0, 0x7F,
  0xFB, 0xFF, 0xDF, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38,
  0x03, 0x80, 0x38, 0x01, 0xC0, 0x1C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x07,
  0x00, 0x70, 0x03, 0x80, 0x38, 0x00, 0x03, 0xC0, 0x7F, 0x87, 0xDE, 0x38,
  0x71, 0x83, 0x8C, 0x1C, 0x70, 0xE3, 0x8E, 0x0F, 0xE0, 0x7C, 0x0F, 0x70,
  0xE1, 0xCE, 0x07, 0x70, 0x3B, 0x81, 0xDC, 0x0E, 0xF0, 0xE3, 0xFE, 0x0F,
  0xE0, 0x03, 0xC0, 0x7F, 0x07, 0xBC, 0x70, 0xE3, 0x03, 0xB8, 0x1D, 0xC0,
  0xEE, 0x07, 0x70, 0x73, 0xC7, 0x8F, 0xFC, 0x3E, 0xE0, 0x07, 0x00, 0x70,
  0x03, 0x80, 0x38, 0x83, 0x87, 0xF8, 0x3F, 0x80, 0x1C, 0x71, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1C, 0xF1, 0xC0, 0x0E, 0x1C, 0x38, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x01, 0xC3, 0x8E, 0x18, 0x70, 0xC0, 0x00, 0x10,
  0x07, 0x01, 0xF0, 0x7C, 0x1F, 0x07, 0x80, 0xE0, 0x0F, 0x00, 0x7E, 0x00,
  0xF8, 0x03, 0xE0, 0x0F, 0x00, 0x10, 0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x80, 0x0E, 0x00, 0xF8, 0x03, 0xE0, 0x0F,
  0x80, 0x3E, 0x00, 0xF0, 0x0F, 0x07, 0xC1, 0xF0, 0xFC, 0x0E, 0x00, 0x80,
  0x00, 0x1F, 0x3F, 0xE7, 0xFD, 0x07, 0x01, 0xC0, 0x70, 0x1C, 0x0E, 0x0F,
  0x07, 0x83, 0xC0, 0xC0, 0x30, 0x10, 0x00, 0x00, 0x00, 0xF0, 0x3C, 0x0E,
  0x00, 0x00, 0x08, 0x00, 0x0F, 0xFC, 0x01, 0xF0, 0xF0, 0x1C, 0x01, 0xC1,
  0xC0, 0x07, 0x1C, 0x08, 0x18, 0xC3, 0xFC, 0xCE, 0x3C, 0xC7, 0x63, 0x86,
  0x3B, 0x18, 0x71, 0xB9, 0xC3, 0x0D, 0xCE, 0x18, 0x6E, 0x61, 0xC7, 0x73,
  0x8E, 0x33, 0x8F, 0xFF, 0x8C, 0x7C, 0xF0, 0x60, 0x00, 0x01, 0x80, 0x00,
  0x0E, 0x00, 0x80, 0x3F, 0xFC, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x6C, 0x00, 0xEC, 0x00, 0xCC, 0x01, 0xCC, 0x01,
  0x8C, 0x03, 0x8E, 0x03, 0x0E, 0x07, 0x0E, 0x0F, 0xFE, 0x0F, 0xFE, 0x1F,
  0xFE, 0x1C, 0x06, 0x38, 0x06, 0x38, 0x06, 0x70, 0x07, 0xF0, 0x07, 0x0F,
  0x80, 0x3F, 0xE1, 0xFF, 0xC7, 0x07, 0x1C, 0x0C, 0x70, 0x31, 0x81, 0xCE,
  0x0F, 0x3F, 0xF0, 0xFF, 0x83, 0x8F, 0x0C, 0x0E, 0x70, 0x39, 0xC0, 0xE7,
  0x03, 0x98, 0x0E, 0xE1, 0xF3, 0xFF, 0x8F, 0xF8, 0x00, 0x01, 0xF8, 0x0F,
  0xFC, 0x3F, 0xF0, 0xF0, 0x23, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07, 0x00, 0x0E, 0x00, 0x1C, 0x00, 0x38,
  0x00, 0x78, 0x00, 0x78, 0x20, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xC0, 0x0F,
  0xF8, 0x1F, 0xFC, 0x1C, 0x1E, 0x1C, 0x0E, 0x1C, 0x0E, 0x18, 0x07, 0x38,
  0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70,
  0x1C, 0x70, 0x3C, 0x60, 0x78, 0xE3, 0xF0, 0xFF, 0xE0, 0xFF, 0x00, 0x0F,
  0xFC, 0x3F, 0xE1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E,
  0x00, 0x3F, 0xF0, 0xFF, 0x83, 0xFE, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x18, 0x00, 0xE0, 0x03, 0xFF, 0x0F, 0xFC, 0x00, 0x0F, 0xFC, 0x3F,
  0xE1, 0xFF, 0x87, 0x00, 0x1C, 0x00, 0x70, 0x01, 0x80, 0x0E, 0x00, 0x38,
  0x00, 0xFF, 0x83, 0xFE, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18,
  0x00, 0xE0, 0x03, 0x80, 0x0E, 0x00, 0x00, 0x01, 0xF8, 0x0F, 0xFC, 0x3F,
  0xF8, 0xF0, 0x13, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xE0, 0x01,
  0xC1, 0xFB, 0x83, 0xF7, 0x00, 0xEE, 0x01, 0xDC, 0x03, 0x38, 0x0E, 0x78,
  0x1C, 0x78, 0x38, 0x7F, 0xF0, 0x7F, 0xC0, 0x0E, 0x03, 0x86, 0x01, 0xC7,
  0x00, 0xE3, 0x80, 0x61, 0xC0, 0x70, 0xE0, 0x38, 0x60, 0x1C, 0x70, 0x0C,
  0x3F, 0xFE, 0x1F, 0xFF, 0x0F, 0xFF, 0x86, 0x01, 0xC7, 0x00, 0xC3, 0x80,
  0xE1, 0xC0, 0x70, 0xE0, 0x38, 0xE0, 0x1C, 0x70, 0x0C, 0x38, 0x0E, 0x00,
  0x0F, 0xE1, 0xFC, 0x1E, 0x01, 0xC0, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x07,
  0x00, 0xC0, 0x38, 0x07, 0x00, 0xE0, 0x18, 0x07, 0x00, 0xE0, 0x1C, 0x0F,
  0xE3, 0xFC, 0x00, 0x00, 0x70, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0E,
  0x00, 0xE0, 0x1C, 0x01, 0xC0, 0x1C, 0x01, 0xC0, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x80, 0x38, 0x03, 0x00, 0x70, 0x07, 0x00, 0x70, 0x0E, 0x09, 0xE0,
  0xFC, 0x0F, 0x80, 0x0E, 0x07, 0x0C, 0x0E, 0x1C, 0x1C, 0x1C, 0x38, 0x1C,
  0x78, 0x1C, 0xF0, 0x19, 0xE0, 0x3B, 0xC0, 0x3B, 0x80, 0x3F, 0x80, 0x3F,
  0x80, 0x39, 0xC0, 0x71, 0xC0, 0x71, 0xC0, 0x70, 0xE0, 0x60, 0xE0, 0xE0,
  0x70, 0xE0, 0x70, 0xE0, 0x78, 0x0E, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x07,
  0x01, 0x80, 0xE0, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01,
  0x80, 0xE0, 0x3F, 0xFF, 0xFC, 0x0F, 0x00, 0x78, 0x78, 0x03, 0xC7, 0xC0,
  0x3E, 0x3E, 0x01, 0xF1, 0xB0, 0x1B, 0x0D, 0x81, 0xD8, 0x6C, 0x0D, 0xC7,
  0x60, 0xEE, 0x3B, 0x06, 0x71, 0xDC, 0x73, 0x0C, 0xE3, 0x38, 0x63, 0x39,
  0xC7, 0x19, 0x8E, 0x38, 0xDC, 0x71, 0x86, 0xC3, 0x0C, 0x3E, 0x38, 0xE1,
  0xE1, 0xC7, 0x0E, 0x0E, 0x38, 0x70, 0x60, 0x0E, 0x01, 0xC3, 0x80, 0x71,
  0xF0, 0x18, 0x7C, 0x06, 0x1B, 0x03, 0x86, 0xE0, 0xE1, 0xB8, 0x38, 0xE6,
  0x0C, 0x39, 0xC3, 0x0E, 0x31, 0xC3, 0x0E, 0x70, 0xC3, 0x9C, 0x70, 0x66,
  0x1C, 0x1D, 0x86, 0x07, 0xE1, 0x80, 0xF8, 0xE0, 0x3E, 0x38, 0x0F, 0x0E,
  0x01, 0xC0, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x3C, 0x0E, 0x38, 0x0F,
  0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x78, 0x78,
  0x3F, 0xF0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0xC1, 0xFF, 0x87, 0x07, 0x1C,
  0x1C, 0x70, 0x71, 0x81, 0xCE, 0x07, 0x38, 0x38, 0xE7, 0xE3, 0xFF, 0x0F,
  0xF0, 0x70, 0x01, 0xC0, 0x07, 0x00, 0x18, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x00, 0x01, 0xE0, 0x07, 0xFC, 0x1F, 0xFE, 0x3C, 0x0E, 0x38, 0x0F,
  0x70, 0x07, 0x70, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xE0, 0x07, 0xE0, 0x0E, 0xE0, 0x0E, 0xE0, 0x1C, 0xF0, 0x3C, 0x78, 0xF8,
  0x3F, 0xF0, 0x1F, 0xC0, 0x01, 0xC0, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x0F, 0x80, 0x3F, 0xC1, 0xFF, 0x87, 0x0F, 0x1C, 0x1C, 0x70, 0x71, 0x81,
  0xCE, 0x07, 0x38, 0x38, 0xFF, 0xC3, 0xFE, 0x0C, 0x70, 0x71, 0xC1, 0xC3,
  0x87, 0x0E, 0x1C, 0x38, 0xE0, 0x73, 0x81, 0xCE, 0x07, 0x80, 0x01, 0xF0,
  0x1F, 0xF0, 0xFF, 0x87, 0x02, 0x1C, 0x00, 0x70, 0x01, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07,
  0x00, 0x38, 0xC1, 0xE3, 0xFF, 0x07, 0xF8, 0x00, 0x7F, 0xFB, 0xFF, 0xFF,
  0xFE, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70,
  0x03, 0x00, 0x38, 0x01, 0xC0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0E, 0x00, 0x18, 0x07, 0x38, 0x07, 0x38, 0x07, 0x38, 0x06, 0x38,
  0x0E, 0x30, 0x0E, 0x70, 0x0E, 0x70, 0x0C, 0x70, 0x1C, 0x70, 0x1C, 0x60,
  0x1C, 0xE0, 0x1C, 0xE0, 0x18, 0xE0, 0x38, 0xE0, 0x38, 0xE0, 0x70, 0xF1,
  0xF0, 0x7F, 0xE0, 0x3F, 0xC0, 0xE0, 0x0F, 0xC0, 0x39, 0x80, 0x73, 0x01,
  0xC6, 0x03, 0x8E, 0x0E, 0x1C, 0x1C, 0x38, 0x70, 0x70, 0xE0, 0xE3, 0x81,
  0xC7, 0x03, 0x9C, 0x03, 0x38, 0x06, 0xE0, 0x0D, 0xC0, 0x1B, 0x00, 0x3E,
  0x00, 0x78, 0x00, 0xF0, 0x00, 0xC0, 0x70, 0x1F, 0x01, 0xC0, 0x6C, 0x0F,
  0x03, 0xB0, 0x3C, 0x0C, 0xC0, 0xF0, 0x73, 0x06, 0xC1, 0xCC, 0x1B, 0x0E,
  0x38, 0xEC, 0x38, 0xE3, 0x31, 0xC3, 0x9C, 0xC7, 0x0E, 0x63, 0x18, 0x3B,
  0x8E, 0xE0, 0xEC, 0x3B, 0x03, 0xF0, 0xFC, 0x0F, 0x83, 0xF0, 0x3E, 0x0F,
  0x80, 0xF0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x01, 0xC0, 0x00, 0x0E, 0x03,
  0x87, 0x03, 0xC1, 0x81, 0xC0, 0xE1, 0xC0, 0x71, 0xC0, 0x19, 0xC0, 0x0E,
  0xE0, 0x07, 0xE0, 0x01, 0xE0, 0x00, 0xE0, 0x00, 0xF8, 0x00, 0xEC, 0x00,
  0x77, 0x00, 0x73, 0x80, 0x71, 0xC0, 0x70, 0x70, 0x78, 0x38, 0x38, 0x1C,
  0x38, 0x07, 0x00, 0xE0, 0x1D, 0x80, 0xE7, 0x03, 0x9C, 0x1C, 0x70, 0xE0,
  0xC3, 0x83, 0x9C, 0x0E, 0xE0, 0x3B, 0x80, 0x7C, 0x01, 0xE0, 0x07, 0x80,
  0x1C, 0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xE0, 0x03, 0x80,
  0x00, 0x0F, 0xFE, 0x1F, 0xFC, 0x7F, 0xF8, 0x00, 0xE0, 0x03, 0x80, 0x0E,
  0x00, 0x38, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x00, 0x1C, 0x00, 0x78, 0x01,
  0xE0, 0x03, 0x80, 0x0E, 0x00, 0x38, 0x00, 0xF0, 0x01, 0xFF, 0xE3, 0xFF,
  0xC0, 0x0F, 0xC3, 0xF0, 0xF8, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x70, 0x18,
  0x06, 0x03, 0x80, 0xE0, 0x30, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x18, 0x06,
  0x03, 0x80, 0xE0, 0x3E, 0x0F, 0x80, 0xC6, 0x39, 0xCE, 0x31, 0x8C, 0x63,
  0x9C, 0xE3, 0x18, 0xC6, 0x39, 0xC6, 0x07, 0xC1, 0xF0, 0x7C, 0x07, 0x01,
  0x80, 0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0xC0,
  0x60, 0x18, 0x0E, 0x03, 0x80, 0xC0, 0x30, 0x0C, 0x1F, 0x0F, 0xC0, 0x03,
  0x00, 0x38, 0x01, 0xC0, 0x1B, 0x00, 0xD8, 0x0E, 0x60, 0x63, 0x07, 0x1C,
  0x30, 0x63, 0x83, 0x98, 0x0D, 0xC0, 0x70, 0xFF, 0xFF, 0xF0, 0xEE, 0x73,
  0x0F, 0x9C, 0x7F, 0x63, 0xC7, 0x8E, 0x1E, 0x70, 0x39, 0xC0, 0xC6, 0x07,
  0x38, 0x1C, 0xE0, 0x73, 0x83, 0xCE, 0x0E, 0x3C, 0x78, 0x7F, 0x60, 0xFB,
  0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0x67,
  0x87, 0x7E, 0x3E, 0x79, 0xE1, 0xCE, 0x0E, 0xE0, 0x77, 0x03, 0xB8, 0x1D,
  0xC1, 0xCE, 0x0E, 0xF0, 0xF7, 0x8F, 0x37, 0xF1, 0x9F, 0x00, 0x0F, 0xE3,
  0xFC, 0xF0, 0x9C, 0x07, 0x00, 0xE0, 0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03,
  0x80, 0x38, 0x47, 0xF8, 0x7F, 0x00, 0x00, 0x0E, 0x00, 0x18, 0x00, 0x30,
  0x00, 0xE0, 0x01, 0xC0, 0x03, 0x83, 0xE6, 0x0F, 0xEC, 0x3C, 0x78, 0x70,
  0xF1, 0xC0, 0xE3, 0x81, 0x8E, 0x07, 0x1C, 0x0E, 0x38, 0x1C, 0x70, 0x70,
  0xE0, 0xE1, 0xE3, 0xC1, 0xFD, 0x81, 0xF7, 0x00, 0x0F, 0xC1, 0xFE, 0x3C,
  0x73, 0x87, 0x70, 0x67, 0x1E, 0xFF, 0xCF, 0xF0, 0xE0, 0x0E, 0x00, 0xE0,
  0x07, 0x04, 0x7F, 0xC3, 0xF8, 0x00, 0x3C, 0x00, 0xFC, 0x03, 0x90, 0x07,
  0x00, 0x1C, 0x00, 0x38, 0x01, 0xFE, 0x07, 0xF8, 0x01, 0x80, 0x07, 0x00,
  0x0E, 0x00, 0x1C, 0x00, 0x30, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0x80, 0x07,
  0x00, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x00,
  0x0E, 0x00, 0xF8, 0x01, 0xE0, 0x00, 0x0F, 0x9C, 0x7F, 0x63, 0xC7, 0x8E,
  0x1E, 0x70, 0x39, 0xC0, 0xCE, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0xCE,
  0x0E, 0x3C, 0xF8, 0x7F, 0xE0, 0xF3, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC2,
  0x0E, 0x0F, 0xF8, 0x3F, 0x80, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01,
  0xC0, 0x0C, 0x00, 0x67, 0xC7, 0x7E, 0x3E, 0x39, 0xE1, 0xCE, 0x0E, 0xE0,
  0x77, 0x03, 0x38, 0x39, 0xC1, 0xCC, 0x0E, 0xE0, 0x77, 0x03, 0x38, 0x39,
  0x81, 0xC0, 0x1C, 0x70, 0xC0, 0x00, 0xE3, 0x8E, 0x38, 0xC7, 0x1C, 0x71,
  0xC6, 0x38, 0xE3, 0x8E, 0x00, 0x01, 0xC0, 0x70, 0x0C, 0x00, 0x00, 0x00,
  0x60, 0x38, 0x0E, 0x03, 0x80, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x60,
  0x38, 0x0E, 0x03, 0x80, 0xE0, 0x30, 0x1C, 0x07, 0x03, 0xC3, 0xE0, 0xF0,
  0x00, 0x0E, 0x00, 0x60, 0x07, 0x00, 0x38, 0x01, 0xC0, 0x0C, 0x00, 0xE0,
  0xE7, 0x0E, 0x38, 0xE1, 0xCE, 0x0C, 0xE0, 0xEE, 0x07, 0xE0, 0x3F, 0x81,
  0xDC, 0x0C, 0x70, 0xE3, 0x87, 0x0E, 0x38, 0x71, 0x81, 0xC0, 0x0E, 0x18,
  0x70, 0xE1, 0xC3, 0x0E, 0x1C, 0x38, 0x70, 0xC3, 0x87, 0x0E, 0x1C, 0x30,
  0xE1, 0xC3, 0x86, 0x00, 0x19, 0xE1, 0xE1, 0xFF, 0xBF, 0x8F, 0x9D, 0x9C,
  0x78, 0x78, 0x73, 0x83, 0x83, 0x38, 0x38, 0x19, 0xC1, 0xC1, 0xCE, 0x0E,
  0x0E, 0x70, 0x70, 0x73, 0x03, 0x03, 0x38, 0x38, 0x39, 0xC1, 0xC1, 0xCE,
  0x0E, 0x0E, 0x60, 0x70, 0x70, 0x39, 0xF1, 0xFF, 0xCF, 0x8E, 0x78, 0x73,
  0x83, 0xBC, 0x1D, 0xC0, 0xCE, 0x0E, 0x70, 0x73, 0x03, 0xB8, 0x1D, 0xC1,
  0xCE, 0x0E, 0x70, 0x70, 0x0F, 0xC0, 0xFF, 0x0F, 0x1C, 0xF0, 0x67, 0x03,
  0xB8, 0x1F, 0x80, 0xFC, 0x06, 0xE0, 0x77, 0x03, 0xB8, 0x38, 0xE3, 0xC7,
  0xFC, 0x0F, 0xC0, 0x06, 0x78, 0x1F, 0xF8, 0x3E, 0x78, 0x78, 0x70, 0xE0,
  0xE3, 0x81, 0xC7, 0x03, 0x8E, 0x07, 0x1C, 0x1C, 0x38, 0x38, 0xF0, 0xF1,
  0xE3, 0xC3, 0xFF, 0x06, 0x7C, 0x0C, 0x00, 0x38, 0x00, 0x70, 0x00, 0xE0,
  0x01, 0x80, 0x07, 0x00, 0x00, 0x0F, 0x9C, 0x7F, 0x63, 0xC7, 0x8E, 0x1E,
  0x70, 0x39, 0xC0, 0xC6, 0x07, 0x38, 0x1C, 0xE0, 0x73, 0x83, 0x8E, 0x0E,
  0x3C, 0x78, 0x7F, 0xE0, 0xF3, 0x80, 0x0C, 0x00, 0x70, 0x01, 0xC0, 0x07,
  0x00, 0x1C, 0x00, 0xE0, 0x39, 0xCE, 0xF3, 0xF0, 0xF0, 0x38, 0x1C, 0x07,
  0x01, 0xC0, 0x70, 0x18, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x00, 0x0F, 0xC7,
  0xFC, 0xE1, 0x1C, 0x03, 0x80, 0x78, 0x07, 0xC0, 0x7C, 0x03, 0xC0, 0x38,
  0x07, 0x41, 0xCF, 0xF9, 0xFE, 0x00, 0x0C, 0x0E, 0x07, 0x0F, 0xFF, 0xF9,
  0xC0, 0xE0, 0x70, 0x30, 0x38, 0x1C, 0x0E, 0x06, 0x03, 0x03, 0x80, 0xF8,
  0x7C, 0x00, 0x38, 0x1C, 0xE0, 0x63, 0x83, 0x8E, 0x0E, 0x30, 0x39, 0xC0,
  0xC7, 0x07, 0x1C, 0x1C, 0x60, 0x73, 0x83, 0xCE, 0x0E, 0x3C, 0xF8, 0x7F,
  0x60, 0xFB, 0x80, 0xE0, 0x3F, 0x03, 0x98, 0x18, 0xC1, 0xC6, 0x1C, 0x30,
  0xE1, 0xCE, 0x0E, 0x70, 0x77, 0x03, 0xB8, 0x1D, 0x80, 0x7C, 0x03, 0xC0,
  0x1E, 0x00, 0xC1, 0xC1, 0xF0, 0x70, 0x7C, 0x3C, 0x3B, 0x0F, 0x0E, 0xC7,
  0xC3, 0x31, 0xB9, 0xCC, 0xEE, 0x63, 0x33, 0xB8, 0xDC, 0xEC, 0x36, 0x3F,
  0x0D, 0x87, 0xC3, 0xC1, 0xE0, 0xF0, 0x78, 0x38, 0x1C, 0x00, 0x1C, 0x1E,
  0x18, 0x78, 0x38, 0xE0, 0x33, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0xE0, 0x03,
  0xC0, 0x07, 0xC0, 0x1F, 0x80, 0x73, 0x81, 0xC7, 0x07, 0x06, 0x1E, 0x0E,
  0x00, 0x1C, 0x07, 0x0C, 0x0E, 0x0C, 0x0C, 0x0C, 0x1C, 0x0E, 0x18, 0x0E,
  0x38, 0x0E, 0x70, 0x0E, 0x70, 0x06, 0xE0, 0x06, 0xE0, 0x06, 0xC0, 0x07,
  0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x00, 0x06, 0x00, 0x0E, 0x00, 0x1C,
  0x00, 0xFC, 0x00, 0xF0, 0x00, 0x1F, 0xF1, 0xFE, 0x20, 0xE0, 0x1C, 0x03,
  0x80, 0x70, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x07, 0x04, 0xFF,
  0x8F, 0xF8, 0x00, 0x60, 0x78, 0x0F, 0x03, 0x80, 0x60, 0x0C, 0x01, 0x80,
  0x70, 0x0E, 0x01, 0x81, 0xF0, 0x78, 0x0F, 0x80, 0x70, 0x06, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xC0, 0x18, 0x03, 0x80, 0x78, 0x07, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x0C, 0x03, 0xC0, 0xF0,
  0x0C, 0x03, 0x00, 0xC0, 0x70, 0x1C, 0x07, 0x01, 0xC0, 0x78, 0x0F, 0x07,
  0xC3, 0x80, 0xC0, 0x30, 0x1C, 0x07, 0x01, 0x80, 0x60, 0x38, 0x3C, 0x0E,
  0x00, 0x78, 0x1F, 0xFF, 0x87, 0xF8, 0x1C,
};

const GFXglyph NotoSans_MediumItalic26pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 7, 0, -1 },
  { 1, 7, 19, 7, 0, -19 },
  { 18, 8, 7, 11, 3, -19 },
  { 25, 16, 19, 17, 1, -19 },
  { 63, 13, 22, 14, 1, -20 },
  { 99, 18, 19, 21, 2, -19 },
  { 142, 16, 19, 18, 1, -19 },
  { 180, 3, 7, 6, 3, -19 },
  { 183, 9, 23, 8, 1, -19 },
  { 209, 9, 23, 8, -2, -19 },
  { 235, 12, 12, 14, 3, -20 },
  { 253, 12, 12, 15, 2, -15 },
  { 271, 5, 6, 7, -1, -3 },
  { 275, 6, 2, 8, 1, -8 },
  { 277, 4, 3, 7, 0, -3 },
  { 279, 13, 19, 10, -1, -19 },
  { 310, 13, 19, 14, 1, -19 },
  { 341, 9, 19, 14, 3, -19 },
  { 363, 14, 19, 14, 0, -19 },
  { 397, 14, 19, 14, 0, -19 },
  { 431, 14, 19, 14, 0, -19 },
  { 465, 13, 19, 14, 1, -19 },
  { 496, 13, 19, 14, 1, -19 },
  { 527, 13, 19, 14, 2, -19 },
  { 558, 13, 19, 14, 1, -19 },
  { 589, 13, 19, 14, 1, -19 },
  { 620, 6, 14, 7, 0, -14 },
  { 631, 7, 17, 7, -1, -14 },
  { 646, 12, 13, 15, 2, -16 },
  { 666, 12, 7, 15, 2, -13 },
  { 677, 12, 13, 15, 2, -16 },
  { 697, 10, 19, 11, 2, -19 },
  { 721, 21, 21, 22, 1, -19 },
  { 777, 16, 19, 15, -2, -19 },
  { 815, 14, 19, 16, 1, -19 },
  { 849, 15, 19, 15, 2, -19 },
  { 885, 16, 19, 17, 1, -19 },
  { 923, 14, 19, 14, 1, -19 },
  { 957, 14, 19, 13, 1, -19 },
  { 991, 15, 19, 18, 2, -19 },
  { 1027, 17, 19, 18, 1, -19 },
  { 1068, 11, 19, 9, -1, -19 },
  { 1095, 12, 24, 8, -4, -19 },
  { 1131, 16, 19, 15, 1, -19 },
  { 1169, 10, 19, 13, 1, -19 },
  { 1193, 21, 19, 22, 1, -19 },
  { 1243, 18, 19, 19, 1, -19 },
  { 1286, 16, 19, 19, 2, -19 },
  { 1324, 14, 19, 15, 1, -19 },
  { 1358, 16, 23, 19, 2, -19 },
  { 1404, 14, 19, 15, 1, -19 },
  { 1438, 14, 19, 13, 0, -19 },
  { 1472, 13, 19, 13, 2, -19 },
  { 1503, 16, 19, 18, 2, -19 },
  { 1541, 15, 19, 15, 2, -19 },
  { 1577, 22, 19, 23, 3, -19 },
  { 1630, 17, 19, 14, -1, -19 },
  { 1671, 14, 19, 14, 2, -19 },
  { 1705, 15, 19, 14, 0, -19 },
  { 1741, 10, 23, 8, 0, -19 },
  { 1770, 5, 19, 10, 3, -19 },
  { 1782, 10, 23, 8, -2, -19 },
  { 1811, 13, 12, 15, 1, -19 },
  { 1831, 10, 2, 10, -2, 2 },
  { 1834, 4, 4, 8, 4, -20 },
  { 1836, 14, 14, 15, 1, -14 },
  { 1861, 13, 20, 15, 1, -20 },
  { 1894, 11, 14, 12, 1, -14 },
  { 1914, 15, 20, 15, 1, -20 },
  { 1952, 12, 14, 13, 1, -14 },
  { 1973, 15, 26, 9, -3, -20 },
  { 2022, 14, 20, 15, 1, -14 },
  { 2057, 13, 20, 15, 1, -20 },
  { 2090, 6, 19, 7, 1, -19 },
  { 2105, 10, 25, 7, -3, -19 },
  { 2137, 13, 20, 13, 1, -20 },
  { 2170, 7, 20, 7, 1, -20 },
  { 2188, 21, 14, 23, 1, -14 },
  { 2225, 13, 14, 15, 1, -14 },
  { 2248, 13, 14, 15, 1, -14 },
  { 2271, 15, 20, 15, -1, -14 },
  { 2309, 14, 20, 15, 1, -14 },
  { 2344, 10, 14, 11, 1, -14 },
  { 2362, 11, 14, 12, 0, -14 },
  { 2382, 9, 17, 9, 1, -17 },
  { 2402, 14, 14, 15, 1, -14 },
  { 2427, 13, 14, 12, 1, -14 },
  { 2450, 18, 14, 19, 2, -14 },
  { 2482, 15, 14, 13, -1, -14 },
  { 2509, 16, 20, 13, -2, -14 },
  { 2549, 12, 14, 12, 0, -14 },
  { 2570, 11, 23, 9, 0, -19 },
  { 2602, 3, 26, 14, 6, -20 },
  { 2612, 10, 23, 9, -1, -19 },
  { 2641, 12, 4, 15, 2, -11 },
};

const GFXfont NotoSans_MediumItalic26pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic26pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic26pt7bGlyphs,
  0x20, 0x7E, 35
};

#endif // _NOTOSANS_MEDIUMITALIC26PT7B_H_
