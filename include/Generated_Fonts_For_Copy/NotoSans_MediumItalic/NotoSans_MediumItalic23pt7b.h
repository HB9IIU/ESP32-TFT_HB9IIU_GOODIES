#ifndef _NOTOSANS_MEDIUMITALIC23PT7B_H_
#define _NOTOSANS_MEDIUMITALIC23PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 23pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic23pt7bBitmaps[] PROGMEM = {
  0x00, 0x0E, 0x38, 0x70, 0xE1, 0x83, 0x06, 0x1C, 0x30, 0x60, 0xC0, 0x00,
  0x0C, 0x3C, 0x70, 0x77, 0x66, 0x66, 0x66, 0x44, 0xC4, 0x03, 0x38, 0x18,
  0xC0, 0x63, 0x01, 0x88, 0x7F, 0xFD, 0xFF, 0xF0, 0xC6, 0x02, 0x30, 0x18,
  0xC0, 0x63, 0x0F, 0xFF, 0x8C, 0x60, 0x31, 0x80, 0xC4, 0x02, 0x30, 0x18,
  0xC0, 0x01, 0x00, 0x60, 0x7F, 0x9F, 0xF3, 0x20, 0x64, 0x0D, 0x81, 0xF0,
  0x1F, 0x00, 0xF0, 0x17, 0x06, 0x60, 0xDD, 0x13, 0x3F, 0xE3, 0xF0, 0x18,
  0x03, 0x00, 0x18, 0x02, 0x7C, 0x0C, 0x66, 0x18, 0xC6, 0x18, 0xC6, 0x30,
  0xC6, 0x60, 0xC6, 0xC0, 0xCC, 0xDE, 0xCD, 0xBF, 0xFB, 0x73, 0x76, 0x63,
  0x06, 0x63, 0x0C, 0x63, 0x18, 0xC6, 0x38, 0xE6, 0x30, 0x7C, 0x60, 0x78,
  0x03, 0x80, 0x3F, 0x81, 0xCE, 0x06, 0x18, 0x18, 0x60, 0x63, 0x81, 0xDC,
  0x03, 0xE0, 0x1E, 0x01, 0xFC, 0x36, 0x31, 0xB8, 0xEE, 0xC1, 0xF3, 0x03,
  0x8E, 0x1E, 0x3F, 0xFC, 0x7E, 0x38, 0x76, 0x66, 0x4C, 0x07, 0x0C, 0x18,
  0x38, 0x30, 0x70, 0x60, 0x60, 0xE0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0,
  0xC0, 0xC0, 0x60, 0x60, 0x60, 0x04, 0x06, 0x06, 0x03, 0x03, 0x03, 0x03,
  0x03, 0x03, 0x03, 0x03, 0x07, 0x06, 0x06, 0x0E, 0x0C, 0x1C, 0x18, 0x30,
  0x60, 0xE0, 0x04, 0x00, 0xE0, 0x18, 0x23, 0x0F, 0x60, 0x3F, 0xC3, 0xF8,
  0xF0, 0x73, 0x0C, 0x60, 0x8E, 0x00, 0x06, 0x00, 0xC0, 0x18, 0x03, 0x00,
  0x61, 0xFF, 0xFF, 0xF8, 0x30, 0x06, 0x00, 0xC0, 0x18, 0x00, 0x39, 0x9C,
  0xC6, 0x60, 0xFF, 0xE0, 0x6F, 0xE0, 0x00, 0x70, 0x0C, 0x01, 0xC0, 0x18,
  0x03, 0x80, 0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0xC0, 0x18, 0x03, 0x80,
  0x30, 0x07, 0x00, 0x60, 0x0E, 0x00, 0x03, 0x01, 0xF8, 0x73, 0x9C, 0x33,
  0x06, 0xE0, 0xD8, 0x1B, 0x03, 0xE0, 0x7C, 0x1F, 0x83, 0xF0, 0x7E, 0x0D,
  0xC3, 0x98, 0xE3, 0xF8, 0x3E, 0x00, 0x0F, 0x3E, 0x76, 0xEE, 0x4C, 0x0C,
  0x0C, 0x1C, 0x1C, 0x18, 0x18, 0x18, 0x38, 0x38, 0x30, 0x30, 0x03, 0x80,
  0xFE, 0x1E, 0xF0, 0x87, 0x00, 0x30, 0x03, 0x00, 0x70, 0x0E, 0x00, 0xC0,
  0x38, 0x07, 0x00, 0xE0, 0x1C, 0x03, 0x80, 0x70, 0x0F, 0xFE, 0xFF, 0xC0,
  0x03, 0x80, 0xFE, 0x1C, 0xF0, 0x83, 0x00, 0x30, 0x07, 0x00, 0x60, 0x1C,
  0x0F, 0x00, 0xFC, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x81, 0xCF, 0xFC,
  0x7F, 0x00, 0x00, 0x70, 0x0F, 0x01, 0xF0, 0x3E, 0x07, 0x60, 0xE6, 0x0C,
  0xE1, 0x8E, 0x30, 0xC7, 0x0C, 0xFF, 0xFF, 0xFF, 0x01, 0x80, 0x18, 0x01,
  0x80, 0x38, 0x1F, 0xE3, 0xFC, 0x60, 0x1C, 0x03, 0x00, 0x60, 0x0F, 0xC3,
  0xFC, 0x01, 0xC0, 0x18, 0x03, 0x00, 0x60, 0x1D, 0x07, 0x3F, 0xE7, 0xF0,
  0x00, 0xF0, 0x7E, 0x0F, 0x21, 0xC0, 0x38, 0x03, 0x00, 0x70, 0x06, 0xF8,
  0x7F, 0xC7, 0x0C, 0xE0, 0xEE, 0x0E, 0xE0, 0xCE, 0x0C, 0x61, 0xC7, 0xF8,
  0x3F, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0x00, 0xE0, 0x38, 0x06, 0x01, 0xC0,
  0x30, 0x0E, 0x03, 0x80, 0x60, 0x1C, 0x03, 0x00, 0xE0, 0x38, 0x07, 0x00,
  0x03, 0x80, 0xFE, 0x1C, 0xE3, 0x87, 0x38, 0x73, 0x86, 0x18, 0xE1, 0xFC,
  0x1F, 0x03, 0xB8, 0x61, 0xCE, 0x0C, 0xC0, 0xCC, 0x0C, 0xE1, 0xC7, 0xF8,
  0x3F, 0x00, 0x07, 0x03, 0xF8, 0xF7, 0x18, 0x77, 0x06, 0xC0, 0xD8, 0x1B,
  0x07, 0x71, 0xE7, 0xFC, 0x7B, 0x00, 0x60, 0x1C, 0x07, 0x01, 0xC7, 0xF8,
  0xFC, 0x00, 0x18, 0xF3, 0x84, 0x00, 0x00, 0x00, 0x00, 0x06, 0x3C, 0xE0,
  0x0C, 0x3C, 0x70, 0x40, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE1, 0x87, 0x0C,
  0x38, 0x60, 0x00, 0x20, 0x1C, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x3C, 0x01,
  0xF0, 0x07, 0x80, 0x3C, 0x01, 0x80, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xFF, 0xF0, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x78,
  0x3C, 0x1E, 0x1F, 0x03, 0x80, 0x00, 0x1C, 0x7F, 0x99, 0xC0, 0x70, 0x38,
  0x18, 0x1C, 0x1C, 0x1C, 0x1C, 0x1C, 0x0C, 0x00, 0x00, 0x03, 0x81, 0xC0,
  0xE0, 0x00, 0x03, 0xFE, 0x01, 0xE1, 0xC1, 0xC0, 0x18, 0xE0, 0x07, 0x30,
  0xFC, 0xD8, 0x7E, 0x36, 0x31, 0x8D, 0x18, 0x63, 0xC6, 0x18, 0xF1, 0x8C,
  0x3C, 0xC3, 0x1B, 0x19, 0xCE, 0xC7, 0xDF, 0x18, 0xC3, 0x06, 0x00, 0x00,
  0xE0, 0x20, 0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0xE0, 0x0F, 0x00, 0x7C,
  0x07, 0x60, 0x33, 0x03, 0x98, 0x18, 0xC1, 0xC6, 0x0C, 0x30, 0xFF, 0x87,
  0xFE, 0x70, 0x73, 0x03, 0xB8, 0x1F, 0x80, 0x7C, 0x03, 0x1F, 0xE0, 0xFF,
  0x86, 0x0E, 0x70, 0x73, 0x83, 0x9C, 0x38, 0xFF, 0x87, 0xF0, 0x71, 0xE3,
  0x83, 0x18, 0x1C, 0xC0, 0xE6, 0x06, 0x70, 0x73, 0xFF, 0x1F, 0xE0, 0x01,
  0xC0, 0x7F, 0xC7, 0xDC, 0x70, 0x07, 0x00, 0x30, 0x03, 0x80, 0x1C, 0x00,
  0xC0, 0x06, 0x00, 0x30, 0x01, 0x80, 0x0C, 0x00, 0x70, 0x03, 0xC1, 0x0F,
  0xF8, 0x3F, 0xC0, 0x1F, 0xE0, 0x7F, 0xC1, 0x83, 0x8E, 0x06, 0x38, 0x1C,
  0xE0, 0x73, 0x01, 0xCC, 0x07, 0x70, 0x19, 0xC0, 0x66, 0x03, 0x98, 0x1C,
  0x60, 0xF3, 0x87, 0x8F, 0xFC, 0x3F, 0xC0, 0x1F, 0xF1, 0xFE, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x3F, 0xC3, 0xFC, 0x7F, 0xC7, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xFF, 0x8F, 0xF8, 0x1F, 0xF1, 0xFE, 0x18, 0x03,
  0x80, 0x38, 0x03, 0x80, 0x30, 0x03, 0xFC, 0x7F, 0xC7, 0x00, 0x60, 0x06,
  0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x01, 0xE0, 0x7F, 0xC7, 0xDE,
  0x70, 0x07, 0x00, 0x38, 0x03, 0x80, 0x1C, 0x00, 0xC1, 0xFE, 0x0F, 0xB0,
  0x0D, 0x80, 0xEC, 0x07, 0x70, 0x33, 0xC1, 0x8F, 0xFC, 0x3F, 0xC0, 0x1C,
  0x0E, 0x30, 0x18, 0x60, 0x31, 0xC0, 0x63, 0x81, 0xC7, 0x03, 0x8F, 0xFE,
  0x1F, 0xFC, 0x7F, 0xF8, 0xE0, 0x71, 0x80, 0xE3, 0x01, 0x86, 0x03, 0x1C,
  0x0E, 0x38, 0x1C, 0x60, 0x30, 0x0F, 0xC1, 0xC0, 0x70, 0x18, 0x06, 0x01,
  0x80, 0xE0, 0x38, 0x0C, 0x03, 0x01, 0xC0, 0x70, 0x1C, 0x06, 0x07, 0xE3,
  0xF8, 0x00, 0xE0, 0x18, 0x03, 0x00, 0x60, 0x1C, 0x03, 0x80, 0x60, 0x0C,
  0x01, 0x80, 0x70, 0x0E, 0x01, 0x80, 0x30, 0x0E, 0x01, 0xC0, 0x38, 0x06,
  0x01, 0xC3, 0xF0, 0x7E, 0x02, 0x00, 0x1C, 0x1C, 0x60, 0xE1, 0x87, 0x0E,
  0x38, 0x39, 0xC0, 0xCE, 0x03, 0x70, 0x0F, 0xC0, 0x7F, 0x01, 0xCC, 0x06,
  0x38, 0x18, 0x60, 0x61, 0xC3, 0x87, 0x0E, 0x0C, 0x30, 0x38, 0x1C, 0x0C,
  0x06, 0x07, 0x03, 0x81, 0xC0, 0xC0, 0x60, 0x70, 0x38, 0x18, 0x0C, 0x06,
  0x07, 0x03, 0xFF, 0xFF, 0x1E, 0x01, 0xE3, 0xC0, 0x78, 0x78, 0x1F, 0x1F,
  0x03, 0x63, 0x60, 0xFC, 0x6C, 0x1B, 0x0D, 0x87, 0x61, 0xB0, 0xCC, 0x73,
  0x33, 0x8C, 0x66, 0x71, 0x8D, 0x8C, 0x31, 0xB1, 0x86, 0x3C, 0x31, 0xC7,
  0x8E, 0x30, 0xE1, 0xC6, 0x1C, 0x30, 0x1C, 0x07, 0x1E, 0x06, 0x1E, 0x06,
  0x3E, 0x06, 0x37, 0x0E, 0x33, 0x0C, 0x33, 0x0C, 0x33, 0x8C, 0x71, 0x8C,
  0x61, 0xDC, 0x60, 0xD8, 0x60, 0xD8, 0x60, 0xF8, 0xE0, 0x78, 0xC0, 0x78,
  0xC0, 0x70, 0x03, 0xC0, 0x3F, 0xC1, 0xEF, 0x8E, 0x0E, 0x70, 0x1D, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xB0, 0x0E, 0xC0,
  0x3B, 0x81, 0xCF, 0x0F, 0x1F, 0xF8, 0x3F, 0x80, 0x1F, 0xE1, 0xFF, 0x18,
  0x73, 0x83, 0x38, 0x33, 0x83, 0x30, 0x73, 0x1E, 0x7F, 0xC7, 0xF0, 0x60,
  0x06, 0x00, 0x60, 0x0E, 0x00, 0xE0, 0x0C, 0x00, 0x03, 0xC0, 0x3F, 0xC1,
  0xEF, 0x8E, 0x0E, 0x70, 0x1D, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xC0, 0x1F,
  0x00, 0x7C, 0x01, 0xB0, 0x0E, 0xC0, 0x3B, 0x81, 0xCF, 0x0E, 0x1F, 0xF0,
  0x3F, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x70, 0x00, 0xE0, 0x1F, 0xE1, 0xFF,
  0x18, 0x73, 0x83, 0x38, 0x33, 0x87, 0x30, 0x73, 0xFE, 0x7F, 0x87, 0x38,
  0x63, 0x86, 0x18, 0x61, 0xCE, 0x0C, 0xE0, 0xEC, 0x0E, 0x03, 0xC0, 0xFF,
  0x1F, 0xF1, 0x80, 0x38, 0x03, 0x80, 0x18, 0x01, 0xE0, 0x0F, 0x00, 0x78,
  0x01, 0xC0, 0x0C, 0x00, 0xC0, 0x0C, 0x81, 0xCF, 0xF8, 0x7F, 0x00, 0xFF,
  0xFF, 0xFE, 0x0E, 0x00, 0xC0, 0x0C, 0x00, 0xC0, 0x1C, 0x01, 0xC0, 0x18,
  0x01, 0x80, 0x38, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x07, 0x00, 0x38,
  0x1C, 0xC0, 0x73, 0x01, 0x9C, 0x06, 0x70, 0x39, 0x80, 0xE6, 0x03, 0x38,
  0x0C, 0xE0, 0x33, 0x81, 0xCC, 0x07, 0x30, 0x18, 0xC0, 0xE3, 0x87, 0x07,
  0xFC, 0x0F, 0xC0, 0xE0, 0x3F, 0x03, 0xB8, 0x1D, 0xC1, 0xC6, 0x0C, 0x30,
  0xE1, 0x86, 0x0C, 0x70, 0x63, 0x03, 0x38, 0x19, 0x80, 0xFC, 0x07, 0xC0,
  0x1E, 0x00, 0xE0, 0x07, 0x00, 0xE0, 0x60, 0x7E, 0x0E, 0x06, 0xE0, 0xE0,
  0xEE, 0x1F, 0x0C, 0x61, 0xB1, 0xC6, 0x33, 0x18, 0x63, 0x33, 0x86, 0x63,
  0x30, 0x66, 0x33, 0x06, 0xE3, 0x70, 0x6C, 0x36, 0x06, 0xC3, 0xE0, 0x78,
  0x3C, 0x07, 0x83, 0xC0, 0x70, 0x38, 0x07, 0x03, 0x80, 0x0C, 0x0F, 0x0E,
  0x1C, 0x06, 0x18, 0x06, 0x30, 0x07, 0x70, 0x03, 0xE0, 0x03, 0xC0, 0x03,
  0x80, 0x07, 0xC0, 0x06, 0xC0, 0x0E, 0xC0, 0x1C, 0xE0, 0x38, 0x60, 0x30,
  0x70, 0x70, 0x70, 0xE0, 0x30, 0xE0, 0x76, 0x0E, 0x60, 0xC6, 0x1C, 0x73,
  0x83, 0x30, 0x36, 0x03, 0xE0, 0x3C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38,
  0x03, 0x00, 0x30, 0x07, 0x00, 0x1F, 0xF8, 0xFF, 0xC0, 0x1C, 0x01, 0xC0,
  0x0C, 0x00, 0xE0, 0x0E, 0x00, 0xE0, 0x0E, 0x00, 0x70, 0x07, 0x00, 0x70,
  0x07, 0x00, 0x30, 0x13, 0xFF, 0x1F, 0xF8, 0x0F, 0x86, 0x07, 0x03, 0x01,
  0x80, 0xC0, 0x60, 0x70, 0x30, 0x18, 0x0C, 0x0E, 0x06, 0x03, 0x01, 0x80,
  0xC0, 0xE0, 0x60, 0x3E, 0x1E, 0x00, 0xE3, 0x18, 0xC6, 0x38, 0xC6, 0x31,
  0x8C, 0x63, 0x8C, 0x63, 0x0F, 0x80, 0xC0, 0xE0, 0x70, 0x30, 0x18, 0x0C,
  0x0E, 0x06, 0x03, 0x01, 0x80, 0xC0, 0xE0, 0x60, 0x30, 0x18, 0x0C, 0x0E,
  0x1E, 0x1F, 0x00, 0x06, 0x00, 0xC0, 0x38, 0x07, 0x81, 0xB0, 0x33, 0x0C,
  0x61, 0x86, 0x60, 0xDC, 0x0F, 0x01, 0x80, 0xFF, 0xFF, 0xC0, 0xE6, 0x33,
  0x06, 0x01, 0xFB, 0x3D, 0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C,
  0xE0, 0xCE, 0x1C, 0xE3, 0xC7, 0xFC, 0x7D, 0x80, 0x1C, 0x03, 0x00, 0x60,
  0x1C, 0x03, 0x98, 0x6F, 0x8F, 0x39, 0xC3, 0x70, 0x6E, 0x0D, 0x81, 0xB0,
  0x76, 0x0F, 0xC1, 0xB8, 0x77, 0xFC, 0xDF, 0x00, 0x07, 0x07, 0xF3, 0xC9,
  0xC0, 0x70, 0x38, 0x0E, 0x03, 0x80, 0xE0, 0x38, 0x0E, 0x11, 0xFC, 0x3F,
  0x00, 0x00, 0x38, 0x01, 0x80, 0x0C, 0x00, 0x60, 0x67, 0x0F, 0xB8, 0xF7,
  0x8E, 0x1C, 0x70, 0xE3, 0x07, 0x38, 0x39, 0xC1, 0x8E, 0x0C, 0x70, 0xE3,
  0x8F, 0x0F, 0xF8, 0x7D, 0x80, 0x07, 0x07, 0xF3, 0x9D, 0xC3, 0x60, 0xD8,
  0xFF, 0xFB, 0xF0, 0xE0, 0x38, 0x0E, 0x09, 0xFE, 0x3F, 0x00, 0x00, 0x30,
  0x07, 0xC0, 0x3A, 0x03, 0x80, 0x18, 0x00, 0xC8, 0x3F, 0x80, 0x70, 0x03,
  0x00, 0x18, 0x00, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x00, 0xC0,
  0x0E, 0x00, 0x70, 0x03, 0x00, 0x18, 0x01, 0xC0, 0x5C, 0x03, 0xE0, 0x04,
  0x00, 0x06, 0x01, 0xFB, 0x3D, 0xE7, 0x0E, 0x70, 0xE6, 0x0E, 0xE0, 0xEE,
  0x0C, 0xE1, 0xCE, 0x1C, 0xE3, 0xC7, 0xFC, 0x7D, 0x80, 0x18, 0x03, 0x80,
  0x30, 0xCF, 0x0F, 0xE0, 0x10, 0x00, 0x1C, 0x03, 0x00, 0x60, 0x1C, 0x03,
  0x98, 0x6F, 0xCF, 0xB9, 0xC3, 0x70, 0x6E, 0x0D, 0x83, 0xB0, 0x76, 0x0D,
  0xC1, 0xB8, 0x36, 0x0E, 0xC1, 0x80, 0x18, 0x71, 0x80, 0x08, 0xC3, 0x0C,
  0x71, 0xC6, 0x18, 0x63, 0x8E, 0x30, 0xC0, 0x01, 0x80, 0x70, 0x18, 0x00,
  0x00, 0x80, 0xC0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0x18, 0x06, 0x03,
  0x80, 0xE0, 0x30, 0x0C, 0x07, 0x01, 0xC0, 0x60, 0xB8, 0x3C, 0x04, 0x00,
  0x1C, 0x01, 0x80, 0x18, 0x03, 0x80, 0x38, 0x13, 0x0E, 0x31, 0xC3, 0x38,
  0x77, 0x06, 0xE0, 0x7E, 0x07, 0xE0, 0xE6, 0x0E, 0x70, 0xE3, 0x0C, 0x38,
  0xC1, 0xC0, 0x1C, 0x61, 0x8E, 0x38, 0xC3, 0x0C, 0x71, 0xC6, 0x18, 0x63,
  0x8E, 0x30, 0xC0, 0x01, 0x83, 0x0D, 0xF3, 0xF3, 0xCF, 0xDC, 0xE3, 0xC3,
  0x70, 0xE0, 0xDC, 0x38, 0x76, 0x0E, 0x1D, 0x83, 0x06, 0x60, 0xC1, 0xB8,
  0x70, 0x6E, 0x1C, 0x3B, 0x06, 0x0E, 0xC1, 0x83, 0x00, 0x00, 0xC1, 0xBF,
  0x1F, 0x71, 0xC3, 0x38, 0x33, 0x83, 0x30, 0x73, 0x07, 0x70, 0x67, 0x06,
  0x70, 0xE6, 0x0E, 0xE0, 0xE0, 0x06, 0x03, 0xF8, 0xF7, 0x38, 0x76, 0x07,
  0xC0, 0xF8, 0x3F, 0x07, 0xE0, 0xFC, 0x1B, 0x87, 0x3F, 0xC3, 0xE0, 0x00,
  0x60, 0x6F, 0x83, 0xCE, 0x1C, 0x31, 0xC1, 0x8E, 0x0C, 0x60, 0x63, 0x07,
  0x18, 0x39, 0xC1, 0x8E, 0x1C, 0x7F, 0xC3, 0x7C, 0x38, 0x01, 0xC0, 0x0C,
  0x00, 0x60, 0x03, 0x00, 0x38, 0x00, 0x06, 0x01, 0xFB, 0x3D, 0xE7, 0x0E,
  0x70, 0xE6, 0x0E, 0xE0, 0xEE, 0x0C, 0xE1, 0xCE, 0x1C, 0xE3, 0xC7, 0xFC,
  0x7D, 0x80, 0x18, 0x03, 0x80, 0x38, 0x03, 0x00, 0x30, 0x03, 0x00, 0x01,
  0x9B, 0xCF, 0xE7, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60, 0x70, 0x38, 0x18,
  0x0C, 0x00, 0x06, 0x07, 0xF3, 0x98, 0xC0, 0x30, 0x0E, 0x01, 0xE0, 0x3C,
  0x03, 0x80, 0xE8, 0x33, 0xFC, 0xFE, 0x00, 0x18, 0x18, 0x38, 0xFF, 0x30,
  0x30, 0x70, 0x70, 0x60, 0x60, 0x60, 0xE0, 0xE0, 0xFC, 0x7C, 0x38, 0x73,
  0x07, 0x70, 0x67, 0x06, 0x60, 0xE6, 0x0E, 0x60, 0xCE, 0x0C, 0xE1, 0xCE,
  0x3C, 0x7F, 0xC7, 0xD8, 0xE0, 0xFC, 0x1B, 0x87, 0x30, 0xC6, 0x38, 0xC6,
  0x19, 0x83, 0x30, 0x6C, 0x0D, 0x81, 0xE0, 0x1C, 0x00, 0xE1, 0xC3, 0xF1,
  0xE1, 0xB8, 0xF1, 0xDC, 0xD8, 0xC6, 0x6C, 0xE3, 0x36, 0x61, 0xB3, 0x70,
  0xD9, 0xB0, 0x78, 0xD8, 0x3C, 0x78, 0x1C, 0x3C, 0x0E, 0x1C, 0x00, 0x1C,
  0x38, 0x63, 0x83, 0x38, 0x1F, 0x80, 0x78, 0x03, 0x80, 0x1C, 0x01, 0xF0,
  0x1D, 0x81, 0xCE, 0x1C, 0x31, 0xC1, 0xC0, 0x1C, 0x1C, 0x70, 0x60, 0xC3,
  0x83, 0x0C, 0x0C, 0x70, 0x31, 0x80, 0xCE, 0x03, 0x30, 0x0D, 0x80, 0x1E,
  0x00, 0x70, 0x01, 0xC0, 0x06, 0x00, 0x38, 0x00, 0xC0, 0x2E, 0x00, 0xF8,
  0x01, 0x00, 0x00, 0x3F, 0xC0, 0x70, 0x38, 0x0C, 0x06, 0x03, 0x81, 0xC0,
  0xE0, 0x30, 0x18, 0x0F, 0xF3, 0xFC, 0x03, 0x83, 0xC1, 0x81, 0xC0, 0xC0,
  0x60, 0x30, 0x38, 0x78, 0x70, 0x1C, 0x07, 0x03, 0x81, 0x80, 0xC0, 0x60,
  0x30, 0x18, 0x0E, 0x01, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x0E,
  0x0F, 0x81, 0xC0, 0xC0, 0x60, 0x30, 0x18, 0x0C, 0x07, 0x01, 0xC3, 0xE1,
  0x81, 0xC0, 0xC0, 0x60, 0x30, 0x38, 0x38, 0x3C, 0x18, 0x00, 0x38, 0x3F,
  0xE7, 0x1F, 0xC0, 0x40,
};

const GFXglyph NotoSans_MediumItalic23pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 6, 0, -1 },
  { 1, 7, 16, 6, 0, -16 },
  { 15, 8, 6, 9, 2, -16 },
  { 21, 14, 16, 15, 1, -16 },
  { 49, 11, 18, 13, 1, -17 },
  { 74, 16, 17, 19, 2, -17 },
  { 108, 14, 17, 16, 1, -17 },
  { 138, 4, 6, 5, 2, -16 },
  { 141, 8, 20, 7, 1, -16 },
  { 161, 8, 21, 7, -2, -17 },
  { 182, 11, 11, 13, 2, -18 },
  { 198, 11, 11, 13, 1, -14 },
  { 214, 5, 6, 6, -1, -3 },
  { 218, 6, 2, 7, 1, -7 },
  { 220, 4, 3, 6, 0, -3 },
  { 222, 12, 16, 9, -1, -16 },
  { 246, 11, 17, 13, 1, -17 },
  { 270, 8, 16, 13, 3, -16 },
  { 286, 12, 17, 13, 0, -17 },
  { 312, 12, 17, 13, 0, -17 },
  { 338, 12, 16, 13, 0, -16 },
  { 362, 11, 16, 13, 1, -16 },
  { 384, 12, 17, 13, 1, -17 },
  { 410, 11, 16, 13, 2, -16 },
  { 432, 12, 17, 13, 1, -17 },
  { 458, 11, 17, 13, 1, -17 },
  { 482, 6, 13, 6, 0, -13 },
  { 492, 7, 16, 6, -1, -13 },
  { 506, 11, 11, 13, 1, -14 },
  { 522, 10, 6, 13, 2, -11 },
  { 530, 11, 11, 13, 1, -14 },
  { 546, 9, 17, 10, 2, -17 },
  { 566, 18, 18, 20, 1, -16 },
  { 607, 13, 16, 13, -1, -16 },
  { 633, 13, 16, 14, 1, -16 },
  { 659, 13, 17, 14, 2, -17 },
  { 687, 14, 16, 15, 1, -16 },
  { 715, 12, 16, 12, 1, -16 },
  { 739, 12, 16, 11, 1, -16 },
  { 763, 13, 17, 16, 2, -17 },
  { 791, 15, 16, 16, 1, -16 },
  { 821, 10, 16, 8, -1, -16 },
  { 841, 11, 21, 7, -4, -16 },
  { 870, 14, 16, 13, 1, -16 },
  { 898, 9, 16, 11, 1, -16 },
  { 916, 19, 16, 20, 1, -16 },
  { 954, 16, 16, 17, 1, -16 },
  { 986, 14, 17, 17, 2, -17 },
  { 1016, 12, 16, 13, 1, -16 },
  { 1040, 14, 21, 17, 2, -17 },
  { 1077, 12, 16, 14, 1, -16 },
  { 1101, 12, 17, 12, 0, -17 },
  { 1127, 12, 16, 12, 2, -16 },
  { 1151, 14, 16, 16, 2, -16 },
  { 1179, 13, 16, 13, 2, -16 },
  { 1205, 20, 16, 20, 2, -16 },
  { 1245, 16, 16, 13, -1, -16 },
  { 1277, 12, 16, 12, 2, -16 },
  { 1301, 13, 16, 12, 0, -16 },
  { 1327, 9, 20, 7, 0, -16 },
  { 1350, 5, 16, 9, 2, -16 },
  { 1360, 9, 20, 7, -2, -16 },
  { 1383, 11, 11, 13, 1, -17 },
  { 1399, 9, 2, 9, -2, 2 },
  { 1402, 4, 4, 7, 3, -18 },
  { 1404, 12, 13, 13, 1, -13 },
  { 1424, 11, 17, 13, 1, -17 },
  { 1448, 10, 13, 11, 1, -13 },
  { 1465, 13, 17, 13, 1, -17 },
  { 1493, 10, 13, 12, 1, -13 },
  { 1510, 13, 24, 8, -3, -18 },
  { 1549, 12, 19, 13, 1, -13 },
  { 1578, 11, 17, 13, 1, -17 },
  { 1602, 6, 17, 6, 1, -17 },
  { 1615, 10, 23, 6, -3, -17 },
  { 1644, 12, 17, 12, 1, -17 },
  { 1670, 6, 17, 6, 1, -17 },
  { 1683, 18, 13, 20, 1, -13 },
  { 1713, 12, 13, 13, 0, -13 },
  { 1733, 11, 13, 13, 1, -13 },
  { 1751, 13, 19, 13, -1, -13 },
  { 1782, 12, 19, 13, 1, -13 },
  { 1811, 9, 13, 9, 1, -13 },
  { 1826, 10, 13, 10, 0, -13 },
  { 1843, 8, 15, 8, 1, -15 },
  { 1858, 12, 12, 13, 1, -12 },
  { 1876, 11, 12, 11, 1, -12 },
  { 1893, 17, 12, 17, 1, -12 },
  { 1919, 13, 12, 11, -1, -12 },
  { 1939, 14, 18, 11, -2, -12 },
  { 1971, 10, 12, 10, 0, -12 },
  { 1986, 9, 20, 8, 0, -16 },
  { 2009, 2, 22, 13, 6, -17 },
  { 2015, 9, 20, 8, -1, -16 },
  { 2038, 11, 4, 13, 1, -10 },
};

const GFXfont NotoSans_MediumItalic23pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic23pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic23pt7bGlyphs,
  0x20, 0x7E, 31
};

#endif // _NOTOSANS_MEDIUMITALIC23PT7B_H_
