#ifndef _NOTOSANS_MEDIUMITALIC48PT7B_H_
#define _NOTOSANS_MEDIUMITALIC48PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 48pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic48pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F,
  0x80, 0xFC, 0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x07, 0xC0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x78, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x7E, 0x03, 0xF8, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x0C, 0x00, 0x3E, 0x3F,
  0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C, 0x7C, 0x3C, 0x78, 0x3C, 0x78, 0x7C,
  0x78, 0x78, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x70, 0xF0, 0x70, 0x00, 0x07,
  0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x00, 0x03, 0xC0,
  0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F, 0x00, 0x01, 0xE0, 0x78,
  0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0, 0x1C, 0x01,
  0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFC, 0x01,
  0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E, 0x07, 0x80, 0x00, 0xF0,
  0x1C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x38, 0x0F,
  0x00, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00,
  0x38, 0x0F, 0x00, 0x01, 0xE0, 0x78, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0xF0, 0x3C, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x03,
  0xC0, 0x00, 0x78, 0x1F, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x01, 0xC0,
  0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0x07, 0xE3, 0x86, 0x07, 0xC7, 0x80,
  0x07, 0x87, 0x00, 0x0F, 0x87, 0x00, 0x0F, 0x87, 0x00, 0x07, 0x87, 0x00,
  0x07, 0xCE, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xF8,
  0x00, 0x1C, 0xFC, 0x00, 0x3C, 0x7C, 0x00, 0x38, 0x7C, 0x00, 0x38, 0x7C,
  0x00, 0x38, 0x7C, 0x80, 0x78, 0xF8, 0xE0, 0x71, 0xF8, 0xFE, 0x77, 0xF0,
  0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x01, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xC0,
  0xFF, 0xE0, 0x01, 0xE0, 0x3F, 0xF8, 0x00, 0xF0, 0x1F, 0x1E, 0x00, 0x78,
  0x0F, 0x87, 0xC0, 0x3E, 0x03, 0xC0, 0xF0, 0x0F, 0x00, 0xF0, 0x3C, 0x07,
  0x80, 0x7C, 0x0F, 0x03, 0xC0, 0x1E, 0x07, 0xC1, 0xF0, 0x07, 0x81, 0xE0,
  0x78, 0x01, 0xE0, 0x78, 0x3C, 0x00, 0x78, 0x1E, 0x1E, 0x00, 0x1E, 0x07,
  0x8F, 0x80, 0x0F, 0x83, 0xC3, 0xC7, 0xE1, 0xE0, 0xF1, 0xE3, 0xFC, 0x78,
  0x7C, 0xF1, 0xFF, 0x9E, 0x3E, 0x7C, 0xFF, 0xF7, 0xFF, 0x1E, 0x7C, 0x7C,
  0xFF, 0xCF, 0x1E, 0x0F, 0x1F, 0xC7, 0xCF, 0x83, 0xC1, 0xC3, 0xE3, 0xC0,
  0xF0, 0x00, 0xF0, 0xF0, 0x3C, 0x00, 0x78, 0x7C, 0x0F, 0x00, 0x3E, 0x1E,
  0x03, 0xC0, 0x1F, 0x07, 0x81, 0xF0, 0x07, 0x81, 0xE0, 0x78, 0x03, 0xC0,
  0x78, 0x1E, 0x01, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x07, 0x83, 0xC0, 0x3C,
  0x01, 0xE1, 0xF0, 0x1E, 0x00, 0x7C, 0xF8, 0x0F, 0x80, 0x0F, 0xFE, 0x03,
  0xC0, 0x03, 0xFF, 0x03, 0xE0, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0x80, 0x01,
  0xFC, 0x7E, 0x00, 0x07, 0xC0, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0xF8,
  0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x1F, 0x00, 0x01, 0xF1, 0xFC, 0x00, 0x07, 0xCF, 0xC0,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0xFF, 0xF0, 0x07, 0xC7, 0xF7, 0xC0, 0x3E, 0x3F,
  0x1F, 0x80, 0xF9, 0xF8, 0x3F, 0x07, 0xCF, 0xC0, 0x7E, 0x3F, 0x3E, 0x00,
  0xF8, 0xF8, 0xF8, 0x03, 0xF7, 0xC3, 0xE0, 0x07, 0xFF, 0x0F, 0x80, 0x0F,
  0xF8, 0x3E, 0x00, 0x3F, 0xC0, 0xF8, 0x00, 0x7E, 0x03, 0xF0, 0x07, 0xFC,
  0x0F, 0xE0, 0x7F, 0xF0, 0x1F, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xCF, 0xC0,
  0xFF, 0xFE, 0x1F, 0x80, 0xFF, 0xE0, 0x7F, 0x00, 0x3E, 0x79, 0xF3, 0xE7,
  0xCF, 0x1E, 0x3C, 0x71, 0xE3, 0xC7, 0x80, 0x00, 0x1F, 0x00, 0x3E, 0x00,
  0x7C, 0x00, 0xF8, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x07,
  0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0x78, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x1E, 0x00,
  0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0,
  0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x03,
  0xE0, 0x01, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x20, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80,
  0x00, 0x3C, 0x01, 0x00, 0xF0, 0x07, 0x03, 0xC0, 0x3F, 0x0E, 0x00, 0xFF,
  0x38, 0x03, 0xFF, 0xE0, 0x11, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0x01, 0xFF,
  0xFC, 0x0F, 0xE0, 0xF0, 0x7F, 0xC0, 0x03, 0xE7, 0x00, 0x1F, 0x1E, 0x00,
  0xF8, 0x78, 0x07, 0xE1, 0xF0, 0x0F, 0x03, 0xC0, 0x18, 0x0F, 0x80, 0x00,
  0x3E, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00,
  0xE0, 0x00, 0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E,
  0x00, 0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x03, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0E, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x38, 0x00, 0x00, 0x70, 0x00, 0x00, 0xE0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x07, 0x00, 0x00, 0x0E, 0x00, 0x00,
  0x1C, 0x00, 0x07, 0xC3, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8,
  0x7C, 0x1E, 0x07, 0x83, 0xC0, 0x7F, 0xFB, 0xFF, 0x9F, 0xFD, 0xFF, 0xE0,
  0x7D, 0xFB, 0xFF, 0xEF, 0xDF, 0x9C, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xF8, 0x01, 0xFF,
  0xFC, 0x03, 0xFD, 0xFC, 0x07, 0xF0, 0x7E, 0x07, 0xE0, 0x3E, 0x0F, 0xC0,
  0x3E, 0x0F, 0x80, 0x3F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7E, 0x00,
  0x3F, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0x7C, 0x00,
  0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xF8, 0x00,
  0x7C, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x7E, 0x07, 0xE0, 0x7E, 0x0F, 0xE0, 0x3F, 0xFF,
  0xC0, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x3F,
  0x00, 0x7F, 0x01, 0xFE, 0x03, 0xFE, 0x0F, 0xFE, 0x3F, 0xFE, 0x7F, 0xBC,
  0xFE, 0x7C, 0x7C, 0x7C, 0x30, 0x7C, 0x20, 0x7C, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0,
  0x01, 0xF0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF8, 0x0F, 0x80,
  0xFC, 0x07, 0x00, 0x3E, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x7F, 0xF8, 0x01, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x03, 0xFD, 0xFF, 0x03,
  0xC0, 0x3F, 0x01, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xC0, 0x01,
  0xFF, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x80,
  0x01, 0xF8, 0xF0, 0x07, 0xF0, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x9F, 0x00, 0x03,
  0xE7, 0x80, 0x01, 0xF3, 0xE0, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0x3E, 0x00,
  0x3E, 0x0F, 0x80, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xE0, 0x7C,
  0x01, 0xF0, 0x1F, 0x00, 0xF8, 0x07, 0x80, 0x7C, 0x03, 0xE0, 0x3E, 0x00,
  0xF8, 0x1F, 0x00, 0x3E, 0x07, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF,
  0xF8, 0x01, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x0C,
  0x00, 0x3F, 0x87, 0x80, 0x3F, 0x83, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x1F,
  0xFC, 0x00, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x1F, 0xFD, 0xE0, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC3, 0xE0, 0x1F,
  0x1F, 0xF0, 0x3E, 0xFF, 0xF0, 0x7F, 0xFF, 0xF0, 0xFF, 0x8F, 0xE3, 0xFC,
  0x07, 0xE7, 0xF0, 0x07, 0xCF, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x00,
  0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x01, 0xF3, 0xE0, 0x07,
  0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x80, 0x7C, 0x1F, 0x83, 0xF8,
  0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0x80, 0x3F, 0xFE, 0x00, 0x3F, 0xF0, 0x00,
  0x1F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0xF8,
  0x00, 0xFF, 0xFC, 0x01, 0xFF, 0xFE, 0x03, 0xF8, 0xFE, 0x07, 0xE0, 0x3F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x1F,
  0x07, 0xC0, 0x1F, 0x07, 0xC0, 0x3E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0xFC,
  0x03, 0xFB, 0xF8, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x07, 0xFF, 0xC0, 0x1F, 0xE7, 0xE0, 0x3F, 0x83, 0xF0, 0x3E, 0x01, 0xF8,
  0x7C, 0x00, 0xF8, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xFC, 0x01, 0xF8,
  0x7E, 0x03, 0xF0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0,
  0x07, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x01, 0xFF, 0xC0, 0x07, 0xFF, 0xC0,
  0x1F, 0xFF, 0xC0, 0x7F, 0xBF, 0xC1, 0xF8, 0x1F, 0x87, 0xE0, 0x1F, 0x8F,
  0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0,
  0x01, 0xF3, 0xE0, 0x03, 0xE7, 0xC0, 0x07, 0xCF, 0x80, 0x1F, 0x9F, 0x00,
  0x3F, 0x3F, 0x00, 0xFE, 0x7E, 0x03, 0xFC, 0x7F, 0xFF, 0xF0, 0xFF, 0xFF,
  0xE0, 0xFF, 0xF7, 0xC0, 0x7F, 0x8F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x20, 0x0F, 0xE0, 0x7F, 0xFF, 0x80, 0xFF,
  0xFE, 0x01, 0xFF, 0xF8, 0x03, 0xFF, 0xC0, 0x00, 0x01, 0x01, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x0F,
  0xC3, 0xF8, 0xFC, 0x3F, 0x0F, 0xC1, 0xC0, 0x00, 0x20, 0x07, 0xC0, 0x7E,
  0x03, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x1F, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x06, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF, 0x00,
  0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x00,
  0x0F, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x01, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xC0, 0xC0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x3F,
  0xF0, 0x01, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x0F, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x38, 0x00, 0x00, 0x40, 0x00, 0x00,
  0x01, 0xF0, 0x07, 0xFF, 0x8F, 0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xFF, 0xCE,
  0x03, 0xF2, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00,
  0x7C, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x07,
  0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF0, 0x00,
  0xFC, 0x00, 0x3F, 0x00, 0x0F, 0x80, 0x01, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x0F, 0xF8, 0x3F, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3C, 0x07,
  0xC0, 0x00, 0x00, 0x78, 0x3E, 0x00, 0xFF, 0x01, 0xE1, 0xF0, 0x0F, 0xFF,
  0x87, 0x87, 0x80, 0xFF, 0xFC, 0x0F, 0x3E, 0x07, 0xF3, 0xF0, 0x3C, 0xF0,
  0x3F, 0x03, 0xC0, 0xF3, 0xC0, 0xF0, 0x1E, 0x03, 0xDE, 0x07, 0xC0, 0x78,
  0x0F, 0x78, 0x1E, 0x01, 0xE0, 0x3D, 0xE0, 0xF0, 0x07, 0x80, 0xF7, 0x83,
  0xC0, 0x3C, 0x07, 0x9E, 0x0F, 0x00, 0xF0, 0x1E, 0xF8, 0x7C, 0x03, 0xC0,
  0x7B, 0xE1, 0xF0, 0x1F, 0x03, 0xCF, 0x87, 0xC0, 0x7C, 0x0F, 0x3E, 0x1F,
  0x03, 0xE0, 0x7C, 0x78, 0x3C, 0x1F, 0xC3, 0xE1, 0xE0, 0xFD, 0xFF, 0xBF,
  0x07, 0x83, 0xFF, 0x9F, 0xF8, 0x1E, 0x07, 0xFC, 0x7F, 0xC0, 0x7C, 0x07,
  0xC0, 0x7C, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x01, 0x80, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0x78, 0x00, 0x01, 0xF7, 0x80, 0x00,
  0x3E, 0x78, 0x00, 0x03, 0xE7, 0x80, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xC7,
  0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00,
  0x1F, 0x07, 0xC0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xC0, 0x07, 0xC0,
  0x3C, 0x00, 0x7C, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xE0,
  0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x0F, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x1F,
  0x1F, 0x80, 0x01, 0xF1, 0xF0, 0x00, 0x1F, 0x3F, 0x00, 0x01, 0xF3, 0xE0,
  0x00, 0x1F, 0x7E, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0x01, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3E,
  0x01, 0xFC, 0x07, 0xC0, 0x1F, 0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x3F,
  0x07, 0xC0, 0x07, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0xFE, 0x03, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00, 0x7C, 0x07,
  0xF8, 0x0F, 0x80, 0x3F, 0x01, 0xF0, 0x03, 0xF0, 0x7E, 0x00, 0x3E, 0x0F,
  0x80, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x3E, 0x00, 0x1F, 0x07, 0xC0, 0x03,
  0xE1, 0xF0, 0x00, 0xFC, 0x3E, 0x00, 0x3F, 0x87, 0xC0, 0x0F, 0xE0, 0xF8,
  0x07, 0xF8, 0x1F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3F, 0xE0,
  0x1C, 0x07, 0xF8, 0x00, 0x40, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x40, 0x3F, 0xC0, 0x38, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0x80, 0x01, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x3E, 0x03,
  0xFC, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E,
  0x07, 0xC0, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C, 0x0F,
  0x80, 0x03, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF0, 0xF8, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x7C, 0x3E, 0x00, 0x07, 0xE1, 0xF0, 0x00, 0x3F, 0x1F,
  0x80, 0x01, 0xF0, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0xFC, 0x3E, 0x00,
  0x0F, 0xC1, 0xF0, 0x00, 0xFE, 0x1F, 0x00, 0x0F, 0xE0, 0xF8, 0x00, 0xFE,
  0x07, 0xC0, 0x1F, 0xE0, 0x3E, 0x1F, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x01, 0x01, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xFF, 0xF0,
  0x1F, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE,
  0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0,
  0x1F, 0xFF, 0xFF, 0x01, 0xFF, 0x00, 0x78, 0x0F, 0xE0, 0x00, 0x80, 0xFE,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xE0,
  0x07, 0xFF, 0x3F, 0x00, 0x7F, 0xF9, 0xF8, 0x03, 0xFF, 0xCF, 0xC0, 0x1F,
  0xFE, 0x7E, 0x00, 0x03, 0xE3, 0xF0, 0x00, 0x1F, 0x1F, 0x80, 0x00, 0xF8,
  0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xFC,
  0x00, 0x1F, 0x07, 0xF0, 0x00, 0xF8, 0x1F, 0xC0, 0x0F, 0xC0, 0xFF, 0x80,
  0xFC, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x3F, 0xFE, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x03, 0xF0, 0x00, 0x7E, 0x07,
  0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x3E,
  0x00, 0x07, 0xC0, 0xFC, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01, 0xF0, 0x00,
  0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0x80, 0x01, 0xF0, 0x1F, 0x00, 0x03,
  0xE0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E,
  0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xF0, 0x1F, 0xFF, 0x01, 0xFF, 0xF0,
  0x07, 0xF8, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x1F, 0xF0, 0x0F, 0xFF, 0x80,
  0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03,
  0xF0, 0x08, 0x3F, 0xC0, 0x1F, 0xFE, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0x80,
  0x0F, 0xF8, 0x00, 0x00, 0x01, 0xF0, 0x01, 0xFC, 0x07, 0xC0, 0x0F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x03, 0xE0, 0x1F, 0xC0, 0x0F,
  0x80, 0xFE, 0x00, 0x3E, 0x03, 0xF0, 0x01, 0xF0, 0x1F, 0x80, 0x07, 0xC0,
  0xFC, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0x7C, 0x3F, 0x00, 0x01, 0xF1, 0xF8,
  0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x3E, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xE3, 0xE0, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8,
  0x1F, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x3E, 0x03,
  0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x7C, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0xC0,
  0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x7E, 0x03, 0xE0, 0x01, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x7E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x5F,
  0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF, 0xDF, 0xFF, 0xF8, 0x01, 0xFC, 0x00,
  0x01, 0xFE, 0x03, 0xF8, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x00, 0x0F, 0xF8,
  0x1F, 0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x7F, 0xC0,
  0x01, 0xFF, 0x80, 0xF7, 0x80, 0x03, 0xDF, 0x03, 0xEF, 0x00, 0x0F, 0xBC,
  0x07, 0xDE, 0x00, 0x1E, 0xF8, 0x0F, 0xBC, 0x00, 0x7D, 0xF0, 0x1E, 0x78,
  0x00, 0xF3, 0xE0, 0x7C, 0xF0, 0x03, 0xE7, 0xC0, 0xF9, 0xE0, 0x07, 0x8F,
  0x01, 0xF3, 0xC0, 0x1F, 0x3E, 0x03, 0xE7, 0xC0, 0x3C, 0x7C, 0x07, 0x8F,
  0x80, 0xF8, 0xF8, 0x1F, 0x0F, 0x01, 0xE1, 0xF0, 0x3E, 0x1E, 0x07, 0xC7,
  0xC0, 0x7C, 0x3C, 0x0F, 0x0F, 0x80, 0xF8, 0x78, 0x3C, 0x1F, 0x01, 0xE0,
  0xF0, 0xF8, 0x3E, 0x07, 0xC1, 0xE1, 0xE0, 0x7C, 0x0F, 0x83, 0xC7, 0xC1,
  0xF0, 0x1F, 0x07, 0x8F, 0x03, 0xE0, 0x3E, 0x0F, 0xBE, 0x07, 0xC0, 0x78,
  0x1F, 0x78, 0x0F, 0x81, 0xF0, 0x1F, 0xF0, 0x1F, 0x03, 0xE0, 0x3F, 0xC0,
  0x7C, 0x07, 0xC0, 0x7F, 0x80, 0xF8, 0x0F, 0x00, 0xFE, 0x01, 0xF0, 0x3E,
  0x01, 0xFC, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0,
  0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80,
  0xFC, 0x00, 0x07, 0xC0, 0xFF, 0x00, 0x07, 0xC0, 0x7F, 0x80, 0x03, 0xE0,
  0x3F, 0xC0, 0x01, 0xF0, 0x1F, 0xF0, 0x00, 0xF8, 0x0F, 0xF8, 0x00, 0x78,
  0x0F, 0xFC, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x3E, 0x03, 0xCF, 0x80, 0x1F,
  0x01, 0xE3, 0xE0, 0x0F, 0x81, 0xF1, 0xF0, 0x07, 0x80, 0xF8, 0xF8, 0x07,
  0xC0, 0x7C, 0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xF0, 0x1E, 0x0F, 0x80,
  0xF8, 0x1F, 0x03, 0xE0, 0xF8, 0x0F, 0x81, 0xF0, 0x7C, 0x07, 0xC0, 0xF8,
  0x3E, 0x03, 0xE0, 0x3E, 0x1F, 0x01, 0xE0, 0x1F, 0x0F, 0x81, 0xF0, 0x0F,
  0x8F, 0x80, 0xF8, 0x03, 0xE7, 0xC0, 0x7C, 0x01, 0xF3, 0xE0, 0x3E, 0x00,
  0x7D, 0xF0, 0x1E, 0x00, 0x3E, 0xF0, 0x1F, 0x00, 0x1F, 0x78, 0x0F, 0x80,
  0x07, 0xFC, 0x07, 0xC0, 0x03, 0xFE, 0x03, 0xC0, 0x01, 0xFF, 0x03, 0xE0,
  0x00, 0x7F, 0x01, 0xF0, 0x00, 0x3F, 0x80, 0xF8, 0x00, 0x1F, 0xC0, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xF0, 0x0F,
  0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x7E, 0x0F, 0xC0,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07, 0xCF, 0xC0, 0x00,
  0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7, 0xE0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x7E, 0xFC, 0x00,
  0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x1F, 0x80, 0x01,
  0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03, 0xFC, 0x0F, 0xF8,
  0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x80, 0x3F,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x07, 0xE0,
  0x3E, 0x00, 0xFC, 0x1F, 0x80, 0x1F, 0x07, 0xC0, 0x07, 0xC1, 0xF0, 0x01,
  0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0x83, 0xE0,
  0x07, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x01, 0xFC, 0x1F, 0x83, 0xFE, 0x07,
  0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xF0, 0x0F, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x7E, 0x0F, 0xC0, 0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x07,
  0xCF, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x00, 0x7C, 0xF8, 0x00, 0x01, 0xF7,
  0xE0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x7D, 0xF0,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x1F, 0xBF, 0x00, 0x00,
  0x7E, 0xFC, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E,
  0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0xFE, 0x03,
  0xFC, 0x0F, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xFC, 0x03, 0xE0, 0x3F, 0x80, 0xF8, 0x07, 0xE0, 0x3E, 0x00, 0xF8,
  0x1F, 0x80, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x03, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0x3E, 0x07, 0xF8, 0x1F, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x01,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0,
  0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x0F, 0x80, 0x3E, 0x03, 0xF0, 0x0F, 0x80,
  0x7C, 0x07, 0xE0, 0x1F, 0x01, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1F,
  0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7E,
  0x3E, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x07, 0xF0, 0x0E, 0x07, 0xE0,
  0x02, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x80, 0x07, 0xF0, 0xF0, 0x0F,
  0xE0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x00, 0x3F, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E,
  0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7E, 0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00,
  0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C,
  0x1F, 0x00, 0x03, 0xE1, 0xF8, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C,
  0x00, 0x0F, 0xC3, 0xE0, 0x00, 0x7C, 0x1F, 0x00, 0x03, 0xE0, 0xF8, 0x00,
  0x1F, 0x07, 0xC0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x81, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xEF, 0x80, 0x00, 0xFD, 0xF0, 0x00, 0x3F, 0x3E, 0x00, 0x07,
  0xC7, 0xC0, 0x01, 0xF8, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0,
  0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x03, 0xF0,
  0x1E, 0x00, 0x7C, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x0F, 0x80,
  0xFC, 0x01, 0xF0, 0x1F, 0x00, 0x3E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00,
  0xF8, 0x3F, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE1, 0xF8, 0x00, 0x3C, 0x3E,
  0x00, 0x07, 0x8F, 0x80, 0x00, 0xF1, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03,
  0xEF, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x1F, 0xFC,
  0x00, 0x3F, 0x00, 0x0F, 0xBE, 0x00, 0x1F, 0x80, 0x0F, 0xDF, 0x00, 0x1F,
  0xC0, 0x07, 0xCF, 0x80, 0x0F, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0xF0, 0x03,
  0xE3, 0xE0, 0x07, 0xF8, 0x01, 0xF1, 0xF0, 0x07, 0xFC, 0x01, 0xF0, 0xF8,
  0x03, 0xDE, 0x00, 0xF8, 0x7C, 0x03, 0xEF, 0x00, 0xFC, 0x3E, 0x01, 0xE7,
  0x80, 0x7C, 0x1F, 0x01, 0xF3, 0xC0, 0x7E, 0x0F, 0x80, 0xF9, 0xE0, 0x3E,
  0x07, 0xC0, 0xF8, 0xF0, 0x1F, 0x03, 0xE0, 0x7C, 0x78, 0x1F, 0x00, 0xF0,
  0x3C, 0x3C, 0x0F, 0x80, 0x78, 0x3E, 0x1F, 0x0F, 0x80, 0x3C, 0x1E, 0x0F,
  0x87, 0xC0, 0x1E, 0x1F, 0x07, 0xC7, 0xC0, 0x0F, 0x0F, 0x03, 0xE3, 0xE0,
  0x07, 0x8F, 0x81, 0xF1, 0xF0, 0x03, 0xC7, 0x80, 0xF9, 0xF0, 0x01, 0xE7,
  0xC0, 0x3C, 0xF8, 0x00, 0xF3, 0xE0, 0x1E, 0xF8, 0x00, 0x79, 0xE0, 0x0F,
  0x7C, 0x00, 0x3D, 0xF0, 0x07, 0xBC, 0x00, 0x1E, 0xF0, 0x03, 0xFE, 0x00,
  0x0F, 0xF8, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xFC,
  0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x1F,
  0xC0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x1F, 0x80, 0x1F, 0x80,
  0x1F, 0x80, 0x07, 0xC0, 0x0F, 0x80, 0x03, 0xE0, 0x0F, 0xC0, 0x01, 0xF8,
  0x0F, 0xC0, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x3E, 0x07, 0xC0, 0x00, 0x0F,
  0x87, 0xC0, 0x00, 0x07, 0xC7, 0xE0, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x00,
  0xFB, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xF7, 0xC0, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x01, 0xF8, 0xF8, 0x00,
  0x01, 0xF8, 0x7C, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x00, 0xF8, 0x0F, 0x80,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0xF8,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F,
  0x80, 0x3E, 0x00, 0x07, 0xC0, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0xFC, 0x00,
  0x1F, 0xDF, 0x00, 0x07, 0xC7, 0xC0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0x3E,
  0x00, 0x7C, 0x0F, 0x80, 0x3F, 0x03, 0xE0, 0x1F, 0x80, 0xF8, 0x07, 0xC0,
  0x1F, 0x03, 0xF0, 0x07, 0xC0, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x3F,
  0x00, 0x0F, 0x8F, 0x80, 0x03, 0xE7, 0xC0, 0x00, 0xFB, 0xF0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFC,
  0x03, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x01, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFC, 0x01, 0xFF,
  0x80, 0x3F, 0xE0, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x1F, 0xF8, 0x00, 0xF8, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F, 0x03, 0xC0, 0xF0,
  0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07,
  0xC0, 0xF0, 0x3C, 0x0F, 0x03, 0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0x78,
  0x1E, 0x07, 0xC1, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0xF0, 0x0F, 0xFC, 0x03,
  0xFF, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x0F, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0xC0,
  0x3F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x01, 0xE7, 0x80, 0x01, 0xE7, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xC3, 0xC0,
  0x07, 0x81, 0xE0, 0x07, 0x81, 0xE0, 0x0F, 0x01, 0xF0, 0x0F, 0x00, 0xF0,
  0x1E, 0x00, 0xF0, 0x1E, 0x00, 0x78, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0x3C,
  0x78, 0x00, 0x3C, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3,
  0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x7F, 0x07, 0x80, 0xFF, 0xC7, 0xC0, 0xFF,
  0xF3, 0xC0, 0xFF, 0xFD, 0xE0, 0xFE, 0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7E,
  0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F,
  0x80, 0x1F, 0x8F, 0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3,
  0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC,
  0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x7F, 0x07, 0xC0, 0x7F, 0x03, 0xF0, 0x7F,
  0x81, 0xFF, 0xFB, 0xC0, 0x7F, 0xF9, 0xE0, 0x3F, 0xF9, 0xF0, 0x07, 0xF0,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0xFE,
  0x00, 0xF8, 0xFF, 0x80, 0x7D, 0xFF, 0xE0, 0x3E, 0xFF, 0xF8, 0x1E, 0xE0,
  0xFC, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x1F, 0x87, 0xE0, 0x07, 0xC3, 0xF0,
  0x03, 0xE1, 0xF0, 0x01, 0xF1, 0xF8, 0x01, 0xF8, 0xF8, 0x00, 0xFC, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x8F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF8, 0x07, 0xE1,
  0xFC, 0x03, 0xF0, 0xFF, 0x07, 0xF0, 0x7B, 0xFF, 0xF0, 0x3D, 0xFF, 0xF0,
  0x1E, 0x7F, 0xF0, 0x1E, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0xFE, 0x06, 0x0F, 0xE0, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFF,
  0x80, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF0, 0x01, 0xFC, 0x3E, 0x00, 0xFF, 0xC7, 0x80, 0x3F, 0xFD, 0xF0,
  0x0F, 0xFF, 0xFE, 0x03, 0xF8, 0x3F, 0xC0, 0xFE, 0x03, 0xF8, 0x1F, 0x80,
  0x7E, 0x07, 0xE0, 0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x1F, 0x07,
  0xE0, 0x03, 0xE0, 0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x1F, 0x03, 0xE0, 0x03,
  0xE0, 0xFC, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xE0, 0x7C,
  0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x1F, 0x01, 0xFC,
  0x03, 0xF0, 0x7F, 0x80, 0x7F, 0xFE, 0xF0, 0x07, 0xFF, 0x9E, 0x00, 0xFF,
  0xE7, 0xC0, 0x07, 0xF0, 0xF0, 0x00, 0x00, 0x7F, 0xC0, 0x0F, 0xFF, 0x80,
  0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0xFE, 0x0F, 0x8F, 0xC0, 0x7C, 0x7C, 0x03,
  0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x01, 0xFC, 0xFF,
  0xFF, 0xC7, 0xFF, 0xFC, 0x7F, 0xFF, 0x83, 0xFF, 0xE0, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x04, 0x3F, 0x00, 0x60, 0xFF, 0xFF, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0,
  0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x8C, 0x00, 0x07, 0xC0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01,
  0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0x83, 0xC0, 0x3F, 0xF1, 0xF0, 0x1F, 0xFE, 0x78, 0x0F,
  0xFF, 0xDE, 0x07, 0xF0, 0x7F, 0x83, 0xF8, 0x0F, 0xE0, 0xFC, 0x03, 0xF0,
  0x7E, 0x00, 0xFC, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC3, 0xF0, 0x03,
  0xF0, 0xF8, 0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0x80, 0x0F, 0x87, 0xE0,
  0x03, 0xE1, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x3F, 0x07,
  0xC0, 0x0F, 0xC1, 0xF8, 0x07, 0xF0, 0x3E, 0x03, 0xF8, 0x0F, 0xC1, 0xFE,
  0x03, 0xFF, 0xFF, 0x80, 0x7F, 0xFB, 0xE0, 0x1F, 0xFC, 0xF8, 0x01, 0xFC,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x3E, 0x02, 0x00, 0x1F, 0x80, 0xE0, 0x0F, 0xC0,
  0x3F, 0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFC,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0xFF, 0x00, 0xF8, 0xFF, 0xC0, 0x7C, 0xFF, 0xF0, 0x3E, 0xFF,
  0xF8, 0x1E, 0xF0, 0xFC, 0x0F, 0xE0, 0x3E, 0x0F, 0xE0, 0x1F, 0x87, 0xF0,
  0x0F, 0x83, 0xF0, 0x07, 0xC1, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xFC,
  0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xF8,
  0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x00, 0x00, 0x60,
  0x07, 0x80, 0x7E, 0x03, 0xF0, 0x1F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xC0,
  0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x1C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00,
  0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x0F, 0xFC, 0x00, 0xFF,
  0xC0, 0x0F, 0xF8, 0x00, 0xFE, 0x00, 0x03, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xFC, 0x1F, 0x00, 0xFC,
  0x07, 0xC0, 0x7E, 0x01, 0xF0, 0x3F, 0x00, 0x7C, 0x1F, 0x80, 0x3F, 0x0F,
  0xC0, 0x0F, 0x87, 0xE0, 0x03, 0xE3, 0xF0, 0x00, 0xF9, 0xF8, 0x00, 0x3E,
  0xFC, 0x00, 0x1F, 0x7E, 0x00, 0x07, 0xDF, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xE7, 0xC0, 0x03, 0xF1, 0xF8,
  0x00, 0xF8, 0x3E, 0x00, 0x3E, 0x0F, 0xC0, 0x0F, 0x81, 0xF0, 0x07, 0xC0,
  0x7E, 0x01, 0xF0, 0x1F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x0F,
  0xC0, 0x1F, 0x03, 0xE0, 0x07, 0xE0, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0,
  0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x03, 0xC3, 0xF8, 0x07, 0xF0, 0x0F, 0x8F,
  0xF8, 0x3F, 0xF0, 0x1E, 0x7F, 0xF8, 0xFF, 0xF0, 0x3D, 0xFF, 0xF3, 0xFF,
  0xE0, 0x7B, 0xC3, 0xEF, 0x07, 0xE0, 0xFE, 0x03, 0xFC, 0x07, 0xC3, 0xF8,
  0x07, 0xF0, 0x0F, 0x87, 0xF0, 0x0F, 0xC0, 0x1F, 0x0F, 0xC0, 0x1F, 0x80,
  0x3E, 0x1F, 0x00, 0x3E, 0x00, 0xF8, 0x7E, 0x00, 0xFC, 0x01, 0xF0, 0xFC,
  0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xC0,
  0x0F, 0x87, 0xC0, 0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0xF8, 0x01, 0xF0,
  0x03, 0xE1, 0xF0, 0x07, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C,
  0x01, 0xF8, 0x7C, 0x01, 0xF0, 0x03, 0xE1, 0xF0, 0x03, 0xE0, 0x07, 0xC0,
  0x03, 0xC3, 0xFC, 0x03, 0xE7, 0xFF, 0x01, 0xF7, 0xFF, 0xC0, 0xF7, 0xFF,
  0xE0, 0x7B, 0xC3, 0xF0, 0x7F, 0xC0, 0xFC, 0x3F, 0xC0, 0x7E, 0x1F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xF0,
  0x03, 0xE1, 0xF0, 0x03, 0xF0, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x7E,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x3F, 0x0F, 0x80, 0x1F, 0x0F,
  0xC0, 0x0F, 0x87, 0xE0, 0x07, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x03, 0xF0,
  0xF8, 0x01, 0xF0, 0xFC, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x00, 0x00, 0x7F,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F,
  0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x1F, 0x9F, 0x80, 0x1F, 0x3E, 0x00, 0x3E,
  0xFC, 0x00, 0x7D, 0xF0, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x1F, 0xFC, 0x00, 0x3E, 0xF8, 0x00, 0x7D, 0xF0,
  0x01, 0xFB, 0xF0, 0x03, 0xE3, 0xE0, 0x0F, 0xC7, 0xC0, 0x3F, 0x0F, 0xE0,
  0xFE, 0x0F, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0xF0, 0xFE, 0x00, 0x3E, 0x3F, 0xE0, 0x07, 0x9F, 0xFE, 0x00,
  0xF7, 0xFF, 0xE0, 0x1E, 0xE0, 0xFC, 0x03, 0xF8, 0x0F, 0x80, 0xFE, 0x01,
  0xF8, 0x1F, 0x80, 0x1F, 0x03, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F,
  0x80, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x0F,
  0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7E, 0x0F, 0x80, 0x0F, 0xC1, 0xF0,
  0x01, 0xF0, 0x3E, 0x00, 0x7E, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x03, 0xF0,
  0x3F, 0xC1, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0xFB, 0xFF, 0xC0, 0x1E, 0x3F,
  0xF0, 0x07, 0xC3, 0xFC, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x7F,
  0x07, 0x80, 0xFF, 0xE7, 0xC0, 0xFF, 0xF3, 0xC0, 0xFF, 0xFD, 0xE0, 0xFE,
  0x0F, 0xF0, 0xFE, 0x03, 0xF8, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0xFC, 0x3E,
  0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x1F, 0x80, 0x1F, 0x8F, 0x80, 0x0F, 0x87,
  0xC0, 0x07, 0xC3, 0xE0, 0x03, 0xE3, 0xF0, 0x01, 0xF1, 0xF0, 0x01, 0xF8,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7E, 0x1F, 0x80, 0x7F,
  0x07, 0xC0, 0x7F, 0x03, 0xF0, 0x7F, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFB,
  0xE0, 0x3F, 0xF9, 0xF0, 0x07, 0xF1, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xC3, 0xF0,
  0x7C, 0xFF, 0x07, 0xDF, 0xE0, 0x79, 0xFE, 0x07, 0xBE, 0x20, 0x7F, 0x80,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF, 0xF0, 0xFF, 0xFF,
  0x0F, 0xC0, 0x61, 0xF8, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xFE, 0x00, 0x1F,
  0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x80, 0x0F, 0xCE, 0x01, 0xF8, 0xFF, 0xFF, 0x8F,
  0xFF, 0xF0, 0xFF, 0xFE, 0x03, 0xFF, 0x80, 0x00, 0xE0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x1F, 0xFF, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x0F, 0x80, 0x0F, 0x80, 0x1F, 0x80, 0x1F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0x7F, 0xF0, 0x7F, 0xF0, 0x3F, 0xF0, 0x1F, 0xF0, 0x1F,
  0x80, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x3E, 0x1F, 0x00, 0x3E, 0x3F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C,
  0x00, 0xF8, 0x7C, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01, 0xF8, 0xF8,
  0x01, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xF8,
  0x0F, 0xF0, 0xFC, 0x1D, 0xE0, 0xFF, 0xFD, 0xE0, 0xFF, 0xF9, 0xE0, 0x7F,
  0xF1, 0xE0, 0x3F, 0xC3, 0xE0, 0xF8, 0x00, 0x3E, 0xF0, 0x00, 0xFD, 0xF0,
  0x01, 0xF3, 0xE0, 0x07, 0xE7, 0xC0, 0x0F, 0x8F, 0x80, 0x3F, 0x1F, 0x00,
  0x7C, 0x3E, 0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x0F, 0x80, 0xF0, 0x1F,
  0x01, 0xE0, 0x7C, 0x03, 0xE0, 0xF8, 0x07, 0xC3, 0xE0, 0x0F, 0x87, 0xC0,
  0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C, 0xF8, 0x00, 0xF9, 0xF0, 0x00,
  0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xF8, 0x03, 0xF0, 0x07,
  0xFF, 0x00, 0x7E, 0x00, 0xFB, 0xE0, 0x1F, 0xC0, 0x3F, 0x7C, 0x03, 0xF8,
  0x07, 0xCF, 0x80, 0xFF, 0x01, 0xF9, 0xF0, 0x1F, 0xE0, 0x3E, 0x3E, 0x07,
  0xBC, 0x07, 0xC7, 0xC0, 0xF7, 0x81, 0xF0, 0xF8, 0x3E, 0xF0, 0x3E, 0x1F,
  0x07, 0x9E, 0x0F, 0x83, 0xE1, 0xF3, 0xC1, 0xF0, 0x7C, 0x3C, 0x78, 0x7C,
  0x0F, 0x87, 0x8F, 0x0F, 0x81, 0xF1, 0xE1, 0xE3, 0xE0, 0x3E, 0x3C, 0x3C,
  0x7C, 0x07, 0xCF, 0x07, 0x8F, 0x00, 0xF9, 0xE0, 0xF3, 0xE0, 0x0F, 0x7C,
  0x1E, 0x7C, 0x01, 0xEF, 0x03, 0xDF, 0x00, 0x3D, 0xE0, 0x7B, 0xE0, 0x07,
  0xF8, 0x07, 0x78, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x03, 0xE0, 0x07, 0xF0, 0x3F, 0x00, 0x7C, 0x01, 0xF0, 0x0F,
  0xC0, 0x1F, 0x01, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0x87, 0xE0, 0x00,
  0xFC, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x7D, 0xF8, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF3, 0xE0, 0x00, 0x7E, 0x1F, 0x00,
  0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x1F, 0x80, 0x1F, 0x80, 0xF8, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xE0, 0x00,
  0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x00, 0x7C, 0x00, 0xFC,
  0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x7C, 0x00,
  0x7C, 0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x0F,
  0x81, 0xF0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE1,
  0xF0, 0x00, 0x0F, 0x87, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00, 0x78, 0xF8,
  0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0x9F, 0x00, 0x00, 0x1E, 0xF8, 0x00,
  0x00, 0x7B, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x40, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x07,
  0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0xFF, 0xF8, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF, 0x80, 0x00,
  0x03, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0xFC, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xC0,
  0x00, 0xFE, 0x00, 0x3F, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xE0,
  0x00, 0x04, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x07, 0xF8, 0x00, 0xFF,
  0x80, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xF0, 0x00, 0x7C, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x07, 0xF0,
  0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x07,
  0xF0, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x00, 0x3F, 0xE0, 0x02, 0xFF, 0xF0,
  0x0F, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xD0, 0x01, 0xFF,
  0x00,
};

const GFXglyph NotoSans_MediumItalic48pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 12, 0, -1 },
  { 1, 13, 35, 13, 1, -34 },
  { 58, 16, 12, 20, 5, -34 },
  { 82, 30, 34, 31, 1, -34 },
  { 210, 24, 39, 26, 1, -36 },
  { 327, 34, 35, 39, 3, -35 },
  { 476, 30, 35, 33, 2, -35 },
  { 608, 7, 12, 11, 5, -34 },
  { 619, 16, 42, 15, 2, -34 },
  { 703, 17, 42, 15, -4, -34 },
  { 793, 22, 23, 26, 5, -37 },
  { 857, 23, 24, 27, 3, -29 },
  { 926, 10, 12, 13, -2, -6 },
  { 941, 13, 4, 15, 1, -15 },
  { 948, 7, 7, 13, 1, -6 },
  { 955, 24, 34, 18, -2, -34 },
  { 1057, 24, 35, 26, 2, -35 },
  { 1162, 16, 34, 26, 6, -34 },
  { 1230, 25, 35, 26, 0, -35 },
  { 1340, 24, 35, 26, 1, -35 },
  { 1445, 26, 34, 26, 0, -34 },
  { 1556, 25, 34, 26, 1, -34 },
  { 1663, 23, 35, 26, 3, -35 },
  { 1764, 24, 34, 26, 3, -34 },
  { 1866, 24, 35, 26, 2, -35 },
  { 1971, 23, 35, 26, 2, -35 },
  { 2072, 10, 28, 13, 1, -27 },
  { 2107, 13, 33, 13, -2, -27 },
  { 2161, 23, 24, 27, 3, -29 },
  { 2230, 23, 14, 27, 3, -24 },
  { 2271, 23, 24, 27, 3, -29 },
  { 2340, 18, 36, 21, 4, -35 },
  { 2421, 38, 38, 41, 2, -34 },
  { 2602, 28, 34, 28, -3, -34 },
  { 2721, 27, 34, 29, 2, -34 },
  { 2836, 28, 35, 29, 3, -35 },
  { 2959, 29, 34, 32, 2, -34 },
  { 3083, 25, 34, 25, 2, -34 },
  { 3190, 25, 34, 24, 2, -34 },
  { 3297, 29, 35, 33, 3, -35 },
  { 3424, 31, 34, 33, 2, -34 },
  { 3556, 20, 34, 16, -1, -34 },
  { 3641, 22, 43, 14, -8, -34 },
  { 3760, 30, 34, 28, 2, -34 },
  { 3888, 19, 34, 24, 2, -34 },
  { 3969, 39, 34, 41, 2, -34 },
  { 4135, 33, 34, 35, 2, -34 },
  { 4276, 30, 35, 35, 3, -35 },
  { 4408, 26, 34, 28, 2, -34 },
  { 4519, 30, 43, 35, 3, -35 },
  { 4681, 26, 34, 28, 2, -34 },
  { 4792, 24, 35, 25, 1, -35 },
  { 4897, 24, 34, 24, 4, -34 },
  { 4999, 29, 34, 33, 4, -34 },
  { 5123, 27, 34, 27, 4, -34 },
  { 5238, 41, 34, 42, 5, -34 },
  { 5413, 33, 34, 26, -3, -34 },
  { 5554, 26, 34, 25, 4, -34 },
  { 5665, 29, 34, 26, -1, -34 },
  { 5789, 19, 42, 15, -1, -34 },
  { 5889, 10, 34, 18, 5, -34 },
  { 5932, 18, 42, 15, -3, -34 },
  { 6027, 24, 22, 27, 2, -35 },
  { 6093, 19, 4, 19, -4, 4 },
  { 6103, 9, 8, 14, 7, -37 },
  { 6112, 25, 26, 28, 2, -26 },
  { 6194, 25, 36, 28, 1, -36 },
  { 6307, 21, 26, 22, 2, -26 },
  { 6376, 27, 36, 28, 2, -36 },
  { 6498, 21, 26, 25, 2, -26 },
  { 6567, 27, 49, 16, -5, -37 },
  { 6733, 26, 38, 28, 1, -26 },
  { 6857, 25, 36, 28, 1, -36 },
  { 6970, 13, 36, 13, 1, -36 },
  { 7029, 20, 48, 13, -6, -36 },
  { 7149, 26, 36, 25, 1, -36 },
  { 7266, 13, 36, 13, 1, -36 },
  { 7325, 39, 26, 42, 1, -26 },
  { 7452, 25, 26, 28, 1, -26 },
  { 7534, 23, 26, 27, 2, -26 },
  { 7609, 27, 38, 28, -1, -26 },
  { 7738, 25, 38, 28, 2, -26 },
  { 7857, 20, 26, 19, 1, -26 },
  { 7922, 20, 26, 21, 0, -26 },
  { 7987, 16, 32, 17, 2, -32 },
  { 8051, 24, 26, 28, 3, -26 },
  { 8129, 23, 26, 23, 2, -26 },
  { 8204, 35, 26, 36, 3, -26 },
  { 8318, 28, 26, 24, -2, -26 },
  { 8409, 30, 38, 23, -4, -26 },
  { 8552, 23, 26, 22, -1, -26 },
  { 8627, 19, 42, 17, 0, -34 },
  { 8727, 4, 47, 26, 12, -36 },
  { 8751, 19, 42, 17, -2, -34 },
  { 8851, 23, 6, 27, 3, -20 },
};

const GFXfont NotoSans_MediumItalic48pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic48pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic48pt7bGlyphs,
  0x20, 0x7E, 65
};

#endif // _NOTOSANS_MEDIUMITALIC48PT7B_H_
