#ifndef _NOTOSANS_MEDIUMITALIC49PT7B_H_
#define _NOTOSANS_MEDIUMITALIC49PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 49pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic49pt7bBitmaps[] PROGMEM = {
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x0F,
  0x80, 0x7C, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0,
  0x3E, 0x01, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F,
  0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x3E, 0x03, 0xF8, 0x1F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x00, 0xE0, 0x00,
  0x3E, 0x1F, 0x3E, 0x3F, 0x3C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3E, 0x7C, 0x3C,
  0x78, 0x3C, 0x78, 0x3C, 0x78, 0x3C, 0x70, 0x78, 0xF0, 0x78, 0xF0, 0x78,
  0xF0, 0x70, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x7C, 0x0F, 0x00, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x03, 0xC0, 0xF0, 0x00, 0x0F, 0x01, 0xE0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF,
  0xF1, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xC0, 0x1E, 0x03, 0xC0,
  0x00, 0x3C, 0x0F, 0x00, 0x00, 0x78, 0x1E, 0x00, 0x00, 0xE0, 0x3C, 0x00,
  0x03, 0xC0, 0x70, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x0F,
  0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xF8, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0x81, 0xE0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E,
  0x07, 0x80, 0x00, 0x78, 0x0F, 0x00, 0x00, 0xF0, 0x3C, 0x00, 0x01, 0xE0,
  0x78, 0x00, 0x07, 0x80, 0xF0, 0x00, 0x0F, 0x03, 0xC0, 0x00, 0x1E, 0x07,
  0x80, 0x00, 0x3C, 0x0F, 0x00, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x03, 0xC0,
  0x00, 0x03, 0xC0, 0x00, 0x03, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x07, 0xE7, 0x1E, 0x0F, 0xC7, 0x04,
  0x0F, 0x87, 0x00, 0x0F, 0x8F, 0x00, 0x0F, 0x0E, 0x00, 0x0F, 0x8E, 0x00,
  0x0F, 0x8E, 0x00, 0x0F, 0xDE, 0x00, 0x0F, 0xFE, 0x00, 0x07, 0xFC, 0x00,
  0x03, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF0,
  0x00, 0x3B, 0xF8, 0x00, 0x38, 0xF8, 0x00, 0x38, 0xF8, 0x00, 0x78, 0xF8,
  0x00, 0x70, 0xF8, 0x00, 0x70, 0xF8, 0x80, 0x71, 0xF8, 0xE0, 0xF3, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00, 0x01, 0xC0, 0x00,
  0x01, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0x03, 0xFF,
  0x00, 0x0F, 0x81, 0xFF, 0xC0, 0x03, 0xC0, 0xFC, 0xF8, 0x01, 0xE0, 0x3C,
  0x1E, 0x00, 0xF8, 0x1F, 0x07, 0x80, 0x7C, 0x07, 0x81, 0xE0, 0x1E, 0x01,
  0xE0, 0x78, 0x0F, 0x00, 0xF8, 0x1E, 0x07, 0xC0, 0x3C, 0x07, 0x83, 0xE0,
  0x0F, 0x01, 0xE0, 0xF0, 0x03, 0xC0, 0xF8, 0x78, 0x00, 0xF0, 0x3C, 0x3E,
  0x00, 0x3C, 0x0F, 0x1F, 0x00, 0x0F, 0x07, 0xC7, 0x8F, 0xE3, 0xC1, 0xE3,
  0xC7, 0xFE, 0xF0, 0xF9, 0xF3, 0xFF, 0xBE, 0x7C, 0x79, 0xF3, 0xFF, 0xFE,
  0x3C, 0xF8, 0x7D, 0xFF, 0x1E, 0x3E, 0x0F, 0x3F, 0x8F, 0x8F, 0x03, 0xC0,
  0x03, 0xC7, 0xC0, 0xF0, 0x01, 0xE1, 0xE0, 0x3C, 0x00, 0xF0, 0x78, 0x1F,
  0x00, 0x7C, 0x1E, 0x07, 0xC0, 0x1E, 0x0F, 0x81, 0xE0, 0x0F, 0x03, 0xE0,
  0x78, 0x07, 0xC0, 0xF8, 0x3E, 0x03, 0xE0, 0x3E, 0x0F, 0x00, 0xF0, 0x0F,
  0x83, 0xC0, 0x78, 0x03, 0xE1, 0xF0, 0x3E, 0x00, 0x7C, 0xF8, 0x1F, 0x00,
  0x1F, 0xFC, 0x07, 0x80, 0x03, 0xFE, 0x03, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x01, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F,
  0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x7C, 0x07, 0xC0, 0x03, 0xE0, 0x1F, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x3E, 0x03, 0xF0, 0x00, 0x7C, 0x0F, 0x80, 0x01, 0xF0, 0xFC, 0x00,
  0x07, 0xC7, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x03, 0xFF,
  0xC0, 0x1F, 0x1F, 0xDF, 0x80, 0xFC, 0xFC, 0x3F, 0x03, 0xE7, 0xE0, 0x7C,
  0x1F, 0xBF, 0x01, 0xF8, 0x7C, 0xF8, 0x03, 0xF3, 0xE3, 0xE0, 0x07, 0xFF,
  0x8F, 0x80, 0x1F, 0xFC, 0x3E, 0x00, 0x3F, 0xE0, 0xF8, 0x00, 0x7F, 0x03,
  0xE0, 0x01, 0xF8, 0x0F, 0xC0, 0x1F, 0xF0, 0x3F, 0x81, 0xFF, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xBF, 0x03, 0xFF, 0xF8, 0x7E, 0x03, 0xFF,
  0x80, 0xFC, 0x3E, 0x7C, 0xF3, 0xE7, 0xCF, 0x9E, 0x3C, 0x78, 0xE3, 0xC7,
  0x8F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x0F,
  0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x07, 0xC0, 0x03, 0xE0, 0x03,
  0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x00, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x7C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xF0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7C, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x3E, 0x00, 0x3E,
  0x00, 0x3E, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x0C, 0x07, 0x80, 0x1E,
  0x0F, 0x00, 0x7F, 0x1C, 0x00, 0xFF, 0xB8, 0x00, 0x7F, 0xFF, 0xFC, 0x1F,
  0xFF, 0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xBF, 0xC0, 0x7F, 0x80, 0x01, 0xF7,
  0x00, 0x07, 0xCF, 0x00, 0x1F, 0x1E, 0x00, 0xFC, 0x1E, 0x00, 0xF8, 0x3C,
  0x00, 0xE0, 0x7C, 0x00, 0x80, 0xF8, 0x00, 0x00, 0xE8, 0x00, 0x01, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x78, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03,
  0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x07, 0xC3,
  0xF0, 0xF8, 0x7E, 0x1F, 0x07, 0xC3, 0xE0, 0xF8, 0x7C, 0x1F, 0x07, 0x83,
  0xC0, 0x7F, 0xFB, 0xFF, 0xFF, 0xFD, 0xFF, 0xE0, 0x7D, 0xFF, 0xFF, 0xFF,
  0xDF, 0x9C, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x00, 0x01, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xFC,
  0x01, 0xFF, 0xFE, 0x03, 0xF8, 0x7E, 0x07, 0xE0, 0x3F, 0x07, 0xC0, 0x3F,
  0x0F, 0xC0, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x80, 0x1F, 0x1F, 0x00, 0x1F,
  0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x1F, 0x7E, 0x00, 0x1F,
  0x7E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F,
  0x7C, 0x00, 0x3E, 0x7C, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E,
  0xFC, 0x00, 0x7C, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8,
  0x7C, 0x01, 0xF8, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF0, 0x3F, 0x0F, 0xE0,
  0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x1F, 0x00, 0x3F, 0x00, 0xFF, 0x03, 0xFF, 0x07, 0xFE, 0x1F, 0xFE,
  0x3F, 0xFE, 0xFF, 0x3E, 0x7E, 0x7E, 0x38, 0x7C, 0x30, 0x7C, 0x00, 0x7C,
  0x00, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF8, 0x01, 0xF8,
  0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x01, 0xF0, 0x03, 0xF0, 0x03, 0xE0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xC0, 0x07, 0xC0,
  0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x80, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01,
  0xF8, 0x3F, 0x80, 0x78, 0x03, 0xF0, 0x08, 0x00, 0xFC, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x3E, 0x03, 0xF0, 0x0C, 0x00, 0xFC, 0x04,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFF, 0xC0, 0x00, 0xFF, 0xC0,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC4, 0x00,
  0x0F, 0xC3, 0xC0, 0x1F, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F,
  0xFF, 0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xBC, 0x00, 0x07, 0xDF, 0x00,
  0x03, 0xE7, 0xC0, 0x01, 0xF9, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0x3E, 0x3E,
  0x00, 0x1F, 0x0F, 0x80, 0x0F, 0x83, 0xE0, 0x07, 0xC0, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xF8, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E, 0x01, 0xF0, 0x1F,
  0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x0F, 0x81, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x70, 0x00, 0x1F, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC6, 0x00, 0x0F, 0xC3, 0xC0, 0x1F,
  0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF,
  0x80, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x7F, 0xFE, 0x00,
  0xFF, 0xFE, 0x01, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x3F, 0x80, 0x7C, 0xFF, 0xE0, 0x7D,
  0xFF, 0xF0, 0x7F, 0xFF, 0xF8, 0x7F, 0x83, 0xF8, 0xFF, 0x00, 0xF8, 0xFE,
  0x00, 0xFC, 0xFC, 0x00, 0xFC, 0xF8, 0x00, 0x7C, 0xF8, 0x00, 0x7C, 0xF8,
  0x00, 0xFC, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8,
  0x01, 0xF8, 0xFC, 0x01, 0xF0, 0xFC, 0x03, 0xF0, 0x7E, 0x0F, 0xE0, 0x7F,
  0xFF, 0xC0, 0x3F, 0xFF, 0x80, 0x1F, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x1F,
  0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xE7, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x00, 0x01, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xFF, 0x00, 0x3F,
  0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x1F, 0x81, 0xF8, 0x1F, 0x80, 0x7E, 0x0F,
  0x80, 0x3F, 0x07, 0xC0, 0x1F, 0x83, 0xE0, 0x07, 0xC1, 0xF0, 0x07, 0xC0,
  0xF8, 0x03, 0xE0, 0x7C, 0x03, 0xF0, 0x1F, 0x03, 0xF0, 0x0F, 0xC3, 0xF0,
  0x03, 0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xF0,
  0x00, 0xFF, 0xFC, 0x01, 0xFC, 0x3F, 0x01, 0xF8, 0x0F, 0xC1, 0xF8, 0x03,
  0xE0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x8F, 0x80, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xF0,
  0x03, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x07,
  0xFF, 0xF0, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x0F, 0xE0, 0xFE, 0x0F, 0xC0, 0x7E,
  0x1F, 0x80, 0x3E, 0x1F, 0x00, 0x3E, 0x3F, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0x3E, 0x00, 0x3F,
  0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0xFE, 0x1F, 0x83, 0xFE,
  0x1F, 0xFF, 0xBE, 0x0F, 0xFF, 0xBE, 0x07, 0xFF, 0x7C, 0x03, 0xFC, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0xC0, 0x3F, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xC0, 0xFC, 0x3F, 0x87, 0xF0, 0xFC, 0x1F, 0x81,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x3F, 0x87, 0xF0,
  0xFE, 0x1F, 0x83, 0xF0, 0x38, 0x00, 0x00, 0x78, 0x03, 0xF0, 0x1F, 0xC0,
  0x7F, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x07, 0xE0,
  0x1F, 0x80, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x3C, 0x01, 0xF0, 0x07, 0x80,
  0x3E, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x1C, 0x00, 0x00,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0x00, 0x0F, 0xF8,
  0x00, 0x7F, 0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xF0, 0x00, 0x0F,
  0xF8, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0x80, 0x00,
  0x03, 0x00, 0x00, 0x02, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x80, 0x00, 0x01,
  0xC0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xF8, 0x00, 0x1F, 0xC0, 0x00,
  0x3E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x07,
  0xFF, 0xE1, 0xFF, 0xFE, 0x3F, 0xFF, 0xE3, 0xC0, 0xFC, 0x40, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03,
  0xF8, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x01, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x3F, 0x80, 0x07, 0xF0,
  0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x38, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x01, 0xF0, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x00, 0x78, 0x0F, 0x00, 0x00, 0x00, 0xF8,
  0x3C, 0x01, 0xFF, 0xC0, 0xF0, 0xF8, 0x0F, 0xFF, 0xC1, 0xE1, 0xE0, 0x3F,
  0xFF, 0x83, 0xC7, 0xC0, 0xFC, 0x1F, 0x07, 0xCF, 0x03, 0xE0, 0x3C, 0x07,
  0x9E, 0x07, 0x80, 0x78, 0x0F, 0x7C, 0x1F, 0x01, 0xF0, 0x3E, 0xF0, 0x3C,
  0x03, 0xC0, 0x79, 0xE0, 0xF8, 0x07, 0x80, 0xF3, 0xC1, 0xE0, 0x0F, 0x01,
  0xE7, 0x83, 0xC0, 0x3E, 0x03, 0xCF, 0x07, 0x80, 0x78, 0x0F, 0xBE, 0x0F,
  0x00, 0xF0, 0x1E, 0x3C, 0x1E, 0x03, 0xE0, 0x7C, 0x78, 0x3C, 0x0F, 0xC0,
  0xF0, 0xF0, 0x7C, 0x3F, 0x83, 0xE1, 0xE0, 0xFF, 0xF7, 0xFF, 0x83, 0xC0,
  0xFF, 0xCF, 0xFE, 0x07, 0xC0, 0xFF, 0x0F, 0xF8, 0x07, 0x80, 0xF8, 0x0F,
  0x80, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01,
  0xC0, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00,
  0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xDF, 0x00,
  0x00, 0x3E, 0xF8, 0x00, 0x03, 0xE7, 0xC0, 0x00, 0x1F, 0x3E, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x3C, 0x00, 0x07, 0xC1,
  0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x03, 0xE0,
  0x01, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0xF8, 0x01, 0xF8, 0x07, 0xC0, 0x0F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0x00, 0x0F, 0x81, 0xF0, 0x00, 0x7C,
  0x1F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x1F, 0x0F, 0xC0, 0x00, 0xF8, 0x7C,
  0x00, 0x07, 0xC7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x3E, 0x01, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0,
  0x07, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x3E, 0x0F, 0xFC, 0x07, 0xC0,
  0x1F, 0xC0, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x1F, 0x07, 0xE0, 0x03, 0xE0,
  0xF8, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x83, 0xE0, 0x03, 0xF0, 0x7C, 0x00,
  0xFC, 0x1F, 0x80, 0x3F, 0x03, 0xE0, 0x3F, 0xC0, 0x7F, 0xFF, 0xF0, 0x0F,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0x80, 0x3F,
  0x01, 0xF0, 0x03, 0xF0, 0x3E, 0x00, 0x3F, 0x0F, 0xC0, 0x07, 0xE1, 0xF0,
  0x00, 0xFC, 0x3E, 0x00, 0x1F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x00, 0x7E,
  0x3F, 0x00, 0x0F, 0x87, 0xC0, 0x03, 0xF0, 0xF8, 0x01, 0xFE, 0x1F, 0x01,
  0xFF, 0x83, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFC, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0x03, 0xE0, 0x3F, 0xC0,
  0x04, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x40, 0x1F, 0xE0, 0x3C, 0x01, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0x0F,
  0xFE, 0x01, 0xF0, 0x07, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x7C, 0x00, 0x7E,
  0x07, 0xE0, 0x01, 0xF8, 0x3E, 0x00, 0x0F, 0xC1, 0xF0, 0x00, 0x7E, 0x0F,
  0x80, 0x01, 0xF0, 0x7C, 0x00, 0x0F, 0x87, 0xE0, 0x00, 0x7C, 0x3E, 0x00,
  0x03, 0xE1, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0xF8, 0x7C, 0x00, 0x07,
  0xC7, 0xE0, 0x00, 0x7E, 0x3E, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x1F, 0x8F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0x7E, 0x3E, 0x00,
  0x07, 0xE1, 0xF0, 0x00, 0x7F, 0x0F, 0x80, 0x07, 0xF0, 0xFC, 0x00, 0x7F,
  0x07, 0xC0, 0x07, 0xF8, 0x3E, 0x00, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x10, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC, 0x07, 0xFF,
  0xFE, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xE0,
  0x3F, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3F, 0xFF, 0xF8, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x07, 0xFF, 0xFC,
  0x07, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x00, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0x01,
  0xF0, 0x0F, 0xF0, 0x00, 0xC0, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0xFF, 0xF1, 0xF0, 0x03,
  0xFF, 0xC7, 0xC0, 0x0F, 0xFE, 0x3F, 0x00, 0x7F, 0xF8, 0xFC, 0x01, 0xFF,
  0xE3, 0xF0, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x7E, 0x3F, 0x00, 0x01, 0xF0,
  0xFC, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x03, 0xF0, 0x7F, 0x00, 0x0F, 0x80, 0xFE, 0x00, 0x3E, 0x01, 0xFE,
  0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x3F, 0x01, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0x00, 0x3E, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xF0,
  0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7C, 0x03, 0xE0,
  0x00, 0x7C, 0x07, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x7C, 0x07, 0xC0,
  0x00, 0xFC, 0x07, 0xC0, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0xF8, 0x0F, 0xC0,
  0x00, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0xF0, 0x1F, 0x00,
  0x03, 0xF0, 0x1F, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x03, 0xE0, 0x3F, 0x00,
  0x03, 0xE0, 0x3F, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7E, 0x00, 0x07, 0xC0, 0x7C, 0x00,
  0x07, 0xC0, 0x7C, 0x00, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x0F, 0x80, 0xFC, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x0F, 0x80, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0x80, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00,
  0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x07,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x07, 0xFE, 0x00, 0x01, 0x80, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFE,
  0x03, 0xE0, 0x03, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F, 0x00,
  0x3E, 0x00, 0xFC, 0x00, 0x7C, 0x03, 0xF8, 0x00, 0xF8, 0x0F, 0xE0, 0x01,
  0xF0, 0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0x81, 0xF8, 0x00, 0x1F,
  0x07, 0xE0, 0x00, 0x3E, 0x1F, 0x80, 0x00, 0x7C, 0x7E, 0x00, 0x01, 0xF9,
  0xF8, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x07, 0xDF, 0x80, 0x00, 0x0F, 0xFF,
  0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFF, 0x7C,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xE0,
  0x00, 0xF8, 0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x1F, 0x80,
  0x0F, 0x80, 0x1F, 0x00, 0x1F, 0x00, 0x3F, 0x00, 0x3E, 0x00, 0x3E, 0x00,
  0xFC, 0x00, 0x7E, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xE0, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xC0, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE,
  0x00, 0x01, 0xFE, 0x03, 0xFE, 0x00, 0x03, 0xFE, 0x03, 0xFE, 0x00, 0x03,
  0xFE, 0x03, 0xDE, 0x00, 0x07, 0xFE, 0x03, 0xDE, 0x00, 0x07, 0xBE, 0x03,
  0xDE, 0x00, 0x0F, 0xBC, 0x07, 0xDE, 0x00, 0x0F, 0x7C, 0x07, 0xDE, 0x00,
  0x1F, 0x7C, 0x07, 0xDE, 0x00, 0x1E, 0x7C, 0x07, 0xDF, 0x00, 0x3E, 0x7C,
  0x07, 0x9F, 0x00, 0x3C, 0xF8, 0x0F, 0x9F, 0x00, 0x7C, 0xF8, 0x0F, 0x8F,
  0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x00, 0xF8, 0xF8, 0x0F, 0x8F, 0x01, 0xF1,
  0xF8, 0x1F, 0x0F, 0x01, 0xF1, 0xF0, 0x1F, 0x0F, 0x03, 0xE1, 0xF0, 0x1F,
  0x0F, 0x03, 0xC1, 0xF0, 0x1F, 0x0F, 0x07, 0xC1, 0xF0, 0x1E, 0x0F, 0x87,
  0x83, 0xE0, 0x3E, 0x0F, 0x8F, 0x83, 0xE0, 0x3E, 0x0F, 0x8F, 0x03, 0xE0,
  0x3E, 0x07, 0x9F, 0x03, 0xE0, 0x3E, 0x07, 0x9E, 0x03, 0xE0, 0x3C, 0x07,
  0xBE, 0x07, 0xC0, 0x7C, 0x07, 0xBC, 0x07, 0xC0, 0x7C, 0x07, 0xFC, 0x07,
  0xC0, 0x7C, 0x07, 0xF8, 0x07, 0xC0, 0x7C, 0x07, 0xF8, 0x0F, 0xC0, 0xF8,
  0x07, 0xF0, 0x0F, 0x80, 0xF8, 0x07, 0xE0, 0x0F, 0x80, 0xF8, 0x03, 0xE0,
  0x0F, 0x80, 0xF8, 0x03, 0xC0, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x07, 0xC0,
  0x7E, 0x00, 0x03, 0xE0, 0x1F, 0xC0, 0x00, 0xF8, 0x0F, 0xF0, 0x00, 0x3E,
  0x03, 0xFE, 0x00, 0x0F, 0x80, 0xFF, 0x80, 0x03, 0xC0, 0x3F, 0xE0, 0x01,
  0xF0, 0x0F, 0x7C, 0x00, 0x7C, 0x07, 0xDF, 0x00, 0x1F, 0x01, 0xF7, 0xC0,
  0x07, 0xC0, 0x7C, 0xF8, 0x03, 0xE0, 0x1E, 0x3E, 0x00, 0xF8, 0x07, 0x8F,
  0x80, 0x3E, 0x03, 0xE1, 0xF0, 0x0F, 0x80, 0xF8, 0x7C, 0x03, 0xE0, 0x3E,
  0x1F, 0x01, 0xF0, 0x0F, 0x83, 0xE0, 0x7C, 0x07, 0xC0, 0xF8, 0x1F, 0x01,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x07, 0xC1, 0xF0, 0x1F, 0x01, 0xF0, 0xF8,
  0x07, 0x80, 0x3E, 0x3E, 0x03, 0xE0, 0x0F, 0x8F, 0x80, 0xF8, 0x03, 0xE3,
  0xE0, 0x3E, 0x00, 0x7C, 0xF0, 0x0F, 0x80, 0x1F, 0x7C, 0x03, 0xC0, 0x07,
  0xDF, 0x01, 0xF0, 0x00, 0xFF, 0xC0, 0x7C, 0x00, 0x3F, 0xF0, 0x1F, 0x00,
  0x0F, 0xF8, 0x07, 0xC0, 0x01, 0xFE, 0x03, 0xE0, 0x00, 0x7F, 0x80, 0xF8,
  0x00, 0x0F, 0xE0, 0x3E, 0x00, 0x03, 0xF8, 0x0F, 0x80, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x00,
  0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03, 0xF3, 0xF0,
  0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD, 0xF0, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xDF, 0x80, 0x00,
  0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x01,
  0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x0F, 0xF0,
  0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00,
  0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xE1, 0xFF,
  0x80, 0xF8, 0x07, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x07, 0xE0,
  0x07, 0xC1, 0xF0, 0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07,
  0xC0, 0x07, 0xC3, 0xF0, 0x03, 0xF0, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x7E,
  0x0F, 0x80, 0x7F, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF,
  0xE0, 0x1F, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x60, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xC1,
  0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0xFC, 0x1F, 0x80, 0x00, 0xF8, 0x7E, 0x00, 0x01, 0xF8, 0xF8, 0x00, 0x03,
  0xF3, 0xF0, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x1F,
  0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00, 0xFD,
  0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07, 0xDF,
  0x80, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x03, 0xF1, 0xF0, 0x00, 0x0F, 0xC3, 0xF0,
  0x00, 0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x0F, 0xF0, 0x0F, 0xF0, 0x7F, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFC, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x00,
  0x1F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFE, 0x03, 0xF0, 0xFF, 0x80, 0xF8, 0x07,
  0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xC1, 0xF0,
  0x01, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0x00, 0x1F, 0x07, 0xC0, 0x0F, 0xC3,
  0xF0, 0x03, 0xE0, 0xF8, 0x01, 0xF8, 0x3E, 0x01, 0xFC, 0x0F, 0x87, 0xFF,
  0x03, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x1F, 0xFF,
  0xC0, 0x07, 0xC1, 0xF8, 0x03, 0xF0, 0x3E, 0x00, 0xFC, 0x0F, 0x80, 0x3E,
  0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x81, 0xF8, 0x07, 0xE0,
  0x7C, 0x00, 0xF8, 0x1F, 0x00, 0x3F, 0x07, 0xC0, 0x0F, 0xC1, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x8F, 0x80, 0x03, 0xF0, 0x00,
  0x3F, 0xFC, 0x00, 0x3F, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x3F, 0x81, 0xE0, 0x3F, 0x00, 0x10, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x07, 0xFC,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x84, 0x00, 0x1F, 0x83, 0xC0, 0x3F, 0xC1,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x3F, 0x00, 0x03, 0xF0, 0xFC,
  0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x1F, 0x87, 0xC0, 0x00, 0x7C, 0x1F, 0x00, 0x01,
  0xF0, 0x7C, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0xF8,
  0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x0F, 0x83, 0xE0, 0x00, 0x3E, 0x1F,
  0x80, 0x01, 0xF8, 0x7E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x1F, 0x07, 0xC0,
  0x00, 0x7C, 0x1F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x3E, 0x0F, 0x80, 0x00, 0xF8, 0x3E, 0x00, 0x03, 0xE0, 0xF8, 0x00, 0x1F,
  0x83, 0xE0, 0x00, 0x7C, 0x0F, 0x80, 0x03, 0xF0, 0x3E, 0x00, 0x0F, 0xC0,
  0xFC, 0x00, 0x7E, 0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x3F, 0xC0, 0x1F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x3E, 0x7C, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x7C, 0x7C, 0x00, 0x0F, 0xC7, 0xC0, 0x00, 0xF8,
  0x7C, 0x00, 0x1F, 0x87, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x3F, 0x07, 0xC0,
  0x03, 0xE0, 0x3E, 0x00, 0x7E, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x01, 0xF0, 0x03, 0xE0, 0x1F, 0x00, 0x3E,
  0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x7C,
  0x00, 0x1E, 0x0F, 0x80, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF1, 0xF0, 0x00, 0x1F, 0x3E, 0x00, 0x01, 0xF3, 0xE0, 0x00, 0x1F, 0x7C,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0xFE,
  0x00, 0x0F, 0x80, 0x03, 0xEF, 0x80, 0x07, 0xF0, 0x01, 0xFB, 0xE0, 0x01,
  0xFC, 0x00, 0x7C, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0x3E, 0x00, 0x3F, 0xC0,
  0x0F, 0x8F, 0x80, 0x1F, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0xFC, 0x01, 0xF0,
  0xF8, 0x03, 0xFF, 0x00, 0x7C, 0x3E, 0x00, 0xF7, 0xC0, 0x3F, 0x0F, 0x80,
  0x3D, 0xF0, 0x0F, 0x83, 0xE0, 0x1F, 0x3C, 0x07, 0xE0, 0xF8, 0x07, 0x8F,
  0x01, 0xF0, 0x1E, 0x03, 0xE3, 0xC0, 0x7C, 0x07, 0x80, 0xF0, 0xF0, 0x3E,
  0x01, 0xE0, 0x7C, 0x3C, 0x0F, 0x80, 0x78, 0x1E, 0x0F, 0x07, 0xC0, 0x1E,
  0x0F, 0x83, 0xC1, 0xF0, 0x07, 0xC3, 0xE0, 0xF0, 0xFC, 0x01, 0xF1, 0xF0,
  0x3C, 0x3E, 0x00, 0x7C, 0x7C, 0x0F, 0x0F, 0x80, 0x1F, 0x3E, 0x03, 0xC7,
  0xC0, 0x07, 0xCF, 0x80, 0xF1, 0xF0, 0x01, 0xF3, 0xC0, 0x3C, 0xF8, 0x00,
  0x7D, 0xF0, 0x0F, 0x3E, 0x00, 0x1F, 0x78, 0x03, 0xCF, 0x00, 0x07, 0xBE,
  0x00, 0xF7, 0xC0, 0x01, 0xEF, 0x00, 0x3D, 0xE0, 0x00, 0x7B, 0xC0, 0x0F,
  0x78, 0x00, 0x1F, 0xE0, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0xFF, 0x00,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0x1F,
  0xC0, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x00,
  0xF8, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x01, 0xF0, 0x1F, 0x80, 0x00, 0x7C, 0x0F, 0xC0, 0x00, 0x0F, 0x83, 0xE0,
  0x00, 0x03, 0xE1, 0xF8, 0x00, 0x00, 0xF8, 0xFC, 0x00, 0x00, 0x1F, 0x7E,
  0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x03, 0xF3, 0xE0, 0x00,
  0x01, 0xF8, 0xF8, 0x00, 0x00, 0xFC, 0x3F, 0x00, 0x00, 0x3E, 0x07, 0xC0,
  0x00, 0x1F, 0x81, 0xF0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x0F,
  0x80, 0x01, 0xF0, 0x03, 0xE0, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x1F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0xE0,
  0x00, 0x3E, 0x00, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x1F, 0xBE, 0x00, 0x0F,
  0xDF, 0x80, 0x0F, 0xC7, 0xC0, 0x0F, 0xC3, 0xE0, 0x07, 0xE1, 0xF0, 0x07,
  0xE0, 0xF8, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0x81,
  0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0x7C,
  0xF8, 0x00, 0x1E, 0xFC, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xF0, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x7C,
  0x00, 0x07, 0xFE, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0xFF, 0xE0, 0x00,
  0xF8, 0x1E, 0x07, 0x81, 0xE0, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0x3C, 0x0F,
  0x03, 0xC0, 0xF8, 0x3E, 0x0F, 0x83, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xF0,
  0x7C, 0x1F, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x83, 0xE0, 0xF8, 0x3E, 0x07,
  0x81, 0xE0, 0x78, 0x1F, 0x07, 0xC1, 0xF0, 0x7C, 0x00, 0xFF, 0xE0, 0x1F,
  0xF8, 0x03, 0xFF, 0x00, 0x7F, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF0, 0x00, 0x3E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x07, 0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00, 0xF7, 0x80,
  0x01, 0xE7, 0xC0, 0x01, 0xE3, 0xC0, 0x03, 0xC3, 0xC0, 0x03, 0xC1, 0xE0,
  0x07, 0x81, 0xE0, 0x07, 0x80, 0xF0, 0x0F, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x1E, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x3C, 0x00, 0x3C, 0x7C, 0x00, 0x3C,
  0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF0, 0x00, 0x1F, 0x7F, 0xFF, 0xFB,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFD, 0xFF, 0xFF, 0xE0, 0xFC, 0x7E, 0x1F, 0x07,
  0xC3, 0xE0, 0xF8, 0x3C, 0x0F, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC3, 0xC0,
  0x7F, 0xF1, 0xE0, 0x7F, 0xFD, 0xF0, 0x7F, 0xBF, 0xF8, 0x7F, 0x03, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x0F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0x7C, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x83, 0xE0,
  0x3F, 0xC1, 0xF8, 0x3F, 0xE0, 0xFF, 0xFD, 0xF0, 0x3F, 0xFC, 0xF0, 0x0F,
  0xFC, 0x78, 0x03, 0xF8, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0xF8, 0x3C, 0x00, 0x7C, 0x7F, 0x80, 0x7C, 0xFF, 0xE0, 0x3E,
  0xFF, 0xF8, 0x1F, 0xF9, 0xFC, 0x0F, 0xF0, 0x3F, 0x07, 0xF0, 0x0F, 0x87,
  0xF0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x00, 0xF8,
  0xFC, 0x00, 0x7C, 0x7C, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x1F, 0x00, 0x1F,
  0x8F, 0x80, 0x0F, 0xCF, 0xC0, 0x07, 0xC7, 0xE0, 0x07, 0xE3, 0xE0, 0x03,
  0xF1, 0xF8, 0x03, 0xF0, 0xFC, 0x01, 0xF8, 0xFE, 0x01, 0xF8, 0x7F, 0x81,
  0xF8, 0x3F, 0xFF, 0xFC, 0x1E, 0x7F, 0xFC, 0x0F, 0x1F, 0xFC, 0x0F, 0x07,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x07, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF,
  0xE0, 0x7F, 0xDF, 0x07, 0xF0, 0x08, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00, 0x01,
  0xFC, 0x06, 0x07, 0xFF, 0xF0, 0x1F, 0xFF, 0x80, 0x7F, 0xFC, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xF8, 0xF8, 0x01, 0xFF, 0xCF, 0x80, 0x7F,
  0xFE, 0xF8, 0x07, 0xFB, 0xFF, 0x00, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7F,
  0x01, 0xF8, 0x03, 0xF0, 0x3F, 0x00, 0x3F, 0x03, 0xE0, 0x03, 0xE0, 0x7E,
  0x00, 0x3E, 0x07, 0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03,
  0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xC0, 0xFC, 0x00, 0x7C, 0x0F,
  0xC0, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC0, 0x1F, 0x80, 0xFC, 0x03,
  0xF8, 0x07, 0xC0, 0x7F, 0x80, 0x7E, 0x0F, 0xF8, 0x07, 0xFF, 0xEF, 0x00,
  0x3F, 0xFC, 0xF0, 0x01, 0xFF, 0x8F, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0xFF, 0xFE, 0x07, 0xF1,
  0xFC, 0x3F, 0x01, 0xF1, 0xF8, 0x07, 0xC7, 0xC0, 0x1F, 0x3F, 0x00, 0xFC,
  0xF8, 0x03, 0xE7, 0xE0, 0x3F, 0x9F, 0x03, 0xFC, 0x7F, 0xFF, 0xE1, 0xFF,
  0xFF, 0x0F, 0xFF, 0xF0, 0x3F, 0xF8, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x87,
  0xF0, 0x0C, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x00, 0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x0F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFC, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0xF0, 0xF0, 0x1F, 0xFE, 0x3C, 0x0F, 0xFF,
  0xDF, 0x03, 0xFD, 0xFF, 0xC1, 0xFC, 0x0F, 0xE0, 0xFC, 0x03, 0xF8, 0x3F,
  0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xC0, 0x07, 0xC3, 0xF0, 0x01, 0xF0,
  0xFC, 0x00, 0x7C, 0x3E, 0x00, 0x1F, 0x0F, 0x80, 0x0F, 0xC3, 0xE0, 0x03,
  0xE1, 0xF8, 0x00, 0xF8, 0x7E, 0x00, 0x7E, 0x1F, 0x80, 0x1F, 0x87, 0xE0,
  0x0F, 0xE1, 0xF8, 0x03, 0xF0, 0x7E, 0x01, 0xFC, 0x0F, 0x80, 0xFF, 0x03,
  0xF0, 0x7F, 0xC0, 0xFF, 0xFD, 0xE0, 0x1F, 0xFE, 0xF8, 0x03, 0xFF, 0x3E,
  0x00, 0x7F, 0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x80, 0x07, 0xE0, 0x30,
  0x03, 0xF8, 0x0F, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x7F, 0xC0, 0x7C, 0xFF, 0xF0,
  0x3E, 0xFF, 0xF8, 0x1F, 0xFC, 0xFE, 0x0F, 0xF0, 0x3F, 0x07, 0xF0, 0x0F,
  0x87, 0xF0, 0x07, 0xC3, 0xF8, 0x03, 0xE1, 0xF8, 0x01, 0xF0, 0xF8, 0x01,
  0xF8, 0xFC, 0x00, 0xF8, 0x7E, 0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00,
  0x1F, 0x0F, 0x80, 0x1F, 0x8F, 0xC0, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0,
  0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x01, 0xF8, 0xFC, 0x00, 0xF8, 0x7C,
  0x00, 0x7C, 0x3E, 0x00, 0x3E, 0x1F, 0x00, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0xC0, 0x0F, 0x80, 0x00, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x1F, 0x00,
  0x20, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00,
  0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x0F, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xF8, 0x00, 0xFF, 0x00, 0x07,
  0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x04, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x1F, 0x80,
  0x7C, 0x0F, 0xC0, 0x1F, 0x07, 0xE0, 0x07, 0xC3, 0xF0, 0x03, 0xE1, 0xF8,
  0x00, 0xF8, 0xFC, 0x00, 0x3E, 0x7E, 0x00, 0x0F, 0xBF, 0x00, 0x07, 0xDF,
  0x80, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x07,
  0xF7, 0xC0, 0x03, 0xF9, 0xF8, 0x00, 0xFC, 0x3E, 0x00, 0x3E, 0x0F, 0xC0,
  0x0F, 0x83, 0xF0, 0x03, 0xE0, 0x7E, 0x01, 0xF8, 0x1F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xC0, 0x1F, 0x03, 0xF0, 0x07, 0xE0, 0xF8,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x3E, 0x03, 0xF0, 0x1F, 0x00,
  0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x7E, 0x03, 0xE0, 0x1F, 0x00,
  0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C,
  0x03, 0xE0, 0x1F, 0x00, 0xF8, 0x0F, 0xC0, 0x7C, 0x03, 0xE0, 0x1F, 0x01,
  0xF8, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xC3, 0xFC,
  0x07, 0xFC, 0x07, 0xCF, 0xFE, 0x1F, 0xFC, 0x07, 0xDF, 0xFE, 0x3F, 0xFE,
  0x07, 0xFE, 0x7F, 0x7C, 0xFE, 0x07, 0xF8, 0x1F, 0x70, 0x3F, 0x07, 0xF0,
  0x1F, 0xE0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x80, 0x3E, 0x0F,
  0x80, 0x1F, 0x00, 0x3E, 0x1F, 0x80, 0x3F, 0x00, 0x3E, 0x1F, 0x00, 0x3E,
  0x00, 0x7E, 0x1F, 0x00, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x00, 0x7C,
  0x3F, 0x00, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x00, 0x7C, 0x3E, 0x00,
  0x7C, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x00,
  0xF8, 0x7E, 0x00, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xFC, 0x00, 0xF8, 0x7C,
  0x00, 0xF8, 0x01, 0xF8, 0x7C, 0x00, 0xF8, 0x01, 0xF0, 0x7C, 0x00, 0xF8,
  0x01, 0xF0, 0xFC, 0x01, 0xF8, 0x01, 0xF0, 0x03, 0xC1, 0xF8, 0x01, 0xE3,
  0xFF, 0x01, 0xF3, 0xFF, 0xC0, 0xFB, 0xFF, 0xF0, 0x7F, 0xF7, 0xF8, 0x3F,
  0xE0, 0xFC, 0x3F, 0xC0, 0x3E, 0x1F, 0xC0, 0x1F, 0x0F, 0xE0, 0x0F, 0x87,
  0xE0, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x01, 0xF0,
  0xF8, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x3E, 0x00, 0x7E, 0x3F, 0x00, 0x3F,
  0x1F, 0x80, 0x1F, 0x0F, 0x80, 0x0F, 0x87, 0xC0, 0x0F, 0xC7, 0xE0, 0x07,
  0xE3, 0xF0, 0x03, 0xE1, 0xF0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7C, 0x00,
  0xFC, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0xFF, 0xE0, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x0F, 0xFB, 0xFC, 0x0F,
  0xC0, 0x7E, 0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x3E, 0x3F, 0x00, 0x3E, 0x3E,
  0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C, 0x00, 0x3F, 0x7C,
  0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x3E, 0xFC, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x7C, 0xFC, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7E,
  0x01, 0xF8, 0x7F, 0x07, 0xF0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xC0, 0x0F,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x1E, 0x1F, 0xE0,
  0x07, 0xCF, 0xFE, 0x00, 0xFB, 0xFF, 0xE0, 0x1F, 0xF9, 0xFC, 0x03, 0xFC,
  0x0F, 0xC0, 0x7F, 0x00, 0xF8, 0x1F, 0xC0, 0x1F, 0x03, 0xF0, 0x03, 0xE0,
  0x7E, 0x00, 0x7C, 0x0F, 0x80, 0x0F, 0x81, 0xF0, 0x01, 0xF0, 0x7C, 0x00,
  0x3E, 0x0F, 0x80, 0x07, 0xC1, 0xF0, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x0F,
  0xC0, 0x07, 0xC1, 0xF8, 0x01, 0xF8, 0x3E, 0x00, 0x3F, 0x07, 0xE0, 0x0F,
  0xC0, 0xFC, 0x01, 0xF8, 0x3F, 0x80, 0x7E, 0x07, 0xF8, 0x1F, 0x80, 0xFF,
  0xFF, 0xF0, 0x1F, 0x7F, 0xFC, 0x03, 0xE7, 0xFF, 0x00, 0xF8, 0x7F, 0x80,
  0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0xC3, 0xC0,
  0x7F, 0xF1, 0xE0, 0xFF, 0xFD, 0xF0, 0x7F, 0xBF, 0xF8, 0x7F, 0x03, 0xF8,
  0x7E, 0x01, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x00, 0x3F, 0x1F, 0x00, 0x1F,
  0x1F, 0x80, 0x0F, 0x8F, 0xC0, 0x07, 0xC7, 0xC0, 0x03, 0xE3, 0xE0, 0x03,
  0xF1, 0xF0, 0x01, 0xF1, 0xF8, 0x00, 0xF8, 0xFC, 0x00, 0xFC, 0x7E, 0x00,
  0x7E, 0x3F, 0x00, 0x7F, 0x1F, 0x80, 0x3F, 0x0F, 0xC0, 0x3F, 0x83, 0xE0,
  0x3F, 0xC1, 0xF8, 0x3F, 0xE0, 0xFF, 0xFD, 0xE0, 0x3F, 0xFD, 0xF0, 0x0F,
  0xFC, 0xF8, 0x03, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x01, 0xF0, 0x3C, 0x7F,
  0x07, 0xCF, 0xF0, 0x7D, 0xFF, 0x07, 0xFF, 0xF0, 0x7F, 0xC0, 0x07, 0xF8,
  0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xF8,
  0x00, 0x1F, 0x80, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF, 0x81, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0xFE, 0x1F, 0x07, 0xC0, 0x10, 0x7E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F,
  0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x40, 0x03,
  0xE3, 0x80, 0x7F, 0x1F, 0xFF, 0xF0, 0xFF, 0xFF, 0x87, 0xFF, 0xF0, 0x0F,
  0xFF, 0x00, 0x00, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C,
  0x00, 0x7E, 0x00, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF, 0xFF, 0x7F, 0xFF, 0x83,
  0xE0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00,
  0x1F, 0x00, 0x1F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xF0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F,
  0xC0, 0x07, 0xFF, 0x03, 0xFF, 0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x1F, 0x80,
  0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x3F, 0x00,
  0x3E, 0x3F, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00,
  0x7E, 0x7E, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0xFC, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0xF8, 0x01,
  0xF8, 0xF8, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0xF8, 0x07, 0xF0, 0xF8, 0x0F,
  0xF0, 0xFC, 0x1F, 0xF0, 0xFF, 0xFD, 0xF0, 0x7F, 0xF9, 0xE0, 0x7F, 0xF1,
  0xE0, 0x3F, 0xC1, 0xE0, 0xFC, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x7C, 0x00,
  0x7C, 0x7C, 0x00, 0xFC, 0x7C, 0x00, 0xF8, 0x7C, 0x01, 0xF8, 0x7C, 0x01,
  0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x03, 0xE0, 0x3C, 0x07, 0xE0, 0x3E, 0x07,
  0xC0, 0x3E, 0x0F, 0xC0, 0x3E, 0x0F, 0x80, 0x3E, 0x1F, 0x80, 0x3E, 0x1F,
  0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x3E, 0x00, 0x3E, 0x7C, 0x00, 0x1E, 0x7C,
  0x00, 0x1E, 0xF8, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0,
  0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0xF8, 0x03,
  0xF0, 0x03, 0xFF, 0x00, 0x7E, 0x00, 0xFF, 0xE0, 0x1F, 0xC0, 0x1F, 0x7C,
  0x03, 0xF8, 0x07, 0xEF, 0x80, 0xF7, 0x00, 0xF9, 0xF0, 0x1E, 0xE0, 0x3F,
  0x3E, 0x07, 0xDC, 0x07, 0xC7, 0xC0, 0xF3, 0xC0, 0xF8, 0xF8, 0x1E, 0xF8,
  0x3E, 0x1F, 0x07, 0x9F, 0x07, 0xC3, 0xE0, 0xF3, 0xE1, 0xF0, 0x7C, 0x3C,
  0x3C, 0x3E, 0x0F, 0x87, 0x87, 0x8F, 0x81, 0xF1, 0xF0, 0xF1, 0xF0, 0x3E,
  0x3C, 0x1E, 0x7C, 0x03, 0xCF, 0x83, 0xCF, 0x80, 0x79, 0xE0, 0x79, 0xF0,
  0x0F, 0x3C, 0x0F, 0x7C, 0x01, 0xEF, 0x01, 0xEF, 0x80, 0x3D, 0xE0, 0x3D,
  0xE0, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x1F, 0x00, 0x7C, 0x01,
  0xF0, 0x0F, 0xC0, 0x0F, 0x81, 0xF8, 0x00, 0xF8, 0x3F, 0x00, 0x0F, 0xC7,
  0xE0, 0x00, 0x7C, 0x7C, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x3F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0xFB, 0xE0, 0x00, 0x1F, 0xBE, 0x00, 0x03, 0xF3, 0xF0, 0x00, 0x7E,
  0x1F, 0x00, 0x07, 0xC1, 0xF8, 0x00, 0xFC, 0x0F, 0x80, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x7E, 0x00, 0x7C, 0x0F, 0xC0, 0x07, 0xE0, 0x03,
  0xF0, 0x00, 0xFC, 0x07, 0xC0, 0x07, 0xE0, 0x1F, 0x00, 0x1F, 0x80, 0x7C,
  0x00, 0xFC, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x7C, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x03, 0xE0, 0x7E,
  0x00, 0x0F, 0x81, 0xF0, 0x00, 0x3E, 0x0F, 0xC0, 0x00, 0xF8, 0x3E, 0x00,
  0x03, 0xE1, 0xF8, 0x00, 0x07, 0x87, 0xC0, 0x00, 0x1E, 0x3E, 0x00, 0x00,
  0x78, 0xF8, 0x00, 0x01, 0xE7, 0xC0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x1F,
  0x78, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x03, 0x7F, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0xFF, 0xF8, 0x3F, 0xFF, 0xF0, 0x7F, 0xFF, 0xC1, 0xFF, 0xFF,
  0x80, 0x00, 0x01, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xE0,
  0x07, 0xFC, 0x00, 0x7F, 0x80, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x00, 0x00, 0xF0,
  0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0xFF, 0x80,
  0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00,
  0x0F, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00,
  0x1F, 0xE0, 0x01, 0xFE, 0x00, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xFE, 0x00,
  0xFC, 0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x1F, 0xE0, 0x07, 0xF8,
  0x00, 0xFF, 0x00, 0x1F, 0x80, 0x03, 0x80, 0x00, 0x00, 0x0F, 0x00, 0x02,
  0x7F, 0xE0, 0x05, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xF8,
  0x03, 0xFF, 0xA0, 0x01, 0xFE, 0x00,
};

const GFXglyph NotoSans_MediumItalic49pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 13, 0, -1 },
  { 1, 13, 36, 13, 1, -35 },
  { 60, 16, 13, 20, 5, -35 },
  { 86, 31, 35, 32, 1, -35 },
  { 222, 24, 40, 27, 2, -37 },
  { 342, 34, 35, 40, 4, -35 },
  { 491, 30, 36, 33, 2, -36 },
  { 626, 7, 13, 11, 5, -35 },
  { 638, 17, 43, 15, 2, -35 },
  { 730, 17, 43, 15, -4, -35 },
  { 822, 23, 23, 27, 5, -37 },
  { 889, 23, 24, 28, 3, -29 },
  { 958, 10, 12, 13, -2, -6 },
  { 973, 13, 4, 15, 1, -15 },
  { 980, 7, 7, 13, 1, -6 },
  { 987, 24, 35, 18, -2, -35 },
  { 1092, 24, 36, 27, 2, -36 },
  { 1200, 16, 35, 27, 6, -35 },
  { 1270, 26, 35, 27, 0, -35 },
  { 1384, 25, 35, 27, 1, -35 },
  { 1494, 26, 35, 27, 0, -35 },
  { 1608, 25, 35, 27, 1, -35 },
  { 1718, 24, 35, 27, 3, -35 },
  { 1823, 25, 35, 27, 3, -35 },
  { 1933, 25, 36, 27, 2, -36 },
  { 2046, 24, 35, 27, 2, -35 },
  { 2151, 11, 28, 13, 1, -27 },
  { 2190, 14, 33, 13, -2, -27 },
  { 2248, 23, 25, 28, 3, -30 },
  { 2320, 23, 14, 28, 3, -24 },
  { 2361, 23, 25, 28, 3, -30 },
  { 2433, 19, 36, 22, 4, -35 },
  { 2519, 39, 39, 42, 2, -35 },
  { 2710, 29, 35, 28, -3, -35 },
  { 2837, 27, 35, 30, 2, -35 },
  { 2956, 28, 35, 29, 3, -35 },
  { 3079, 29, 35, 33, 2, -35 },
  { 3206, 25, 35, 26, 2, -35 },
  { 3316, 25, 35, 24, 2, -35 },
  { 3426, 30, 35, 33, 3, -35 },
  { 3558, 32, 35, 34, 2, -35 },
  { 3698, 21, 35, 17, -1, -35 },
  { 3790, 23, 45, 14, -8, -35 },
  { 3920, 31, 35, 28, 2, -35 },
  { 4056, 19, 35, 24, 2, -35 },
  { 4140, 40, 35, 42, 2, -35 },
  { 4315, 34, 35, 35, 2, -35 },
  { 4464, 31, 36, 35, 3, -36 },
  { 4604, 26, 35, 28, 2, -35 },
  { 4718, 31, 44, 35, 3, -36 },
  { 4889, 26, 35, 29, 2, -35 },
  { 5003, 25, 35, 25, 1, -35 },
  { 5113, 25, 35, 25, 4, -35 },
  { 5223, 30, 35, 33, 4, -35 },
  { 5355, 28, 35, 28, 4, -35 },
  { 5478, 42, 35, 42, 5, -35 },
  { 5662, 34, 35, 27, -3, -35 },
  { 5811, 25, 35, 26, 5, -35 },
  { 5921, 29, 35, 26, -1, -35 },
  { 6048, 20, 43, 15, -1, -35 },
  { 6156, 10, 35, 18, 5, -35 },
  { 6200, 19, 43, 15, -3, -35 },
  { 6303, 24, 22, 28, 2, -35 },
  { 6369, 21, 4, 19, -5, 4 },
  { 6380, 9, 8, 14, 7, -38 },
  { 6389, 25, 27, 28, 2, -27 },
  { 6474, 25, 37, 29, 1, -37 },
  { 6590, 21, 27, 23, 2, -27 },
  { 6661, 28, 37, 29, 2, -37 },
  { 6791, 22, 27, 25, 2, -27 },
  { 6866, 27, 49, 16, -5, -37 },
  { 7032, 26, 39, 29, 1, -27 },
  { 7159, 25, 37, 29, 1, -37 },
  { 7275, 13, 36, 13, 1, -36 },
  { 7334, 20, 48, 13, -6, -36 },
  { 7454, 26, 37, 25, 1, -37 },
  { 7575, 13, 37, 13, 1, -37 },
  { 7636, 40, 27, 43, 1, -27 },
  { 7771, 25, 27, 29, 1, -27 },
  { 7856, 24, 27, 28, 2, -27 },
  { 7937, 27, 39, 29, -1, -27 },
  { 8069, 25, 39, 29, 2, -27 },
  { 8191, 20, 27, 20, 1, -27 },
  { 8259, 21, 27, 22, 0, -27 },
  { 8330, 17, 32, 17, 2, -32 },
  { 8398, 24, 26, 29, 3, -26 },
  { 8476, 24, 26, 24, 2, -26 },
  { 8554, 35, 26, 36, 3, -26 },
  { 8668, 28, 26, 24, -2, -26 },
  { 8759, 30, 38, 24, -4, -26 },
  { 8902, 23, 26, 22, -1, -26 },
  { 8977, 20, 43, 17, 0, -35 },
  { 9085, 4, 49, 27, 12, -37 },
  { 9110, 19, 43, 17, -2, -35 },
  { 9213, 23, 7, 28, 3, -21 },
};

const GFXfont NotoSans_MediumItalic49pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic49pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic49pt7bGlyphs,
  0x20, 0x7E, 67
};

#endif // _NOTOSANS_MEDIUMITALIC49PT7B_H_
