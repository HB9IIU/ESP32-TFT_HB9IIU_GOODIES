#ifndef _NOTOSANS_MEDIUMITALIC14PT7B_H_
#define _NOTOSANS_MEDIUMITALIC14PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 14pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic14pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x22, 0x66, 0x40, 0x4C, 0x5A, 0xD5, 0x20, 0x09, 0x04, 0x86,
  0xCF, 0xF1, 0x20, 0x93, 0xFC, 0x48, 0x24, 0x34, 0x00, 0x04, 0x08, 0xF9,
  0x42, 0x87, 0x03, 0x0B, 0x97, 0xF8, 0x41, 0x00, 0x70, 0x94, 0x49, 0x22,
  0x58, 0x95, 0xBA, 0x91, 0x24, 0xDB, 0x26, 0x90, 0xE0, 0x1E, 0x09, 0x0C,
  0x82, 0xC1, 0x83, 0x45, 0x37, 0x8E, 0x47, 0x3E, 0xC0, 0x56, 0x12, 0x44,
  0xC8, 0x88, 0x88, 0x8C, 0x10, 0x86, 0x31, 0x8C, 0x42, 0x31, 0x19, 0x80,
  0x08, 0x33, 0x41, 0xF3, 0x89, 0x02, 0x00, 0x10, 0x23, 0xFF, 0xF1, 0x02,
  0x00, 0x2D, 0x60, 0xF0, 0x70, 0x02, 0x0C, 0x10, 0x41, 0x82, 0x0C, 0x10,
  0x61, 0x80, 0x3C, 0xC9, 0x16, 0x38, 0x50, 0xA1, 0x46, 0xD8, 0xE0, 0x37,
  0xF3, 0x22, 0x26, 0x64, 0x3E, 0x44, 0x08, 0x10, 0x61, 0x86, 0x10, 0x43,
  0xF8, 0x3E, 0x44, 0x08, 0x33, 0xC1, 0x81, 0x83, 0x8D, 0xF0, 0x06, 0x0C,
  0x28, 0xB2, 0x4C, 0xB1, 0x7F, 0x0C, 0x10, 0x1F, 0x30, 0x20, 0x20, 0x7C,
  0x06, 0x06, 0x06, 0x8C, 0xF8, 0x1E, 0x61, 0x06, 0x0F, 0xD9, 0xA1, 0x46,
  0xC8, 0xF0, 0x7F, 0x0C, 0x30, 0x41, 0x82, 0x0C, 0x30, 0x41, 0x80, 0x3C,
  0xCD, 0x1B, 0x23, 0x8F, 0x23, 0x46, 0x8D, 0xF0, 0x3D, 0x1C, 0x71, 0xCD,
  0xD0, 0xC2, 0x1B, 0xC0, 0x2C, 0x00, 0x16, 0x13, 0x00, 0x00, 0x26, 0x4C,
  0x02, 0x1C, 0xE7, 0x0C, 0x07, 0x03, 0x80, 0xFC, 0x00, 0x3F, 0x81, 0x80,
  0xC0, 0x60, 0xE6, 0x30, 0x00, 0x7A, 0x20, 0xC6, 0x31, 0x84, 0x00, 0xC3,
  0x00, 0x0F, 0x86, 0x19, 0x01, 0x67, 0xB9, 0x37, 0x64, 0xAC, 0x95, 0xB6,
  0x89, 0x08, 0x00, 0xFC, 0x00, 0x06, 0x06, 0x0F, 0x0B, 0x1B, 0x13, 0x3F,
  0x21, 0x61, 0xC1, 0x3C, 0xCD, 0x8A, 0x37, 0xD9, 0xB1, 0xE3, 0x8D, 0xF0,
  0x1F, 0x31, 0x60, 0xC0, 0xC0, 0xC0, 0xC0, 0xC0, 0xE4, 0x7C, 0x3C, 0x66,
  0x63, 0x43, 0x43, 0xC3, 0xC3, 0xC6, 0x8C, 0xF8, 0x3E, 0xC1, 0x82, 0x07,
  0xD8, 0x30, 0x60, 0x81, 0xF0, 0x3E, 0xC1, 0x82, 0x04, 0x5F, 0x30, 0x60,
  0x81, 0x00, 0x1F, 0x31, 0x60, 0xC0, 0xC0, 0xCF, 0xC2, 0xC2, 0xE2, 0x7E,
  0x21, 0xB0, 0x98, 0x48, 0x67, 0xF6, 0x13, 0x09, 0x84, 0x86, 0x43, 0x00,
  0x3C, 0x43, 0x0C, 0x20, 0x82, 0x18, 0x63, 0xC0, 0x04, 0x30, 0xC2, 0x08,
  0x21, 0x86, 0x10, 0x43, 0x38, 0xC0, 0x23, 0x66, 0x6C, 0x58, 0x70, 0xF0,
  0xD8, 0xC8, 0x8C, 0x8C, 0x23, 0x18, 0x84, 0x63, 0x18, 0x87, 0xC0, 0x18,
  0x33, 0x87, 0x28, 0xE2, 0x8A, 0x29, 0xA6, 0x96, 0x6B, 0x64, 0xA4, 0x4E,
  0x4C, 0xCC, 0x10, 0x4E, 0x32, 0x8C, 0xB2, 0x2C, 0x99, 0x26, 0x79, 0x0E,
  0x43, 0x30, 0xC0, 0x1E, 0x19, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x05, 0x86,
  0xE6, 0x3E, 0x00, 0x3C, 0xCD, 0x8A, 0x14, 0x7F, 0xB0, 0x60, 0x81, 0x00,
  0x1E, 0x19, 0x98, 0x78, 0x3C, 0x1E, 0x0F, 0x05, 0x86, 0xE6, 0x3E, 0x03,
  0x00, 0xC0, 0x3C, 0xCD, 0x8A, 0x34, 0xDF, 0x36, 0x64, 0x8D, 0x08, 0x1E,
  0x65, 0x81, 0x03, 0x83, 0x81, 0x02, 0x8D, 0xF0, 0xFE, 0x20, 0x41, 0x83,
  0x06, 0x08, 0x10, 0x60, 0xC0, 0x61, 0xB0, 0x90, 0x48, 0x64, 0x36, 0x1B,
  0x09, 0x8C, 0xC6, 0x3E, 0x00, 0xC3, 0xC2, 0x46, 0x44, 0x4C, 0x48, 0x58,
  0x50, 0x70, 0x60, 0xC6, 0x1C, 0x63, 0x46, 0x24, 0xA6, 0x4A, 0x45, 0x2C,
  0x52, 0x87, 0x28, 0x63, 0x86, 0x30, 0x10, 0xC6, 0x61, 0xB0, 0x28, 0x0C,
  0x03, 0x01, 0xE0, 0xC8, 0x62, 0x30, 0xC0, 0xC3, 0x46, 0x4C, 0x68, 0x78,
  0x30, 0x20, 0x20, 0x60, 0x60, 0x3F, 0x03, 0x06, 0x0C, 0x18, 0x10, 0x30,
  0x60, 0xC0, 0xFC, 0x39, 0x08, 0x46, 0x31, 0x08, 0x46, 0x31, 0xC0, 0xAA,
  0xBD, 0x50, 0x38, 0x42, 0x31, 0x88, 0x42, 0x31, 0x09, 0xC0, 0x18, 0x30,
  0xD1, 0x26, 0x78, 0x40, 0xFC, 0xC8, 0x80, 0x32, 0xFF, 0x16, 0x28, 0xD1,
  0xA7, 0x74, 0x10, 0x30, 0x30, 0x24, 0x3E, 0x23, 0x62, 0x62, 0x46, 0x66,
  0xFC, 0x3D, 0xEC, 0x20, 0x82, 0x0C, 0x9E, 0x02, 0x04, 0x09, 0xB7, 0xF8,
  0xA1, 0x46, 0x8D, 0x3B, 0xA0, 0x39, 0xBC, 0xE6, 0xF2, 0x0C, 0x9E, 0x03,
  0x07, 0x0C, 0x0E, 0x1E, 0x08, 0x08, 0x18, 0x18, 0x10, 0x10, 0x10, 0x30,
  0xE0, 0x19, 0x3F, 0x62, 0x62, 0x46, 0x46, 0x4E, 0x74, 0x04, 0x0C, 0xF8,
  0x10, 0x60, 0xC1, 0x23, 0xE4, 0x58, 0xB1, 0x46, 0x8F, 0x10, 0x30, 0x22,
  0x26, 0x64, 0x4C, 0x0C, 0x00, 0x82, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x08,
  0xE0, 0x10, 0x30, 0x30, 0x23, 0x26, 0x2C, 0x78, 0x78, 0x48, 0x4C, 0xC4,
  0x13, 0x32, 0x22, 0x66, 0x44, 0xC0, 0x24, 0x63, 0xEF, 0x23, 0x36, 0x22,
  0x66, 0x24, 0x62, 0x44, 0x6C, 0x46, 0x26, 0x7D, 0x8B, 0x16, 0x28, 0xD1,
  0xE2, 0x39, 0xFC, 0x61, 0x86, 0x3C, 0x9C, 0x24, 0x3E, 0x23, 0x62, 0x62,
  0x46, 0x66, 0xFC, 0xC0, 0xC0, 0x80, 0x32, 0xFF, 0x14, 0x28, 0xD1, 0xA7,
  0x74, 0x08, 0x30, 0x60, 0x2C, 0xF3, 0x18, 0x61, 0x04, 0x30, 0x39, 0xB4,
  0x18, 0x38, 0x28, 0xBC, 0x27, 0xF4, 0xCC, 0x88, 0xE0, 0x46, 0x8F, 0x16,
  0x28, 0xD1, 0xA7, 0x74, 0x86, 0x38, 0xA6, 0xD3, 0xCE, 0x18, 0x8C, 0xE3,
  0x29, 0x4A, 0x56, 0xA5, 0x29, 0xCC, 0x63, 0x18, 0x31, 0x13, 0x16, 0x1C,
  0x18, 0x1C, 0x24, 0xE6, 0x21, 0x23, 0x22, 0x36, 0x34, 0x3C, 0x18, 0x18,
  0x10, 0x30, 0xE0, 0x3D, 0xF0, 0x84, 0x31, 0x8C, 0x3E, 0x1C, 0x41, 0x0C,
  0x33, 0x8C, 0x18, 0x61, 0x04, 0x18, 0xFF, 0xFF, 0xFF, 0xF0, 0x18, 0x20,
  0x86, 0x10, 0x61, 0xC4, 0x30, 0x82, 0x38, 0xE3, 0x38,
};

const GFXglyph NotoSans_MediumItalic14pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 10, 4, 0, -10 },
  { 6, 5, 4, 6, 1, -10 },
  { 9, 9, 10, 9, 0, -10 },
  { 21, 7, 12, 8, 0, -11 },
  { 32, 10, 10, 11, 1, -10 },
  { 45, 9, 10, 10, 0, -10 },
  { 57, 2, 4, 3, 1, -10 },
  { 58, 4, 12, 4, 1, -10 },
  { 64, 5, 12, 4, -1, -10 },
  { 72, 7, 7, 8, 1, -11 },
  { 79, 7, 6, 8, 1, -8 },
  { 85, 3, 4, 4, -1, -2 },
  { 87, 4, 1, 4, 0, -4 },
  { 88, 2, 2, 4, 0, -2 },
  { 89, 7, 10, 5, -1, -10 },
  { 98, 7, 10, 8, 1, -10 },
  { 107, 4, 10, 8, 2, -10 },
  { 112, 7, 10, 8, 0, -10 },
  { 121, 7, 10, 8, 0, -10 },
  { 130, 7, 10, 8, 0, -10 },
  { 139, 8, 10, 8, 0, -10 },
  { 149, 7, 10, 8, 1, -10 },
  { 158, 7, 10, 8, 1, -10 },
  { 167, 7, 10, 8, 1, -10 },
  { 176, 6, 10, 8, 1, -10 },
  { 184, 3, 8, 4, 0, -8 },
  { 187, 4, 10, 4, -1, -8 },
  { 192, 7, 7, 8, 1, -9 },
  { 199, 6, 4, 8, 1, -7 },
  { 202, 7, 7, 8, 1, -9 },
  { 209, 6, 10, 6, 1, -10 },
  { 217, 11, 11, 12, 1, -10 },
  { 233, 8, 10, 8, -1, -10 },
  { 243, 7, 10, 8, 1, -10 },
  { 252, 8, 10, 8, 1, -10 },
  { 262, 8, 10, 9, 1, -10 },
  { 272, 7, 10, 7, 1, -10 },
  { 281, 7, 10, 7, 1, -10 },
  { 290, 8, 10, 10, 1, -10 },
  { 300, 9, 10, 10, 1, -10 },
  { 312, 6, 10, 5, 0, -10 },
  { 320, 6, 13, 4, -2, -10 },
  { 330, 8, 10, 8, 1, -10 },
  { 340, 5, 10, 7, 1, -10 },
  { 347, 12, 10, 12, 0, -10 },
  { 362, 10, 10, 10, 0, -10 },
  { 375, 9, 10, 10, 1, -10 },
  { 387, 7, 10, 8, 1, -10 },
  { 396, 9, 12, 10, 1, -10 },
  { 410, 7, 10, 8, 1, -10 },
  { 419, 7, 10, 7, 0, -10 },
  { 428, 7, 10, 7, 1, -10 },
  { 437, 9, 10, 10, 1, -10 },
  { 449, 8, 10, 8, 1, -10 },
  { 459, 12, 10, 12, 1, -10 },
  { 474, 10, 10, 8, -1, -10 },
  { 487, 8, 10, 7, 1, -10 },
  { 497, 8, 10, 7, 0, -10 },
  { 507, 5, 12, 4, 0, -10 },
  { 515, 2, 10, 5, 2, -10 },
  { 518, 5, 12, 4, -1, -10 },
  { 526, 7, 6, 8, 0, -10 },
  { 532, 6, 1, 6, -1, 1 },
  { 533, 3, 3, 4, 2, -11 },
  { 535, 7, 8, 8, 1, -8 },
  { 542, 8, 11, 8, 0, -11 },
  { 553, 6, 8, 6, 1, -8 },
  { 559, 7, 11, 8, 1, -11 },
  { 569, 6, 8, 7, 1, -8 },
  { 575, 8, 14, 5, -2, -11 },
  { 589, 8, 11, 8, 0, -8 },
  { 600, 7, 11, 8, 0, -11 },
  { 610, 4, 10, 4, 0, -10 },
  { 615, 6, 13, 4, -2, -10 },
  { 625, 8, 11, 7, 0, -11 },
  { 636, 4, 11, 4, 0, -11 },
  { 642, 12, 8, 12, 0, -8 },
  { 654, 7, 8, 8, 0, -8 },
  { 661, 6, 8, 8, 1, -8 },
  { 667, 8, 11, 8, 0, -8 },
  { 678, 7, 11, 8, 1, -8 },
  { 688, 6, 8, 6, 0, -8 },
  { 694, 6, 8, 6, 0, -8 },
  { 700, 4, 9, 5, 1, -9 },
  { 705, 7, 8, 8, 1, -8 },
  { 712, 6, 8, 7, 1, -8 },
  { 718, 10, 8, 10, 1, -8 },
  { 728, 8, 8, 7, -1, -8 },
  { 736, 8, 11, 7, -1, -8 },
  { 747, 6, 8, 6, 0, -8 },
  { 753, 6, 12, 5, 0, -10 },
  { 762, 2, 14, 8, 3, -11 },
  { 766, 6, 12, 5, -1, -10 },
  { 775, 7, 2, 8, 1, -6 },
};

const GFXfont NotoSans_MediumItalic14pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic14pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic14pt7bGlyphs,
  0x20, 0x7E, 19
};

#endif // _NOTOSANS_MEDIUMITALIC14PT7B_H_
