#ifndef _NOTOSANS_MEDIUMITALIC38PT7B_H_
#define _NOTOSANS_MEDIUMITALIC38PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 38pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic38pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x78, 0x1E, 0x0F, 0x83, 0xE0, 0xF0, 0x3C, 0x0F,
  0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x07, 0x81, 0xC0, 0xF0, 0x3C, 0x0F, 0x03,
  0x80, 0x00, 0x00, 0x00, 0x07, 0x03, 0xE0, 0xF8, 0x3E, 0x0F, 0x01, 0x00,
  0x78, 0xF7, 0x8F, 0x78, 0xF7, 0x0E, 0x70, 0xE7, 0x1E, 0xF1, 0xCE, 0x1C,
  0xE1, 0xCE, 0x18, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38,
  0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0x70, 0x70, 0x00, 0xE0, 0xE0,
  0x00, 0xE0, 0xE0, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF, 0x3F, 0xFF, 0xFF,
  0x01, 0xC1, 0xC0, 0x01, 0xC1, 0xC0, 0x03, 0x83, 0x80, 0x03, 0x83, 0x80,
  0x03, 0x83, 0x80, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC,
  0x07, 0x07, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00,
  0x1E, 0x1E, 0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x3C, 0x3C, 0x00,
  0x00, 0x0E, 0x00, 0x01, 0x80, 0x00, 0x30, 0x00, 0x1F, 0x00, 0x1F, 0xFE,
  0x0F, 0xFF, 0xC3, 0xFF, 0xF0, 0x79, 0xC2, 0x0E, 0x38, 0x03, 0xC7, 0x00,
  0x78, 0xC0, 0x0F, 0x18, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x01, 0xFE, 0x00,
  0x1F, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x03, 0x9E, 0x00, 0x63, 0xC0,
  0x0C, 0x78, 0x03, 0x8F, 0x20, 0x73, 0xE7, 0x8E, 0xF8, 0xFF, 0xFE, 0x1F,
  0xFF, 0x80, 0xFF, 0xC0, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x06, 0x00, 0x01,
  0xC0, 0x00, 0x01, 0x00, 0x00, 0x03, 0xF0, 0x01, 0xE1, 0xFE, 0x00, 0xF0,
  0xF7, 0xC0, 0x78, 0x78, 0xF0, 0x1C, 0x1C, 0x1C, 0x0E, 0x07, 0x07, 0x07,
  0x83, 0xC3, 0xC1, 0xC0, 0xE0, 0xF0, 0xE0, 0x38, 0x38, 0x70, 0x0E, 0x0E,
  0x3C, 0x03, 0x83, 0x8E, 0x18, 0xE1, 0xE7, 0x3F, 0xB8, 0x73, 0x9F, 0xFF,
  0x7D, 0xEF, 0x3D, 0xFE, 0x73, 0x87, 0x7F, 0x39, 0xE1, 0xC2, 0x1E, 0x70,
  0x70, 0x0F, 0x1C, 0x1C, 0x03, 0x87, 0x07, 0x01, 0xC3, 0xC1, 0xC0, 0xF0,
  0xF0, 0xF0, 0x78, 0x3C, 0x38, 0x1C, 0x0F, 0x0E, 0x0E, 0x03, 0xC7, 0x87,
  0x80, 0x7F, 0xC3, 0xC0, 0x1F, 0xE1, 0xE0, 0x03, 0xF0, 0x00, 0x04, 0x00,
  0x00, 0x7F, 0x80, 0x01, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x03, 0xC1, 0xE0,
  0x03, 0xC1, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xE0, 0x03, 0x81, 0xE0,
  0x03, 0xC3, 0xC0, 0x03, 0xCF, 0x80, 0x03, 0xFF, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xF8, 0x0F, 0x3E, 0x3C, 0x1E,
  0x7C, 0x3E, 0x1E, 0x78, 0x1F, 0x3C, 0xF8, 0x0F, 0x7C, 0xF0, 0x0F, 0xF8,
  0xF0, 0x07, 0xF0, 0xF0, 0x03, 0xE0, 0xF8, 0x07, 0xE0, 0x7C, 0x1F, 0xF0,
  0x7F, 0xFF, 0xF8, 0x3F, 0xFC, 0x78, 0x1F, 0xF0, 0x7C, 0x7B, 0xDE, 0xE7,
  0x3B, 0xDC, 0xE7, 0x00, 0x00, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0, 0x3C,
  0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0E, 0x00, 0xF0, 0x07, 0x00, 0x78, 0x03,
  0xC0, 0x1C, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03, 0x80, 0x1C, 0x00, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x1E, 0x00,
  0xF0, 0x07, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x80, 0x1C, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80,
  0x38, 0x03, 0xC0, 0x1C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0,
  0x0F, 0x00, 0xF0, 0x00, 0x00, 0xE0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1C,
  0x04, 0x0E, 0x07, 0x87, 0x03, 0xF3, 0x00, 0xFF, 0x9F, 0x0F, 0xFF, 0x81,
  0xFF, 0xC1, 0xF8, 0x61, 0xDC, 0x01, 0xEE, 0x01, 0xE3, 0x81, 0xE1, 0xC0,
  0x60, 0xF0, 0x10, 0x38, 0x00, 0x10, 0x00, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00, 0x0E, 0x00, 0x03,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x03, 0x80, 0x00, 0xE0,
  0x00, 0x38, 0x00, 0x0E, 0x00, 0x03, 0x80, 0x00, 0xE0, 0x00, 0x38, 0x00,
  0x0E, 0x00, 0x0F, 0x1F, 0x1E, 0x1E, 0x3C, 0x38, 0x78, 0x70, 0xF0, 0x7F,
  0xFF, 0xFF, 0xFB, 0xFE, 0x77, 0xFF, 0xFF, 0x20, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03,
  0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x10, 0x00, 0x7F, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0x87,
  0xC7, 0xC0, 0xF1, 0xE0, 0x3C, 0xF8, 0x0F, 0x3C, 0x03, 0xDF, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x0F, 0x78, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xC0,
  0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x1E, 0xF0, 0x0F,
  0x3C, 0x03, 0xCF, 0x01, 0xF3, 0xE0, 0xF8, 0x7C, 0x7C, 0x1F, 0xFE, 0x03,
  0xFF, 0x00, 0x7F, 0x80, 0x00, 0xF0, 0x3F, 0x07, 0xF1, 0xFF, 0x3F, 0xEF,
  0xDE, 0xF9, 0xE6, 0x1E, 0x41, 0xE0, 0x3C, 0x03, 0xC0, 0x3C, 0x03, 0xC0,
  0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x0F, 0x00, 0xF0, 0x0F, 0x00,
  0xF0, 0x1F, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x1E, 0x00, 0x00, 0x0C, 0x00,
  0x0F, 0xF8, 0x03, 0xFF, 0xE0, 0x7F, 0xFE, 0x07, 0xC1, 0xF0, 0x30, 0x0F,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7F, 0xFF, 0xCF,
  0xFF, 0xF8, 0xFF, 0xFF, 0x8F, 0xFF, 0xF8, 0x00, 0x18, 0x00, 0x3F, 0xE0,
  0x1F, 0xFF, 0x07, 0xFF, 0xE0, 0x70, 0x3E, 0x08, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x3F, 0xF0, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00,
  0x03, 0xE4, 0x00, 0x78, 0xE0, 0x3F, 0x1F, 0xFF, 0xC3, 0xFF, 0xF0, 0x3F,
  0xF8, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x0E, 0xE0, 0x01, 0xFE, 0x00, 0x3D, 0xE0, 0x07, 0x9E, 0x00, 0xF1,
  0xC0, 0x0F, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x07, 0x83, 0x80, 0xF0,
  0x78, 0x1E, 0x07, 0x83, 0xC0, 0x78, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0xF0, 0x00, 0x1E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xFF,
  0xF0, 0x3F, 0xFE, 0x03, 0xFF, 0xE0, 0x38, 0x00, 0x07, 0x80, 0x00, 0x78,
  0x00, 0x07, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0E,
  0xF8, 0x01, 0xFF, 0xE0, 0x1F, 0xFF, 0x00, 0xF7, 0xF8, 0x00, 0x0F, 0x80,
  0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x80, 0x1F, 0x0E, 0x03, 0xF0, 0xFF, 0xFE,
  0x0F, 0xFF, 0xC0, 0x7F, 0xF0, 0x00, 0x00, 0x01, 0x00, 0x07, 0xFC, 0x03,
  0xFF, 0x80, 0xFF, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x1E, 0x7E, 0x07, 0xBF,
  0xE0, 0xFF, 0xFE, 0x1F, 0x83, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0x9F, 0x00,
  0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03,
  0xC3, 0xC0, 0xF8, 0x7C, 0x3E, 0x07, 0xFF, 0x80, 0xFF, 0xE0, 0x07, 0xF8,
  0x00, 0x7F, 0xFF, 0xEF, 0xFF, 0xF9, 0xFF, 0xFF, 0x00, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x07, 0x80,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x10, 0x00, 0x3F, 0xE0, 0x0F,
  0xFE, 0x03, 0xFF, 0xE0, 0xF8, 0x3C, 0x1E, 0x07, 0xC7, 0x80, 0x78, 0xF0,
  0x0F, 0x1E, 0x03, 0xC3, 0xE0, 0x78, 0x3C, 0x1E, 0x07, 0xCF, 0x80, 0x7F,
  0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x00, 0xFF, 0xF0, 0x7E, 0x1F, 0x0F, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3C, 0x03,
  0xE7, 0x80, 0x78, 0xF8, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF, 0xF0, 0x0F, 0xF8,
  0x00, 0x00, 0x20, 0x00, 0xFF, 0x80, 0x7F, 0xF0, 0x3F, 0xFE, 0x1F, 0x0F,
  0x8F, 0x81, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03, 0xDE, 0x00, 0xF7,
  0x80, 0x3D, 0xE0, 0x1F, 0x78, 0x07, 0xDF, 0x03, 0xF3, 0xE3, 0xF8, 0xFF,
  0xFE, 0x1F, 0xF7, 0x83, 0xF1, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F,
  0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x81, 0xF8, 0x3F, 0xFC, 0x0F,
  0xFE, 0x03, 0xFE, 0x00, 0x0E, 0x1F, 0x1F, 0x1F, 0x1E, 0x0C, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x70, 0xF8, 0xF8, 0xF8,
  0xF0, 0x40, 0x01, 0xC0, 0x7C, 0x0F, 0x81, 0xF0, 0x3C, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x78, 0x0F, 0x03, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0x70,
  0x1C, 0x00, 0x00, 0x00, 0x60, 0x00, 0x3C, 0x00, 0x1F, 0x80, 0x0F, 0xE0,
  0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x1F,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xE0, 0x00, 0x1C, 0x00, 0x00, 0x80,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0,
  0xC0, 0x00, 0x1E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7C,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x07, 0xF0, 0x07,
  0xF8, 0x00, 0xFC, 0x00, 0x1C, 0x00, 0x02, 0x00, 0x00, 0x00, 0x01, 0x80,
  0x3F, 0xE1, 0xFF, 0xE3, 0xFF, 0xE7, 0x03, 0xC8, 0x07, 0xC0, 0x07, 0x80,
  0x0F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0xFC,
  0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xC0, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x38, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0,
  0x07, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0xFF, 0xFC,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x7C, 0x00, 0xF8, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x07, 0x87, 0x80, 0x78, 0x0E, 0x3C,
  0x0F, 0xFC, 0x38, 0xE0, 0x7F, 0xF0, 0xE7, 0x83, 0xC3, 0xC3, 0x9C, 0x1E,
  0x0E, 0x0F, 0x70, 0xF0, 0x38, 0x3B, 0xC3, 0x80, 0xE0, 0xEE, 0x1E, 0x07,
  0x83, 0xB8, 0x78, 0x1C, 0x0E, 0xE1, 0xC0, 0x70, 0x7B, 0x87, 0x03, 0xC1,
  0xCE, 0x1C, 0x0F, 0x0F, 0x38, 0x78, 0x7C, 0x78, 0xE0, 0xFF, 0x7F, 0xC3,
  0xC3, 0xFC, 0xFE, 0x07, 0x07, 0xC1, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x80, 0x03, 0xFC,
  0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x7B, 0xC0, 0x01, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x3C, 0x1C, 0x00, 0xF0, 0x70, 0x07, 0x81,
  0xE0, 0x1E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0xFF, 0xFF, 0x83, 0xC0, 0x1E, 0x1F, 0x00, 0x78, 0x78, 0x00, 0xE3, 0xE0,
  0x03, 0xCF, 0x00, 0x0F, 0x78, 0x00, 0x3D, 0xE0, 0x00, 0xFF, 0x00, 0x03,
  0xC0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0xC0, 0x3F, 0xFF, 0x81, 0xE0, 0x7E,
  0x07, 0x80, 0x78, 0x1E, 0x01, 0xF0, 0x78, 0x07, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0x78, 0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0x80, 0x7F, 0xFE, 0x01, 0xFF, 0xFC, 0x07, 0x80, 0xF8, 0x1E, 0x01, 0xF0,
  0xF0, 0x03, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0,
  0x07, 0x87, 0x80, 0x3E, 0x1E, 0x07, 0xF0, 0x7F, 0xFF, 0x81, 0xFF, 0xFC,
  0x0F, 0xFF, 0x80, 0x00, 0x00, 0x02, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xFE,
  0x07, 0xFF, 0xF0, 0x7E, 0x07, 0x07, 0xC0, 0x08, 0x7C, 0x00, 0x07, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0x07, 0x01, 0xFF, 0xF8,
  0x07, 0xFF, 0xC0, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x07, 0xFF, 0xC0,
  0x0F, 0xFF, 0xC0, 0x3C, 0x3F, 0xC0, 0x78, 0x0F, 0xC0, 0xF0, 0x07, 0x81,
  0xE0, 0x0F, 0x83, 0xC0, 0x0F, 0x0F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x3C,
  0x00, 0x78, 0x78, 0x00, 0xF1, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7, 0x80,
  0x07, 0x8F, 0x00, 0x1F, 0x1E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01,
  0xF1, 0xE0, 0x07, 0xC3, 0xC0, 0x1F, 0x87, 0x80, 0x7E, 0x1E, 0x01, 0xF8,
  0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0x80, 0xFF, 0xFC, 0x03, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F,
  0xFF, 0x81, 0xE0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0xFF, 0xE0,
  0x7F, 0xFE, 0x07, 0xFF, 0xE0, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xF0, 0x3F,
  0xFF, 0x03, 0xFF, 0xF0, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07,
  0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x1F, 0xFF, 0x81, 0xFF, 0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xF0,
  0x1E, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x01, 0xFF, 0xE0, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFF, 0x07, 0xF0, 0x38, 0x3E, 0x00, 0x21, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xC0, 0x3F, 0xEF, 0x00, 0xFF, 0xBC, 0x07, 0xFE,
  0xF0, 0x1F, 0xF3, 0xC0, 0x03, 0xCF, 0x00, 0x0F, 0x3C, 0x00, 0x3C, 0xF0,
  0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x1E, 0x1F, 0x00, 0x78, 0x7F, 0x07,
  0xE0, 0xFF, 0xFF, 0x01, 0xFF, 0xFC, 0x01, 0xFF, 0xC0, 0x03, 0xC0, 0x07,
  0x81, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0, 0xF0, 0x01, 0xE0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x78, 0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x0F, 0x00,
  0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0, 0x07, 0x81, 0xFF, 0xFF, 0xC1, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xF0, 0x3C, 0x00, 0x78, 0x1E,
  0x00, 0x3C, 0x1F, 0x00, 0x3E, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03,
  0xC0, 0x07, 0x81, 0xE0, 0x03, 0xC1, 0xE0, 0x03, 0xC0, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0xF0, 0x3C, 0x00, 0x78, 0x3E, 0x00, 0x7C, 0x00, 0x03, 0xFF,
  0x07, 0xFF, 0x03, 0xFE, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x7F, 0xC0,
  0xFF, 0xE0, 0xFF, 0xE0, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00,
  0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x1F, 0x01, 0xFF, 0x80,
  0xFF, 0x80, 0x7F, 0x80, 0x00, 0x03, 0xC0, 0x1F, 0x03, 0xC0, 0x3E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF8, 0x07, 0x81, 0xF0, 0x07, 0x83, 0xE0, 0x07,
  0x87, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1F, 0x00, 0x0F, 0x3E, 0x00, 0x0F,
  0x3C, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F,
  0xFC, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x1E, 0x00, 0x3C,
  0x1E, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x00, 0x3C, 0x0F, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x07, 0xC0, 0x78, 0x03, 0xC0, 0xF8,
  0x03, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x1E, 0x00, 0x3F, 0xFF, 0x7F,
  0xFE, 0xFF, 0xFF, 0xFF, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00,
  0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF0, 0x01,
  0xFE, 0x07, 0x70, 0x01, 0xDC, 0x07, 0x70, 0x03, 0xFC, 0x0F, 0x70, 0x07,
  0xBC, 0x0F, 0x78, 0x07, 0xBC, 0x0F, 0x78, 0x0F, 0x3C, 0x0F, 0x78, 0x0E,
  0x78, 0x0E, 0x38, 0x1E, 0x78, 0x1E, 0x38, 0x1C, 0x78, 0x1E, 0x38, 0x3C,
  0x78, 0x1E, 0x38, 0x38, 0x70, 0x1E, 0x38, 0x78, 0xF0, 0x1C, 0x38, 0x70,
  0xF0, 0x3C, 0x38, 0xF0, 0xF0, 0x3C, 0x3C, 0xE0, 0xF0, 0x3C, 0x3D, 0xE0,
  0xE0, 0x3C, 0x3D, 0xC1, 0xE0, 0x38, 0x1F, 0xC1, 0xE0, 0x78, 0x1F, 0x81,
  0xE0, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0x1F, 0x03, 0xC0, 0x70, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x78,
  0x0F, 0xC0, 0x0F, 0x03, 0xF8, 0x01, 0xE0, 0x7F, 0x00, 0x3C, 0x0E, 0xF0,
  0x07, 0x01, 0xDE, 0x01, 0xE0, 0x7B, 0xC0, 0x3C, 0x0F, 0x3C, 0x07, 0x81,
  0xE7, 0x80, 0xF0, 0x3C, 0xF0, 0x1C, 0x07, 0x0F, 0x07, 0x81, 0xE1, 0xE0,
  0xF0, 0x3C, 0x1C, 0x1E, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x78, 0xF0, 0x1C,
  0x07, 0x9E, 0x07, 0x80, 0xF3, 0xC0, 0xF0, 0x1E, 0x78, 0x1E, 0x01, 0xEE,
  0x03, 0xC0, 0x3D, 0xC0, 0x70, 0x07, 0xF8, 0x1E, 0x00, 0x7F, 0x03, 0xC0,
  0x0F, 0xE0, 0x78, 0x01, 0xF8, 0x0E, 0x00, 0x1F, 0x03, 0xC0, 0x03, 0xE0,
  0x00, 0x00, 0x0C, 0x00, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0xFE, 0x0F, 0xC3, 0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F,
  0x3C, 0x00, 0x1E, 0xF8, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF,
  0x80, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00,
  0x07, 0x9F, 0x00, 0x1F, 0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7F, 0x0F,
  0xE0, 0x7F, 0xFF, 0x80, 0x7F, 0xFC, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x07, 0xE0, 0x78, 0x0F, 0x83,
  0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78, 0x03,
  0xC3, 0xC0, 0x3E, 0x1E, 0x03, 0xE1, 0xF0, 0x3F, 0x0F, 0xFF, 0xF0, 0x7F,
  0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xF0, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0C, 0x00,
  0x01, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0xFE, 0x0F, 0xC3,
  0xF0, 0x0F, 0x87, 0xC0, 0x0F, 0x9F, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0xF8,
  0x00, 0x3D, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xE0, 0x00,
  0x7F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF, 0x00, 0x07, 0x9F, 0x00, 0x1F,
  0x3E, 0x00, 0x7C, 0x3E, 0x01, 0xF8, 0x7F, 0x0F, 0xE0, 0x7F, 0xFF, 0x80,
  0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x03,
  0xFF, 0x80, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x0F, 0x07, 0xE0, 0x78, 0x0F,
  0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x07, 0xC3, 0xC0, 0x3C, 0x1E, 0x03, 0xE1, 0xF1, 0xFE, 0x0F, 0xFF, 0xE0,
  0x7F, 0xFC, 0x03, 0xFF, 0xC0, 0x1E, 0x1E, 0x01, 0xE0, 0xF0, 0x0F, 0x03,
  0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF0, 0x1E, 0x03, 0xC1, 0xE0, 0x1E, 0x0F,
  0x00, 0xF8, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x3E, 0x00, 0xF8, 0x00, 0x18,
  0x00, 0x3F, 0xF8, 0x0F, 0xFF, 0x83, 0xFF, 0xE0, 0xFC, 0x1C, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x07, 0xC4, 0x00, 0xF0, 0xE0, 0x7E, 0x1F, 0xFF, 0x83,
  0xFF, 0xE0, 0x3F, 0xF0, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0xFF, 0xFF,
  0xE0, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03,
  0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00,
  0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00,
  0x00, 0x0F, 0x00, 0x1E, 0x3E, 0x00, 0x3C, 0x78, 0x00, 0x78, 0xF0, 0x01,
  0xF1, 0xE0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x0F, 0x1E, 0x00, 0x1E,
  0x3C, 0x00, 0x78, 0x78, 0x00, 0xF0, 0xF0, 0x01, 0xE3, 0xC0, 0x03, 0xC7,
  0x80, 0x0F, 0x8F, 0x00, 0x1E, 0x1E, 0x00, 0x3C, 0x7C, 0x00, 0x78, 0xF0,
  0x00, 0xF1, 0xE0, 0x03, 0xE3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x0F, 0x00,
  0x3E, 0x1E, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x3F, 0x0F, 0xC0, 0x7F, 0xFF,
  0x00, 0x7F, 0xFC, 0x00, 0x3F, 0xE0, 0x00, 0xF8, 0x00, 0x7D, 0xE0, 0x01,
  0xE7, 0x80, 0x0F, 0x9E, 0x00, 0x3C, 0x78, 0x01, 0xE1, 0xE0, 0x07, 0x87,
  0x80, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x07, 0x81, 0xE0, 0x1E, 0x03, 0x80,
  0xF0, 0x0E, 0x03, 0xC0, 0x3C, 0x1E, 0x00, 0xF0, 0x78, 0x03, 0xC3, 0xC0,
  0x0F, 0x0F, 0x00, 0x3C, 0x78, 0x00, 0xF1, 0xE0, 0x03, 0xCF, 0x00, 0x0F,
  0x3C, 0x00, 0x1D, 0xE0, 0x00, 0x77, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0xF0, 0x07, 0xC0, 0x1F, 0xF0, 0x07, 0xC0, 0x1E, 0xF0, 0x0F,
  0xC0, 0x1E, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x1D,
  0xC0, 0x78, 0xF0, 0x1D, 0xC0, 0x78, 0xF0, 0x3D, 0xC0, 0xF0, 0xF0, 0x39,
  0xC0, 0xF0, 0xF0, 0x79, 0xC0, 0xF0, 0xF0, 0x71, 0xE1, 0xE0, 0xF0, 0xF1,
  0xE1, 0xE0, 0xF0, 0xE1, 0xE3, 0xC0, 0xF1, 0xE1, 0xE3, 0xC0, 0xF1, 0xE1,
  0xE7, 0x80, 0x73, 0xC1, 0xE7, 0x80, 0x73, 0xC1, 0xE7, 0x00, 0x73, 0x81,
  0xEF, 0x00, 0x77, 0x81, 0xEF, 0x00, 0x77, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x7C, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0xF8, 0x00, 0x78, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x07, 0xC0, 0x78, 0x03, 0xE0, 0x1E, 0x01, 0xF0, 0x03, 0xC0, 0x78, 0x00,
  0xF0, 0x3C, 0x00, 0x3C, 0x1F, 0x00, 0x07, 0x8F, 0x80, 0x01, 0xE3, 0xC0,
  0x00, 0x79, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x7D, 0xE0, 0x00, 0x3E, 0x3C, 0x00,
  0x0F, 0x0F, 0x00, 0x07, 0x83, 0xE0, 0x03, 0xE0, 0x78, 0x01, 0xF0, 0x1E,
  0x00, 0x78, 0x07, 0xC0, 0x3C, 0x00, 0xF0, 0x1F, 0x00, 0x3C, 0x0F, 0x80,
  0x0F, 0x80, 0xF8, 0x01, 0xF7, 0x80, 0x1E, 0x78, 0x03, 0xE7, 0x80, 0x3C,
  0x3C, 0x07, 0x83, 0xC0, 0xF8, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x1E, 0x3E,
  0x01, 0xE3, 0xC0, 0x1E, 0x78, 0x01, 0xEF, 0x80, 0x0F, 0xF0, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0x03, 0xFF,
  0xFE, 0x07, 0xFF, 0xFC, 0x0F, 0xFF, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0,
  0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF,
  0x83, 0xFF, 0xFF, 0x00, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0xE0, 0x03,
  0x80, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0x00, 0x1C, 0x00, 0xF0, 0x03,
  0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x78, 0x01,
  0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01,
  0xE0, 0x07, 0x80, 0x1C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFE, 0x00, 0xF0, 0xF0, 0x70, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x38,
  0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x0E, 0x0E, 0x0E, 0x0F, 0x0F, 0x01, 0xFE, 0x03, 0xFC, 0x07, 0xF8, 0x00,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x70,
  0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1C, 0x00, 0x78, 0x00,
  0xF0, 0x1F, 0xE0, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x70, 0x00, 0x1E, 0x00,
  0x03, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x07, 0x38, 0x00, 0xE7, 0x80,
  0x38, 0x70, 0x07, 0x0E, 0x01, 0xC0, 0xE0, 0x38, 0x1C, 0x0E, 0x03, 0xC1,
  0xC0, 0x38, 0x70, 0x07, 0x8E, 0x00, 0x73, 0x80, 0x0F, 0xF0, 0x00, 0xE0,
  0x7F, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0xF3, 0xC7, 0x8E, 0x3C, 0x70, 0x01,
  0xE0, 0x00, 0xFF, 0x1C, 0x3F, 0xF7, 0x8F, 0xFF, 0xF3, 0xF0, 0x7C, 0x7C,
  0x0F, 0x9F, 0x01, 0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xDF, 0x00, 0xF3, 0xC0,
  0x1E, 0x78, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80,
  0xF8, 0xF0, 0x3F, 0x1F, 0x0F, 0xE1, 0xFF, 0xB8, 0x3F, 0xE7, 0x03, 0xF8,
  0xE0, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x0F, 0x01, 0xE7,
  0xF0, 0x3D, 0xFF, 0x07, 0x7B, 0xF1, 0xFC, 0x1E, 0x3F, 0x03, 0xC7, 0xC0,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0x80, 0x3C, 0xF0, 0x07, 0x9E, 0x00,
  0xF3, 0xC0, 0x3E, 0x78, 0x07, 0x9F, 0x00, 0xF3, 0xE0, 0x3E, 0x7C, 0x0F,
  0x8F, 0xC3, 0xE3, 0xDF, 0xFC, 0x7B, 0xFF, 0x0E, 0x3F, 0x80, 0x00, 0xFC,
  0x03, 0xFF, 0x0F, 0xFE, 0x1F, 0xFE, 0x3F, 0x00, 0x3C, 0x00, 0x7C, 0x00,
  0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0xFC, 0x18, 0x7F, 0xF8,
  0x3F, 0xF8, 0x1F, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3C,
  0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x01, 0xE1, 0xE0, 0x3F, 0xCF, 0x03, 0xFF, 0x78, 0x3F, 0xFF, 0xC3,
  0xE0, 0x7C, 0x1E, 0x03, 0xE1, 0xF0, 0x1F, 0x0F, 0x00, 0x78, 0x78, 0x07,
  0x87, 0xC0, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0x0F, 0x0F, 0x00, 0x78, 0x78,
  0x07, 0x83, 0xC0, 0x3C, 0x1E, 0x03, 0xE0, 0xF0, 0x3F, 0x07, 0xC3, 0xF8,
  0x1F, 0xFB, 0x80, 0xFF, 0x9C, 0x03, 0xF8, 0xE0, 0x00, 0x00, 0xF8, 0x01,
  0xFF, 0x03, 0xFF, 0xC3, 0xF3, 0xE3, 0xE0, 0xF9, 0xE0, 0x3D, 0xF0, 0x3C,
  0xF0, 0x1E, 0x78, 0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x06, 0x1F,
  0xFF, 0x07, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0x03, 0xFE, 0x00, 0x3E, 0x10, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x27,
  0xC0, 0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x3F, 0xC7, 0x07, 0xFE, 0xF0, 0xFF, 0xFF, 0x1F, 0x83, 0xE1, 0xF0,
  0x3E, 0x3E, 0x03, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7, 0xC0, 0x3C, 0x78,
  0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x0F, 0x87,
  0x80, 0xF8, 0x78, 0x1F, 0x87, 0xC3, 0xF8, 0x3F, 0xF7, 0x03, 0xFE, 0xF0,
  0x1F, 0x8F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x08, 0x03, 0xC0, 0xE0, 0xFC, 0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x03, 0xFC,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x0F, 0x0F, 0x01, 0xE7,
  0xF8, 0x3D, 0xFF, 0x87, 0x7B, 0xF1, 0xFC, 0x1E, 0x3F, 0x03, 0xC7, 0xC0,
  0x78, 0xF0, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0, 0x0F, 0x1E, 0x01,
  0xE3, 0xC0, 0x3C, 0x78, 0x07, 0x9E, 0x00, 0xF3, 0xC0, 0x3C, 0x78, 0x07,
  0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00, 0xF0, 0x03, 0xC1,
  0xF0, 0x7C, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0x03, 0xC0, 0xF0,
  0x7C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3C, 0x0F, 0x03, 0xC0, 0xF0, 0x3C,
  0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03, 0xC0, 0x00, 0x0F, 0x00,
  0x1F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03,
  0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x9F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03,
  0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00,
  0x78, 0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x10, 0xF0, 0x3E,
  0x0F, 0x07, 0xC0, 0xF0, 0xF8, 0x1E, 0x1F, 0x01, 0xE3, 0xE0, 0x1E, 0x7C,
  0x01, 0xE7, 0x80, 0x1C, 0xF0, 0x03, 0xDE, 0x00, 0x3F, 0xF0, 0x03, 0xFF,
  0x00, 0x3E, 0xF0, 0x07, 0xC7, 0x80, 0x78, 0x78, 0x07, 0x83, 0xC0, 0x78,
  0x3C, 0x07, 0x83, 0xE0, 0xF0, 0x1E, 0x0F, 0x01, 0xF0, 0xF0, 0x0F, 0x00,
  0x03, 0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x3E, 0x0F, 0x03,
  0xC0, 0xF0, 0x3C, 0x1E, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E, 0x0F, 0x03, 0xC0, 0xF0,
  0x00, 0x00, 0x0F, 0x01, 0xF0, 0x1C, 0x7F, 0x0F, 0xF0, 0x39, 0xFF, 0x3F,
  0xF0, 0x77, 0xBE, 0xFB, 0xE1, 0xFC, 0x3D, 0xC3, 0xC3, 0xF0, 0x3E, 0x07,
  0xC7, 0xC0, 0x7C, 0x0F, 0x0F, 0x00, 0xF0, 0x1E, 0x1E, 0x03, 0xE0, 0x3C,
  0x7C, 0x07, 0x80, 0x78, 0xF0, 0x0F, 0x00, 0xF1, 0xE0, 0x1E, 0x03, 0xE3,
  0xC0, 0x3C, 0x07, 0x87, 0x80, 0xF0, 0x0F, 0x1E, 0x01, 0xE0, 0x1E, 0x3C,
  0x03, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0xF0, 0xF0, 0x1E, 0x01, 0xE3, 0xC0,
  0x3C, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x8F, 0x00, 0xF0, 0x1F, 0x00, 0x0F,
  0x0F, 0x01, 0xC7, 0xF8, 0x39, 0xFF, 0x87, 0x7F, 0xF1, 0xFC, 0x1E, 0x3F,
  0x03, 0xC7, 0xC0, 0x78, 0xF8, 0x0F, 0x1E, 0x01, 0xE7, 0xC0, 0x3C, 0xF0,
  0x0F, 0x9E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x01, 0xF3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xE0, 0x1E, 0x78, 0x07, 0xCF, 0x00,
  0xF0, 0x00, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xF0, 0x7F, 0xFE, 0x3E, 0x07,
  0x8F, 0x01, 0xF7, 0xC0, 0x3D, 0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x3F, 0xC0, 0x1F, 0xF0, 0x07, 0xBC, 0x01, 0xEF, 0x00, 0xFB, 0xC0,
  0x3C, 0xF8, 0x1F, 0x1F, 0x0F, 0x87, 0xFF, 0xC0, 0xFF, 0xE0, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xC0, 0x1C, 0x7F, 0x00, 0xE7, 0xFC, 0x07, 0x7B, 0xF0,
  0x7F, 0x07, 0x83, 0xF0, 0x3C, 0x1F, 0x01, 0xE0, 0xF0, 0x0F, 0x07, 0x80,
  0x78, 0x78, 0x03, 0xC3, 0xC0, 0x1E, 0x1E, 0x00, 0xF0, 0xF0, 0x0F, 0x87,
  0x80, 0x78, 0x7C, 0x03, 0xC3, 0xE0, 0x3E, 0x1F, 0x03, 0xE0, 0xFC, 0x3E,
  0x0F, 0x7F, 0xF0, 0x7B, 0xFF, 0x03, 0xC7, 0xE0, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFF,
  0x1C, 0x3F, 0xF7, 0x8F, 0xFF, 0xF3, 0xE0, 0x7C, 0x7C, 0x0F, 0x9F, 0x01,
  0xF3, 0xC0, 0x3E, 0x78, 0x07, 0xDF, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x03,
  0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x03, 0xC7, 0x80, 0xF8, 0xF0, 0x3F,
  0x1F, 0x0F, 0xE1, 0xFF, 0xB8, 0x3F, 0xEF, 0x03, 0xF9, 0xE0, 0x00, 0x3C,
  0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x01, 0x1F, 0x0E, 0x3E,
  0x0E, 0x7E, 0x0E, 0xFE, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00, 0x1F, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00,
  0xF0, 0x00, 0x01, 0xF8, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x9E, 0x1E, 0x02,
  0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xF0,
  0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0xC0, 0x7C, 0xFF, 0xF8, 0xFF, 0xF0, 0x7F, 0xE0, 0x03, 0x00, 0x38, 0x03,
  0xC0, 0x1E, 0x01, 0xE0, 0xBF, 0xFB, 0xFF, 0xDF, 0xFE, 0x1E, 0x01, 0xE0,
  0x0F, 0x00, 0x78, 0x03, 0xC0, 0x3E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x03,
  0xC0, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0x7C, 0x03, 0xFE, 0x0F, 0xF0, 0x3F,
  0x80, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0xF8, 0x07, 0x9E, 0x01, 0xE3, 0xC0,
  0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x1E, 0x78, 0x07, 0x8F, 0x00,
  0xF1, 0xE0, 0x1E, 0x3C, 0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3C, 0x07,
  0xC7, 0x81, 0xF8, 0xF8, 0x7F, 0x1F, 0xFD, 0xE1, 0xFF, 0x38, 0x1F, 0xC7,
  0x00, 0xF0, 0x07, 0xFC, 0x01, 0xEF, 0x00, 0xFB, 0xC0, 0x3C, 0xF0, 0x1E,
  0x1C, 0x07, 0x87, 0x03, 0xC1, 0xE0, 0xF0, 0x78, 0x78, 0x1E, 0x1E, 0x07,
  0x8F, 0x01, 0xE3, 0xC0, 0x79, 0xE0, 0x1E, 0x78, 0x03, 0xBC, 0x00, 0xEF,
  0x00, 0x3F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0xF0, 0x1F,
  0x01, 0xFF, 0x01, 0xF0, 0x1E, 0xF0, 0x3F, 0x03, 0xCF, 0x03, 0xF0, 0x3C,
  0xF0, 0x7F, 0x07, 0x8F, 0x07, 0x70, 0x78, 0x70, 0xF7, 0x0F, 0x87, 0x0E,
  0x70, 0xF0, 0x70, 0xE7, 0x0F, 0x07, 0x1C, 0x71, 0xE0, 0x71, 0xC7, 0x1E,
  0x07, 0x3C, 0x73, 0xC0, 0x73, 0x87, 0x3C, 0x07, 0x78, 0x73, 0x80, 0x77,
  0x07, 0x78, 0x07, 0x70, 0x77, 0x00, 0x7E, 0x07, 0xF0, 0x07, 0xE0, 0x3E,
  0x00, 0x7C, 0x03, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x0F,
  0x03, 0xE0, 0x3C, 0x1F, 0x00, 0x78, 0xF8, 0x01, 0xE3, 0xC0, 0x03, 0xDE,
  0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x01, 0xFE, 0x00, 0x0F, 0x78, 0x00, 0x78,
  0xF0, 0x03, 0xE3, 0xC0, 0x1F, 0x07, 0x80, 0x78, 0x1E, 0x03, 0xC0, 0x7C,
  0x3F, 0x00, 0xF0, 0x07, 0x80, 0x3E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0,
  0x3C, 0x03, 0xC0, 0x38, 0x0F, 0x80, 0x78, 0x1E, 0x00, 0xF0, 0x78, 0x01,
  0xE0, 0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x87, 0x80, 0x0F, 0x1E, 0x00, 0x0E,
  0x3C, 0x00, 0x1C, 0xF0, 0x00, 0x39, 0xE0, 0x00, 0x77, 0x80, 0x00, 0xEF,
  0x00, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x07, 0xFF, 0xC1, 0xFF, 0xF0, 0x7F, 0xFC, 0x00, 0x3E,
  0x00, 0x1F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00,
  0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0,
  0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1F, 0xFF, 0x87, 0xFF, 0xE3, 0xFF, 0xF0,
  0x00, 0x1E, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xC0, 0x0E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0x78, 0x01, 0xFC, 0x00, 0x78, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x01, 0xC0, 0x03, 0xC0, 0x07, 0xE0, 0x07, 0xC0,
  0x07, 0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xE0, 0x07,
  0xE0, 0x0F, 0xE0, 0x07, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x1E, 0x00,
  0x3E, 0x00, 0x3F, 0x00, 0x1E, 0x01, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0x3C,
  0x00, 0x70, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x03, 0xE0, 0x3F, 0x80, 0x7E, 0x00, 0xF8, 0x00, 0x3F,
  0x80, 0x2F, 0xFC, 0x1F, 0xFF, 0xFF, 0xF0, 0xFF, 0xE8, 0x03, 0xF8,
};

const GFXglyph NotoSans_MediumItalic38pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 28, 10, 1, -27 },
  { 36, 12, 10, 16, 4, -27 },
  { 51, 24, 27, 25, 1, -27 },
  { 132, 19, 31, 21, 1, -29 },
  { 206, 26, 28, 31, 3, -28 },
  { 297, 24, 28, 26, 1, -28 },
  { 381, 5, 10, 9, 4, -27 },
  { 388, 13, 33, 12, 1, -27 },
  { 442, 13, 33, 12, -3, -27 },
  { 496, 17, 18, 21, 4, -29 },
  { 535, 18, 19, 22, 2, -23 },
  { 578, 8, 9, 10, -2, -4 },
  { 587, 10, 4, 12, 1, -12 },
  { 592, 5, 6, 10, 1, -5 },
  { 596, 19, 27, 14, -2, -27 },
  { 661, 18, 28, 21, 2, -28 },
  { 724, 12, 27, 21, 5, -27 },
  { 765, 20, 28, 21, 0, -28 },
  { 835, 19, 28, 21, 1, -28 },
  { 902, 20, 27, 21, 0, -27 },
  { 970, 20, 27, 21, 1, -27 },
  { 1038, 19, 28, 21, 2, -28 },
  { 1105, 19, 27, 21, 3, -27 },
  { 1170, 19, 28, 21, 2, -28 },
  { 1237, 18, 28, 21, 2, -28 },
  { 1300, 8, 22, 10, 1, -21 },
  { 1322, 11, 26, 10, -2, -21 },
  { 1358, 19, 19, 22, 2, -23 },
  { 1404, 17, 11, 22, 3, -19 },
  { 1428, 19, 19, 22, 2, -23 },
  { 1474, 15, 29, 17, 3, -28 },
  { 1529, 30, 30, 32, 2, -27 },
  { 1642, 22, 27, 22, -2, -27 },
  { 1717, 22, 27, 23, 1, -27 },
  { 1792, 21, 28, 23, 3, -28 },
  { 1866, 23, 27, 25, 1, -27 },
  { 1944, 20, 27, 20, 1, -27 },
  { 2012, 20, 27, 19, 1, -27 },
  { 2080, 22, 28, 26, 3, -28 },
  { 2157, 25, 27, 26, 1, -27 },
  { 2242, 16, 27, 13, -1, -27 },
  { 2296, 17, 34, 11, -6, -27 },
  { 2369, 24, 27, 22, 1, -27 },
  { 2450, 15, 27, 19, 1, -27 },
  { 2501, 32, 27, 32, 1, -27 },
  { 2609, 27, 27, 27, 1, -27 },
  { 2701, 23, 28, 28, 3, -28 },
  { 2782, 21, 27, 22, 1, -27 },
  { 2853, 23, 34, 28, 3, -28 },
  { 2951, 21, 27, 22, 1, -27 },
  { 3022, 19, 28, 19, 1, -28 },
  { 3089, 20, 27, 19, 3, -27 },
  { 3157, 23, 27, 26, 3, -27 },
  { 3235, 22, 27, 21, 3, -27 },
  { 3310, 32, 27, 33, 4, -27 },
  { 3418, 26, 27, 21, -2, -27 },
  { 3506, 20, 27, 20, 3, -27 },
  { 3574, 23, 27, 20, -1, -27 },
  { 3652, 14, 33, 11, 0, -27 },
  { 3710, 8, 27, 14, 4, -27 },
  { 3737, 15, 33, 11, -3, -27 },
  { 3799, 19, 17, 22, 1, -27 },
  { 3840, 16, 3, 15, -4, 3 },
  { 3846, 6, 6, 11, 6, -29 },
  { 3851, 19, 21, 22, 2, -21 },
  { 3901, 19, 29, 22, 1, -29 },
  { 3970, 16, 21, 18, 2, -21 },
  { 4012, 21, 29, 22, 2, -29 },
  { 4089, 17, 21, 20, 2, -21 },
  { 4134, 21, 38, 13, -4, -29 },
  { 4234, 20, 30, 22, 1, -21 },
  { 4309, 19, 29, 22, 1, -29 },
  { 4378, 10, 28, 10, 1, -28 },
  { 4413, 16, 37, 10, -5, -28 },
  { 4487, 20, 29, 20, 1, -29 },
  { 4560, 10, 29, 10, 1, -29 },
  { 4597, 31, 21, 34, 1, -21 },
  { 4679, 19, 21, 22, 1, -21 },
  { 4729, 18, 21, 22, 2, -21 },
  { 4777, 21, 30, 22, -1, -21 },
  { 4856, 19, 30, 22, 2, -21 },
  { 4928, 16, 21, 15, 1, -21 },
  { 4970, 16, 21, 17, 0, -21 },
  { 5012, 13, 25, 13, 2, -25 },
  { 5053, 19, 20, 22, 2, -20 },
  { 5101, 18, 20, 18, 2, -20 },
  { 5146, 28, 20, 28, 2, -20 },
  { 5216, 22, 20, 19, -2, -20 },
  { 5271, 23, 29, 18, -3, -20 },
  { 5355, 18, 20, 17, -1, -20 },
  { 5400, 15, 33, 13, 0, -27 },
  { 5462, 4, 38, 21, 9, -29 },
  { 5481, 15, 33, 13, -2, -27 },
  { 5543, 19, 5, 22, 2, -16 },
};

const GFXfont NotoSans_MediumItalic38pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic38pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic38pt7bGlyphs,
  0x20, 0x7E, 52
};

#endif // _NOTOSANS_MEDIUMITALIC38PT7B_H_
