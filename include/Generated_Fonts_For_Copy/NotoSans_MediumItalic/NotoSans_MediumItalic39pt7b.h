#ifndef _NOTOSANS_MEDIUMITALIC39PT7B_H_
#define _NOTOSANS_MEDIUMITALIC39PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 39pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic39pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xC1, 0xF0, 0x7C, 0x1E, 0x07, 0x83, 0xE0, 0xF8, 0x3C, 0x0F,
  0x03, 0xC1, 0xF0, 0x78, 0x1E, 0x07, 0x81, 0xE0, 0x70, 0x3C, 0x0F, 0x03,
  0xC0, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xE0, 0xF8, 0x3E, 0x0F, 0x83, 0xC0,
  0x40, 0x00, 0x7C, 0xFB, 0xC7, 0x9E, 0x3C, 0xF1, 0xE7, 0x0E, 0x38, 0x71,
  0xC3, 0x9E, 0x3C, 0xE1, 0xC7, 0x0E, 0x00, 0x00, 0x3C, 0x1C, 0x00, 0x38,
  0x3C, 0x00, 0x38, 0x38, 0x00, 0x38, 0x38, 0x00, 0x78, 0x38, 0x00, 0x70,
  0x70, 0x00, 0x70, 0x70, 0x00, 0xF0, 0x70, 0x1F, 0xFF, 0xFF, 0x3F, 0xFF,
  0xFF, 0x3F, 0xFF, 0xFF, 0x01, 0xC1, 0xE0, 0x01, 0xC1, 0xC0, 0x01, 0xC1,
  0xC0, 0x03, 0xC1, 0xC0, 0x03, 0x83, 0xC0, 0x03, 0x83, 0x80, 0xFF, 0xFF,
  0xFC, 0xFF, 0xFF, 0xFC, 0xFF, 0xFF, 0xFC, 0x07, 0x07, 0x00, 0x0F, 0x07,
  0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x0E, 0x0E, 0x00, 0x1C, 0x1E,
  0x00, 0x1C, 0x1C, 0x00, 0x1C, 0x1C, 0x00, 0x00, 0x0E, 0x00, 0x00, 0xE0,
  0x00, 0x0E, 0x00, 0x00, 0xC0, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xF9, 0x8E, 0x0F, 0x18, 0x00, 0xE3, 0x80, 0x1E, 0x38, 0x01, 0xE3,
  0x80, 0x0F, 0x30, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x01,
  0xFF, 0x00, 0x07, 0xF8, 0x00, 0x6F, 0x80, 0x0E, 0x78, 0x00, 0xE3, 0xC0,
  0x0C, 0x3C, 0x00, 0xC7, 0x88, 0x1C, 0x78, 0xF1, 0xDF, 0x0F, 0xFF, 0xF0,
  0xFF, 0xFC, 0x03, 0xFF, 0x00, 0x03, 0x80, 0x00, 0x38, 0x00, 0x03, 0x80,
  0x00, 0x30, 0x00, 0x0F, 0xC0, 0x03, 0xC3, 0xFC, 0x00, 0xF0, 0xFF, 0xC0,
  0x3C, 0x1E, 0x38, 0x07, 0x07, 0x87, 0x01, 0xC0, 0xE0, 0xE0, 0x78, 0x1C,
  0x1C, 0x1E, 0x07, 0x83, 0x83, 0x80, 0xE0, 0x70, 0xE0, 0x1C, 0x1E, 0x3C,
  0x03, 0x83, 0x8F, 0x00, 0x70, 0x71, 0xC7, 0xCE, 0x1E, 0x73, 0xFD, 0xE3,
  0x9E, 0xFF, 0xFF, 0xF7, 0x9E, 0x7B, 0xFC, 0xE7, 0x87, 0x3E, 0x38, 0xE0,
  0xE0, 0x0F, 0x3C, 0x1C, 0x03, 0xC7, 0x83, 0x80, 0x70, 0xE0, 0xF0, 0x1C,
  0x1C, 0x1E, 0x07, 0x83, 0x83, 0x81, 0xE0, 0x70, 0x70, 0x38, 0x0E, 0x1E,
  0x0F, 0x01, 0xC3, 0x83, 0xC0, 0x3F, 0xF0, 0x70, 0x03, 0xFC, 0x3C, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF8, 0x00,
  0x7C, 0x3E, 0x00, 0x3C, 0x0F, 0x00, 0x1E, 0x07, 0x80, 0x0F, 0x03, 0xC0,
  0x07, 0x83, 0xC0, 0x03, 0xC1, 0xE0, 0x01, 0xE3, 0xE0, 0x00, 0xFB, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0xE0,
  0x1E, 0x3E, 0xF8, 0x1E, 0x3E, 0x3E, 0x0F, 0x3E, 0x0F, 0x0F, 0x1E, 0x03,
  0xCF, 0x9F, 0x01, 0xF7, 0x8F, 0x00, 0x7F, 0x87, 0x80, 0x1F, 0x83, 0xE0,
  0x0F, 0x81, 0xF0, 0x0F, 0xE0, 0x7C, 0x1F, 0xF8, 0x3F, 0xFF, 0xFC, 0x0F,
  0xFF, 0x9F, 0x01, 0xFF, 0x07, 0xC0, 0x7D, 0xE7, 0x9E, 0x71, 0xC7, 0x3C,
  0xE3, 0x80, 0x00, 0x78, 0x07, 0x80, 0x78, 0x07, 0x80, 0x78, 0x03, 0xC0,
  0x3C, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80, 0x3C,
  0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xC0, 0x0E, 0x00,
  0x70, 0x03, 0x80, 0x1C, 0x00, 0xE0, 0x07, 0x00, 0x38, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0x38, 0x01, 0xE0, 0x00, 0x01, 0xE0,
  0x07, 0x00, 0x3C, 0x00, 0xE0, 0x07, 0x00, 0x3C, 0x01, 0xE0, 0x0F, 0x00,
  0x78, 0x03, 0xC0, 0x0E, 0x00, 0x70, 0x03, 0x80, 0x3C, 0x01, 0xE0, 0x0F,
  0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xE0, 0x0F, 0x00, 0x78, 0x07, 0x80,
  0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x78,
  0x07, 0x80, 0x78, 0x07, 0x80, 0x00, 0x00, 0x48, 0x00, 0x1C, 0x00, 0x0F,
  0x00, 0x03, 0xC0, 0x40, 0xE0, 0x1C, 0x38, 0x0F, 0xCE, 0x03, 0xFF, 0x00,
  0x1F, 0xFF, 0xC0, 0xFF, 0xF0, 0x3F, 0xFC, 0x1F, 0x80, 0x1E, 0x70, 0x0F,
  0x9C, 0x07, 0xC7, 0x80, 0xE1, 0xE0, 0x10, 0x3C, 0x00, 0x0F, 0x00, 0x02,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0x01, 0xC0,
  0x00, 0x70, 0x00, 0x1C, 0x00, 0x07, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x07, 0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x07,
  0x00, 0x01, 0xC0, 0x00, 0x70, 0x00, 0x1C, 0x00, 0x0F, 0x87, 0x87, 0xC3,
  0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x70, 0x78, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x7F, 0xFF, 0xFF, 0x20, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x3C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3C,
  0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1E,
  0x00, 0x01, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x78, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xFE, 0x07, 0xE3, 0xE0,
  0xF8, 0x3C, 0x3E, 0x07, 0xC7, 0x80, 0x79, 0xF0, 0x0F, 0x3C, 0x01, 0xEF,
  0x80, 0x3D, 0xE0, 0x07, 0xBC, 0x00, 0xF7, 0x80, 0x3F, 0xF0, 0x07, 0xFC,
  0x00, 0xF7, 0x80, 0x1E, 0xF0, 0x03, 0xDE, 0x00, 0x7B, 0xC0, 0x1F, 0x78,
  0x03, 0xCF, 0x00, 0xF9, 0xE0, 0x1E, 0x3E, 0x07, 0xC3, 0xC0, 0xF0, 0x7C,
  0x7E, 0x0F, 0xFF, 0x80, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x00, 0x78, 0x0F,
  0xC0, 0xFC, 0x1F, 0xE3, 0xFF, 0x3F, 0x7B, 0xF7, 0x8E, 0x3C, 0x61, 0xE0,
  0x0F, 0x00, 0xF8, 0x07, 0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF8, 0x07,
  0x80, 0x3C, 0x01, 0xE0, 0x0F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x01, 0xE0,
  0x1F, 0x00, 0xF0, 0x07, 0x80, 0x3C, 0x00, 0x00, 0x7F, 0x80, 0x0F, 0xFF,
  0x01, 0xFF, 0xFC, 0x0F, 0xC7, 0xE0, 0x38, 0x0F, 0x01, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C,
  0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7F, 0xFF,
  0xC7, 0xFF, 0xFE, 0x3F, 0xFF, 0xF1, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xFC, 0x0F, 0xFF, 0xE0, 0xFC, 0x7E, 0x06, 0x01, 0xE0, 0x00, 0x1F,
  0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF8, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x03, 0xFE, 0x00, 0x43,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0x78, 0x00, 0x07, 0x88, 0x00, 0xF8, 0xF0, 0x3F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0x78, 0x00,
  0x7B, 0x80, 0x07, 0xBC, 0x00, 0x79, 0xE0, 0x07, 0x8F, 0x00, 0x78, 0x70,
  0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x03, 0xC1, 0xE0, 0x3C, 0x0F, 0x03, 0xC0,
  0xF0, 0x3C, 0x07, 0x83, 0xE0, 0x3C, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xF8, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xFF, 0xF0,
  0x3F, 0xFF, 0x03, 0xFF, 0xF0, 0x3F, 0xFE, 0x03, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x01, 0xFF, 0xC0, 0x1F, 0xFF, 0x01, 0xFF, 0xF8, 0x0C, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x88, 0x00, 0xF8, 0xF0, 0x3F, 0x0F,
  0xFF, 0xE0, 0xFF, 0xFC, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xFC,
  0x07, 0xFF, 0x81, 0xFC, 0x10, 0x7C, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0xC0, 0x3E, 0xFF, 0x07,
  0xBF, 0xF0, 0xFF, 0xFF, 0x1F, 0x83, 0xE3, 0xE0, 0x3C, 0xF8, 0x07, 0xDF,
  0x00, 0x7B, 0xC0, 0x0F, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0, 0x0F, 0x3E,
  0x03, 0xE3, 0xC0, 0x78, 0x7C, 0x3F, 0x07, 0xFF, 0xC0, 0x7F, 0xF0, 0x07,
  0xF8, 0x00, 0x3F, 0xFF, 0xEF, 0xFF, 0xFD, 0xFF, 0xFF, 0xBF, 0xFF, 0xE0,
  0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03,
  0xC0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3C,
  0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x7F, 0xF0, 0x1F, 0xFF, 0x07, 0xE1, 0xF0, 0xF0, 0x1E, 0x1E, 0x03, 0xC7,
  0x80, 0x78, 0xF0, 0x0F, 0x0F, 0x01, 0xE1, 0xE0, 0x78, 0x3E, 0x1F, 0x03,
  0xEF, 0xC0, 0x3F, 0xE0, 0x07, 0xF0, 0x03, 0xFF, 0x01, 0xF9, 0xF0, 0x7C,
  0x1F, 0x0F, 0x01, 0xF3, 0xC0, 0x1E, 0x78, 0x03, 0xCF, 0x00, 0x79, 0xE0,
  0x0F, 0x3C, 0x01, 0xE7, 0x80, 0x7C, 0xFC, 0x1F, 0x0F, 0xFF, 0xC0, 0xFF,
  0xF0, 0x0F, 0xFC, 0x00, 0x01, 0xFE, 0x01, 0xFF, 0xC0, 0xFF, 0xF8, 0x7E,
  0x3F, 0x1E, 0x07, 0xCF, 0x00, 0xF3, 0xC0, 0x3D, 0xF0, 0x0F, 0x78, 0x03,
  0xDE, 0x00, 0xF7, 0x80, 0x3D, 0xE0, 0x0F, 0x7C, 0x07, 0xDF, 0x03, 0xF3,
  0xFF, 0xFC, 0xFF, 0xEF, 0x1F, 0xF7, 0x81, 0xF1, 0xE0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x01, 0xF0, 0x81, 0xF8,
  0x3F, 0xFC, 0x0F, 0xFE, 0x03, 0xFE, 0x00, 0x02, 0x0F, 0x1F, 0x1F, 0x1F,
  0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x78, 0xF8, 0xF8, 0xF8, 0xF0, 0x40, 0x00, 0x40, 0x3C, 0x0F, 0x81, 0xF0,
  0x3E, 0x07, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x7C, 0x0F, 0x81, 0xE0, 0x78,
  0x0F, 0x03, 0xC0, 0x78, 0x0E, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x40, 0x00,
  0x70, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xF8, 0x00, 0x3F,
  0x80, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01,
  0xF0, 0x00, 0x1C, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x80, 0x00, 0x30, 0x00, 0x0F, 0x00,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xF0,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x00, 0x7F, 0x00, 0xFF, 0x00,
  0xFF, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x3C, 0x00, 0x0C, 0x00,
  0x02, 0x00, 0x00, 0x0F, 0xF0, 0xFF, 0xF1, 0xFF, 0xF3, 0xE3, 0xF2, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x78, 0x01, 0xF0,
  0x07, 0xC0, 0x3F, 0x00, 0xFC, 0x03, 0xE0, 0x0F, 0x80, 0x1E, 0x00, 0x78,
  0x00, 0xF0, 0x01, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00,
  0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x02, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x7F, 0x01,
  0xF8, 0x03, 0xE0, 0x00, 0xF0, 0x1E, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x03,
  0x87, 0x80, 0x00, 0x0F, 0x1C, 0x07, 0xFC, 0x1C, 0xF0, 0x3F, 0xF8, 0x73,
  0x83, 0xF7, 0xC1, 0xDE, 0x0F, 0x07, 0x07, 0x70, 0x78, 0x3C, 0x1D, 0xC3,
  0xC0, 0xF0, 0x7F, 0x0E, 0x03, 0x81, 0xF8, 0x38, 0x0E, 0x07, 0xE1, 0xE0,
  0x78, 0x3F, 0x87, 0x81, 0xE0, 0xEE, 0x1E, 0x07, 0x03, 0xB8, 0x78, 0x3C,
  0x1C, 0xE0, 0xE1, 0xF8, 0xF3, 0xC3, 0xFE, 0xFF, 0x8F, 0x07, 0xF3, 0xFC,
  0x1C, 0x0F, 0x03, 0xC0, 0x78, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x07, 0xC0, 0x03, 0x00, 0x0F, 0xF1, 0xFC, 0x00, 0x1F,
  0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFE, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x38, 0x00, 0x3C, 0x70,
  0x00, 0x78, 0xE0, 0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x07, 0x80,
  0x1E, 0x0F, 0x00, 0x78, 0x1E, 0x01, 0xF0, 0x3C, 0x03, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x1F, 0xFF, 0xF0, 0x7F, 0xFF, 0xE0, 0xF0, 0x03, 0xC3, 0xE0,
  0x07, 0x87, 0x80, 0x0F, 0x1F, 0x00, 0x1E, 0x3C, 0x00, 0x3C, 0xF8, 0x00,
  0x79, 0xE0, 0x00, 0xF7, 0x80, 0x01, 0xF0, 0x03, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x3F, 0xFF, 0x80, 0xFF, 0xFF, 0x07, 0xC0, 0x7C, 0x1E, 0x00, 0xF0,
  0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x01, 0xF0, 0xF0,
  0x0F, 0x83, 0xC0, 0xFC, 0x0F, 0xFF, 0xE0, 0x7F, 0xFC, 0x01, 0xFF, 0xFC,
  0x07, 0x80, 0xF8, 0x1E, 0x01, 0xF0, 0x78, 0x03, 0xC3, 0xE0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x00, 0xF0, 0xF0, 0x03, 0xC3, 0xC0, 0x1F, 0x1F, 0x00,
  0xF8, 0x7F, 0xFF, 0xE1, 0xFF, 0xFF, 0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0x00, 0x3F, 0xF0, 0x03, 0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xFF, 0x7E, 0x0F,
  0xC0, 0x10, 0x7E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7F, 0x87, 0x80, 0xFF, 0xFE, 0x01,
  0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFF, 0x80, 0x03, 0xFF, 0xE0, 0x03,
  0xFF, 0xF8, 0x03, 0xFF, 0xFC, 0x07, 0xC0, 0xFC, 0x07, 0x80, 0x3E, 0x07,
  0x80, 0x3E, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F,
  0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x1F, 0x1E,
  0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E,
  0x00, 0x3E, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x3C, 0x00, 0xF8, 0x3C,
  0x01, 0xF0, 0x7C, 0x07, 0xE0, 0x7F, 0xFF, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xC0, 0xFF,
  0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7F, 0xFF, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x1F, 0xFF,
  0xC0, 0xFF, 0xFC, 0x07, 0xFF, 0xE0, 0x7C, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x04, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x03, 0xFF,
  0xF0, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x03,
  0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0,
  0x01, 0xFF, 0xFC, 0x0F, 0xFF, 0xF8, 0x3F, 0xE7, 0xE0, 0xFC, 0x00, 0xC3,
  0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1E, 0x01,
  0xFF, 0xBC, 0x03, 0xFE, 0x78, 0x07, 0xFC, 0xF0, 0x1F, 0xF9, 0xE0, 0x00,
  0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x07, 0x8F, 0x00, 0x0F, 0x1F, 0x00, 0x1E,
  0x3E, 0x00, 0x7C, 0x3E, 0x00, 0xF0, 0x7F, 0x87, 0xE0, 0x7F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0x3F, 0xFC, 0x00, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x01,
  0xF0, 0x3C, 0x00, 0x78, 0x0F, 0x00, 0x1E, 0x07, 0xC0, 0x07, 0x81, 0xE0,
  0x01, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00, 0x3C, 0x07, 0x80, 0x0F, 0x03,
  0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C, 0x00, 0x7C, 0x0F, 0xFF, 0xFE,
  0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0x78, 0x00, 0xF8, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x3C,
  0x00, 0x7C, 0x0F, 0x00, 0x1E, 0x03, 0xC0, 0x07, 0x81, 0xF0, 0x01, 0xE0,
  0x78, 0x00, 0x78, 0x1E, 0x00, 0x3E, 0x07, 0x80, 0x0F, 0x03, 0xE0, 0x03,
  0xC0, 0x03, 0xFF, 0x81, 0xFF, 0x80, 0xFF, 0xC0, 0x1F, 0x00, 0x0F, 0x00,
  0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03,
  0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x3F, 0xF0, 0x3F, 0xF8, 0x1F, 0xFC,
  0x00, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x07, 0xC0,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x80, 0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF0, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x0F, 0x81, 0xE0, 0x0F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80, 0x7C,
  0x0F, 0x80, 0x3C, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x80, 0x07,
  0x8F, 0x80, 0x07, 0x8F, 0x80, 0x03, 0xCF, 0x80, 0x01, 0xEF, 0x80, 0x00,
  0xF7, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0x78, 0x00,
  0x1F, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x0F, 0x87, 0xC0, 0x07, 0x81, 0xE0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x7C, 0x00, 0xF0, 0x1E, 0x00, 0xF8, 0x0F,
  0x80, 0x78, 0x07, 0xC0, 0x3C, 0x01, 0xE0, 0x1E, 0x00, 0xF8, 0x1F, 0x00,
  0x3C, 0x00, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0,
  0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00,
  0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00,
  0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x7C, 0x00, 0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0xFF, 0xFE, 0x03, 0xF0,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0xFF, 0x07, 0xF0, 0x00, 0xFE, 0x07, 0xF8, 0x01, 0xFE, 0x07, 0xF8,
  0x01, 0xFE, 0x07, 0x78, 0x03, 0xDE, 0x07, 0x78, 0x03, 0x9E, 0x0F, 0x38,
  0x07, 0xBC, 0x0F, 0x38, 0x07, 0x3C, 0x0F, 0x38, 0x0F, 0x3C, 0x0F, 0x38,
  0x0E, 0x3C, 0x1E, 0x38, 0x1E, 0x3C, 0x1E, 0x38, 0x1C, 0x78, 0x1E, 0x3C,
  0x3C, 0x78, 0x1E, 0x3C, 0x38, 0x78, 0x1C, 0x3C, 0x78, 0x78, 0x3C, 0x3C,
  0xF0, 0x78, 0x3C, 0x1C, 0xF0, 0xF0, 0x3C, 0x1D, 0xE0, 0xF0, 0x3C, 0x1D,
  0xC0, 0xF0, 0x38, 0x1F, 0xC0, 0xF0, 0x78, 0x1F, 0x81, 0xF0, 0x78, 0x1F,
  0x81, 0xE0, 0x78, 0x1F, 0x01, 0xE0, 0x78, 0x1F, 0x01, 0xE0, 0xF0, 0x1E,
  0x01, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x7C, 0x00, 0x3C, 0x0F, 0xC0, 0x07,
  0x81, 0xF8, 0x00, 0xF0, 0x7F, 0x00, 0x3C, 0x0F, 0xF0, 0x07, 0x81, 0xFE,
  0x00, 0xF0, 0x3B, 0xE0, 0x1E, 0x07, 0x3C, 0x03, 0xC1, 0xE7, 0x80, 0xF0,
  0x3C, 0x78, 0x1E, 0x07, 0x8F, 0x03, 0xC0, 0xF1, 0xE0, 0x78, 0x3C, 0x1E,
  0x0F, 0x07, 0x83, 0xC3, 0xC0, 0xF0, 0x78, 0x78, 0x1E, 0x07, 0x8F, 0x03,
  0xC0, 0xF1, 0xE0, 0xF0, 0x1E, 0x38, 0x1E, 0x01, 0xEF, 0x03, 0xC0, 0x3D,
  0xE0, 0x78, 0x03, 0xFC, 0x0E, 0x00, 0x7F, 0x83, 0xC0, 0x0F, 0xE0, 0x78,
  0x00, 0xFC, 0x0F, 0x00, 0x1F, 0x81, 0xE0, 0x03, 0xF0, 0x78, 0x00, 0x3E,
  0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xF8, 0x07, 0xF3,
  0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x3E, 0x00,
  0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0xF8, 0x00,
  0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3E, 0xF0, 0x00,
  0x3C, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0xF8, 0xF8, 0x00, 0xF8, 0x7C, 0x03,
  0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x07, 0xFE,
  0x00, 0x03, 0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0xFF, 0xFE,
  0x07, 0xC0, 0xF8, 0x1E, 0x01, 0xE0, 0x78, 0x07, 0xC1, 0xE0, 0x1F, 0x07,
  0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x3E, 0x0F, 0x01,
  0xF8, 0x7C, 0x1F, 0xC1, 0xFF, 0xFE, 0x07, 0xFF, 0xF0, 0x1F, 0xFE, 0x00,
  0x78, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00,
  0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0xF0,
  0x03, 0xFF, 0xF8, 0x07, 0xF3, 0xFC, 0x0F, 0xC0, 0x7E, 0x1F, 0x00, 0x3E,
  0x3E, 0x00, 0x1E, 0x3E, 0x00, 0x1F, 0x7C, 0x00, 0x1F, 0x7C, 0x00, 0x0F,
  0x78, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF0, 0x00, 0x1E, 0xF0, 0x00, 0x1E,
  0xF0, 0x00, 0x3E, 0xF0, 0x00, 0x3C, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0xF8,
  0xF8, 0x00, 0xF8, 0x7C, 0x03, 0xF0, 0x7F, 0x0F, 0xE0, 0x3F, 0xFF, 0xC0,
  0x1F, 0xFF, 0x80, 0x07, 0xFE, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xF0, 0x03, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0xFF, 0xFC, 0x07,
  0xFF, 0xF0, 0x7C, 0x0F, 0x83, 0xC0, 0x3C, 0x1E, 0x01, 0xE0, 0xF0, 0x0F,
  0x07, 0x80, 0x78, 0x7C, 0x03, 0xC3, 0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0xF0,
  0x3F, 0x0F, 0xFF, 0xF0, 0x7F, 0xFF, 0x03, 0xFF, 0xE0, 0x1F, 0xFE, 0x00,
  0xF0, 0xF0, 0x0F, 0x83, 0xC0, 0x78, 0x1E, 0x03, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0xF0, 0x1E, 0x0F, 0x80, 0xF8, 0x78, 0x03, 0xC3, 0xC0, 0x1F, 0x1E,
  0x00, 0xF9, 0xF0, 0x03, 0xE0, 0x00, 0xFF, 0x80, 0x3F, 0xFF, 0x07, 0xFF,
  0xE0, 0xFF, 0x7E, 0x0F, 0x80, 0x41, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07,
  0xE0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0,
  0x00, 0x0F, 0x08, 0x01, 0xF0, 0xF0, 0x7E, 0x0F, 0xFF, 0xE0, 0xFF, 0xF8,
  0x07, 0xFE, 0x00, 0x7F, 0xFF, 0xF7, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0xFE, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x0F, 0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1E, 0x1E, 0x00,
  0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x1E, 0x00, 0x3E, 0x3E, 0x00,
  0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00, 0x3C, 0x3C, 0x00,
  0x7C, 0x7C, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00, 0x78, 0x78, 0x00,
  0xF8, 0x78, 0x00, 0xF8, 0xF8, 0x00, 0xF0, 0xF0, 0x00, 0xF0, 0xF0, 0x00,
  0xF0, 0xF0, 0x01, 0xF0, 0xF0, 0x01, 0xE0, 0xF8, 0x03, 0xE0, 0xF8, 0x07,
  0xC0, 0x7E, 0x1F, 0xC0, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0x00, 0x0F, 0xFC,
  0x00, 0xF0, 0x00, 0x7F, 0xC0, 0x03, 0xEF, 0x00, 0x0F, 0x3C, 0x00, 0x7C,
  0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x8F, 0x00, 0x3C, 0x3C, 0x01, 0xF0, 0xF0,
  0x07, 0x83, 0xC0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0x78, 0x1E,
  0x01, 0xE0, 0xF8, 0x07, 0x83, 0xC0, 0x1E, 0x1E, 0x00, 0x78, 0x78, 0x01,
  0xE3, 0xC0, 0x07, 0x8F, 0x00, 0x0E, 0x78, 0x00, 0x39, 0xE0, 0x00, 0xEF,
  0x00, 0x03, 0xBC, 0x00, 0x0E, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0xF8, 0x01,
  0xF0, 0x07, 0xFC, 0x00, 0xF8, 0x03, 0xDE, 0x00, 0xFC, 0x01, 0xEF, 0x00,
  0x7E, 0x01, 0xE7, 0x80, 0x7F, 0x00, 0xF3, 0xC0, 0x3F, 0x80, 0xF1, 0xE0,
  0x3F, 0xC0, 0x78, 0xF0, 0x1D, 0xE0, 0x7C, 0x78, 0x1E, 0x70, 0x3C, 0x3C,
  0x0F, 0x38, 0x3E, 0x1E, 0x0F, 0x1C, 0x1E, 0x0F, 0x07, 0x8E, 0x0F, 0x03,
  0x87, 0x87, 0x0F, 0x01, 0xC3, 0xC3, 0x87, 0x80, 0xE3, 0xC1, 0xC7, 0x80,
  0x71, 0xE0, 0xE3, 0xC0, 0x38, 0xE0, 0x71, 0xC0, 0x1C, 0xF0, 0x39, 0xE0,
  0x0E, 0x70, 0x1C, 0xF0, 0x07, 0x78, 0x0E, 0xF0, 0x03, 0xB8, 0x07, 0x78,
  0x01, 0xDC, 0x03, 0xB8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x03, 0xE0, 0x3C, 0x00, 0xF8, 0x07, 0x80, 0x3E,
  0x00, 0x78, 0x0F, 0x80, 0x0F, 0x01, 0xE0, 0x01, 0xE0, 0x78, 0x00, 0x1E,
  0x1F, 0x00, 0x03, 0xC7, 0xC0, 0x00, 0x78, 0xF0, 0x00, 0x07, 0xBC, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x1E, 0x78, 0x00, 0x07, 0xCF, 0x00, 0x01, 0xF1, 0xE0, 0x00, 0x3C, 0x3E,
  0x00, 0x0F, 0x03, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0xF8, 0x0F, 0x80, 0x1E,
  0x00, 0xF0, 0x07, 0x80, 0x1E, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x00, 0x3C,
  0x00, 0xF0, 0x01, 0xFF, 0x00, 0x1E, 0xF0, 0x03, 0xCF, 0x80, 0x7C, 0x78,
  0x07, 0x87, 0x80, 0xF0, 0x78, 0x1F, 0x07, 0x81, 0xE0, 0x3C, 0x3C, 0x03,
  0xC7, 0xC0, 0x3C, 0x78, 0x01, 0xCF, 0x00, 0x1F, 0xF0, 0x01, 0xFE, 0x00,
  0x1F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x01,
  0xFF, 0xFF, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x03, 0xFF, 0xFE, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0xF0, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F,
  0xFF, 0xE0, 0x7F, 0xFF, 0xE0, 0x7F, 0xFF, 0xC0, 0xFF, 0xFF, 0xC0, 0x01,
  0xFE, 0x07, 0xF8, 0x0F, 0xF0, 0x1E, 0x00, 0x3C, 0x00, 0x70, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00, 0x78, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x38, 0x00, 0xF0, 0x01,
  0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x7F, 0x80, 0xFF,
  0x01, 0xFE, 0x00, 0xF0, 0xF0, 0x70, 0x70, 0x78, 0x78, 0x78, 0x78, 0x78,
  0x38, 0x38, 0x3C, 0x3C, 0x3C, 0x3C, 0x1C, 0x1C, 0x1C, 0x1E, 0x1E, 0x1E,
  0x1E, 0x0E, 0x0E, 0x0F, 0x0F, 0x0F, 0x0F, 0x01, 0xFE, 0x03, 0xFC, 0x07,
  0xF8, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x70, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1C, 0x00,
  0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xE0, 0x01, 0xC0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00,
  0x38, 0x00, 0xF0, 0x01, 0xE0, 0x3F, 0xC0, 0x7F, 0x81, 0xFE, 0x00, 0x00,
  0x70, 0x00, 0x07, 0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xFC, 0x00,
  0x1D, 0xC0, 0x03, 0x9E, 0x00, 0x38, 0xE0, 0x07, 0x0F, 0x00, 0x70, 0x70,
  0x0E, 0x07, 0x01, 0xE0, 0x38, 0x1C, 0x03, 0x83, 0xC0, 0x3C, 0x38, 0x01,
  0xC7, 0x80, 0x1E, 0x70, 0x00, 0xEF, 0x00, 0x0F, 0x7F, 0xFF, 0xFF, 0xFF,
  0x80, 0xF1, 0xF1, 0xE1, 0xC3, 0xC3, 0xC0, 0x03, 0xF8, 0xF0, 0x7F, 0xCE,
  0x0F, 0xFE, 0xE1, 0xF8, 0xFE, 0x3E, 0x07, 0xE3, 0xC0, 0x3E, 0x7C, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x07, 0xCF, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0xF8,
  0x3F, 0x0F, 0x87, 0xF0, 0x7F, 0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0x8E, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF1,
  0xF8, 0x0F, 0x3F, 0xC0, 0xF7, 0xFE, 0x0F, 0xE3, 0xE1, 0xFC, 0x1F, 0x1F,
  0x80, 0xF1, 0xF0, 0x0F, 0x1E, 0x00, 0xF1, 0xE0, 0x0F, 0x3E, 0x00, 0xF3,
  0xC0, 0x1F, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C, 0x03, 0xE7, 0xC0, 0x3C,
  0x7C, 0x07, 0xC7, 0xC0, 0x78, 0x7E, 0x1F, 0x8F, 0x7F, 0xF0, 0xF7, 0xFE,
  0x0E, 0x1F, 0x80, 0x01, 0xFF, 0x07, 0xFF, 0x0F, 0xFF, 0x1F, 0x82, 0x3E,
  0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF8, 0x00, 0xF8, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x18, 0x7F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x0F, 0xE3,
  0xC0, 0x7F, 0xDE, 0x03, 0xFF, 0xF8, 0x1F, 0x8F, 0xE0, 0xF8, 0x1F, 0x83,
  0xC0, 0x3E, 0x1F, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xE0, 0x0F, 0x0F, 0x80,
  0x3C, 0x3C, 0x01, 0xF0, 0xF0, 0x07, 0x83, 0xC0, 0x1E, 0x0F, 0x00, 0xF8,
  0x3C, 0x03, 0xE0, 0xF0, 0x1F, 0x03, 0xC0, 0xFC, 0x0F, 0x87, 0xF0, 0x1F,
  0xFB, 0xC0, 0x7F, 0xCF, 0x00, 0xFE, 0x38, 0x00, 0x01, 0xFE, 0x03, 0xFF,
  0x83, 0xFF, 0xE3, 0xE1, 0xF3, 0xE0, 0x79, 0xE0, 0x3D, 0xF0, 0x1E, 0xF0,
  0x1E, 0x78, 0x3F, 0x7F, 0xFF, 0x3F, 0xFE, 0x1F, 0xFC, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x02, 0x3E, 0x06, 0x1F, 0xFF,
  0x07, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0xF0, 0x00,
  0xFF, 0x80, 0x03, 0xFE, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xFF, 0x80, 0x3F, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00,
  0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0x78, 0x00, 0x01,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x78, 0x1F, 0xF3, 0x81, 0xFF,
  0xDC, 0x1F, 0x8F, 0xE1, 0xF0, 0x3F, 0x0F, 0x00, 0xF8, 0xF8, 0x07, 0x87,
  0x80, 0x3C, 0x3C, 0x01, 0xE3, 0xE0, 0x0F, 0x1E, 0x00, 0xF8, 0xF0, 0x07,
  0x87, 0x80, 0x3C, 0x3C, 0x03, 0xE1, 0xE0, 0x1F, 0x0F, 0x01, 0xF0, 0x7C,
  0x1F, 0x83, 0xE1, 0xFC, 0x0F, 0xFD, 0xE0, 0x7F, 0xCF, 0x01, 0xFC, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x04, 0x01,
  0xF0, 0x38, 0x1F, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0x80, 0x3F, 0xF0, 0x00,
  0x03, 0xC0, 0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x07, 0x80, 0x00, 0xF1,
  0xFC, 0x0F, 0x3F, 0xE0, 0xF7, 0xFE, 0x0F, 0xE1, 0xF1, 0xFC, 0x1F, 0x1F,
  0x80, 0xF1, 0xF0, 0x1F, 0x1E, 0x01, 0xF1, 0xE0, 0x1E, 0x3E, 0x01, 0xE3,
  0xC0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3C, 0x3C, 0x03, 0xC7, 0x80, 0x3C,
  0x78, 0x03, 0xC7, 0x80, 0x7C, 0x78, 0x07, 0x8F, 0x80, 0x78, 0xF0, 0x07,
  0x8F, 0x00, 0x78, 0x03, 0xC0, 0xF0, 0x7C, 0x1F, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x1F, 0x07, 0x81, 0xE0, 0x78, 0x1E,
  0x0F, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E, 0x0F,
  0x83, 0xC0, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1F,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0,
  0x01, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x0F, 0xC3, 0xC0,
  0xF8, 0x1E, 0x0F, 0x80, 0xF0, 0xF8, 0x0F, 0x8F, 0x80, 0x78, 0xF8, 0x03,
  0xCF, 0x80, 0x1E, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xFC, 0x00, 0x7F, 0xE0,
  0x03, 0xFF, 0x80, 0x1F, 0x3C, 0x00, 0xF1, 0xE0, 0x0F, 0x0F, 0x80, 0x78,
  0x3C, 0x03, 0xC1, 0xF0, 0x1E, 0x07, 0x81, 0xF0, 0x3E, 0x0F, 0x00, 0xF0,
  0x78, 0x07, 0xC0, 0x03, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78,
  0x1E, 0x07, 0x83, 0xC0, 0xF0, 0x3C, 0x0F, 0x07, 0xC1, 0xE0, 0x78, 0x1E,
  0x07, 0x83, 0xE0, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xE0, 0x78, 0x1E, 0x07,
  0x83, 0xE0, 0xF0, 0x3C, 0x00, 0x0F, 0x1F, 0x81, 0xF8, 0x1E, 0x7F, 0x8F,
  0xF8, 0x39, 0xFF, 0xBF, 0xF8, 0x77, 0x1F, 0x71, 0xF1, 0xFC, 0x1F, 0xC1,
  0xE3, 0xF0, 0x3F, 0x03, 0xC7, 0xC0, 0x7C, 0x07, 0x8F, 0x80, 0xF8, 0x0F,
  0x1E, 0x01, 0xE0, 0x1E, 0x7C, 0x07, 0xC0, 0x3C, 0xF0, 0x0F, 0x00, 0xF1,
  0xE0, 0x1E, 0x01, 0xE3, 0xC0, 0x3C, 0x03, 0xC7, 0x80, 0x78, 0x07, 0x9E,
  0x01, 0xF0, 0x1F, 0x3C, 0x03, 0xC0, 0x3C, 0x78, 0x07, 0x80, 0x78, 0xF0,
  0x0F, 0x00, 0xF3, 0xE0, 0x1E, 0x01, 0xE7, 0x80, 0x78, 0x07, 0xCF, 0x00,
  0xF0, 0x0F, 0x00, 0x0F, 0x1F, 0xC0, 0xF7, 0xFE, 0x0F, 0xFF, 0xE0, 0xEE,
  0x1F, 0x1F, 0xC1, 0xF1, 0xF8, 0x0F, 0x1F, 0x01, 0xF1, 0xF0, 0x1F, 0x1E,
  0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x3E, 0x3C, 0x03, 0xE7,
  0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7, 0x80, 0x78,
  0xF8, 0x07, 0x8F, 0x00, 0x78, 0xF0, 0x0F, 0x80, 0x01, 0xFC, 0x01, 0xFF,
  0xC0, 0xFF, 0xF8, 0x7E, 0x3E, 0x3E, 0x07, 0xCF, 0x00, 0xF7, 0xC0, 0x3D,
  0xE0, 0x0F, 0xF8, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0xC0, 0x0F, 0xF0,
  0x03, 0xFC, 0x01, 0xEF, 0x00, 0x7B, 0xC0, 0x3E, 0xF8, 0x1F, 0x1F, 0x0F,
  0x87, 0xFF, 0xE0, 0xFF, 0xE0, 0x0F, 0xF0, 0x00, 0x03, 0xC7, 0xE0, 0x0F,
  0x3F, 0xC0, 0x3B, 0xFF, 0x80, 0xEE, 0x3E, 0x07, 0xF0, 0x7C, 0x1F, 0x80,
  0xF0, 0x7C, 0x03, 0xC1, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3E, 0x00, 0xF0,
  0xF0, 0x07, 0xC3, 0xC0, 0x1E, 0x0F, 0x00, 0x78, 0x3C, 0x03, 0xE1, 0xF0,
  0x0F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x1F, 0x81, 0xDF, 0xFC,
  0x0F, 0x3F, 0xE0, 0x3C, 0x7E, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0xF0, 0x7F, 0xCE,
  0x0F, 0xFE, 0xE1, 0xF8, 0xFE, 0x3E, 0x07, 0xE3, 0xC0, 0x3E, 0x7C, 0x03,
  0xC7, 0x80, 0x3C, 0x78, 0x03, 0xCF, 0x80, 0x3C, 0xF0, 0x07, 0xCF, 0x00,
  0x78, 0xF0, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF0, 0xF0,
  0x3F, 0x0F, 0x87, 0xF0, 0x7F, 0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0x9E, 0x00,
  0x01, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0,
  0x00, 0x3C, 0x00, 0x03, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x0F, 0x1F,
  0x0F, 0x7F, 0x0F, 0x7E, 0x0E, 0xF2, 0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x00,
  0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00,
  0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF8, 0x00,
  0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFE, 0x07, 0xFF, 0xC3, 0xFF, 0xC3, 0xE0,
  0xE1, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x80, 0x3C, 0x70, 0x3E, 0x3F, 0xFF, 0x1F, 0xFF, 0x07, 0xFE,
  0x00, 0x03, 0x80, 0x38, 0x01, 0xC0, 0x1E, 0x00, 0xF0, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFE, 0x1E, 0x00, 0xF0, 0x0F, 0x80, 0x78, 0x03, 0xC0, 0x1E, 0x00,
  0xF0, 0x0F, 0x00, 0x78, 0x03, 0xC0, 0x1E, 0x01, 0xF0, 0x0F, 0x00, 0x78,
  0x03, 0xE1, 0x1F, 0xF0, 0x7F, 0x81, 0xFC, 0x00, 0x1E, 0x00, 0xF1, 0xE0,
  0x1F, 0x1E, 0x01, 0xE3, 0xE0, 0x1E, 0x3C, 0x01, 0xE3, 0xC0, 0x1E, 0x3C,
  0x03, 0xE3, 0xC0, 0x3C, 0x7C, 0x03, 0xC7, 0x80, 0x3C, 0x78, 0x07, 0xC7,
  0x80, 0x78, 0x78, 0x07, 0x8F, 0x00, 0xF8, 0xF0, 0x0F, 0x8F, 0x01, 0xF8,
  0xF0, 0x3F, 0x0F, 0x87, 0xF0, 0x7F, 0xEF, 0x07, 0xFC, 0xF0, 0x3F, 0x8F,
  0x00, 0xF0, 0x03, 0xFE, 0x00, 0xFB, 0xC0, 0x1E, 0x78, 0x07, 0xCF, 0x00,
  0xF0, 0xE0, 0x3E, 0x1E, 0x07, 0x83, 0xC1, 0xF0, 0x78, 0x3C, 0x0F, 0x0F,
  0x81, 0xE1, 0xE0, 0x3C, 0x78, 0x07, 0x8F, 0x00, 0xF3, 0xC0, 0x0E, 0x78,
  0x01, 0xDE, 0x00, 0x3B, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xF0, 0x0F, 0x00, 0xFF, 0x80, 0xFC, 0x07, 0xBC, 0x07,
  0xE0, 0x79, 0xE0, 0x7F, 0x03, 0xCF, 0x03, 0xB8, 0x3C, 0x38, 0x3D, 0xC1,
  0xE1, 0xC1, 0xCE, 0x1F, 0x0E, 0x0E, 0x70, 0xF0, 0x70, 0xF3, 0x8F, 0x83,
  0x87, 0x1C, 0x78, 0x1C, 0x78, 0xE3, 0xC0, 0xE3, 0x87, 0x3C, 0x07, 0x3C,
  0x39, 0xE0, 0x39, 0xC1, 0xDE, 0x01, 0xDE, 0x0E, 0xF0, 0x0E, 0xE0, 0x77,
  0x00, 0x77, 0x03, 0xF8, 0x03, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00,
  0xFC, 0x07, 0xE0, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x07,
  0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x0F, 0x0F, 0x80, 0x1E, 0x3E, 0x00, 0x3E,
  0x78, 0x00, 0x3D, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0,
  0x00, 0xF3, 0xC0, 0x03, 0xC7, 0x80, 0x0F, 0x87, 0x80, 0x3E, 0x0F, 0x00,
  0xF8, 0x1F, 0x01, 0xE0, 0x1E, 0x0F, 0xC0, 0x3E, 0x00, 0x07, 0x80, 0x1F,
  0x07, 0x80, 0x1E, 0x07, 0x80, 0x3C, 0x07, 0x80, 0x7C, 0x03, 0xC0, 0x78,
  0x03, 0xC0, 0xF8, 0x03, 0xC0, 0xF0, 0x03, 0xC1, 0xF0, 0x03, 0xC1, 0xE0,
  0x03, 0xC3, 0xE0, 0x03, 0xC3, 0xC0, 0x01, 0xC7, 0xC0, 0x01, 0xC7, 0x80,
  0x01, 0xEF, 0x00, 0x01, 0xEF, 0x00, 0x01, 0xEE, 0x00, 0x01, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xF8, 0x1F, 0xFF, 0x00, 0x03,
  0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00,
  0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x01, 0xFF, 0xF8,
  0x3F, 0xFF, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0xF0, 0x00, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0, 0x01,
  0xC0, 0x01, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0x80, 0x0F, 0x80, 0x7F,
  0x00, 0x7E, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1C, 0x00, 0x1C, 0x00, 0x1E, 0x00, 0x1F, 0x80, 0x1F, 0x80, 0x07,
  0x80, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF8, 0x01, 0xC0, 0x01, 0xF0, 0x03, 0xF8, 0x03, 0xF8,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x3F, 0x00, 0x3E, 0x00, 0xFE, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x07, 0x00, 0x0F, 0x00, 0x1F, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0xF8, 0x00,
  0x08, 0x00, 0x5F, 0xE0, 0x1F, 0xFF, 0x1F, 0xFF, 0xFF, 0x80, 0xFF, 0xA0,
  0x0F, 0xC0,
};

const GFXglyph NotoSans_MediumItalic39pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 10, 0, -1 },
  { 1, 10, 29, 10, 1, -28 },
  { 38, 13, 10, 16, 4, -28 },
  { 55, 24, 28, 25, 1, -28 },
  { 139, 20, 32, 21, 1, -30 },
  { 219, 27, 28, 32, 3, -28 },
  { 314, 25, 28, 27, 1, -28 },
  { 402, 6, 10, 9, 4, -28 },
  { 410, 13, 34, 12, 2, -28 },
  { 466, 13, 34, 12, -3, -28 },
  { 522, 18, 19, 21, 4, -30 },
  { 565, 18, 19, 22, 3, -23 },
  { 608, 9, 10, 10, -2, -5 },
  { 620, 10, 3, 12, 1, -12 },
  { 624, 5, 6, 10, 1, -5 },
  { 628, 20, 28, 15, -2, -28 },
  { 698, 19, 28, 21, 2, -28 },
  { 765, 13, 28, 21, 5, -28 },
  { 811, 21, 28, 21, 0, -28 },
  { 885, 20, 28, 21, 1, -28 },
  { 955, 21, 28, 21, 0, -28 },
  { 1029, 20, 28, 21, 1, -28 },
  { 1099, 19, 28, 21, 2, -28 },
  { 1166, 19, 28, 21, 3, -28 },
  { 1233, 19, 28, 21, 2, -28 },
  { 1300, 18, 28, 21, 2, -28 },
  { 1363, 8, 23, 10, 1, -22 },
  { 1386, 11, 27, 10, -2, -22 },
  { 1424, 18, 20, 22, 3, -24 },
  { 1469, 18, 11, 22, 3, -19 },
  { 1494, 18, 20, 22, 3, -24 },
  { 1539, 15, 29, 17, 3, -28 },
  { 1594, 30, 32, 33, 2, -28 },
  { 1714, 23, 28, 23, -2, -28 },
  { 1795, 22, 28, 24, 1, -28 },
  { 1872, 22, 28, 23, 3, -28 },
  { 1949, 24, 28, 26, 1, -28 },
  { 2033, 21, 28, 20, 1, -28 },
  { 2107, 21, 28, 19, 1, -28 },
  { 2181, 23, 28, 27, 3, -28 },
  { 2262, 26, 28, 27, 1, -28 },
  { 2353, 17, 28, 13, -1, -28 },
  { 2413, 18, 36, 11, -6, -28 },
  { 2494, 25, 28, 23, 1, -28 },
  { 2582, 16, 28, 19, 1, -28 },
  { 2638, 32, 28, 33, 1, -28 },
  { 2750, 27, 28, 28, 1, -28 },
  { 2845, 24, 28, 28, 3, -28 },
  { 2929, 22, 28, 23, 1, -28 },
  { 3006, 24, 35, 28, 3, -28 },
  { 3111, 21, 28, 23, 1, -28 },
  { 3185, 20, 28, 20, 1, -28 },
  { 3255, 20, 28, 20, 3, -28 },
  { 3325, 24, 28, 27, 3, -28 },
  { 3409, 22, 28, 22, 4, -28 },
  { 3486, 33, 28, 34, 4, -28 },
  { 3602, 27, 28, 21, -2, -28 },
  { 3697, 20, 28, 20, 4, -28 },
  { 3767, 24, 28, 21, -1, -28 },
  { 3851, 15, 34, 12, 0, -28 },
  { 3915, 8, 28, 15, 4, -28 },
  { 3943, 15, 34, 12, -3, -28 },
  { 4007, 20, 18, 22, 1, -28 },
  { 4052, 17, 2, 15, -4, 4 },
  { 4057, 7, 6, 11, 6, -30 },
  { 4063, 20, 21, 22, 2, -21 },
  { 4116, 20, 30, 23, 1, -30 },
  { 4191, 16, 21, 18, 2, -21 },
  { 4233, 22, 30, 23, 2, -30 },
  { 4316, 17, 21, 20, 2, -21 },
  { 4361, 22, 39, 13, -4, -30 },
  { 4469, 21, 30, 23, 1, -21 },
  { 4548, 20, 30, 23, 1, -30 },
  { 4623, 10, 29, 11, 1, -29 },
  { 4660, 16, 38, 11, -5, -29 },
  { 4736, 21, 30, 20, 1, -30 },
  { 4815, 10, 30, 11, 1, -30 },
  { 4853, 31, 21, 34, 1, -21 },
  { 4935, 20, 21, 23, 1, -21 },
  { 4988, 18, 21, 22, 2, -21 },
  { 5036, 22, 30, 23, -1, -21 },
  { 5119, 20, 30, 23, 2, -21 },
  { 5194, 16, 21, 16, 1, -21 },
  { 5236, 17, 21, 17, 0, -21 },
  { 5281, 13, 26, 14, 2, -26 },
  { 5324, 20, 21, 23, 2, -21 },
  { 5377, 19, 21, 19, 2, -21 },
  { 5427, 29, 21, 29, 2, -21 },
  { 5504, 23, 21, 19, -2, -21 },
  { 5565, 24, 30, 19, -3, -21 },
  { 5655, 19, 21, 18, -1, -21 },
  { 5705, 16, 34, 14, 0, -28 },
  { 5773, 3, 39, 21, 10, -30 },
  { 5788, 16, 34, 14, -2, -28 },
  { 5856, 18, 6, 22, 3, -17 },
};

const GFXfont NotoSans_MediumItalic39pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic39pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic39pt7bGlyphs,
  0x20, 0x7E, 53
};

#endif // _NOTOSANS_MEDIUMITALIC39PT7B_H_
