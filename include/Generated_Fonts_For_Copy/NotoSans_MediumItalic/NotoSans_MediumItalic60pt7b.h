#ifndef _NOTOSANS_MEDIUMITALIC60PT7B_H_
#define _NOTOSANS_MEDIUMITALIC60PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 60pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic60pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x07,
  0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0x80, 0x0F, 0x80, 0x0F,
  0x80, 0x10, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF,
  0x00, 0x7E, 0x00, 0x38, 0x00, 0x3F, 0x87, 0xF3, 0xF8, 0x7E, 0x3F, 0x07,
  0xE3, 0xF0, 0x7E, 0x3F, 0x07, 0xC3, 0xE0, 0xFC, 0x3E, 0x0F, 0xC7, 0xE0,
  0xFC, 0x7E, 0x0F, 0x87, 0xC0, 0xF8, 0x7C, 0x0F, 0x87, 0xC0, 0xF0, 0x78,
  0x0F, 0x07, 0x81, 0xF0, 0xF8, 0x1F, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xFF, 0xFF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFF, 0x1F,
  0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x7C,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x1E, 0x00, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00,
  0x00, 0x7C, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF, 0xFC, 0x7F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x3E, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0xF8, 0x00, 0x00, 0xF8,
  0x0F, 0x80, 0x00, 0x07, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x1F, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x03,
  0xC0, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x03, 0xC0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x80, 0xFE, 0x3C,
  0x1C, 0x03, 0xF0, 0xF0, 0x10, 0x1F, 0x83, 0xC0, 0x00, 0x7E, 0x0F, 0x00,
  0x01, 0xF8, 0x78, 0x00, 0x07, 0xE1, 0xE0, 0x00, 0x1F, 0x87, 0x80, 0x00,
  0x7E, 0x1E, 0x00, 0x01, 0xFC, 0x78, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F,
  0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF,
  0xF0, 0x00, 0x07, 0xBF, 0xC0, 0x00, 0x3C, 0x3F, 0x00, 0x00, 0xF0, 0xFC,
  0x00, 0x03, 0xC3, 0xF8, 0x00, 0x0F, 0x0F, 0xE0, 0x00, 0x3C, 0x3F, 0x00,
  0x01, 0xE0, 0xFC, 0x20, 0x07, 0x87, 0xF0, 0xE0, 0x1E, 0x3F, 0x83, 0xF0,
  0x7B, 0xFE, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x78, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07, 0x80, 0x00,
  0x00, 0x1E, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x3F, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0x80, 0x7F, 0xFC, 0x00, 0x07, 0xC0,
  0x3F, 0xFF, 0x80, 0x03, 0xE0, 0x0F, 0xC7, 0xE0, 0x01, 0xF8, 0x07, 0xE0,
  0xF8, 0x00, 0x7C, 0x01, 0xF0, 0x3E, 0x00, 0x3E, 0x00, 0xFC, 0x0F, 0x80,
  0x1F, 0x80, 0x3E, 0x03, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0xF8, 0x03, 0xE0,
  0x07, 0xE0, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x0F, 0x80, 0xFC, 0x00, 0x7C,
  0x03, 0xE0, 0x7E, 0x00, 0x1F, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC0, 0x7E,
  0x0F, 0x80, 0x03, 0xF0, 0x1F, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xC3, 0xF0,
  0x00, 0x3F, 0x01, 0xF0, 0xF8, 0x7F, 0x8F, 0xC0, 0xF8, 0x7C, 0x7F, 0xF3,
  0xF0, 0x3E, 0x3F, 0x3F, 0xFE, 0x7C, 0x1F, 0x1F, 0x9F, 0xFF, 0xDF, 0x8F,
  0xC7, 0xC7, 0xE3, 0xF7, 0xFF, 0xE3, 0xE3, 0xF0, 0x7C, 0xFF, 0xF1, 0xF8,
  0xF8, 0x1F, 0x1F, 0xF8, 0xFC, 0x7E, 0x07, 0xC3, 0xFC, 0x3E, 0x1F, 0x01,
  0xF0, 0x00, 0x1F, 0x0F, 0xC0, 0x7C, 0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0x00,
  0x03, 0xE0, 0xF8, 0x07, 0xC0, 0x01, 0xF0, 0x3E, 0x01, 0xF0, 0x00, 0xF8,
  0x0F, 0x80, 0x7C, 0x00, 0x7E, 0x07, 0xE0, 0x3F, 0x00, 0x1F, 0x01, 0xF8,
  0x0F, 0x80, 0x0F, 0x80, 0x7E, 0x03, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0xF8,
  0x03, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x01, 0xF8, 0x1F, 0x00, 0x7C,
  0x00, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x0F, 0xC7, 0xE0, 0x1F, 0x80, 0x03,
  0xFF, 0xF0, 0x07, 0xC0, 0x00, 0x7F, 0xFC, 0x03, 0xE0, 0x00, 0x1F, 0xFC,
  0x01, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x08, 0x00, 0x00,
  0x00, 0x08, 0x00, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFE,
  0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00, 0x0F,
  0xC0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0x1F,
  0x83, 0xFC, 0x00, 0x00, 0x7E, 0x1F, 0xE0, 0x00, 0x00, 0xFD, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xFC, 0x00, 0x7F, 0x0F, 0xFB, 0xF8, 0x01, 0xF8, 0x7F, 0x87,
  0xF0, 0x0F, 0xC3, 0xFC, 0x1F, 0xC0, 0x3F, 0x0F, 0xE0, 0x3F, 0x81, 0xF8,
  0x7F, 0x00, 0x7F, 0x0F, 0xE1, 0xF8, 0x01, 0xFC, 0x3F, 0x0F, 0xE0, 0x03,
  0xF9, 0xFC, 0x3F, 0x80, 0x07, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xFF, 0x03,
  0xF0, 0x00, 0x3F, 0xF8, 0x0F, 0xC0, 0x00, 0x7F, 0xC0, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0x07, 0xFC, 0x03, 0xFC, 0x00, 0x7F, 0xF0, 0x07,
  0xF8, 0x07, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0x7F, 0x00, 0x7F, 0xFF, 0xF0, 0xFE, 0x00, 0xFF, 0xFF, 0x01, 0xFC, 0x00,
  0xFF, 0xF0, 0x07, 0xF8, 0x00, 0x38, 0x00, 0x00, 0x00, 0x3F, 0x9F, 0xCF,
  0xC7, 0xE3, 0xF1, 0xF0, 0xF8, 0xFC, 0x7E, 0x3E, 0x1F, 0x0F, 0x87, 0x83,
  0xC3, 0xE1, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0,
  0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03,
  0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F,
  0x00, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x7C, 0x00, 0x40, 0x07,
  0xC0, 0x07, 0x00, 0x78, 0x00, 0x7C, 0x07, 0x80, 0x07, 0xF0, 0xF8, 0x00,
  0xFF, 0xCF, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0x83,
  0xF0, 0x1F, 0xF8, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x0F,
  0xC3, 0xE0, 0x01, 0xFC, 0x3E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xF0, 0x1F,
  0x00, 0x0E, 0x01, 0xF8, 0x00, 0x60, 0x1F, 0x80, 0x04, 0x01, 0xFC, 0x00,
  0x00, 0x0E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xF0, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x03, 0xF8, 0x1F,
  0xC1, 0xFC, 0x0F, 0xE0, 0x7E, 0x07, 0xF0, 0x3F, 0x03, 0xF8, 0x1F, 0x80,
  0xF8, 0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x3E, 0x03, 0xE0, 0x00, 0x3F, 0xFF,
  0x7F, 0xFF, 0x7F, 0xFF, 0x7F, 0xFE, 0x7F, 0xFE, 0xFF, 0xFE, 0x1E, 0x7F,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x38, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0, 0x07,
  0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0xFE, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0x80,
  0x1F, 0xC3, 0xF8, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF1, 0xFC, 0x00, 0x1F,
  0x8F, 0xE0, 0x00, 0xFC, 0x7E, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x3F, 0x3F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x7E, 0xFE, 0x00,
  0x07, 0xF7, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x7E, 0xFE, 0x00, 0x03, 0xF7, 0xF0, 0x00, 0x3F, 0xBF,
  0x80, 0x01, 0xFD, 0xF8, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7E, 0x7E, 0x00,
  0x07, 0xF3, 0xF0, 0x00, 0x3F, 0x9F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0xFE, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x07,
  0xE0, 0x07, 0xF0, 0x3F, 0x80, 0x7F, 0x01, 0xFE, 0x07, 0xF8, 0x07, 0xFF,
  0xFF, 0x80, 0x3F, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xF0, 0x1F, 0xFE, 0x0F, 0xFF, 0x83,
  0xFF, 0xF1, 0xFF, 0xFE, 0x7F, 0xEF, 0xDF, 0xF3, 0xF3, 0xFC, 0x7E, 0x3E,
  0x0F, 0xC3, 0x83, 0xF8, 0x40, 0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0x03, 0xFE, 0x00, 0x7C, 0x00, 0xFE, 0x00, 0x70, 0x00, 0xFF,
  0x00, 0x20, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF0,
  0x7F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0x80, 0x7F, 0x80, 0x3C, 0x00, 0x7F, 0x00,
  0x20, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x84,
  0x00, 0x00, 0xFF, 0x0C, 0x00, 0x03, 0xFC, 0x1F, 0x00, 0x1F, 0xF0, 0x3F,
  0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x01, 0xFC, 0xF8, 0x00,
  0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x07, 0xE1, 0xF8, 0x00,
  0x0F, 0xC1, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x03, 0xF0, 0x00,
  0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xC0, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x80, 0x0F, 0xC0, 0x3F,
  0x00, 0x0F, 0xC0, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF,
  0xFF, 0xE0, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0x00, 0x20, 0x07, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x20, 0x00, 0x0F, 0xF0, 0xC0, 0x00, 0x7F, 0x83, 0xE0, 0x07,
  0xFC, 0x0F, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x5A, 0x00, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0,
  0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0x80, 0x20, 0x0F,
  0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x1F, 0x83, 0xFC, 0x00, 0xFE, 0x7F, 0xF8, 0x03, 0xF3, 0xFF, 0xF8, 0x0F,
  0xDF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xC1, 0xFF, 0xC0, 0xFF, 0x07, 0xFE,
  0x00, 0xFE, 0x1F, 0xE0, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xE1, 0xFC, 0x00,
  0x1F, 0x87, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8,
  0x7E, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x1F,
  0xC0, 0x0F, 0xE0, 0x7F, 0x00, 0x7F, 0x80, 0xFF, 0x03, 0xFC, 0x03, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x06, 0x00, 0x00, 0x1F, 0xFF, 0xFF,
  0xFC, 0x7F, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF,
  0x3F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0xFF, 0x00, 0xFE, 0x00, 0xFE, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xC0,
  0x07, 0xF0, 0x3F, 0x80, 0x0F, 0xC0, 0x7F, 0x00, 0x1F, 0x80, 0x7E, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x07, 0xF8, 0x01, 0xFC, 0x1F,
  0xE0, 0x01, 0xFC, 0xFF, 0x80, 0x01, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xE0,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x80,
  0x07, 0xFC, 0xFF, 0x80, 0x1F, 0xE0, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xFC,
  0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x1F, 0xE0, 0x0F, 0xF0, 0x1F, 0xFD,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFE, 0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC0, 0x3F, 0xC1,
  0xFC, 0x00, 0xFE, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0,
  0x00, 0xFC, 0x7F, 0x00, 0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01,
  0xFC, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x7E, 0x3F, 0x00, 0x03, 0xF1,
  0xF8, 0x00, 0x3F, 0x8F, 0xC0, 0x03, 0xFC, 0x7F, 0x00, 0x1F, 0xE3, 0xF8,
  0x01, 0xFF, 0x0F, 0xF0, 0x3F, 0xF8, 0x7F, 0xFF, 0xFF, 0x81, 0xFF, 0xFE,
  0xFC, 0x07, 0xFF, 0xE7, 0xE0, 0x1F, 0xFE, 0x7F, 0x00, 0x7F, 0xC3, 0xF0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x60, 0x0F, 0xFC, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0x01, 0xF0, 0x1F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x83, 0xFC,
  0x1F, 0xC0, 0x7E, 0x00, 0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xF0, 0x1F, 0xC0, 0xFE, 0x0F,
  0xF0, 0x7F, 0x83, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xC0, 0x00, 0x00, 0x1F,
  0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0x7E, 0x00, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x10, 0x00, 0x00, 0x03, 0x00, 0x00, 0x00,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x0F, 0xFC, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00,
  0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x0E, 0x00,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x01, 0xFF, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFE,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x00,
  0x0C, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xFF, 0xC1, 0xFF, 0xFF,
  0xE3, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xC7, 0xE0, 0x7F, 0x8E, 0x00, 0x3F,
  0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F,
  0xF0, 0x00, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x00, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0,
  0x00, 0x00, 0x03, 0xE0, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7C, 0x00,
  0x3F, 0xF0, 0x07, 0xC1, 0xF0, 0x01, 0xFF, 0xFC, 0x0F, 0x87, 0xE0, 0x0F,
  0xFF, 0xF8, 0x1F, 0x0F, 0x80, 0x3F, 0xFF, 0xF0, 0x1F, 0x3F, 0x00, 0xFE,
  0x07, 0xC0, 0x3E, 0x7C, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0xF8, 0x0F, 0xC0,
  0x1F, 0x00, 0xFB, 0xE0, 0x1F, 0x00, 0x7E, 0x01, 0xF7, 0xC0, 0x7C, 0x00,
  0xF8, 0x03, 0xEF, 0x80, 0xF8, 0x01, 0xF0, 0x07, 0xDF, 0x03, 0xE0, 0x03,
  0xE0, 0x1F, 0x7C, 0x07, 0xC0, 0x0F, 0xC0, 0x3E, 0xF8, 0x0F, 0x80, 0x1F,
  0x00, 0x7D, 0xF0, 0x3F, 0x00, 0x3E, 0x00, 0xFB, 0xE0, 0x7E, 0x00, 0xFC,
  0x03, 0xE7, 0xC0, 0xFC, 0x01, 0xF8, 0x07, 0xCF, 0x81, 0xF8, 0x07, 0xE0,
  0x1F, 0x9F, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x3E, 0x07, 0xE0, 0x3F, 0x80,
  0xFC, 0x7C, 0x07, 0xE0, 0xFF, 0x83, 0xF0, 0xFC, 0x0F, 0xFF, 0xDF, 0xFF,
  0xC0, 0xF8, 0x0F, 0xFF, 0x9F, 0xFF, 0x01, 0xF0, 0x1F, 0xFE, 0x3F, 0xFC,
  0x03, 0xF0, 0x1F, 0xF0, 0x3F, 0xF0, 0x07, 0xE0, 0x0F, 0x80, 0x0F, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x80, 0x00, 0x1F, 0xE0, 0x00, 0x0E, 0x00, 0x00,
  0x1F, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x0F,
  0xC7, 0xE0, 0x00, 0x03, 0xF8, 0x7C, 0x00, 0x00, 0x7E, 0x0F, 0x80, 0x00,
  0x1F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0x1F, 0x80, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03,
  0xF0, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x01, 0xF8,
  0x01, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x1F, 0x80, 0x00,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x00, 0xFC, 0x7F,
  0x00, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00,
  0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xC0, 0x07, 0xF8, 0x03, 0xF0, 0x00, 0xFE,
  0x00, 0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0x80, 0xFE, 0x00,
  0x07, 0xE0, 0x3F, 0x80, 0x03, 0xF8, 0x0F, 0xC0, 0x01, 0xFC, 0x03, 0xF0,
  0x00, 0xFF, 0x00, 0xFC, 0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F,
  0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xF0, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x3F, 0x80, 0x7F, 0xE0, 0x0F, 0xE0, 0x03, 0xF8,
  0x03, 0xF0, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x0F, 0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0x00, 0x0F, 0xF8, 0x1F, 0xC0, 0x3F, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x3F, 0xFC, 0x0F, 0xE0, 0x1F, 0xF8, 0x00, 0x30, 0x0F,
  0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x40, 0x07, 0xFE, 0x00, 0xF0, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x7F, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x00, 0xFC, 0x00, 0xFF, 0xC0, 0x0F, 0xC0, 0x03, 0xFC,
  0x00, 0xFC, 0x00, 0x1F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x00, 0x3F,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0x03, 0xF0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xF0, 0x3F, 0x00, 0x03,
  0xFE, 0x03, 0xF0, 0x00, 0xFF, 0xC0, 0x3F, 0x00, 0x3F, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x20, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0xF0,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0x01,
  0xFE, 0x01, 0xFF, 0x80, 0x01, 0xC0, 0x1F, 0xF0, 0x00, 0x04, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xCF, 0xE0, 0x01, 0xFF,
  0xFC, 0xFE, 0x00, 0x1F, 0xFF, 0x8F, 0xE0, 0x01, 0xFF, 0xF8, 0xFE, 0x00,
  0x3F, 0xFF, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7F, 0x00,
  0x00, 0x7E, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x80, 0x00, 0xFE, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0xE0, 0x00, 0xFC, 0x01, 0xFF, 0x80, 0x3F,
  0xC0, 0x0F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0x80, 0x00,
  0x00, 0x1C, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0x00,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x01, 0xFC,
  0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF,
  0xC0, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x01,
  0xF8, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00,
  0x1F, 0x80, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0xFC, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x7F, 0xFF, 0xC0, 0x3F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x03,
  0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xF0, 0x01,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0x80, 0x3F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFF, 0x00, 0x1F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0x80, 0x01,
  0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x03, 0xFC,
  0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x07, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0x80,
  0x07, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x01, 0xFE, 0x00,
  0x0F, 0xC0, 0x0F, 0xF0, 0x00, 0x3F, 0x00, 0x7F, 0x80, 0x00, 0xFC, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x00,
  0x7E, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x00, 0xFC, 0x3F, 0xC0, 0x00, 0x03,
  0xF1, 0xFE, 0x00, 0x00, 0x0F, 0xCF, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xEF, 0xF0, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x7E, 0x00,
  0x00, 0x0F, 0xF9, 0xFC, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0xFC,
  0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7E, 0x00,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0x07, 0xE0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x03, 0xF0, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xFC, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0x7F, 0xFF, 0xFE, 0x7F, 0xFF, 0xFE, 0x7F,
  0xFF, 0xFE, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFF, 0x80,
  0x3F, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x1F, 0xF0, 0x00, 0x00, 0x7F, 0xE0,
  0x1F, 0xF8, 0x00, 0x00, 0x7F, 0xF0, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x07, 0xFF, 0x00, 0x00, 0x3F, 0xF8, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFC,
  0x01, 0xF7, 0xC0, 0x00, 0x1F, 0xFE, 0x01, 0xFB, 0xE0, 0x00, 0x1F, 0xBF,
  0x00, 0xFD, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x7E, 0xF8, 0x00, 0x0F, 0xDF,
  0x80, 0x3F, 0x7C, 0x00, 0x07, 0xEF, 0xC0, 0x1F, 0x3E, 0x00, 0x07, 0xE7,
  0xE0, 0x1F, 0x9F, 0x00, 0x03, 0xE3, 0xF0, 0x0F, 0xCF, 0xC0, 0x03, 0xF3,
  0xF0, 0x07, 0xE7, 0xE0, 0x01, 0xF1, 0xF8, 0x03, 0xF3, 0xF0, 0x01, 0xF8,
  0xFC, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x7E, 0x01, 0xF8, 0x7C, 0x00, 0xFC,
  0x7F, 0x00, 0xFC, 0x3E, 0x00, 0x7C, 0x3F, 0x00, 0x7E, 0x1F, 0x00, 0x7E,
  0x1F, 0x80, 0x3F, 0x0F, 0x80, 0x3E, 0x0F, 0xC0, 0x3F, 0x07, 0xC0, 0x3F,
  0x07, 0xE0, 0x1F, 0x83, 0xE0, 0x3F, 0x07, 0xE0, 0x0F, 0xC1, 0xF8, 0x1F,
  0x83, 0xF0, 0x07, 0xE0, 0xFC, 0x1F, 0x81, 0xF8, 0x03, 0xF0, 0x7E, 0x0F,
  0x80, 0xFC, 0x03, 0xF0, 0x1F, 0x0F, 0xC0, 0xFE, 0x01, 0xF8, 0x0F, 0x87,
  0xC0, 0x7E, 0x00, 0xFC, 0x07, 0xC7, 0xE0, 0x3F, 0x00, 0x7E, 0x03, 0xE3,
  0xE0, 0x1F, 0x80, 0x3F, 0x01, 0xF3, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xF9,
  0xF0, 0x0F, 0xE0, 0x1F, 0x80, 0x7D, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x3F,
  0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xFC, 0x01, 0xF8, 0x03, 0xE0, 0x07,
  0xFC, 0x00, 0xFC, 0x03, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x01, 0xF8, 0x01,
  0xFE, 0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0x1F, 0x80, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x1F,
  0xE0, 0x00, 0x07, 0xE0, 0x07, 0xF8, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x00,
  0x00, 0x7E, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0x80, 0x3F, 0xF0, 0x00, 0x0F,
  0xE0, 0x0F, 0xFE, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0x80, 0x00, 0xFC, 0x01,
  0xFF, 0xE0, 0x00, 0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xC0, 0x1F, 0xBF,
  0x00, 0x07, 0xE0, 0x07, 0xCF, 0xC0, 0x01, 0xF8, 0x01, 0xF1, 0xF8, 0x00,
  0x7E, 0x00, 0xFC, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x07, 0xE0,
  0x0F, 0xC3, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0xFC, 0x00, 0xFC, 0x00, 0xF8,
  0x3F, 0x80, 0x3F, 0x00, 0x7E, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x81, 0xF8,
  0x07, 0xF0, 0x07, 0xE0, 0x7F, 0x01, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0x7E,
  0x00, 0xFC, 0x03, 0xF0, 0x1F, 0x80, 0x3F, 0x00, 0xFE, 0x07, 0xE0, 0x0F,
  0xC0, 0x1F, 0x83, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0xFC, 0x00, 0xFC, 0x00,
  0xFC, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0xC3,
  0xF0, 0x07, 0xE0, 0x01, 0xF9, 0xF8, 0x01, 0xF8, 0x00, 0x7E, 0x7E, 0x00,
  0x7E, 0x00, 0x1F, 0xDF, 0x80, 0x3F, 0x00, 0x03, 0xF7, 0xE0, 0x0F, 0xC0,
  0x00, 0xFD, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0x00, 0x3E, 0x00, 0x01, 0xFF, 0xC0, 0x1F, 0x80, 0x00, 0x7F, 0xF0,
  0x07, 0xE0, 0x00, 0x0F, 0xFC, 0x01, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x7E,
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xC0, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0,
  0x00, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE,
  0x00, 0x7F, 0xC0, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xEF,
  0xE0, 0x00, 0x00, 0x3F, 0xBF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0xBF,
  0x80, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00,
  0x3F, 0xCF, 0xE0, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0xFE,
  0x00, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07,
  0xF8, 0x1F, 0xE0, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F,
  0xFF, 0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0x80, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x1F, 0xFF,
  0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xF0, 0x03, 0xFC, 0x01, 0xF8, 0x00, 0xFE, 0x00, 0xFC,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x0F, 0xE0, 0x3F,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x3F, 0xC0,
  0x7E, 0x00, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x02, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF,
  0xC0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFE, 0x0F, 0xFE, 0x00, 0x7F, 0xC0, 0x07,
  0xF8, 0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x1F, 0x8F, 0xE0,
  0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x07,
  0xF7, 0xF0, 0x00, 0x00, 0x1F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0x7F, 0x00,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x3F,
  0xBF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00,
  0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x00, 0x3F, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x00, 0x3F, 0xCF, 0xE0, 0x00,
  0x00, 0xFE, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0xF8, 0x1F, 0xE0, 0x00,
  0x1F, 0xE0, 0x3F, 0xC0, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x0F, 0xF8, 0x01,
  0xFF, 0x80, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF,
  0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF,
  0xE0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF0, 0x07, 0xFC, 0x01, 0xF8, 0x00,
  0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x1F, 0x80, 0x7F, 0x00,
  0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFE, 0x03, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0xFE,
  0x00, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0x80, 0x1F,
  0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF8, 0x0F, 0xE0, 0x01,
  0xFC, 0x07, 0xF0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x0F, 0xC0, 0x03, 0xF0, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0xFE,
  0x03, 0xF8, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x0F,
  0xE0, 0x7E, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x3F, 0xF0,
  0x3F, 0x00, 0x7F, 0x80, 0x0E, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x04, 0x00, 0x01, 0xFC, 0x0C, 0x00, 0x07,
  0xF8, 0x1F, 0x00, 0x3F, 0xE0, 0x3F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF, 0xFF,
  0xF9, 0xFF, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00,
  0x1F, 0x81, 0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F,
  0x81, 0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00,
  0x00, 0x7F, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81,
  0xFC, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00,
  0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0x81, 0xFC,
  0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E,
  0x07, 0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x07,
  0xF0, 0x00, 0x03, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01, 0xFE, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0xE0, 0x3F, 0xF0, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0x18, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xDF, 0x80, 0x00, 0x07,
  0xF7, 0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0x7F, 0x1F, 0x80, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x03, 0xF0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x07, 0xF0, 0x0F,
  0xC0, 0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x3F, 0x00, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF8,
  0x00, 0xFC, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x7F, 0x00, 0x07, 0xE0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x1F, 0x81,
  0xF8, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x7E,
  0x1F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0xF8, 0xFC, 0x00, 0x00, 0x3E, 0x3F, 0x00, 0x00, 0x0F, 0x9F, 0x80, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0x7F, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0x7F,
  0x80, 0x01, 0xF9, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x03,
  0xFE, 0x00, 0x0F, 0xE7, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xF8, 0xFE, 0x00,
  0x1F, 0xF8, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xFF, 0x00, 0x0F, 0xC1, 0xF8,
  0x00, 0xFB, 0xE0, 0x03, 0xF8, 0x3F, 0x00, 0x3F, 0x7C, 0x00, 0x7E, 0x07,
  0xE0, 0x07, 0xCF, 0x80, 0x1F, 0xC0, 0xFC, 0x01, 0xF9, 0xF0, 0x03, 0xF0,
  0x1F, 0x80, 0x3F, 0x3E, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC7, 0xC0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x1F, 0x80,
  0xFE, 0x01, 0xF8, 0x0F, 0xC3, 0xF0, 0x1F, 0x80, 0x3F, 0x01, 0xF0, 0x7E,
  0x07, 0xF0, 0x07, 0xE0, 0x7E, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0x81,
  0xF8, 0x1F, 0x80, 0x1F, 0x83, 0xF0, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x7E,
  0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0x80, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF0, 0x0F, 0x87, 0xE0, 0x01, 0xF8, 0xFC, 0x01, 0xF1, 0xFC, 0x00, 0x3F,
  0x1F, 0x80, 0x3E, 0x3F, 0x00, 0x07, 0xE3, 0xE0, 0x07, 0xC7, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0xF9, 0xF8, 0x00, 0x1F, 0x9F, 0x00, 0x1F, 0x3F, 0x00,
  0x03, 0xF7, 0xE0, 0x03, 0xEF, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x7D, 0xF8,
  0x00, 0x0F, 0xDF, 0x00, 0x0F, 0xBE, 0x00, 0x01, 0xFF, 0xE0, 0x01, 0xFF,
  0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xF8, 0x00,
  0x1F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x7F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x03, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x00,
  0x03, 0xF7, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xF9, 0xF8, 0x00,
  0x00, 0x01, 0xF8, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x01,
  0xFC, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0xFC,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xFB, 0xF0, 0x00, 0x0F, 0xE7, 0xF0,
  0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x1F, 0x80,
  0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x7F, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x07, 0xF0, 0x01, 0xF8, 0x0F,
  0xE0, 0x03, 0xF0, 0x3F, 0x80, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xE1, 0xFC,
  0x00, 0x0F, 0xC7, 0xF0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x3F, 0x3F, 0x80,
  0x00, 0x3E, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF,
  0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE, 0x00, 0x1F, 0xFE,
  0x00, 0x3F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x04, 0x00,
  0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0x7F, 0xF8, 0x00, 0xFF, 0xF8, 0x00,
  0xFC, 0x03, 0xE0, 0x1F, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0x01, 0xF8, 0x07,
  0xC0, 0x3E, 0x01, 0xF0, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C,
  0x03, 0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x3F, 0x00, 0xF8, 0x07, 0xC0,
  0x3E, 0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x03, 0xF0, 0x0F, 0x80, 0x7C, 0x03,
  0xE0, 0x1F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x00, 0xF8, 0x07, 0xC0, 0x3F,
  0x01, 0xF8, 0x0F, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x80, 0x7E, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xE0, 0x03, 0xFF,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0xFC, 0x00, 0x7F, 0xF8, 0x01, 0xFF, 0xF0, 0x03, 0xFF, 0xC0,
  0x07, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x1F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xBE, 0x00, 0x00, 0x3E,
  0xFC, 0x00, 0x01, 0xF1, 0xF0, 0x00, 0x07, 0xC7, 0xC0, 0x00, 0x3E, 0x0F,
  0x80, 0x00, 0xF8, 0x3E, 0x00, 0x07, 0xC0, 0x7C, 0x00, 0x1F, 0x01, 0xF0,
  0x00, 0xF8, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0x80, 0x1F, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xF0, 0x1F, 0x80, 0x03, 0xE0, 0x7C,
  0x00, 0x0F, 0x83, 0xF0, 0x00, 0x1F, 0x0F, 0x80, 0x00, 0x7C, 0x7E, 0x00,
  0x01, 0xF9, 0xF0, 0x00, 0x03, 0xEF, 0xC0, 0x00, 0x0F, 0xC0, 0x7F, 0xFF,
  0xFF, 0xBF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x3F, 0x87, 0xE1, 0xFC, 0x3F, 0x07, 0xE0, 0xF8, 0x1F, 0x07, 0xC0, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x0F, 0xFF, 0x87, 0xC0,
  0x7F, 0xFF, 0x3F, 0x03, 0xFF, 0xFE, 0xFC, 0x1F, 0xF9, 0xFF, 0xE0, 0xFF,
  0x80, 0xFF, 0x83, 0xF8, 0x03, 0xFE, 0x1F, 0xE0, 0x07, 0xF8, 0x7F, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01, 0xF8,
  0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0xFE, 0x3F,
  0x00, 0x03, 0xF8, 0xFC, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7F, 0x0F, 0xC0,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x7F, 0x83, 0xF8, 0x03,
  0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x1F, 0xC0, 0xFF, 0xE0, 0x7F, 0xFF, 0xDF,
  0x81, 0xFF, 0xFE, 0x7C, 0x03, 0xFF, 0xF1, 0xF0, 0x07, 0xFF, 0x87, 0xC0,
  0x0F, 0xF8, 0x1F, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x81, 0xF0, 0x00, 0x7E, 0x1F, 0xF8, 0x00, 0xFC, 0x7F, 0xF8, 0x01, 0xF9,
  0xFF, 0xF8, 0x03, 0xF7, 0xFF, 0xF8, 0x0F, 0xDF, 0x9F, 0xF0, 0x1F, 0xFC,
  0x0F, 0xF0, 0x3F, 0xE0, 0x0F, 0xE0, 0x7F, 0x80, 0x1F, 0xC1, 0xFE, 0x00,
  0x1F, 0x83, 0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E,
  0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x07, 0xE0,
  0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0xFE, 0x0F,
  0xF0, 0x03, 0xFC, 0x1F, 0xF0, 0x0F, 0xF0, 0x3F, 0xF0, 0x3F, 0xC0, 0xFD,
  0xFF, 0xFF, 0x81, 0xFB, 0xFF, 0xFE, 0x03, 0xE3, 0xFF, 0xF8, 0x07, 0xC3,
  0xFF, 0xC0, 0x0F, 0x83, 0xFF, 0x00, 0x20, 0x00, 0x60, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x3F, 0xFF, 0xF0,
  0x3F, 0xFF, 0xF0, 0x3F, 0xF9, 0xF8, 0x3F, 0xE0, 0x0C, 0x1F, 0xC0, 0x00,
  0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x02, 0x0F,
  0xF0, 0x0F, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0,
  0x1F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFF, 0xC3, 0xF0,
  0x01, 0xFF, 0xF1, 0xF8, 0x01, 0xFF, 0xFC, 0xFC, 0x01, 0xFF, 0xFF, 0x7E,
  0x01, 0xFF, 0x9F, 0xFE, 0x01, 0xFF, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x1F, 0xE0, 0x7F, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01,
  0xFC, 0x0F, 0xC0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x7E, 0x07, 0xF0, 0x00,
  0x3F, 0x03, 0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x1F, 0xC0, 0xFC, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x1F, 0x80,
  0x03, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x03, 0xFC, 0x03, 0xF8,
  0x03, 0xFE, 0x01, 0xFC, 0x03, 0xFF, 0x00, 0xFF, 0x03, 0xFF, 0x80, 0x3F,
  0xFF, 0xEF, 0xC0, 0x1F, 0xFF, 0xE7, 0xC0, 0x07, 0xFF, 0xE3, 0xE0, 0x01,
  0xFF, 0xE1, 0xF0, 0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x03, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF0, 0x07, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC1, 0xFF, 0x0F, 0xF0, 0xFF, 0x00, 0xFC, 0x3F,
  0x80, 0x3F, 0x1F, 0xC0, 0x0F, 0xC7, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0xFC,
  0xFC, 0x00, 0x7F, 0x7F, 0x00, 0x3F, 0x9F, 0x80, 0x3F, 0xE7, 0xE7, 0xFF,
  0xF3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xF0, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x41, 0xFE, 0x00, 0x70, 0x3F, 0xF3, 0xFC, 0x0F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xE0, 0x00,
  0x06, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0x80, 0x00, 0x07, 0xF8, 0x60, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x3F, 0x81, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xE0, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0xE0, 0x00,
  0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x80, 0x07,
  0xFE, 0x0F, 0x80, 0x0F, 0xFF, 0x87, 0xC0, 0x0F, 0xFF, 0xE7, 0xE0, 0x0F,
  0xFF, 0xFB, 0xF0, 0x0F, 0xFC, 0xFF, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x07,
  0xF0, 0x03, 0xFC, 0x07, 0xF8, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0xFF, 0x03,
  0xF8, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x03, 0xF0,
  0x3F, 0x80, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0xFE,
  0x07, 0xE0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F,
  0x80, 0xFC, 0x00, 0x3F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x3F, 0x00, 0x1F,
  0xE0, 0x1F, 0xC0, 0x1F, 0xF0, 0x0F, 0xE0, 0x1F, 0xF8, 0x07, 0xF8, 0x1F,
  0xFC, 0x01, 0xFF, 0xFF, 0x7E, 0x00, 0xFF, 0xFF, 0x7E, 0x00, 0x3F, 0xFF,
  0x3F, 0x00, 0x0F, 0xFF, 0x1F, 0x80, 0x03, 0xFE, 0x0F, 0xC0, 0x00, 0x30,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0xC0, 0x00, 0xFE, 0x00, 0x7C, 0x01, 0xFF, 0x00, 0x3F,
  0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x81, 0xF8, 0x00, 0x7E, 0x1F, 0xFC, 0x00, 0xFC, 0x7F, 0xFC, 0x01, 0xF9,
  0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xF8, 0x0F, 0xDF, 0x8F, 0xF8, 0x1F, 0xFC,
  0x07, 0xF0, 0x3F, 0xF0, 0x0F, 0xE0, 0x7F, 0xC0, 0x1F, 0xC1, 0xFF, 0x00,
  0x3F, 0x83, 0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x01,
  0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F,
  0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xE0,
  0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0x7E, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x00, 0x08, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x01,
  0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x18, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x1F,
  0xE0, 0x03, 0xFF, 0xE0, 0x01, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x00, 0x7F,
  0xF0, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x01, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xF8, 0x01, 0xFC, 0x01, 0xF8,
  0x03, 0xF8, 0x03, 0xF8, 0x07, 0xF0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF0,
  0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x07, 0xE1, 0xFC, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x07, 0xE7,
  0xF0, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x0F, 0xFF,
  0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x1F, 0xFF,
  0xF0, 0x00, 0x1F, 0xF3, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0x81, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x3F, 0x80,
  0xFE, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x3F, 0x80, 0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0x80, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01,
  0xF8, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0x1F, 0x80,
  0x0F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC,
  0x00, 0xFE, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F,
  0xE0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0,
  0x03, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0xF8, 0x3F, 0xF0, 0x07, 0xFE,
  0x00, 0x7C, 0x3F, 0xFC, 0x0F, 0xFF, 0x80, 0x3E, 0x3F, 0xFF, 0x0F, 0xFF,
  0xE0, 0x1F, 0x3F, 0xFF, 0x8F, 0xFF, 0xF0, 0x1F, 0xBF, 0x1F, 0xCF, 0xC7,
  0xF8, 0x0F, 0xFE, 0x07, 0xFF, 0x80, 0xFE, 0x07, 0xFC, 0x01, 0xFF, 0x80,
  0x7F, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0x81, 0xFE, 0x00, 0x7F, 0x80,
  0x1F, 0xC1, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xC0,
  0x07, 0xE0, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0,
  0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFC, 0x1F, 0xC0, 0x03, 0xF0,
  0x00, 0xFE, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x01, 0xFC,
  0x00, 0x3F, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x7E,
  0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F,
  0x80, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x3F, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03,
  0xF0, 0x00, 0xFE, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0, 0x01,
  0xFC, 0x00, 0x3F, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00,
  0x7E, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0xFC, 0x00,
  0x3F, 0x80, 0x07, 0xE0, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x00,
  0x08, 0x1F, 0xC0, 0x03, 0xE0, 0xFF, 0xE0, 0x07, 0xC3, 0xFF, 0xE0, 0x0F,
  0x8F, 0xFF, 0xE0, 0x3F, 0x3F, 0xFF, 0xC0, 0x7E, 0xFE, 0xFF, 0xC0, 0xFF,
  0xE0, 0x3F, 0x81, 0xFF, 0x80, 0x7F, 0x03, 0xFE, 0x00, 0xFE, 0x0F, 0xF8,
  0x01, 0xFC, 0x1F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0, 0x07, 0xF0, 0x7F, 0x00,
  0x0F, 0xE1, 0xFE, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xF0, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x07,
  0xE0, 0xFE, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7F,
  0x07, 0xE0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x80, 0x07, 0xF0,
  0x7F, 0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xC0, 0x7F, 0xE7, 0xFE, 0x0F, 0xF0, 0x0F, 0xE1, 0xFE, 0x00, 0x7F, 0x1F,
  0xC0, 0x07, 0xF3, 0xF8, 0x00, 0x3F, 0x3F, 0x80, 0x03, 0xF7, 0xF0, 0x00,
  0x3F, 0x7F, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x3F, 0x7E, 0x00, 0x03, 0xFF,
  0xE0, 0x00, 0x3F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x7F, 0xFC, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFE,
  0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xFC, 0xFE, 0x00, 0x1F, 0xCF, 0xE0,
  0x03, 0xF8, 0x7F, 0x00, 0x7F, 0x87, 0xF8, 0x0F, 0xF0, 0x3F, 0xFF, 0xFE,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x03,
  0xFF, 0xC0, 0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x0F,
  0x83, 0xFF, 0x00, 0x03, 0xE1, 0xFF, 0xE0, 0x00, 0xF8, 0xFF, 0xFC, 0x00,
  0x3E, 0x7F, 0xFF, 0x80, 0x1F, 0xBF, 0x3F, 0xE0, 0x07, 0xFF, 0x03, 0xFC,
  0x01, 0xFF, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x03,
  0xF0, 0x0F, 0xF0, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0xFC, 0x07, 0xF0,
  0x00, 0x7F, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x07, 0xF0, 0x1F,
  0x80, 0x01, 0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xF0, 0x00, 0x3F, 0x80,
  0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC,
  0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFE, 0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x3F,
  0xC0, 0x1F, 0xF8, 0x1F, 0xE0, 0x0F, 0xDF, 0xFF, 0xF8, 0x03, 0xF7, 0xFF,
  0xFC, 0x00, 0xFC, 0xFF, 0xFE, 0x00, 0x3F, 0x1F, 0xFE, 0x00, 0x0F, 0xC3,
  0xFF, 0x00, 0x07, 0xF0, 0x0C, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFF, 0xC1, 0xF0, 0x0F, 0xFF,
  0xC7, 0xC0, 0x7F, 0xFF, 0x1F, 0x03, 0xFF, 0xFE, 0xFC, 0x1F, 0xF9, 0xFF,
  0xE0, 0xFF, 0x80, 0xFF, 0x83, 0xF8, 0x03, 0xFE, 0x1F, 0xC0, 0x07, 0xF8,
  0x7F, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x7F,
  0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xE0, 0x00, 0x7F, 0x1F, 0x80,
  0x01, 0xF8, 0xFE, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x1F, 0x8F, 0xE0, 0x00,
  0xFE, 0x3F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xFC, 0x3F, 0x00, 0x0F, 0xF0, 0xFC, 0x00, 0x7F, 0x83,
  0xF8, 0x03, 0xFE, 0x0F, 0xE0, 0x1F, 0xF8, 0x3F, 0xC0, 0xFF, 0xE0, 0x7F,
  0xFF, 0xDF, 0x81, 0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xF3, 0xF0, 0x07, 0xFF,
  0x8F, 0xC0, 0x0F, 0xF8, 0x7F, 0x00, 0x02, 0x01, 0xF8, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x08, 0x1F, 0x80, 0xF8, 0x3F, 0xC0, 0x7C, 0x3F, 0xE0, 0x3E, 0x3F, 0xF0,
  0x1F, 0x3F, 0xF0, 0x1F, 0xBF, 0xF8, 0x0F, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x1F,
  0xFF, 0x80, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81,
  0xFE, 0x07, 0xC0, 0xFE, 0x00, 0x30, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x08, 0x00, 0x1F, 0xC3, 0xC0,
  0x0F, 0xF0, 0xFF, 0xBF, 0xF8, 0x3F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x00,
  0xFC, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00,
  0x1F, 0x80, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7E, 0x00, 0x07, 0xE0,
  0x00, 0x7E, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x07, 0xFF, 0xC0, 0x7F, 0xFC, 0x07, 0xFF, 0xC0, 0x3F, 0xFC, 0x01,
  0xFF, 0xC0, 0x00, 0x80, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x01,
  0xF8, 0x3F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0xC1, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFC,
  0x1F, 0xC0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x0F, 0xC1,
  0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x0F,
  0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x03, 0xF0, 0x7F, 0x00, 0x07, 0xE0, 0xFE,
  0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F, 0xF0, 0x7F, 0x00,
  0x3F, 0xE0, 0xFE, 0x00, 0xFF, 0x81, 0xFC, 0x03, 0xFF, 0x03, 0xFC, 0x0F,
  0xFE, 0x03, 0xFF, 0xFE, 0xFC, 0x07, 0xFF, 0xF9, 0xF8, 0x07, 0xFF, 0xE3,
  0xE0, 0x07, 0xFF, 0x87, 0xC0, 0x07, 0xFC, 0x0F, 0x80, 0x01, 0x80, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x3F, 0xBF, 0x00, 0x01, 0xF9,
  0xFC, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x0F, 0xE1, 0xF8,
  0x00, 0xFE, 0x0F, 0xC0, 0x07, 0xF0, 0x7E, 0x00, 0x7F, 0x03, 0xF0, 0x03,
  0xF8, 0x1F, 0x80, 0x3F, 0x80, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0,
  0x1F, 0x00, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x7E, 0x00, 0x3F,
  0x07, 0xF0, 0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F,
  0x80, 0x03, 0xF1, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x7C, 0xFE, 0x00,
  0x03, 0xE7, 0xE0, 0x00, 0x1F, 0x7E, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xF7, 0xE0, 0x03, 0xF8, 0x00, 0x7E, 0x7E, 0x00, 0x7F, 0x80,
  0x0F, 0xE7, 0xE0, 0x07, 0xFC, 0x00, 0xFC, 0x7E, 0x00, 0xFF, 0xC0, 0x1F,
  0xC7, 0xE0, 0x0F, 0xFC, 0x01, 0xF8, 0x7E, 0x01, 0xF7, 0xC0, 0x3F, 0x87,
  0xE0, 0x1F, 0x7C, 0x03, 0xF0, 0x7E, 0x03, 0xF7, 0xC0, 0x7F, 0x07, 0xE0,
  0x3E, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE7, 0xC0, 0x7E, 0x07, 0xE0, 0x7C,
  0x7C, 0x0F, 0xE0, 0x7E, 0x07, 0xC7, 0xC0, 0xFC, 0x07, 0xE0, 0xFC, 0x7C,
  0x1F, 0xC0, 0x7E, 0x0F, 0x87, 0xC1, 0xF8, 0x07, 0xE1, 0xF8, 0x7C, 0x3F,
  0x80, 0x7E, 0x1F, 0x07, 0xC3, 0xF0, 0x07, 0xE3, 0xF0, 0x7C, 0x3F, 0x00,
  0x7E, 0x3E, 0x07, 0xC7, 0xE0, 0x07, 0xE7, 0xE0, 0x7C, 0x7E, 0x00, 0x7E,
  0x7C, 0x07, 0xCF, 0xC0, 0x07, 0xE7, 0xC0, 0x7C, 0xFC, 0x00, 0x7E, 0xF8,
  0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x7D, 0xF8, 0x00, 0x3E, 0xF0, 0x07,
  0xDF, 0x00, 0x03, 0xFF, 0x00, 0x7D, 0xF0, 0x00, 0x3F, 0xF0, 0x07, 0xFF,
  0x00, 0x03, 0xFE, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xE0, 0x03, 0xFE, 0x00,
  0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x7E,
  0x01, 0xFC, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x7F, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFE, 0x00,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0x03,
  0xF8, 0x3F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0x03, 0xF8,
  0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xF8, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00, 0x7E,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x3F, 0x80,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00, 0x1F, 0x80,
  0xFC, 0x00, 0x00, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0x3F, 0x07, 0xF0, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0x07, 0xC3, 0xF8,
  0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x0F,
  0xCF, 0xC0, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00,
  0x00, 0x0F, 0xBF, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFF, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x1F, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x07,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0xFF, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0,
  0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x00, 0x7C, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00,
  0x07, 0xFE, 0x00, 0x03, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFE,
  0x00, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0xE0, 0x01, 0xFF, 0xC0,
  0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFF, 0x00, 0x03,
  0xFC, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x17, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xC8, 0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_MediumItalic60pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 16, 44, 16, 1, -43 },
  { 89, 20, 16, 25, 6, -43 },
  { 129, 37, 43, 39, 2, -43 },
  { 328, 30, 49, 33, 2, -46 },
  { 512, 42, 44, 49, 4, -43 },
  { 743, 38, 45, 41, 2, -44 },
  { 957, 9, 16, 14, 6, -43 },
  { 975, 21, 52, 18, 2, -43 },
  { 1112, 21, 52, 18, -5, -43 },
  { 1249, 28, 28, 33, 6, -46 },
  { 1347, 28, 29, 34, 4, -36 },
  { 1449, 13, 15, 16, -3, -7 },
  { 1474, 16, 6, 19, 1, -19 },
  { 1486, 8, 9, 16, 1, -8 },
  { 1495, 30, 43, 23, -3, -43 },
  { 1657, 29, 45, 33, 3, -44 },
  { 1821, 19, 43, 33, 8, -43 },
  { 1924, 32, 43, 33, 0, -43 },
  { 2096, 31, 44, 33, 1, -43 },
  { 2267, 32, 43, 33, 0, -43 },
  { 2439, 30, 44, 33, 2, -43 },
  { 2604, 30, 44, 33, 3, -43 },
  { 2769, 30, 43, 33, 4, -43 },
  { 2931, 31, 45, 33, 2, -44 },
  { 3106, 29, 44, 33, 3, -43 },
  { 3266, 13, 34, 16, 1, -33 },
  { 3322, 17, 41, 16, -3, -33 },
  { 3410, 28, 30, 34, 4, -37 },
  { 3515, 28, 16, 34, 4, -29 },
  { 3571, 28, 30, 34, 4, -37 },
  { 3676, 23, 44, 26, 5, -43 },
  { 3803, 47, 48, 51, 3, -43 },
  { 4085, 35, 43, 35, -3, -43 },
  { 4274, 34, 43, 36, 2, -43 },
  { 4457, 34, 44, 36, 4, -43 },
  { 4644, 36, 43, 40, 2, -43 },
  { 4838, 32, 43, 31, 2, -43 },
  { 5010, 32, 43, 30, 2, -43 },
  { 5182, 36, 44, 41, 4, -43 },
  { 5380, 39, 43, 41, 2, -43 },
  { 5590, 25, 43, 20, -1, -43 },
  { 5725, 27, 55, 17, -9, -43 },
  { 5911, 38, 43, 35, 2, -43 },
  { 6116, 24, 43, 29, 2, -43 },
  { 6245, 49, 43, 51, 2, -43 },
  { 6509, 42, 43, 43, 2, -43 },
  { 6735, 38, 45, 43, 4, -44 },
  { 6949, 33, 43, 35, 2, -43 },
  { 7127, 38, 54, 43, 4, -44 },
  { 7384, 33, 43, 35, 2, -43 },
  { 7562, 31, 44, 31, 1, -43 },
  { 7733, 31, 43, 31, 5, -43 },
  { 7900, 37, 44, 41, 5, -43 },
  { 8104, 34, 43, 34, 5, -43 },
  { 8287, 51, 43, 52, 6, -43 },
  { 8562, 41, 43, 33, -3, -43 },
  { 8783, 31, 43, 32, 6, -43 },
  { 8950, 36, 43, 32, -1, -43 },
  { 9144, 24, 52, 18, -1, -43 },
  { 9300, 13, 43, 23, 6, -43 },
  { 9370, 23, 52, 18, -4, -43 },
  { 9520, 30, 27, 34, 2, -43 },
  { 9622, 25, 4, 24, -6, 5 },
  { 9635, 10, 10, 17, 9, -46 },
  { 9648, 30, 34, 35, 3, -33 },
  { 9776, 31, 47, 35, 1, -46 },
  { 9959, 25, 34, 28, 3, -33 },
  { 10066, 33, 47, 35, 3, -46 },
  { 10260, 26, 34, 31, 3, -33 },
  { 10371, 34, 60, 20, -7, -46 },
  { 10626, 33, 47, 35, 1, -33 },
  { 10820, 31, 46, 35, 1, -46 },
  { 10999, 16, 45, 16, 1, -45 },
  { 11089, 25, 59, 16, -8, -45 },
  { 11274, 32, 46, 31, 1, -46 },
  { 11458, 17, 46, 16, 1, -46 },
  { 11556, 49, 33, 53, 1, -33 },
  { 11759, 31, 33, 35, 1, -33 },
  { 11887, 28, 34, 34, 3, -33 },
  { 12006, 34, 47, 35, -2, -33 },
  { 12206, 30, 47, 35, 3, -33 },
  { 12383, 25, 33, 24, 1, -33 },
  { 12487, 26, 34, 27, 0, -33 },
  { 12598, 20, 41, 21, 3, -40 },
  { 12701, 31, 33, 35, 3, -32 },
  { 12829, 29, 32, 29, 3, -32 },
  { 12945, 44, 32, 45, 3, -32 },
  { 13121, 34, 32, 30, -2, -32 },
  { 13257, 37, 46, 29, -5, -32 },
  { 13470, 28, 32, 27, -1, -32 },
  { 13582, 24, 52, 21, 0, -43 },
  { 13738, 5, 60, 33, 15, -46 },
  { 13776, 23, 52, 21, -2, -43 },
  { 13926, 28, 8, 34, 4, -25 },
};

const GFXfont NotoSans_MediumItalic60pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic60pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic60pt7bGlyphs,
  0x20, 0x7E, 82
};

#endif // _NOTOSANS_MEDIUMITALIC60PT7B_H_
