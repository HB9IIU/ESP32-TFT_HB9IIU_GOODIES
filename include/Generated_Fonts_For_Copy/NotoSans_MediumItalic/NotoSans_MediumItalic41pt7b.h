#ifndef _NOTOSANS_MEDIUMITALIC41PT7B_H_
#define _NOTOSANS_MEDIUMITALIC41PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 41pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic41pt7bBitmaps[] PROGMEM = {
  0x00, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xE0, 0x7C, 0x0F, 0x03, 0xE0, 0x7C,
  0x0F, 0x81, 0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x07, 0x80, 0xF0, 0x1E,
  0x03, 0x80, 0xF0, 0x1E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x1F,
  0x03, 0xE0, 0x7C, 0x0F, 0x80, 0x40, 0x00, 0x3C, 0x7C, 0xF1, 0xE7, 0x87,
  0x9E, 0x1C, 0x78, 0xF1, 0xE3, 0xC7, 0x0F, 0x1C, 0x38, 0x70, 0xE3, 0x83,
  0x80, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x00,
  0xE0, 0x70, 0x00, 0x38, 0x3C, 0x00, 0x1E, 0x0E, 0x00, 0x07, 0x83, 0x80,
  0x01, 0xC0, 0xE0, 0x1F, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xF1, 0xFF, 0xFF,
  0xFC, 0x83, 0x83, 0xC0, 0x00, 0xE0, 0xE0, 0x00, 0x78, 0x38, 0x00, 0x1C,
  0x0E, 0x00, 0x07, 0x07, 0x80, 0x03, 0xC1, 0xC0, 0x3F, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFE, 0x01, 0xC1, 0xE0,
  0x00, 0x70, 0x78, 0x00, 0x3C, 0x1C, 0x00, 0x0E, 0x07, 0x00, 0x03, 0x83,
  0xC0, 0x01, 0xE0, 0xE0, 0x00, 0x70, 0x38, 0x00, 0x1C, 0x1E, 0x00, 0x00,
  0x00, 0x07, 0x00, 0x00, 0x30, 0x00, 0x03, 0x80, 0x00, 0x3F, 0x00, 0x0F,
  0xFF, 0x01, 0xFF, 0xFC, 0x1F, 0xFF, 0xC1, 0xF3, 0x8E, 0x0F, 0x1C, 0x00,
  0x78, 0xE0, 0x03, 0xC7, 0x00, 0x1E, 0x30, 0x00, 0xF3, 0x80, 0x07, 0xFC,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x00, 0xEF, 0x80, 0x06, 0x3C, 0x00, 0x71, 0xF0, 0x03, 0x8F,
  0x00, 0x1C, 0x78, 0xC0, 0xE7, 0xC7, 0xF7, 0xFC, 0x3F, 0xFF, 0xC1, 0xFF,
  0xFC, 0x01, 0xFF, 0x80, 0x00, 0xC0, 0x00, 0x06, 0x00, 0x00, 0x70, 0x00,
  0x03, 0x80, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x0F, 0x07, 0xFC,
  0x00, 0xF0, 0x7D, 0xF0, 0x0F, 0x03, 0xC7, 0x80, 0x70, 0x3C, 0x3C, 0x07,
  0x01, 0xE1, 0xE0, 0x78, 0x0E, 0x0F, 0x07, 0x80, 0xF0, 0x78, 0x38, 0x07,
  0x83, 0xC3, 0xC0, 0x3C, 0x1E, 0x3C, 0x01, 0xE0, 0xE3, 0xC0, 0x0F, 0x0F,
  0x1C, 0x7C, 0x78, 0x79, 0xE7, 0xF3, 0xC7, 0x9E, 0x7F, 0xDF, 0x79, 0xE7,
  0x9E, 0x7F, 0xCE, 0x78, 0x79, 0xFC, 0xF3, 0xC3, 0xC3, 0x0F, 0x1C, 0x1E,
  0x00, 0xF1, 0xE0, 0xF0, 0x07, 0x0F, 0x07, 0x80, 0x78, 0x70, 0x38, 0x07,
  0x83, 0x81, 0xC0, 0x78, 0x1C, 0x1E, 0x03, 0x80, 0xE0, 0xF0, 0x3C, 0x07,
  0x0F, 0x03, 0xC0, 0x3C, 0x78, 0x3C, 0x01, 0xFF, 0x81, 0xC0, 0x07, 0xF8,
  0x1E, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0xF8, 0x00, 0x0F,
  0xFF, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xF0, 0xF8, 0x00, 0xF8, 0x1E, 0x00,
  0x3C, 0x07, 0x80, 0x0F, 0x01, 0xE0, 0x03, 0xC0, 0xF8, 0x00, 0xF0, 0x7C,
  0x00, 0x3E, 0x3E, 0x00, 0x07, 0xBF, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xFC, 0x07, 0xCF,
  0xCF, 0x81, 0xE3, 0xE1, 0xF0, 0xF9, 0xF0, 0x3E, 0x3C, 0x78, 0x0F, 0x9F,
  0x3E, 0x01, 0xFF, 0x8F, 0x80, 0x3F, 0xC3, 0xE0, 0x07, 0xE0, 0xF8, 0x01,
  0xF0, 0x1F, 0x01, 0xFE, 0x07, 0xE1, 0xFF, 0xC0, 0xFF, 0xFF, 0xF0, 0x3F,
  0xFE, 0x3E, 0x03, 0xFE, 0x07, 0xC0, 0x3C, 0xF7, 0x9E, 0x79, 0xE7, 0x1C,
  0x73, 0x80, 0x00, 0x7C, 0x03, 0xC0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1E,
  0x00, 0xF0, 0x03, 0xC0, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x7C,
  0x01, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C,
  0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F,
  0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00, 0x78, 0x00,
  0xE0, 0x03, 0xC0, 0x00, 0x00, 0xE0, 0x03, 0xC0, 0x07, 0x00, 0x1E, 0x00,
  0x78, 0x01, 0xE0, 0x03, 0x80, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x1E, 0x00, 0x78, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x01, 0xE0,
  0x07, 0x80, 0x3C, 0x00, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0xF0, 0x07, 0x80,
  0x3C, 0x00, 0xF0, 0x0F, 0x80, 0x00, 0x00, 0x78, 0x00, 0x0F, 0x00, 0x01,
  0xE0, 0x00, 0x38, 0x06, 0x07, 0x00, 0xF0, 0xE0, 0x3F, 0x98, 0x07, 0xFF,
  0x01, 0x1F, 0xFF, 0xE0, 0x3F, 0xFC, 0x0F, 0xBF, 0x83, 0xF8, 0x00, 0xF7,
  0x00, 0x3C, 0x70, 0x0F, 0x8E, 0x03, 0xE1, 0xE0, 0x18, 0x3C, 0x01, 0x03,
  0xC0, 0x00, 0x40, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03, 0x80, 0x00,
  0x70, 0x00, 0x0E, 0x00, 0x01, 0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x70, 0x00, 0x0E, 0x00, 0x01,
  0xC0, 0x00, 0x38, 0x00, 0x07, 0x00, 0x00, 0xE0, 0x00, 0x1C, 0x00, 0x03,
  0x80, 0x00, 0x0F, 0x87, 0x87, 0xC3, 0xC1, 0xE1, 0xE0, 0xF0, 0xF0, 0x78,
  0x78, 0x00, 0x7F, 0xFF, 0xFB, 0xFF, 0x7F, 0xE0, 0x7F, 0xFF, 0xFF, 0xA0,
  0x00, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C,
  0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x03, 0xE0, 0x00, 0x1E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF0,
  0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xF8, 0x03, 0xFF,
  0xC0, 0x7F, 0xFE, 0x07, 0xC3, 0xE0, 0xF8, 0x1E, 0x1F, 0x01, 0xF1, 0xE0,
  0x1F, 0x3E, 0x00, 0xF3, 0xE0, 0x0F, 0x3C, 0x00, 0xF7, 0xC0, 0x0F, 0x7C,
  0x01, 0xF7, 0x80, 0x1F, 0x78, 0x01, 0xFF, 0x80, 0x1F, 0xF8, 0x01, 0xEF,
  0x80, 0x1E, 0xF0, 0x03, 0xEF, 0x00, 0x3E, 0xF0, 0x03, 0xCF, 0x00, 0x7C,
  0xF0, 0x07, 0xCF, 0x80, 0xF8, 0xF8, 0x0F, 0x87, 0x81, 0xF0, 0x7E, 0x7E,
  0x03, 0xFF, 0xE0, 0x3F, 0xF8, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x07, 0xE0,
  0x3F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0xCF, 0x1E, 0x3C, 0x20, 0xF0,
  0x07, 0xC0, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0,
  0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00, 0x78,
  0x03, 0xE0, 0x0F, 0x00, 0x3C, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00, 0x00,
  0x0F, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x01, 0xFF, 0xFE, 0x07, 0xE1,
  0xF8, 0x0E, 0x01, 0xF0, 0x10, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7C,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF,
  0xFE, 0x3F, 0xFF, 0xF8, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x78, 0x1F, 0x01,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x07,
  0x80, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x01, 0xFF, 0xC0, 0x0F,
  0xF8, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00,
  0x78, 0x00, 0x07, 0xC4, 0x00, 0x7E, 0x3E, 0x0F, 0xE1, 0xFF, 0xFE, 0x0F,
  0xFF, 0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x3D, 0xC0, 0x01, 0xEF,
  0x00, 0x0F, 0xBC, 0x00, 0x7C, 0xF0, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x78, 0x78, 0x03, 0xC1, 0xE0, 0x1F, 0x07, 0x80, 0xF8, 0x3E, 0x03, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF0, 0x0F, 0x07, 0x80, 0x3C, 0x1F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0x80, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F,
  0x00, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0xFF, 0xFE, 0x07, 0xFF, 0xE0,
  0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80,
  0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0xFC, 0x01, 0xFF, 0xF0, 0x0F,
  0xFF, 0xC0, 0x3C, 0xFF, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x1F,
  0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0xC0, 0x0F, 0xC7, 0xC1, 0xFC, 0x3F, 0xFF, 0xC1,
  0xFF, 0xFC, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xE8, 0x01, 0xFF, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xE0, 0x3F, 0x80, 0x03, 0xF0, 0x00, 0x1F, 0x00,
  0x01, 0xF0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78,
  0x10, 0x03, 0xCF, 0xF0, 0x3E, 0xFF, 0xC1, 0xEF, 0xFF, 0x0F, 0xE0, 0xF8,
  0x7E, 0x03, 0xC3, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x07, 0xCF, 0x80,
  0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0x78, 0x07, 0x83,
  0xE0, 0x7C, 0x1F, 0x8F, 0xC0, 0x7F, 0xFE, 0x01, 0xFF, 0xC0, 0x07, 0xFC,
  0x00, 0x3F, 0xFF, 0xF3, 0xFF, 0xFF, 0x7F, 0xFF, 0xF7, 0xFF, 0xFE, 0x00,
  0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00, 0x07, 0xC0,
  0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x00, 0x01, 0xF0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0xF8,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x0F, 0xFC, 0x03, 0xFF, 0xE0, 0x7F, 0xFE,
  0x07, 0xC1, 0xF0, 0xF8, 0x0F, 0x0F, 0x00, 0xF0, 0xF0, 0x0F, 0x0F, 0x00,
  0xF0, 0xF0, 0x1F, 0x0F, 0x81, 0xE0, 0xF8, 0x3E, 0x07, 0xCF, 0xC0, 0x3F,
  0xF0, 0x01, 0xFC, 0x00, 0x7F, 0xE0, 0x1F, 0xFF, 0x03, 0xE0, 0xF8, 0x7C,
  0x07, 0x8F, 0x80, 0x7C, 0xF0, 0x03, 0xCF, 0x00, 0x3C, 0xF0, 0x03, 0xCF,
  0x00, 0x3C, 0xF0, 0x07, 0xCF, 0x80, 0x78, 0xFC, 0x1F, 0x87, 0xFF, 0xF0,
  0x3F, 0xFE, 0x00, 0xFF, 0x80, 0x00, 0x38, 0x00, 0x1F, 0xF0, 0x07, 0xFF,
  0x80, 0xFF, 0xFC, 0x1F, 0x87, 0xE1, 0xF0, 0x3E, 0x3E, 0x01, 0xE3, 0xC0,
  0x1E, 0x3C, 0x01, 0xE7, 0xC0, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x1E, 0x7C,
  0x03, 0xE7, 0xC0, 0x3E, 0x3C, 0x07, 0xE3, 0xF1, 0xFE, 0x3F, 0xFF, 0xE1,
  0xFF, 0xBC, 0x07, 0xF3, 0xC0, 0x00, 0x3C, 0x00, 0x07, 0xC0, 0x00, 0x78,
  0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x1F, 0x00, 0x07, 0xE0, 0xC1, 0xFC,
  0x0F, 0xFF, 0x80, 0xFF, 0xF0, 0x0F, 0xFC, 0x00, 0x06, 0x07, 0xC7, 0xE3,
  0xF1, 0xF0, 0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x1E, 0x1F, 0x0F, 0x87, 0xC3, 0xE0, 0x80, 0x00,
  0xC0, 0x1F, 0x03, 0xF0, 0x3F, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0x81, 0xF0, 0x1F, 0x01, 0xE0, 0x3E, 0x03, 0xC0, 0x3C,
  0x07, 0x80, 0x70, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x1C, 0x00, 0x0F,
  0x80, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x3F, 0x80, 0x1F, 0x80, 0x03, 0xC0, 0x00, 0x7E, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x00, 0x3F, 0xC0, 0x01, 0xFC,
  0x00, 0x07, 0x80, 0x00, 0x30, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x1C, 0x00,
  0x03, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0x80, 0x07,
  0xF0, 0x03, 0xFC, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0xFF, 0x80,
  0x1F, 0x80, 0x03, 0xC0, 0x00, 0x60, 0x00, 0x00, 0x01, 0xC0, 0x1F, 0xF8,
  0x7F, 0xFE, 0x7F, 0xFE, 0x38, 0x3F, 0x20, 0x1F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1F, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF8,
  0x03, 0xF0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x1E, 0x00, 0x1C, 0x00,
  0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00,
  0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xF8, 0x00, 0x20, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFC,
  0x01, 0xF8, 0x03, 0xE0, 0x00, 0x7C, 0x07, 0xC0, 0x00, 0x3C, 0x0F, 0x80,
  0x00, 0x1E, 0x0F, 0x00, 0x00, 0x0E, 0x1E, 0x03, 0xFE, 0x0F, 0x3C, 0x0F,
  0xFF, 0x0F, 0x38, 0x1F, 0xFF, 0x0F, 0x78, 0x3E, 0x0E, 0x07, 0x78, 0x3C,
  0x0E, 0x07, 0x70, 0x78, 0x1E, 0x07, 0x70, 0x70, 0x1E, 0x0F, 0xF0, 0xF0,
  0x1C, 0x0F, 0xF0, 0xF0, 0x3C, 0x0E, 0xF0, 0xE0, 0x3C, 0x0E, 0xF0, 0xE0,
  0x3C, 0x1E, 0xF0, 0xE0, 0x78, 0x1C, 0xF0, 0xF0, 0xFC, 0x3C, 0xF0, 0xF1,
  0xDC, 0x78, 0xF0, 0x7F, 0xDF, 0xF0, 0x70, 0x7F, 0x0F, 0xE0, 0x78, 0x0E,
  0x07, 0x80, 0x78, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x06, 0x00, 0x0F, 0xF8, 0xFE, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07,
  0xF8, 0x00, 0x0F, 0x78, 0x00, 0x0F, 0x78, 0x00, 0x1E, 0x78, 0x00, 0x1E,
  0x78, 0x00, 0x3C, 0x78, 0x00, 0x3C, 0x3C, 0x00, 0x78, 0x3C, 0x00, 0xF8,
  0x3C, 0x00, 0xF0, 0x3C, 0x01, 0xF0, 0x3C, 0x01, 0xE0, 0x3C, 0x03, 0xE0,
  0x3C, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFE, 0x0F, 0xFF,
  0xFE, 0x0F, 0x00, 0x1E, 0x1F, 0x00, 0x1E, 0x1E, 0x00, 0x1E, 0x3E, 0x00,
  0x1E, 0x7C, 0x00, 0x1E, 0x7C, 0x00, 0x1E, 0xF8, 0x00, 0x1F, 0xF8, 0x00,
  0x1F, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xC0, 0x7F, 0xFF, 0x81, 0xE0, 0xFF,
  0x07, 0x80, 0x7C, 0x3E, 0x00, 0xF0, 0xF8, 0x03, 0xC3, 0xC0, 0x0F, 0x0F,
  0x00, 0x3C, 0x3C, 0x01, 0xF1, 0xF0, 0x0F, 0x87, 0xC0, 0x7C, 0x1F, 0xFF,
  0xE0, 0x7F, 0xFE, 0x01, 0xFF, 0xF8, 0x0F, 0xFF, 0xF8, 0x3E, 0x01, 0xF0,
  0xF0, 0x07, 0xC3, 0xC0, 0x0F, 0x0F, 0x00, 0x3E, 0x7C, 0x00, 0xF9, 0xE0,
  0x03, 0xC7, 0x80, 0x1F, 0x1E, 0x00, 0x7C, 0xF8, 0x07, 0xE3, 0xFF, 0xFF,
  0x8F, 0xFF, 0xFC, 0x3F, 0xFF, 0xC0, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0x80,
  0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x7F, 0x83, 0xC1,
  0xFC, 0x00, 0x83, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0x7C,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00,
  0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFC, 0x00, 0x80,
  0xFF, 0x3F, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00,
  0x03, 0xFF, 0xC0, 0x07, 0xFF, 0xF0, 0x07, 0xFF, 0xF8, 0x07, 0x87, 0xFC,
  0x07, 0x80, 0x7E, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1F, 0x0F, 0x00, 0x1F,
  0x0F, 0x00, 0x1F, 0x0F, 0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x1F, 0x00, 0x0F,
  0x1E, 0x00, 0x0F, 0x1E, 0x00, 0x1F, 0x1E, 0x00, 0x1F, 0x3E, 0x00, 0x1F,
  0x3E, 0x00, 0x1F, 0x3C, 0x00, 0x1E, 0x3C, 0x00, 0x3E, 0x3C, 0x00, 0x3E,
  0x7C, 0x00, 0x7C, 0x78, 0x00, 0xFC, 0x78, 0x01, 0xF8, 0x78, 0x03, 0xF0,
  0xF8, 0x0F, 0xE0, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0x80, 0xFF, 0xFE, 0x00,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F,
  0xFF, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xFF,
  0xFC, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07, 0xFF, 0xF0, 0x3E, 0x00, 0x01,
  0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xFF, 0xF8, 0x3F,
  0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xF8, 0x3F,
  0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x78, 0x00, 0x07, 0xC0, 0x00,
  0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x07, 0xC0,
  0x00, 0x3E, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x7F, 0xFE, 0x07,
  0xFF, 0xF0, 0x3F, 0xFF, 0x81, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00,
  0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x3F, 0xFE, 0x00, 0xFF, 0xFF, 0x03, 0xFF,
  0xFF, 0x07, 0xF8, 0x1E, 0x0F, 0xE0, 0x02, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x07, 0xFE, 0xF8, 0x07,
  0xFE, 0xF8, 0x07, 0xFC, 0xF0, 0x0F, 0xFC, 0xF0, 0x00, 0x3C, 0xF0, 0x00,
  0x7C, 0xF0, 0x00, 0x7C, 0xF8, 0x00, 0x78, 0xF8, 0x00, 0x78, 0xF8, 0x00,
  0x78, 0x7C, 0x00, 0xF8, 0x7E, 0x00, 0xF0, 0x3F, 0xE7, 0xF0, 0x1F, 0xFF,
  0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x03, 0xC0, 0x03, 0xC1, 0xF0,
  0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1E, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x83,
  0xE0, 0x01, 0xE0, 0xF8, 0x00, 0xF8, 0x3C, 0x00, 0x3E, 0x0F, 0x00, 0x0F,
  0x03, 0xC0, 0x03, 0xC1, 0xF0, 0x00, 0xF0, 0x7C, 0x00, 0x7C, 0x1F, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xF8, 0x3E,
  0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0, 0x03, 0xC0, 0xF0, 0x00, 0xF0,
  0x7C, 0x00, 0x3C, 0x1F, 0x00, 0x1F, 0x07, 0x80, 0x07, 0x81, 0xE0, 0x01,
  0xE0, 0xF8, 0x00, 0x78, 0x3E, 0x00, 0x3E, 0x0F, 0x00, 0x0F, 0x83, 0xC0,
  0x03, 0xC0, 0xF0, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0x81, 0xFF, 0xC0, 0x7F,
  0xC0, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00,
  0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00,
  0x0F, 0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x1F, 0xFC, 0x1F, 0xFC, 0x0F, 0xFE, 0x00, 0x00, 0x03, 0xC0, 0x01,
  0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8,
  0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00,
  0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x3E, 0x00, 0x0F,
  0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0x80,
  0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00,
  0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xE0, 0x3F, 0xF0,
  0x0F, 0xFC, 0x03, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xC0, 0x1F, 0x83,
  0xE0, 0x1F, 0x81, 0xE0, 0x1F, 0x80, 0xF0, 0x0F, 0x80, 0x78, 0x0F, 0x80,
  0x7C, 0x0F, 0x80, 0x3E, 0x0F, 0x80, 0x1E, 0x0F, 0x80, 0x0F, 0x0F, 0x80,
  0x07, 0x8F, 0x80, 0x07, 0xCF, 0x80, 0x03, 0xEF, 0x80, 0x01, 0xEF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0x3C,
  0x00, 0x1F, 0x1F, 0x00, 0x0F, 0x07, 0x80, 0x07, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xC0, 0x78, 0x01, 0xE0, 0x3E, 0x00, 0xF0, 0x0F, 0x00, 0xF8,
  0x07, 0xC0, 0x7C, 0x03, 0xE0, 0x3C, 0x00, 0xF0, 0x1E, 0x00, 0x7C, 0x0F,
  0x00, 0x3E, 0x00, 0x03, 0xC0, 0x07, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x0F, 0x80, 0x0F, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x1F,
  0x00, 0x1F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFE, 0xFF,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80,
  0x03, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x03, 0xB8, 0x00, 0x7F, 0x81, 0xEE,
  0x00, 0x1D, 0xE0, 0x7B, 0x80, 0x0F, 0x78, 0x1E, 0xE0, 0x07, 0xBC, 0x07,
  0xBC, 0x01, 0xEF, 0x01, 0xEF, 0x00, 0xF3, 0xC0, 0xF3, 0xC0, 0x3C, 0xF0,
  0x3C, 0xF0, 0x1E, 0x7C, 0x0F, 0x3C, 0x07, 0x9E, 0x03, 0xC7, 0x03, 0xC7,
  0x80, 0xF1, 0xC0, 0xF1, 0xE0, 0x78, 0x70, 0x78, 0x78, 0x1E, 0x1C, 0x1E,
  0x3E, 0x07, 0x87, 0x8F, 0x0F, 0x01, 0xE1, 0xE3, 0x83, 0xC0, 0xF8, 0x79,
  0xE0, 0xF0, 0x3C, 0x1E, 0x70, 0x3C, 0x0F, 0x07, 0xBC, 0x1F, 0x03, 0xC1,
  0xEE, 0x07, 0x80, 0xF0, 0x3F, 0x81, 0xE0, 0x78, 0x0F, 0xC0, 0x78, 0x1E,
  0x03, 0xF0, 0x3E, 0x07, 0x80, 0xF8, 0x0F, 0x81, 0xE0, 0x3E, 0x03, 0xC0,
  0xF8, 0x0F, 0x00, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x78, 0x1F, 0x80, 0x07,
  0x80, 0xFE, 0x00, 0x3C, 0x07, 0xF0, 0x01, 0xE0, 0x3F, 0x80, 0x0F, 0x03,
  0xFE, 0x00, 0xF8, 0x1E, 0xF0, 0x07, 0x80, 0xF7, 0x80, 0x3C, 0x07, 0xBE,
  0x01, 0xE0, 0x3C, 0xF0, 0x0F, 0x03, 0xC7, 0x80, 0xF8, 0x1E, 0x1E, 0x07,
  0x80, 0xF0, 0xF0, 0x3C, 0x07, 0x87, 0x81, 0xE0, 0x3C, 0x1E, 0x0F, 0x03,
  0xC0, 0xF0, 0xF0, 0x1E, 0x07, 0xC7, 0x80, 0xF0, 0x1E, 0x3C, 0x07, 0x80,
  0xF1, 0xE0, 0x7C, 0x07, 0xCF, 0x03, 0xC0, 0x1E, 0xF0, 0x1E, 0x00, 0xF7,
  0x80, 0xF0, 0x07, 0xFC, 0x07, 0x80, 0x1F, 0xE0, 0x7C, 0x00, 0xFF, 0x03,
  0xC0, 0x03, 0xF0, 0x1E, 0x00, 0x1F, 0x80, 0xF0, 0x00, 0xFC, 0x0F, 0x80,
  0x03, 0xE0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07, 0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00,
  0x7E, 0x3E, 0x00, 0x1F, 0x3E, 0x00, 0x0F, 0x9F, 0x00, 0x03, 0xDF, 0x00,
  0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF, 0x00, 0x01, 0xF7, 0xC0, 0x01, 0xFB,
  0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xFC, 0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC,
  0x0F, 0xF3, 0xFC, 0x03, 0xFF, 0xFC, 0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8,
  0x00, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0x80, 0x7F, 0xFF, 0x01, 0xE1, 0xFE,
  0x07, 0x80, 0xF8, 0x3E, 0x01, 0xF0, 0xF8, 0x07, 0xC3, 0xC0, 0x1F, 0x0F,
  0x00, 0x7C, 0x3C, 0x01, 0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x3E, 0x1E, 0x01,
  0xF8, 0x78, 0x0F, 0xC1, 0xFF, 0xFE, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0x00,
  0xFF, 0xE0, 0x03, 0xC0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x7F, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x7F, 0x07,
  0xF0, 0x7E, 0x01, 0xF8, 0x7E, 0x00, 0x7E, 0x3E, 0x00, 0x1F, 0x3E, 0x00,
  0x0F, 0x9F, 0x00, 0x03, 0xDF, 0x00, 0x01, 0xEF, 0x80, 0x00, 0xF7, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x1F, 0xF8,
  0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xEF,
  0x00, 0x01, 0xF7, 0xC0, 0x00, 0xF3, 0xE0, 0x00, 0xF9, 0xF0, 0x00, 0xF8,
  0x7C, 0x00, 0xFC, 0x3F, 0x00, 0xFC, 0x0F, 0xF3, 0xFC, 0x03, 0xFF, 0xFC,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80, 0x1F, 0xFF, 0x80, 0x7F,
  0xFF, 0x01, 0xE1, 0xFE, 0x07, 0x80, 0xF8, 0x3E, 0x01, 0xE0, 0xF8, 0x07,
  0xC3, 0xC0, 0x1F, 0x0F, 0x00, 0x7C, 0x3C, 0x01, 0xE1, 0xF0, 0x0F, 0x87,
  0xC0, 0x3E, 0x1E, 0x01, 0xF0, 0x78, 0xFF, 0x81, 0xFF, 0xFC, 0x0F, 0xFF,
  0xE0, 0x3F, 0xFE, 0x00, 0xF0, 0x78, 0x03, 0xC1, 0xF0, 0x0F, 0x07, 0xC0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3E, 0x07, 0x80, 0xF8, 0x1E, 0x01, 0xE0, 0xF8,
  0x07, 0xC3, 0xE0, 0x0F, 0x0F, 0x00, 0x3E, 0x3C, 0x00, 0xF8, 0xF0, 0x01,
  0xF0, 0x00, 0x1E, 0x00, 0x07, 0xFF, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xE0,
  0xFE, 0x1E, 0x07, 0xC0, 0x10, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xFF, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00,
  0x1E, 0x00, 0x00, 0xF0, 0x00, 0x0F, 0x84, 0x00, 0xFC, 0x3E, 0x3F, 0xC1,
  0xFF, 0xFC, 0x0F, 0xFF, 0xC0, 0x3F, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01,
  0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xC0, 0x00,
  0x3C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80, 0x00, 0x78, 0x00,
  0x07, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF0, 0x00, 0x0F, 0x00,
  0x00, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1E, 0x00, 0x01, 0xE0,
  0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x07,
  0x87, 0x80, 0x03, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x01, 0xF1, 0xF0, 0x00,
  0xF0, 0xF8, 0x00, 0x78, 0x78, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00,
  0x1F, 0x1F, 0x00, 0x0F, 0x0F, 0x00, 0x07, 0x87, 0x80, 0x07, 0xC3, 0xC0,
  0x03, 0xE3, 0xE0, 0x01, 0xE1, 0xF0, 0x00, 0xF0, 0xF0, 0x00, 0x78, 0x78,
  0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x3E, 0x00, 0x1E, 0x1F, 0x00, 0x0F, 0x0F,
  0x80, 0x0F, 0x87, 0xC0, 0x07, 0xC3, 0xE0, 0x07, 0xC1, 0xF0, 0x03, 0xE0,
  0x7C, 0x03, 0xE0, 0x3F, 0xDF, 0xF0, 0x0F, 0xFF, 0xF0, 0x03, 0xFF, 0xE0,
  0x00, 0xFF, 0xE0, 0x00, 0xF0, 0x00, 0x3F, 0xE0, 0x00, 0xFB, 0xC0, 0x01,
  0xE7, 0x80, 0x07, 0xCF, 0x00, 0x0F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x78,
  0x3C, 0x01, 0xF0, 0x78, 0x03, 0xC0, 0xF0, 0x0F, 0x81, 0xE0, 0x1E, 0x03,
  0xC0, 0x7C, 0x07, 0x80, 0xF0, 0x0F, 0x03, 0xE0, 0x1E, 0x07, 0x80, 0x3C,
  0x1F, 0x00, 0x7C, 0x3C, 0x00, 0x78, 0xF8, 0x00, 0xF1, 0xE0, 0x01, 0xE7,
  0x80, 0x03, 0xCF, 0x00, 0x07, 0xBC, 0x00, 0x0F, 0x78, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xF0, 0x00, 0x00, 0xF0, 0x01, 0xF0, 0x03, 0xFE, 0x00, 0x3E, 0x00,
  0x7B, 0xC0, 0x0F, 0xC0, 0x1F, 0x7C, 0x01, 0xF8, 0x03, 0xEF, 0x80, 0x7F,
  0x00, 0x79, 0xF0, 0x0F, 0xE0, 0x1F, 0x3E, 0x03, 0xFC, 0x03, 0xC7, 0xC0,
  0x7F, 0x80, 0xF8, 0x78, 0x1E, 0xF0, 0x1E, 0x0F, 0x03, 0xCE, 0x07, 0xC1,
  0xE0, 0x71, 0xC0, 0xF0, 0x3C, 0x1E, 0x38, 0x1E, 0x07, 0x83, 0xC7, 0x07,
  0x80, 0xF0, 0xF0, 0xE0, 0xF0, 0x1E, 0x1E, 0x1C, 0x3E, 0x03, 0xC7, 0x83,
  0x87, 0x80, 0x78, 0xF0, 0x71, 0xF0, 0x0F, 0x3C, 0x0F, 0x3C, 0x01, 0xE7,
  0x81, 0xE7, 0x80, 0x3D, 0xE0, 0x3D, 0xE0, 0x07, 0xBC, 0x07, 0xBC, 0x00,
  0xF7, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x1F, 0xE0, 0x03, 0xFC, 0x03, 0xFC,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x01, 0xF8, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x01,
  0xE0, 0x03, 0xF0, 0x1F, 0x00, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x0F, 0x00,
  0xF8, 0x00, 0xF8, 0x1F, 0x00, 0x07, 0x81, 0xE0, 0x00, 0x78, 0x3E, 0x00,
  0x07, 0xC7, 0xC0, 0x00, 0x3C, 0xF8, 0x00, 0x03, 0xCF, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x07,
  0xBC, 0x00, 0x00, 0xF3, 0xE0, 0x00, 0x1F, 0x1E, 0x00, 0x03, 0xE1, 0xE0,
  0x00, 0x7C, 0x1F, 0x00, 0x07, 0xC0, 0xF0, 0x00, 0xF8, 0x0F, 0x00, 0x1F,
  0x00, 0xF8, 0x03, 0xE0, 0x07, 0x80, 0x3E, 0x00, 0x78, 0x07, 0xC0, 0x07,
  0xC0, 0xF8, 0x00, 0x7C, 0x00, 0xF0, 0x00, 0xFF, 0xC0, 0x0F, 0xBE, 0x00,
  0x78, 0xF0, 0x07, 0xC7, 0x80, 0x7C, 0x3E, 0x03, 0xC0, 0xF0, 0x3E, 0x07,
  0x83, 0xE0, 0x3C, 0x1E, 0x01, 0xE1, 0xF0, 0x07, 0x9F, 0x00, 0x3C, 0xF0,
  0x01, 0xEF, 0x80, 0x0F, 0xF8, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xC0, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xFF,
  0xFF, 0x80, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xE0, 0x00,
  0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF8, 0x0F, 0xFF,
  0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x01, 0xFF, 0x01, 0xFE, 0x01, 0xFE, 0x03,
  0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07,
  0x80, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x0F, 0x00, 0x0F, 0x00, 0x0F,
  0x00, 0x0F, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x78, 0x00, 0x78,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0, 0x00, 0xFF, 0x80, 0xFF,
  0x00, 0xFF, 0x00, 0xF0, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC1, 0xE0, 0x70,
  0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x70, 0x3C, 0x1E, 0x0F, 0x07,
  0x83, 0xC0, 0xE0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0x83, 0xC0, 0xE0, 0x78,
  0x01, 0xFF, 0x01, 0xFF, 0x01, 0xFE, 0x00, 0x1E, 0x00, 0x1E, 0x00, 0x1E,
  0x00, 0x1E, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0xF0,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0, 0x01, 0xE0,
  0x01, 0xE0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x07, 0x80, 0x7F, 0x80, 0x7F, 0x80, 0xFF, 0x80, 0x00, 0x38,
  0x00, 0x03, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0xE7, 0x00, 0x0F, 0x3C, 0x00, 0x71, 0xE0, 0x07, 0x87, 0x00, 0x38, 0x3C,
  0x03, 0xC0, 0xE0, 0x1C, 0x07, 0x81, 0xE0, 0x1C, 0x0E, 0x00, 0xF0, 0xF0,
  0x03, 0x87, 0x00, 0x1E, 0x78, 0x00, 0xF7, 0x80, 0x03, 0xC0, 0x7F, 0xFF,
  0xFF, 0xFF, 0xC0, 0xF8, 0xF0, 0xF1, 0xE1, 0xE1, 0xC0, 0x00, 0x20, 0x00,
  0x0F, 0xE3, 0xC1, 0xFF, 0x9E, 0x1F, 0xFE, 0xE1, 0xFC, 0x7F, 0x0F, 0x81,
  0xF8, 0xF8, 0x0F, 0xC7, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E,
  0x00, 0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F,
  0x1E, 0x00, 0xF8, 0xF0, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8,
  0xFF, 0x07, 0xFF, 0x78, 0x1F, 0xF3, 0xC0, 0x7E, 0x1C, 0x00, 0x03, 0xE0,
  0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0xFE,
  0x03, 0xEF, 0xF8, 0x1E, 0xFF, 0xE0, 0xFF, 0x1F, 0x07, 0xE0, 0x7C, 0x3E,
  0x03, 0xE3, 0xF0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x03, 0xC7, 0x80, 0x3E,
  0x7C, 0x01, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80,
  0x3E, 0x7C, 0x01, 0xE3, 0xE0, 0x1F, 0x1F, 0x81, 0xF0, 0xFE, 0x3F, 0x87,
  0x7F, 0xF8, 0x79, 0xFF, 0x83, 0xC7, 0xF0, 0x00, 0x00, 0x10, 0x00, 0xFF,
  0xC1, 0xFF, 0xE1, 0xFF, 0xF1, 0xFC, 0x30, 0xF8, 0x00, 0xF8, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x01,
  0x0F, 0xC3, 0x87, 0xFF, 0xC1, 0xFF, 0xE0, 0x3F, 0xE0, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0,
  0x00, 0x0F, 0x80, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x03,
  0xF8, 0xF0, 0x1F, 0xFB, 0xE0, 0x7F, 0xFF, 0x81, 0xF8, 0x7F, 0x03, 0xE0,
  0x7E, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x7C, 0x01, 0xE0, 0xF0, 0x03,
  0xC1, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1E, 0x00, 0x78,
  0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE0, 0xF0, 0x0F, 0xC1, 0xF0, 0x1F, 0x03,
  0xE0, 0x7E, 0x07, 0xE3, 0xFC, 0x07, 0xFF, 0x78, 0x07, 0xFC, 0xE0, 0x07,
  0xE1, 0xC0, 0x00, 0x00, 0x10, 0x00, 0x7F, 0xC0, 0x7F, 0xF8, 0x3F, 0xFF,
  0x1F, 0x87, 0xC7, 0xC0, 0xF3, 0xE0, 0x3C, 0xF0, 0x1F, 0x7C, 0x07, 0x9E,
  0x07, 0xEF, 0xFF, 0xF3, 0xFF, 0xF8, 0xFF, 0xF8, 0x3F, 0xC0, 0x0F, 0x00,
  0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x21, 0xF8, 0x38,
  0x7F, 0xFE, 0x0F, 0xFF, 0x80, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x03,
  0xFE, 0x00, 0x03, 0xFE, 0x00, 0x07, 0xC2, 0x00, 0x07, 0x80, 0x00, 0x0F,
  0x80, 0x00, 0x0F, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x7F,
  0xF0, 0x01, 0xFF, 0xF0, 0x01, 0xFF, 0xF0, 0x00, 0x1E, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x78, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xE0,
  0x00, 0x01, 0xE0, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xE0, 0x00, 0x03, 0xE0,
  0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0xFF, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x10,
  0x00, 0x03, 0xF8, 0xF0, 0x3F, 0xF3, 0xC1, 0xFF, 0xEE, 0x0F, 0xC3, 0xF8,
  0x3E, 0x07, 0xE1, 0xF0, 0x1F, 0x87, 0x80, 0x3E, 0x3E, 0x00, 0xF0, 0xF0,
  0x03, 0xC3, 0xC0, 0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xE1, 0xE0, 0x07,
  0x87, 0x80, 0x3E, 0x1E, 0x00, 0xF8, 0x78, 0x07, 0xE1, 0xF0, 0x3F, 0x07,
  0xC1, 0xFC, 0x1F, 0x8F, 0xF0, 0x3F, 0xFB, 0xC0, 0x7F, 0xDF, 0x00, 0xFC,
  0x78, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0xC0, 0xC0, 0x3E, 0x03, 0xFF, 0xF8, 0x0F, 0xFF, 0xC0, 0x3F,
  0xFC, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x7F, 0x03, 0xEF, 0xFC, 0x1E, 0xFF,
  0xE0, 0xFF, 0x1F, 0x87, 0xE0, 0x7C, 0x3E, 0x03, 0xE3, 0xF0, 0x1F, 0x1F,
  0x00, 0xF8, 0xF8, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0, 0x1F,
  0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xE0,
  0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x87, 0x80, 0x3C, 0x7C, 0x01, 0xE3,
  0xC0, 0x1F, 0x00, 0x03, 0xC0, 0x7C, 0x0F, 0x81, 0xE0, 0x10, 0x00, 0x00,
  0x00, 0x00, 0x07, 0x81, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0,
  0xF0, 0x1E, 0x03, 0xC0, 0xF8, 0x1F, 0x03, 0xC0, 0x78, 0x0F, 0x03, 0xE0,
  0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xE0, 0x00, 0x00, 0x0F, 0x00,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0x40, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00,
  0x3E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x01,
  0xF0, 0x0F, 0xF8, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xF0, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00,
  0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x07, 0x80, 0x04, 0x1E,
  0x03, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0xF8, 0x0F, 0x07, 0xC0, 0x3C, 0x3E,
  0x01, 0xF1, 0xF0, 0x07, 0xCF, 0x80, 0x1E, 0x7C, 0x00, 0x7B, 0xE0, 0x01,
  0xFF, 0x00, 0x0F, 0xFC, 0x00, 0x3F, 0xF8, 0x00, 0xFD, 0xE0, 0x03, 0xE7,
  0xC0, 0x0F, 0x0F, 0x00, 0x7C, 0x3E, 0x01, 0xE0, 0x78, 0x07, 0x81, 0xF0,
  0x1E, 0x07, 0xC0, 0x78, 0x0F, 0x83, 0xE0, 0x3E, 0x0F, 0x00, 0x7C, 0x00,
  0x03, 0xE0, 0x7C, 0x0F, 0x01, 0xE0, 0x3C, 0x0F, 0x81, 0xF0, 0x3C, 0x07,
  0x80, 0xF0, 0x3E, 0x07, 0x80, 0xF0, 0x1E, 0x07, 0xC0, 0xF8, 0x1E, 0x03,
  0xC0, 0x78, 0x1F, 0x03, 0xE0, 0x78, 0x0F, 0x01, 0xE0, 0x7C, 0x0F, 0x81,
  0xE0, 0x3C, 0x07, 0x81, 0xF0, 0x3C, 0x00, 0x00, 0x03, 0x00, 0x10, 0x03,
  0x8F, 0xE0, 0x7F, 0x03, 0xCF, 0xF8, 0x7F, 0xC1, 0xEF, 0xFE, 0x7F, 0xF0,
  0xFF, 0x1F, 0x70, 0xF8, 0x7E, 0x07, 0xF0, 0x7C, 0x3E, 0x03, 0xF0, 0x1E,
  0x3F, 0x01, 0xF0, 0x0F, 0x1F, 0x00, 0xF8, 0x0F, 0x8F, 0x80, 0x78, 0x07,
  0xC7, 0x80, 0x7C, 0x03, 0xC7, 0xC0, 0x3E, 0x01, 0xE3, 0xE0, 0x1E, 0x00,
  0xF1, 0xE0, 0x0F, 0x00, 0xF8, 0xF0, 0x07, 0x80, 0x7C, 0x78, 0x07, 0xC0,
  0x3C, 0x7C, 0x03, 0xC0, 0x1E, 0x3E, 0x01, 0xE0, 0x0F, 0x1E, 0x00, 0xF0,
  0x0F, 0x8F, 0x00, 0xF8, 0x07, 0xC7, 0x80, 0x7C, 0x03, 0xC7, 0xC0, 0x3C,
  0x01, 0xE3, 0xC0, 0x1E, 0x01, 0xF0, 0x00, 0x03, 0x00, 0x78, 0xFF, 0x03,
  0xCF, 0xFC, 0x1E, 0xFF, 0xE0, 0xFF, 0x1F, 0x87, 0xF0, 0x7C, 0x7F, 0x03,
  0xE3, 0xF0, 0x1F, 0x1F, 0x00, 0xF8, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x7C,
  0x01, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80, 0x3C,
  0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x1E, 0x00, 0xF8, 0xF0, 0x07, 0x8F, 0x80,
  0x3C, 0x7C, 0x03, 0xE3, 0xE0, 0x1F, 0x00, 0x01, 0xFE, 0x00, 0xFF, 0xF0,
  0x3F, 0xFF, 0x0F, 0xC3, 0xE3, 0xF0, 0x3E, 0x7C, 0x03, 0xDF, 0x00, 0x7B,
  0xE0, 0x0F, 0x78, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF,
  0x00, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0xF7, 0x80, 0x3E, 0xF8, 0x07, 0x8F,
  0x01, 0xF1, 0xF8, 0xFC, 0x1F, 0xFF, 0x01, 0xFF, 0xC0, 0x1F, 0xE0, 0x00,
  0x01, 0xC7, 0xF0, 0x07, 0x9F, 0xF0, 0x0F, 0x7F, 0xF0, 0x1F, 0xE3, 0xE0,
  0x3F, 0x03, 0xE0, 0x7C, 0x07, 0xC1, 0xF8, 0x07, 0x83, 0xE0, 0x0F, 0x07,
  0x80, 0x1E, 0x0F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0, 0xF0,
  0x03, 0xC1, 0xE0, 0x0F, 0x83, 0xC0, 0x1F, 0x0F, 0x80, 0x3C, 0x1F, 0x00,
  0xF8, 0x3F, 0x03, 0xE0, 0x7F, 0x1F, 0xC0, 0xFF, 0xFF, 0x03, 0xEF, 0xFC,
  0x07, 0x8F, 0xE0, 0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80, 0x00, 0x1F,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x20, 0x00, 0x0F,
  0xE3, 0xC1, 0xFF, 0x9E, 0x1F, 0xFE, 0xE1, 0xF8, 0x7F, 0x0F, 0x81, 0xF8,
  0xF8, 0x0F, 0xC7, 0x80, 0x3C, 0x7C, 0x01, 0xE3, 0xC0, 0x0F, 0x1E, 0x00,
  0x79, 0xF0, 0x07, 0xCF, 0x80, 0x3C, 0x78, 0x01, 0xE3, 0xC0, 0x1F, 0x1E,
  0x00, 0xF8, 0xF0, 0x0F, 0xC7, 0xC0, 0x7C, 0x3E, 0x07, 0xE1, 0xF8, 0xFF,
  0x07, 0xFF, 0x78, 0x1F, 0xF7, 0xC0, 0x7E, 0x3C, 0x00, 0x01, 0xE0, 0x00,
  0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0,
  0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x00,
  0x02, 0x03, 0x8F, 0xC3, 0xCF, 0xE1, 0xEF, 0xE0, 0xFF, 0xF0, 0x7F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7C, 0x00, 0x3E,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0, 0x03, 0xE0, 0x00,
  0x00, 0x20, 0x01, 0xFF, 0x81, 0xFF, 0xE1, 0xFF, 0xF1, 0xF0, 0x30, 0xF0,
  0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x0F, 0xC0, 0x03, 0xF8, 0x00,
  0xFF, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xF8, 0x00, 0x3C, 0x00, 0x1E,
  0x00, 0x0F, 0x20, 0x0F, 0x9C, 0x0F, 0xCF, 0xFF, 0xC7, 0xFF, 0xC1, 0xFF,
  0xC0, 0x03, 0x80, 0x0E, 0x00, 0x78, 0x01, 0xC0, 0x0F, 0x00, 0xFF, 0xFF,
  0xFF, 0xBF, 0xFE, 0x1E, 0x00, 0x78, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0x80, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x10, 0x7F, 0xC1, 0xFF, 0x03, 0xFC,
  0x00, 0x1F, 0x00, 0x78, 0xF8, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01, 0xE3,
  0xE0, 0x0F, 0x1F, 0x00, 0x78, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C, 0x01,
  0xE3, 0xE0, 0x0F, 0x1F, 0x00, 0xF8, 0xF0, 0x07, 0xC7, 0x80, 0x3C, 0x3C,
  0x03, 0xE3, 0xE0, 0x1F, 0x1F, 0x01, 0xF8, 0xF8, 0x0F, 0x87, 0xC0, 0xFC,
  0x3F, 0x1F, 0xE0, 0xFF, 0xEF, 0x07, 0xFE, 0x78, 0x1F, 0xC3, 0x80, 0xF0,
  0x01, 0xFF, 0x00, 0x3E, 0xF8, 0x03, 0xCF, 0x80, 0x7C, 0x78, 0x07, 0x87,
  0x80, 0xF8, 0x78, 0x0F, 0x07, 0x81, 0xF0, 0x78, 0x1E, 0x07, 0x83, 0xE0,
  0x78, 0x3C, 0x07, 0x87, 0xC0, 0x78, 0x78, 0x03, 0xCF, 0x00, 0x3C, 0xF0,
  0x03, 0xDE, 0x00, 0x3D, 0xE0, 0x03, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x7F, 0xE0, 0x3E,
  0x01, 0xEF, 0x80, 0xFC, 0x0F, 0x9E, 0x07, 0xF0, 0x3C, 0x78, 0x1F, 0xC0,
  0xF1, 0xE0, 0xFF, 0x07, 0xC7, 0x83, 0xBC, 0x1E, 0x1E, 0x1E, 0xF0, 0xF8,
  0x78, 0x73, 0xC3, 0xC1, 0xE3, 0xCF, 0x1F, 0x07, 0x8F, 0x3C, 0x78, 0x1E,
  0x78, 0xF3, 0xE0, 0x79, 0xE3, 0xCF, 0x01, 0xE7, 0x0F, 0x3C, 0x07, 0xBC,
  0x1D, 0xE0, 0x1E, 0xE0, 0x77, 0x80, 0x7F, 0x81, 0xDC, 0x01, 0xFC, 0x07,
  0xF0, 0x07, 0xF0, 0x1F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x01, 0xF0, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x3F, 0x03, 0xC0, 0x7C, 0x03,
  0xE0, 0x7C, 0x01, 0xE0, 0xF8, 0x01, 0xF1, 0xF0, 0x00, 0xF3, 0xE0, 0x00,
  0xF3, 0xC0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x01,
  0xEF, 0x00, 0x03, 0xCF, 0x80, 0x07, 0xC7, 0x80, 0x0F, 0x87, 0xC0, 0x1F,
  0x03, 0xC0, 0x3E, 0x03, 0xC0, 0x3E, 0x03, 0xE0, 0xFC, 0x01, 0xF0, 0x03,
  0xC0, 0x07, 0xC0, 0xF0, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x07, 0x80, 0x7C,
  0x01, 0xE0, 0x1E, 0x00, 0x78, 0x0F, 0x80, 0x1E, 0x03, 0xC0, 0x07, 0x81,
  0xF0, 0x01, 0xE0, 0x78, 0x00, 0x78, 0x3E, 0x00, 0x0F, 0x0F, 0x00, 0x03,
  0xC7, 0xC0, 0x00, 0xF1, 0xE0, 0x00, 0x3C, 0xF0, 0x00, 0x0F, 0x3C, 0x00,
  0x03, 0xDE, 0x00, 0x00, 0xF7, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x00, 0x01, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x1E, 0x00, 0x00, 0x0F, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0xFF, 0xFC,
  0x1F, 0xFF, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07, 0xC0,
  0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00,
  0x3E, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x3F, 0xFF, 0x87, 0xFF, 0xF1, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0xC0, 0x0F, 0x80, 0x0F, 0x00, 0x07,
  0x80, 0x03, 0xC0, 0x01, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00,
  0x3C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x3C, 0x00, 0x3F, 0x80, 0x03, 0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1F, 0xC0, 0x07, 0xE0,
  0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x01, 0xF0, 0x01, 0xF8, 0x01, 0xF8, 0x02, 0xFC, 0x00, 0x3C, 0x00, 0x3C,
  0x00, 0x3C, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x78, 0x00, 0x70,
  0x00, 0xF0, 0x00, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x7F, 0x00, 0x1F,
  0x00, 0x7F, 0x00, 0xFF, 0x01, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x03, 0xC0,
  0x03, 0xC0, 0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80, 0x07, 0x80,
  0x0F, 0x00, 0x1F, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x7F, 0x80,
  0x3F, 0xFC, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF, 0xF8, 0x03, 0xFC,
};

const GFXglyph NotoSans_MediumItalic41pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 11, 30, 11, 1, -29 },
  { 43, 14, 10, 17, 4, -29 },
  { 61, 26, 29, 26, 1, -29 },
  { 156, 21, 33, 23, 1, -31 },
  { 243, 29, 30, 33, 3, -30 },
  { 352, 26, 30, 28, 1, -30 },
  { 450, 6, 10, 9, 4, -29 },
  { 458, 14, 35, 12, 2, -29 },
  { 520, 14, 35, 13, -3, -29 },
  { 582, 19, 19, 23, 4, -31 },
  { 628, 19, 19, 23, 3, -24 },
  { 674, 9, 10, 11, -2, -5 },
  { 686, 11, 4, 13, 1, -13 },
  { 692, 5, 6, 11, 1, -5 },
  { 696, 21, 29, 15, -2, -29 },
  { 773, 20, 30, 23, 2, -30 },
  { 848, 14, 29, 23, 5, -29 },
  { 899, 22, 30, 23, 0, -30 },
  { 982, 21, 30, 23, 1, -30 },
  { 1061, 22, 29, 23, 0, -29 },
  { 1141, 21, 29, 23, 1, -29 },
  { 1218, 21, 30, 23, 2, -30 },
  { 1297, 20, 29, 23, 3, -29 },
  { 1370, 20, 30, 23, 2, -30 },
  { 1445, 20, 30, 23, 2, -30 },
  { 1520, 9, 24, 11, 1, -23 },
  { 1547, 12, 28, 11, -2, -23 },
  { 1589, 19, 20, 23, 3, -25 },
  { 1637, 19, 11, 23, 3, -20 },
  { 1664, 19, 20, 23, 3, -25 },
  { 1712, 16, 31, 18, 3, -30 },
  { 1774, 32, 33, 35, 2, -29 },
  { 1906, 24, 29, 24, -2, -29 },
  { 1993, 22, 29, 25, 2, -29 },
  { 2073, 23, 30, 24, 3, -30 },
  { 2160, 24, 29, 27, 2, -29 },
  { 2247, 21, 29, 21, 2, -29 },
  { 2324, 21, 29, 20, 2, -29 },
  { 2401, 24, 30, 28, 3, -30 },
  { 2491, 26, 29, 28, 2, -29 },
  { 2586, 17, 29, 14, -1, -29 },
  { 2648, 18, 37, 12, -6, -29 },
  { 2732, 25, 29, 24, 2, -29 },
  { 2823, 16, 29, 20, 2, -29 },
  { 2881, 34, 29, 35, 1, -29 },
  { 3005, 29, 29, 30, 1, -29 },
  { 3111, 25, 30, 30, 3, -30 },
  { 3205, 22, 29, 24, 2, -29 },
  { 3285, 25, 37, 30, 3, -30 },
  { 3401, 22, 29, 24, 2, -29 },
  { 3481, 21, 30, 21, 1, -30 },
  { 3560, 20, 29, 21, 4, -29 },
  { 3633, 25, 29, 28, 3, -29 },
  { 3724, 23, 29, 23, 4, -29 },
  { 3808, 35, 29, 36, 4, -29 },
  { 3935, 28, 29, 23, -2, -29 },
  { 4037, 21, 29, 22, 4, -29 },
  { 4114, 25, 29, 22, -1, -29 },
  { 4205, 16, 35, 12, 0, -29 },
  { 4275, 9, 29, 15, 4, -29 },
  { 4308, 16, 35, 12, -3, -29 },
  { 4378, 21, 18, 23, 1, -29 },
  { 4426, 17, 2, 16, -4, 4 },
  { 4431, 7, 6, 12, 6, -31 },
  { 4437, 21, 23, 24, 2, -23 },
  { 4498, 21, 31, 24, 1, -31 },
  { 4580, 17, 23, 19, 2, -23 },
  { 4629, 23, 31, 24, 2, -31 },
  { 4719, 18, 23, 21, 2, -23 },
  { 4771, 24, 41, 14, -5, -31 },
  { 4894, 22, 33, 24, 1, -23 },
  { 4985, 21, 31, 24, 1, -31 },
  { 5067, 11, 30, 11, 1, -30 },
  { 5109, 17, 40, 11, -5, -30 },
  { 5194, 22, 31, 21, 1, -31 },
  { 5280, 11, 31, 11, 1, -31 },
  { 5323, 33, 23, 36, 1, -23 },
  { 5418, 21, 23, 24, 1, -23 },
  { 5479, 19, 22, 23, 2, -22 },
  { 5532, 23, 32, 24, -1, -22 },
  { 5624, 21, 33, 24, 2, -23 },
  { 5711, 17, 23, 17, 1, -23 },
  { 5760, 17, 23, 18, 0, -23 },
  { 5809, 14, 27, 15, 2, -27 },
  { 5857, 21, 22, 24, 2, -22 },
  { 5915, 20, 22, 20, 2, -22 },
  { 5970, 30, 22, 30, 2, -22 },
  { 6053, 24, 22, 20, -2, -22 },
  { 6119, 26, 32, 20, -4, -22 },
  { 6223, 19, 22, 19, -1, -22 },
  { 6276, 17, 35, 14, 0, -29 },
  { 6351, 4, 41, 23, 10, -31 },
  { 6372, 16, 35, 14, -2, -29 },
  { 6442, 19, 5, 23, 3, -17 },
};

const GFXfont NotoSans_MediumItalic41pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic41pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic41pt7bGlyphs,
  0x20, 0x7E, 56
};

#endif // _NOTOSANS_MEDIUMITALIC41PT7B_H_
