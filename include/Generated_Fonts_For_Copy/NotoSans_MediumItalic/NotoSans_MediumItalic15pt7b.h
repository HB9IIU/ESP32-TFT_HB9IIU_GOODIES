#ifndef _NOTOSANS_MEDIUMITALIC15PT7B_H_
#define _NOTOSANS_MEDIUMITALIC15PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 15pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic15pt7bBitmaps[] PROGMEM = {
  0x00, 0x33, 0x33, 0x22, 0x66, 0x04, 0xC0, 0xD9, 0x9A, 0x0C, 0x82, 0x40,
  0x91, 0xFF, 0x7F, 0xC4, 0x81, 0x23, 0xFE, 0x24, 0x09, 0x06, 0xC0, 0x04,
  0x1F, 0x35, 0x28, 0x38, 0x1C, 0x0E, 0x12, 0x96, 0xFC, 0x10, 0x10, 0x30,
  0xCB, 0x13, 0x24, 0x4D, 0x89, 0xA9, 0xAB, 0x9A, 0xD8, 0xD3, 0x12, 0x44,
  0x49, 0x0E, 0x00, 0x0E, 0x06, 0xC1, 0x30, 0x4C, 0x1E, 0x0E, 0x06, 0xCD,
  0x1E, 0xC3, 0x19, 0xC7, 0xD8, 0xEA, 0x19, 0x98, 0x8C, 0x62, 0x10, 0x84,
  0x21, 0x0C, 0x00, 0x10, 0x86, 0x30, 0x8C, 0x63, 0x11, 0x88, 0xCC, 0x00,
  0x08, 0x93, 0xC8, 0xF2, 0x89, 0x82, 0x00, 0x10, 0x20, 0x47, 0xF1, 0x02,
  0x04, 0x00, 0x36, 0x4C, 0x7F, 0x70, 0x03, 0x02, 0x06, 0x04, 0x0C, 0x18,
  0x10, 0x30, 0x20, 0x60, 0xC0, 0x1C, 0x6D, 0x9E, 0x3C, 0x78, 0xE1, 0xC2,
  0x8D, 0x99, 0xE0, 0x19, 0xF5, 0x23, 0x18, 0xC4, 0x23, 0x18, 0x1E, 0x3F,
  0x03, 0x03, 0x02, 0x06, 0x0C, 0x18, 0x20, 0xC0, 0xFE, 0x1E, 0x37, 0x03,
  0x03, 0x06, 0x18, 0x26, 0x02, 0x06, 0x86, 0xFC, 0x03, 0x07, 0x0E, 0x1A,
  0x12, 0x26, 0x66, 0xFF, 0xFF, 0x0C, 0x0C, 0x1F, 0x1F, 0x30, 0x30, 0x38,
  0x3E, 0x06, 0x02, 0x06, 0x8E, 0xFC, 0x0E, 0x75, 0x82, 0x0D, 0x9D, 0xB1,
  0xC3, 0x85, 0x99, 0xE0, 0x7F, 0x7E, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30,
  0x20, 0x60, 0xC0, 0x1C, 0xED, 0x8B, 0x32, 0xC7, 0x33, 0x42, 0x85, 0x99,
  0xE0, 0x3C, 0xD9, 0x1E, 0x3C, 0x79, 0xDD, 0x02, 0x0D, 0x33, 0xC0, 0x72,
  0x00, 0x00, 0x4C, 0x38, 0x80, 0x00, 0x00, 0x8C, 0x46, 0x00, 0x02, 0x18,
  0xC6, 0x07, 0x03, 0x81, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x80, 0xC0, 0x60,
  0x30, 0xCE, 0x30, 0x00, 0x7B, 0xF0, 0xC3, 0x18, 0xC6, 0x10, 0x03, 0x0C,
  0x00, 0x07, 0x03, 0x18, 0x81, 0xA3, 0xDC, 0x93, 0x22, 0x64, 0xCC, 0x99,
  0x9D, 0xD8, 0x01, 0x00, 0x1F, 0x80, 0x03, 0x03, 0x81, 0x41, 0xA0, 0x90,
  0xC8, 0x7C, 0x7F, 0x61, 0xB0, 0xF0, 0x60, 0x3C, 0x3F, 0x63, 0x63, 0x66,
  0x7C, 0x46, 0xC2, 0xC6, 0x8E, 0xFC, 0x0F, 0x9F, 0x98, 0x0C, 0x0C, 0x06,
  0x03, 0x01, 0x80, 0xC0, 0x31, 0x0F, 0x80, 0x3C, 0x1F, 0x98, 0xCC, 0x36,
  0x1A, 0x0D, 0x05, 0x86, 0xC7, 0x47, 0x3E, 0x00, 0x3E, 0x7D, 0x83, 0x06,
  0x0F, 0x90, 0x60, 0xC1, 0x03, 0xE0, 0x3E, 0x7D, 0x83, 0x06, 0x0F, 0x9F,
  0x60, 0xC1, 0x02, 0x00, 0x0F, 0x1F, 0xD8, 0x0C, 0x0C, 0x06, 0x3B, 0x1D,
  0x86, 0xC3, 0x31, 0x8F, 0x80, 0x20, 0x90, 0x58, 0x6C, 0x36, 0x13, 0xF9,
  0x0D, 0x86, 0xC3, 0x41, 0x21, 0x80, 0x3C, 0x61, 0x0C, 0x30, 0xC2, 0x08,
  0x61, 0x8F, 0x00, 0x04, 0x10, 0xC3, 0x0C, 0x20, 0x86, 0x18, 0x61, 0x0C,
  0xF3, 0x80, 0x21, 0x91, 0x99, 0x8D, 0x87, 0x83, 0xC1, 0xE1, 0x90, 0xCC,
  0x42, 0x21, 0x80, 0x21, 0x18, 0xC6, 0x21, 0x18, 0xC4, 0x3E, 0x30, 0x73,
  0x07, 0x70, 0xE7, 0x0A, 0x51, 0xE5, 0x96, 0xDB, 0x6D, 0xA4, 0xCC, 0x48,
  0xCC, 0x88, 0xC0, 0x30, 0xCC, 0x37, 0x09, 0xE2, 0x49, 0x92, 0x6C, 0xDB,
  0x14, 0xC7, 0x21, 0xC8, 0x30, 0x0E, 0x1F, 0xD8, 0x68, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC3, 0x33, 0x8F, 0x80, 0x3C, 0x3E, 0x63, 0x63, 0x63, 0x4E,
  0x7C, 0xC0, 0xC0, 0x80, 0x80, 0x0E, 0x1F, 0xD8, 0x68, 0x1C, 0x0E, 0x07,
  0x07, 0x83, 0xC3, 0x33, 0x8F, 0x01, 0x80, 0x60, 0x18, 0x3C, 0x3E, 0x63,
  0x63, 0x62, 0x7E, 0x78, 0xCC, 0xCC, 0x84, 0x86, 0x1E, 0x3F, 0x20, 0x20,
  0x30, 0x18, 0x0C, 0x06, 0x06, 0x8C, 0xF8, 0x7F, 0xFF, 0x18, 0x10, 0x10,
  0x30, 0x30, 0x30, 0x20, 0x60, 0x60, 0x20, 0xB0, 0x58, 0x6C, 0x34, 0x12,
  0x0B, 0x0D, 0x86, 0xC3, 0x63, 0x1F, 0x00, 0xC1, 0xE1, 0x90, 0xC8, 0xC4,
  0x62, 0x61, 0x30, 0xF0, 0x78, 0x38, 0x18, 0x00, 0x86, 0x18, 0x63, 0x8E,
  0x28, 0xA6, 0x9A, 0x49, 0x2C, 0xB2, 0xCA, 0x28, 0xE3, 0x8C, 0x30, 0xC3,
  0x00, 0x10, 0x46, 0x31, 0x98, 0x2C, 0x0E, 0x03, 0x00, 0xE0, 0x68, 0x33,
  0x18, 0xCC, 0x10, 0xC3, 0x42, 0x66, 0x6C, 0x68, 0x38, 0x30, 0x30, 0x20,
  0x20, 0x60, 0x3F, 0x9F, 0x80, 0xC0, 0xC0, 0xC0, 0xC0, 0x40, 0x60, 0x60,
  0x60, 0x3F, 0x80, 0x1C, 0xE3, 0x08, 0x21, 0x86, 0x18, 0x41, 0x0C, 0x30,
  0xE0, 0x92, 0x6D, 0x92, 0x49, 0x80, 0x1C, 0xF0, 0x82, 0x18, 0x61, 0x04,
  0x10, 0xC3, 0x08, 0xE0, 0x08, 0x18, 0x14, 0x34, 0x22, 0x62, 0xC3, 0xFC,
  0xCC, 0x3A, 0xCF, 0x1E, 0x38, 0x51, 0xB7, 0x7E, 0x10, 0x30, 0x30, 0x3E,
  0x33, 0x23, 0x63, 0x63, 0x62, 0x66, 0xDC, 0x3D, 0x8C, 0x30, 0x82, 0x0C,
  0x9E, 0x03, 0x03, 0x02, 0x3A, 0x66, 0xC6, 0xC6, 0x84, 0x8C, 0xDC, 0xFC,
  0x3D, 0x9C, 0x7F, 0xE2, 0x0C, 0x9E, 0x07, 0x82, 0x03, 0x03, 0xE0, 0xC0,
  0x40, 0x20, 0x30, 0x18, 0x0C, 0x04, 0x02, 0x03, 0x07, 0x01, 0x00, 0x1D,
  0x33, 0x63, 0x63, 0x42, 0x46, 0x6E, 0x7E, 0x06, 0x04, 0xFC, 0x30, 0x10,
  0x30, 0x30, 0x2F, 0x33, 0x23, 0x63, 0x63, 0x42, 0x42, 0xC6, 0x31, 0x03,
  0x22, 0x66, 0x64, 0xC0, 0x0C, 0x10, 0x03, 0x08, 0x21, 0x86, 0x10, 0x43,
  0x0C, 0x33, 0x8C, 0x00, 0x10, 0x30, 0x30, 0x33, 0x26, 0x2C, 0x78, 0x68,
  0x4C, 0x4C, 0xC6, 0x13, 0x33, 0x22, 0x66, 0x44, 0xC0, 0x2E, 0x73, 0x39,
  0x23, 0x16, 0x31, 0x62, 0x34, 0x23, 0x46, 0x3C, 0x62, 0x2F, 0x33, 0x23,
  0x63, 0x63, 0x62, 0x46, 0xC6, 0x3C, 0xCF, 0x1C, 0x38, 0x70, 0xB3, 0x3C,
  0x2E, 0x33, 0x23, 0x63, 0x63, 0x62, 0x66, 0xDC, 0xC0, 0xC0, 0x80, 0x80,
  0x3A, 0xCF, 0x1E, 0x38, 0x51, 0xB7, 0x7E, 0x0C, 0x10, 0x20, 0xC0, 0x2E,
  0x60, 0x83, 0x06, 0x0C, 0x10, 0x60, 0x3D, 0x96, 0x0C, 0x18, 0x38, 0xBE,
  0x23, 0x3E, 0x84, 0x63, 0x18, 0xC7, 0x00, 0x62, 0x87, 0x1E, 0x3C, 0x51,
  0xB7, 0x7E, 0x87, 0x1B, 0x36, 0xCD, 0x1E, 0x18, 0x30, 0x8C, 0x71, 0x9A,
  0x73, 0x4A, 0x4B, 0x59, 0x4A, 0x39, 0xC6, 0x30, 0x31, 0x89, 0x87, 0x81,
  0x81, 0xC1, 0xA0, 0x99, 0xC4, 0x21, 0x91, 0x8C, 0xC6, 0xC3, 0x60, 0xE0,
  0x60, 0x30, 0x10, 0x18, 0x38, 0x18, 0x00, 0x7E, 0x18, 0x20, 0xC3, 0x0C,
  0x30, 0x7C, 0x0C, 0x71, 0x04, 0x30, 0xCE, 0x18, 0x21, 0x86, 0x10, 0x70,
  0xFF, 0xFE, 0x10, 0x60, 0x82, 0x18, 0x60, 0xC7, 0x10, 0xC3, 0x08, 0xE0,
  0xFB, 0x18,
};

const GFXglyph NotoSans_MediumItalic15pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 4, 11, 4, 0, -11 },
  { 7, 4, 4, 6, 2, -11 },
  { 9, 10, 11, 10, 0, -11 },
  { 23, 8, 12, 8, 0, -11 },
  { 35, 11, 11, 12, 1, -11 },
  { 51, 10, 11, 10, 0, -11 },
  { 65, 2, 4, 3, 2, -11 },
  { 66, 5, 13, 5, 1, -11 },
  { 75, 5, 13, 5, -1, -11 },
  { 84, 7, 7, 8, 1, -11 },
  { 91, 7, 7, 9, 1, -9 },
  { 98, 4, 4, 4, -1, -2 },
  { 100, 4, 2, 5, 0, -5 },
  { 101, 2, 2, 4, 0, -2 },
  { 102, 8, 11, 6, -1, -11 },
  { 113, 7, 11, 8, 1, -11 },
  { 123, 5, 11, 8, 2, -11 },
  { 130, 8, 11, 8, 0, -11 },
  { 141, 8, 11, 8, 0, -11 },
  { 152, 8, 11, 8, 0, -11 },
  { 163, 8, 11, 8, 0, -11 },
  { 174, 7, 11, 8, 1, -11 },
  { 184, 8, 11, 8, 1, -11 },
  { 195, 7, 11, 8, 1, -11 },
  { 205, 7, 11, 8, 1, -11 },
  { 215, 4, 8, 4, 0, -8 },
  { 219, 5, 10, 4, -1, -8 },
  { 226, 7, 7, 9, 1, -9 },
  { 233, 7, 4, 9, 1, -7 },
  { 237, 7, 7, 9, 1, -9 },
  { 244, 6, 11, 7, 1, -11 },
  { 253, 11, 12, 13, 1, -11 },
  { 270, 9, 11, 9, -1, -11 },
  { 283, 8, 11, 9, 1, -11 },
  { 294, 9, 11, 9, 1, -11 },
  { 307, 9, 11, 10, 1, -11 },
  { 320, 7, 11, 8, 1, -11 },
  { 330, 7, 11, 7, 1, -11 },
  { 340, 9, 11, 10, 1, -11 },
  { 353, 9, 11, 10, 1, -11 },
  { 366, 6, 11, 5, 0, -11 },
  { 375, 6, 14, 4, -2, -11 },
  { 386, 9, 11, 9, 1, -11 },
  { 399, 5, 11, 7, 1, -11 },
  { 406, 12, 11, 13, 1, -11 },
  { 423, 10, 11, 11, 1, -11 },
  { 437, 9, 11, 11, 1, -11 },
  { 450, 8, 11, 9, 1, -11 },
  { 461, 9, 14, 11, 1, -11 },
  { 477, 8, 11, 9, 1, -11 },
  { 488, 8, 11, 8, 0, -11 },
  { 499, 8, 11, 8, 1, -11 },
  { 510, 9, 11, 10, 1, -11 },
  { 523, 9, 11, 8, 1, -11 },
  { 536, 12, 11, 13, 2, -11 },
  { 553, 10, 11, 8, -1, -11 },
  { 567, 8, 11, 8, 1, -11 },
  { 578, 9, 11, 8, 0, -11 },
  { 591, 6, 13, 5, 0, -11 },
  { 601, 3, 11, 6, 2, -11 },
  { 606, 6, 13, 5, -1, -11 },
  { 616, 8, 7, 8, 0, -11 },
  { 623, 6, 1, 6, -1, 1 },
  { 624, 3, 2, 4, 2, -11 },
  { 625, 7, 8, 9, 1, -8 },
  { 632, 8, 11, 9, 0, -11 },
  { 643, 6, 8, 7, 1, -8 },
  { 649, 8, 11, 9, 1, -11 },
  { 660, 6, 8, 8, 1, -8 },
  { 666, 9, 15, 5, -2, -11 },
  { 683, 8, 12, 9, 0, -8 },
  { 695, 8, 11, 9, 0, -11 },
  { 706, 4, 11, 4, 0, -11 },
  { 712, 6, 15, 4, -2, -11 },
  { 724, 8, 11, 8, 0, -11 },
  { 735, 4, 11, 4, 0, -11 },
  { 741, 12, 8, 13, 0, -8 },
  { 753, 8, 8, 9, 0, -8 },
  { 761, 7, 8, 9, 1, -8 },
  { 768, 8, 12, 9, 0, -8 },
  { 780, 7, 12, 9, 1, -8 },
  { 791, 7, 8, 6, 0, -8 },
  { 798, 6, 8, 7, 0, -8 },
  { 804, 5, 10, 5, 1, -10 },
  { 811, 7, 8, 9, 1, -8 },
  { 818, 7, 8, 7, 1, -8 },
  { 825, 11, 8, 11, 1, -8 },
  { 836, 9, 8, 7, -1, -8 },
  { 845, 9, 12, 7, -1, -8 },
  { 859, 7, 8, 7, 0, -8 },
  { 866, 6, 13, 5, 0, -11 },
  { 876, 1, 15, 8, 4, -11 },
  { 878, 6, 13, 5, -1, -11 },
  { 888, 7, 2, 9, 1, -6 },
};

const GFXfont NotoSans_MediumItalic15pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic15pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic15pt7bGlyphs,
  0x20, 0x7E, 20
};

#endif // _NOTOSANS_MEDIUMITALIC15PT7B_H_
