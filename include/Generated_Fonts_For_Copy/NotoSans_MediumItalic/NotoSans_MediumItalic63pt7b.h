#ifndef _NOTOSANS_MEDIUMITALIC63PT7B_H_
#define _NOTOSANS_MEDIUMITALIC63PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 63pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic63pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x7F, 0x80, 0x3F, 0xC0, 0x1F, 0xE0, 0x0F, 0xE0, 0x0F, 0xF0,
  0x07, 0xF8, 0x03, 0xFC, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x3F, 0x80,
  0x1F, 0x80, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0, 0x01, 0xF0, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3E, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFE, 0x00,
  0xFF, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x3F, 0xE0, 0x1F, 0xE0, 0x07, 0xE0,
  0x01, 0xE0, 0x00, 0x3F, 0x87, 0xF3, 0xF0, 0x7F, 0x3F, 0x07, 0xE7, 0xF0,
  0x7E, 0x7E, 0x07, 0xE7, 0xE0, 0xFC, 0x7E, 0x0F, 0xC7, 0xC0, 0xFC, 0x7C,
  0x0F, 0xC7, 0xC0, 0xF8, 0xFC, 0x0F, 0x8F, 0x80, 0xF8, 0xF8, 0x1F, 0x0F,
  0x81, 0xF0, 0xF0, 0x1F, 0x0F, 0x01, 0xE0, 0x00, 0x00, 0xFC, 0x03, 0xE0,
  0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07,
  0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF0,
  0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00, 0x01, 0xF8, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C,
  0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x01, 0xFF,
  0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF, 0x87, 0xFF, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x7C, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x01, 0xF0, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x7E, 0x00, 0x00,
  0x1F, 0x00, 0xF8, 0x00, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x0F, 0x80, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFF, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x1F, 0x00, 0x00, 0x07, 0xC0, 0x3E, 0x00, 0x00, 0x1F, 0x80,
  0x7C, 0x00, 0x00, 0x3E, 0x01, 0xF8, 0x00, 0x00, 0x7C, 0x03, 0xE0, 0x00,
  0x00, 0xF8, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x3E, 0x00, 0x00, 0x0F, 0x80, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x03, 0xF0, 0x00, 0x00, 0xF8, 0x07, 0xC0, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x00, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xF0, 0x0F, 0xF3, 0xC3, 0xE0, 0x3F, 0x87,
  0x80, 0x80, 0x7E, 0x0F, 0x00, 0x01, 0xFC, 0x1E, 0x00, 0x03, 0xF8, 0x7C,
  0x00, 0x07, 0xE0, 0xF0, 0x00, 0x0F, 0xC1, 0xE0, 0x00, 0x1F, 0xC3, 0xC0,
  0x00, 0x3F, 0x87, 0x80, 0x00, 0x3F, 0xDE, 0x00, 0x00, 0x7F, 0xFC, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFB, 0xFC, 0x00, 0x01, 0xE3, 0xFC, 0x00,
  0x03, 0xC3, 0xF8, 0x00, 0x07, 0x87, 0xF0, 0x00, 0x0F, 0x07, 0xE0, 0x00,
  0x3C, 0x1F, 0xC0, 0x00, 0x78, 0x3F, 0x80, 0x00, 0xF0, 0x7E, 0x18, 0x01,
  0xE1, 0xFC, 0x3C, 0x07, 0xC7, 0xF8, 0x7F, 0xCF, 0x7F, 0xE0, 0xFF, 0xFF,
  0xFF, 0x81, 0xFF, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1E, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xF8, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0x00, 0x7F, 0xFC, 0x00, 0x03, 0xE0, 0x0F, 0xFF, 0xE0, 0x00, 0x7E,
  0x01, 0xFC, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x83, 0xE0, 0x01, 0xF8, 0x03,
  0xF0, 0x3F, 0x00, 0x1F, 0x00, 0x3E, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0,
  0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x07, 0xC0, 0x3F,
  0x00, 0xF8, 0x00, 0xFC, 0x03, 0xE0, 0x1F, 0x80, 0x0F, 0xC0, 0x3E, 0x03,
  0xF0, 0x00, 0xF8, 0x03, 0xE0, 0x7E, 0x00, 0x0F, 0x80, 0x7E, 0x07, 0xC0,
  0x00, 0xF8, 0x07, 0xE0, 0xFC, 0x00, 0x0F, 0x80, 0x7C, 0x1F, 0x80, 0x00,
  0xF8, 0x07, 0xC1, 0xF0, 0x18, 0x0F, 0x80, 0xFC, 0x3E, 0x1F, 0xF0, 0xF8,
  0x0F, 0x87, 0xE3, 0xFF, 0xCF, 0x81, 0xF8, 0xFC, 0x7F, 0xFC, 0xFC, 0x3F,
  0x0F, 0x8F, 0xFF, 0xEF, 0xE7, 0xF1, 0xF1, 0xFC, 0x7E, 0x7F, 0xFE, 0x3F,
  0x1F, 0x83, 0xF7, 0xFF, 0xC7, 0xE3, 0xF0, 0x3F, 0x3F, 0xF8, 0x7C, 0x3E,
  0x03, 0xF1, 0xFF, 0x0F, 0xC7, 0xE0, 0x3F, 0x03, 0x01, 0xF8, 0x7E, 0x03,
  0xF0, 0x00, 0x3F, 0x07, 0xC0, 0x3F, 0x00, 0x03, 0xE0, 0xFC, 0x03, 0xF0,
  0x00, 0x7E, 0x0F, 0xC0, 0x3E, 0x00, 0x0F, 0xC0, 0xFC, 0x03, 0xE0, 0x01,
  0xF8, 0x0F, 0x80, 0x3E, 0x00, 0x1F, 0x00, 0xF8, 0x07, 0xE0, 0x03, 0xF0,
  0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x00, 0xF8, 0x07, 0xC0, 0x0F, 0xC0, 0x0F,
  0x80, 0xFC, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0xC0, 0x1F, 0x80, 0x0F, 0x81,
  0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x7E, 0x00, 0x0F, 0xE7, 0xF0,
  0x07, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x1F,
  0x80, 0x00, 0x3F, 0xF8, 0x03, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x03, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xFC, 0x00,
  0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x00, 0x3F,
  0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x00, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0xFE, 0x00, 0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xFC, 0x00,
  0x00, 0x3F, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0x9F, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x7F, 0x07, 0xFD, 0xFC,
  0x00, 0xFE, 0x0F, 0xF1, 0xFE, 0x00, 0xFC, 0x1F, 0xE0, 0xFE, 0x01, 0xFC,
  0x3F, 0xC0, 0x7F, 0x01, 0xF8, 0x7F, 0x80, 0x7F, 0x83, 0xF8, 0x7F, 0x00,
  0x3F, 0xC7, 0xF0, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0xFE, 0x00, 0x0F, 0xEF,
  0xE0, 0xFE, 0x00, 0x0F, 0xFF, 0xC0, 0xFE, 0x00, 0x07, 0xFF, 0x80, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x01,
  0xFE, 0x00, 0xFF, 0x00, 0x07, 0xFE, 0x00, 0x7F, 0x80, 0x1F, 0xFF, 0x00,
  0x7F, 0xC0, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xFF, 0x9F, 0xC0, 0x1F, 0xFF, 0xFE, 0x1F, 0xE0, 0x0F, 0xFF, 0xFC, 0x0F,
  0xF0, 0x03, 0xFF, 0xE0, 0x07, 0xF8, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x3F,
  0x9F, 0x8F, 0xCF, 0xE7, 0xE3, 0xF1, 0xF8, 0xF8, 0x7C, 0x3E, 0x3F, 0x1F,
  0x0F, 0x87, 0xC3, 0xC1, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F,
  0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03,
  0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07,
  0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00,
  0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x02, 0x00, 0x3E, 0x00, 0x0E,
  0x00, 0xF8, 0x00, 0x7E, 0x03, 0xC0, 0x01, 0xFE, 0x1F, 0x00, 0x07, 0xFE,
  0x7C, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x0F, 0xFF,
  0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFE, 0x00, 0x3F, 0xDF,
  0xF8, 0x03, 0xFF, 0x00, 0x60, 0x1F, 0xBE, 0x00, 0x00, 0xFE, 0xF8, 0x00,
  0x07, 0xF1, 0xF0, 0x00, 0x3F, 0x87, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x0F,
  0xF0, 0x7E, 0x00, 0x1F, 0x80, 0xF8, 0x00, 0x3C, 0x03, 0xF0, 0x00, 0x60,
  0x0F, 0xC0, 0x00, 0x80, 0x1F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xFC, 0x0F, 0xE0, 0x7F, 0x81, 0xFC, 0x07, 0xF0,
  0x3F, 0x80, 0xFC, 0x07, 0xF0, 0x1F, 0x80, 0x7E, 0x03, 0xF0, 0x0F, 0xC0,
  0x7E, 0x01, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0xFF, 0xBF, 0xFF, 0xDF, 0xFF,
  0xEF, 0xFF, 0xE7, 0xFF, 0xF7, 0xFF, 0xF8, 0x3F, 0x3F, 0xDF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFC, 0xFC, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xC1, 0xFE, 0x00, 0xFF, 0x01,
  0xFE, 0x03, 0xFC, 0x01, 0xFC, 0x0F, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x03,
  0xF0, 0x7F, 0x80, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE,
  0x7F, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x07, 0xF7,
  0xF0, 0x00, 0x0F, 0xEF, 0xE0, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x3F,
  0x80, 0x00, 0xFE, 0x7E, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x03, 0xFB, 0xF8,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x3F, 0x9F, 0xC0,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0xFE, 0x7F, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x07, 0xF1, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x07, 0xF8, 0x1F, 0xC0, 0x1F,
  0xE0, 0x3F, 0xC0, 0x7F, 0xC0, 0x3F, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x07, 0xFC, 0x00, 0xFF, 0xE0, 0x0F, 0xFF, 0x01, 0xFF,
  0xF8, 0x1F, 0xFF, 0x83, 0xFF, 0xFC, 0x3F, 0xF7, 0xE7, 0xFF, 0x7F, 0x1F,
  0xE3, 0xF8, 0xFE, 0x1F, 0x83, 0xC0, 0xFC, 0x18, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFE, 0x07,
  0xFE, 0x00, 0xFC, 0x00, 0xFF, 0x00, 0x38, 0x00, 0x3F, 0x80, 0x18, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xE0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF,
  0xFC, 0x3F, 0xFF, 0xFF, 0xFE, 0x1F, 0xFF, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF,
  0xFF, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0x03, 0xFF, 0x00, 0x78,
  0x00, 0xFF, 0x00, 0x60, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x43,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x80, 0x00, 0x0F, 0xF0, 0xF0, 0x00, 0x1F, 0xE0, 0xFE, 0x00,
  0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFC,
  0x00, 0x00, 0x1F, 0xBF, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x07, 0xF7,
  0xE0, 0x00, 0x03, 0xF9, 0xF8, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x0F,
  0xE0, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0x80, 0x01,
  0xFC, 0x07, 0xE0, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0xFE, 0x00,
  0x1F, 0xC0, 0x3F, 0x80, 0x0F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x03, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x07, 0xE0, 0x1F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFE, 0x7F, 0xFF, 0xFF, 0xFF, 0xBF, 0xFF,
  0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x3F,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x07, 0xFF,
  0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xE0, 0x01, 0x00,
  0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x80, 0x00, 0x1F, 0xE0, 0xE0, 0x00,
  0x7F, 0xC0, 0xFC, 0x01, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00,
  0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xE0, 0x01, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0x80, 0x1F, 0xFC, 0x01, 0x00, 0x7F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0xC0, 0x00, 0xFC, 0x1F, 0xF0, 0x01, 0xF8, 0xFF, 0xF8, 0x07,
  0xF7, 0xFF, 0xF8, 0x0F, 0xFF, 0xFF, 0xF8, 0x1F, 0xBF, 0xFF, 0xF0, 0x3F,
  0xF8, 0x1F, 0xF0, 0xFF, 0xC0, 0x0F, 0xE1, 0xFF, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x7F, 0x1F, 0xC0,
  0x00, 0xFE, 0x3F, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x03, 0xF8, 0xFC, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x3F, 0x87, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x0F,
  0xE0, 0x3F, 0x80, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x00, 0x7F, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x00, 0x06, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF,
  0xFE, 0x1F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x38,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0x80, 0x7F, 0x80, 0xFF,
  0x80, 0xFE, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0xFC,
  0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0,
  0x7E, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE, 0x03,
  0xF8, 0x03, 0xFC, 0x03, 0xF8, 0x0F, 0xF0, 0x03, 0xF8, 0x7F, 0xC0, 0x07,
  0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x1F, 0xF9,
  0xFF, 0x00, 0x7F, 0xC0, 0xFF, 0x01, 0xFE, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0xFE, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x03,
  0xF8, 0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x0F, 0xE3, 0xF0, 0x00, 0x1F,
  0xC7, 0xE0, 0x00, 0x3F, 0x8F, 0xC0, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0xFE,
  0x3F, 0x80, 0x03, 0xF8, 0x7F, 0x80, 0x0F, 0xF0, 0x7F, 0xC0, 0x7F, 0xC0,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF0, 0x00,
  0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x60, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xC0, 0x7F,
  0xE0, 0xFF, 0x81, 0xFE, 0x01, 0xFE, 0x0F, 0xF0, 0x03, 0xF8, 0x3F, 0x80,
  0x07, 0xF1, 0xFC, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x1F, 0x80, 0x01,
  0xFC, 0xFE, 0x00, 0x03, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F,
  0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF,
  0xE0, 0x00, 0xFF, 0x3F, 0x80, 0x07, 0xFC, 0xFE, 0x00, 0x1F, 0xF1, 0xFC,
  0x00, 0xFF, 0x87, 0xF8, 0x0F, 0xFE, 0x1F, 0xFF, 0xFF, 0xF8, 0x3F, 0xFF,
  0xFF, 0xE0, 0x7F, 0xFF, 0xBF, 0x80, 0xFF, 0xF8, 0xFC, 0x01, 0xFF, 0xC7,
  0xF0, 0x00, 0x30, 0x1F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0xE0, 0x1F, 0xFC, 0x03, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80,
  0x03, 0xFF, 0xF0, 0x00, 0x00, 0xB8, 0x00, 0x00, 0x00, 0x00, 0x70, 0x07,
  0xE0, 0x3F, 0xC0, 0xFF, 0x07, 0xFC, 0x1F, 0xF0, 0x7F, 0xC1, 0xFE, 0x03,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x81,
  0xFE, 0x0F, 0xF8, 0x3F, 0xE0, 0xFF, 0x83, 0xFC, 0x07, 0xE0, 0x0F, 0x00,
  0x00, 0x07, 0x00, 0x07, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x7F, 0xC0,
  0x1F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0,
  0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x0F,
  0xC0, 0x03, 0xF0, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0x1F, 0x00, 0x0F, 0x80,
  0x00, 0x00, 0x00, 0x00, 0x04, 0x00, 0x00, 0x00, 0x30, 0x00, 0x00, 0x03,
  0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x3F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xF0, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0x80, 0x00,
  0x07, 0xFF, 0xC0, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0x80, 0x00, 0x00,
  0x03, 0x00, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x03, 0xFF, 0xC0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x7F, 0xF8, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0x80, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0x20, 0x00, 0x00, 0x00, 0x00, 0x0E, 0x00,
  0x03, 0xFF, 0xE0, 0x1F, 0xFF, 0xF8, 0x7F, 0xFF, 0xFC, 0x7F, 0xFF, 0xFE,
  0x3F, 0xFF, 0xFE, 0x3F, 0x81, 0xFF, 0x1C, 0x00, 0xFF, 0x10, 0x00, 0x7F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0xFF, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xC0,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F,
  0xE0, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x7E, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07, 0xE0,
  0x01, 0xF0, 0x3F, 0x00, 0x1F, 0xFF, 0x80, 0xFC, 0x3F, 0x00, 0x3F, 0xFF,
  0xE0, 0x7E, 0x3F, 0x00, 0x7F, 0xFF, 0xF0, 0x1F, 0x1F, 0x80, 0x7F, 0xFF,
  0xF0, 0x0F, 0x8F, 0x80, 0x7F, 0x80, 0xF8, 0x07, 0xCF, 0xC0, 0x7F, 0x00,
  0xFC, 0x03, 0xE7, 0xC0, 0x3F, 0x00, 0x7E, 0x01, 0xF7, 0xE0, 0x3F, 0x00,
  0x3E, 0x00, 0xFB, 0xF0, 0x1F, 0x00, 0x1F, 0x00, 0x7D, 0xF0, 0x1F, 0x80,
  0x1F, 0x80, 0x3E, 0xF8, 0x0F, 0x80, 0x0F, 0xC0, 0x1F, 0x7C, 0x07, 0xC0,
  0x07, 0xC0, 0x1F, 0xFE, 0x07, 0xE0, 0x03, 0xE0, 0x0F, 0xBF, 0x03, 0xF0,
  0x03, 0xF0, 0x07, 0xDF, 0x81, 0xF8, 0x01, 0xF8, 0x07, 0xEF, 0xC0, 0xF8,
  0x01, 0xF8, 0x03, 0xF7, 0xE0, 0x7C, 0x00, 0xFC, 0x01, 0xF3, 0xF0, 0x3F,
  0x00, 0xFE, 0x01, 0xF9, 0xF8, 0x1F, 0x80, 0x7F, 0x01, 0xF8, 0xFC, 0x0F,
  0xC0, 0x7F, 0x81, 0xF8, 0x7E, 0x03, 0xF0, 0xFB, 0xE1, 0xFC, 0x1F, 0x01,
  0xFF, 0xF9, 0xFF, 0xFC, 0x0F, 0x80, 0x7F, 0xFC, 0xFF, 0xFC, 0x07, 0xE0,
  0x3F, 0xF8, 0x3F, 0xFC, 0x03, 0xF0, 0x07, 0xF8, 0x0F, 0xF8, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x02, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x0E, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x03,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x00,
  0x7F, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x3F, 0x87, 0xE0,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC1, 0xF8, 0x00, 0x00, 0xFC,
  0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x00, 0x7E, 0x03, 0xF0, 0x00,
  0x07, 0xF0, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xF8,
  0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x01,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00,
  0xFC, 0x0F, 0xF0, 0x00, 0x07, 0xE0, 0x7F, 0x00, 0x00, 0x3F, 0x07, 0xF0,
  0x00, 0x01, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x80, 0x01, 0xFF, 0xFF,
  0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0x80, 0x3F, 0x80, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0xFF, 0x00,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF0, 0x00, 0x3F,
  0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x1F, 0xC0, 0x7E, 0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80,
  0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07, 0xE0, 0x0F,
  0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x03, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFF, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F,
  0x83, 0xF0, 0x00, 0x0F, 0xE0, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x07, 0xFC, 0x0F, 0xC0,
  0x03, 0xFF, 0x03, 0xFF, 0xFF, 0xFF, 0xE0, 0x7F, 0xFF, 0xFF, 0xF8, 0x0F,
  0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFC, 0x1F,
  0xE0, 0x0F, 0xFC, 0x00, 0x1C, 0x01, 0xFF, 0x80, 0x00, 0x40, 0x3F, 0xE0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x03, 0x00, 0x1F, 0xFE, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x07,
  0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xFF,
  0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x0F, 0xE0, 0x07, 0xFE, 0x00, 0x3F,
  0x80, 0x07, 0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x0F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC,
  0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x1F,
  0xC0, 0x7E, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xE0,
  0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x00,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x3F, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00,
  0x1F, 0xE0, 0x7E, 0x00, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x07, 0xFC, 0x0F,
  0xE0, 0x00, 0x3F, 0xE0, 0x3F, 0x80, 0x03, 0xFF, 0x00, 0xFE, 0x00, 0x1F,
  0xF8, 0x03, 0xF0, 0x03, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xF0,
  0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x1F, 0xFF,
  0xFF, 0x80, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xE0, 0xFF, 0x80, 0x3F, 0xF8, 0x00,
  0x3C, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0xFF,
  0x1F, 0xC0, 0x03, 0xFF, 0xF8, 0x7F, 0x00, 0x0F, 0xFF, 0xE3, 0xFC, 0x00,
  0x3F, 0xFF, 0x8F, 0xF0, 0x00, 0xFF, 0xFE, 0x3F, 0x80, 0x07, 0xFF, 0xF8,
  0xFE, 0x00, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x00, 0x7E, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x1F, 0xE0, 0x00,
  0x0F, 0xE0, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0xFC, 0x03,
  0xFE, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xFF, 0x07,
  0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0x80, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x01, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00,
  0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF0,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC,
  0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0xFF, 0xFF,
  0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xFF, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xFF, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x0F, 0xE0, 0x00, 0x07,
  0xE0, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x00, 0x3F,
  0x80, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x0F,
  0xC0, 0x00, 0x07, 0xE0, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F,
  0xFF, 0xC0, 0x1F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFF, 0xE0, 0x0F, 0xFF, 0xF8, 0x03, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x7F, 0xFF, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0x00,
  0x01, 0xFE, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8,
  0x00, 0x7F, 0x00, 0x0F, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0xE0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0xFF,
  0x00, 0x00, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xFC, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x1F,
  0xE0, 0x00, 0x01, 0xF8, 0x3F, 0xC0, 0x00, 0x01, 0xF8, 0x7F, 0x80, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xF9,
  0xFE, 0x00, 0x00, 0x03, 0xF3, 0xFC, 0x00, 0x00, 0x07, 0xF7, 0xF8, 0x00,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFC, 0x00, 0x00, 0x07, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0xFE,
  0x00, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x00,
  0x0F, 0xC0, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x7E, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07,
  0xE0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xBF, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFF, 0xCF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x7F, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xFE,
  0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x00,
  0x3F, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x07, 0xEF, 0xC0, 0x0F, 0xFF, 0x00,
  0x00, 0x7E, 0xFC, 0x00, 0xF9, 0xF0, 0x00, 0x0F, 0xDF, 0xC0, 0x1F, 0x9F,
  0x00, 0x00, 0xFD, 0xFC, 0x01, 0xF9, 0xF0, 0x00, 0x1F, 0x9F, 0x80, 0x1F,
  0x9F, 0x00, 0x01, 0xF9, 0xF8, 0x01, 0xF9, 0xF8, 0x00, 0x3F, 0x1F, 0x80,
  0x3F, 0x9F, 0x80, 0x03, 0xF3, 0xF8, 0x03, 0xF1, 0xF8, 0x00, 0x7E, 0x3F,
  0x80, 0x3F, 0x1F, 0x80, 0x07, 0xE3, 0xF0, 0x03, 0xF1, 0xF8, 0x00, 0xFC,
  0x3F, 0x00, 0x3F, 0x0F, 0x80, 0x0F, 0xC7, 0xF0, 0x07, 0xF0, 0xF8, 0x01,
  0xF8, 0x7F, 0x00, 0x7E, 0x0F, 0x80, 0x1F, 0x07, 0xE0, 0x07, 0xE0, 0xF8,
  0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0x80, 0x7E, 0x07, 0xE0, 0x07, 0xE0,
  0xFC, 0x07, 0xE0, 0xFE, 0x00, 0xFE, 0x0F, 0xC0, 0xFC, 0x0F, 0xE0, 0x0F,
  0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x00, 0xFC, 0x0F, 0xC1, 0xF8, 0x0F, 0xC0,
  0x0F, 0xC0, 0xFC, 0x1F, 0x81, 0xFC, 0x00, 0xFC, 0x07, 0xC3, 0xF0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x7C, 0x3F, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xC7, 0xE0,
  0x1F, 0x80, 0x1F, 0x80, 0x7C, 0x7E, 0x01, 0xF8, 0x01, 0xF8, 0x07, 0xCF,
  0xC0, 0x3F, 0x80, 0x3F, 0x80, 0x7E, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x07,
  0xFF, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F, 0xF0, 0x03, 0xF0, 0x03, 0xF0,
  0x07, 0xFF, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7F, 0xE0, 0x07, 0xF0, 0x07,
  0xF0, 0x03, 0xFE, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x3F, 0xC0, 0x07, 0xF0,
  0x07, 0xE0, 0x03, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x80, 0x07,
  0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x3F, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x07, 0xFC, 0x00,
  0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x00, 0x07, 0xE0, 0x07, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x07, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x00, 0x00, 0xFC, 0x00,
  0xFF, 0xF0, 0x00, 0x0F, 0xC0, 0x0F, 0xFF, 0x80, 0x01, 0xFC, 0x00, 0xFB,
  0xF8, 0x00, 0x1F, 0xC0, 0x1F, 0x9F, 0x80, 0x01, 0xF8, 0x01, 0xF9, 0xFC,
  0x00, 0x1F, 0x80, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x01, 0xF8, 0xFC, 0x00,
  0x3F, 0x80, 0x3F, 0x8F, 0xE0, 0x03, 0xF8, 0x03, 0xF0, 0x7E, 0x00, 0x3F,
  0x00, 0x3F, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x00,
  0x3F, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x3F, 0x80, 0x7E, 0x00, 0x7F,
  0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x01,
  0xFC, 0x0F, 0xE0, 0x07, 0xE0, 0x1F, 0xC0, 0xFE, 0x00, 0xFE, 0x00, 0xFC,
  0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xE0, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x0F,
  0xC0, 0x0F, 0xC0, 0x07, 0xE1, 0xFC, 0x00, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x1F, 0xC0, 0x03, 0xF1, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x1F,
  0x80, 0x03, 0xF9, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x9F, 0x80, 0x3F, 0x80,
  0x01, 0xFF, 0xF8, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x00, 0x00,
  0xFF, 0xF0, 0x03, 0xF0, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0x00, 0x00, 0x7F,
  0xF0, 0x07, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x7F, 0xE0,
  0x07, 0xE0, 0x00, 0x03, 0xFE, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0xE0, 0x07,
  0xE0, 0x00, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x01, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xF0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0xC0, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFE, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0x80,
  0x07, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0x80, 0x3F,
  0xF0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0,
  0x03, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F,
  0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03, 0xF0,
  0x0F, 0xC0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x0F, 0xF0, 0x0F, 0xE0, 0x0F, 0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x03, 0xFF,
  0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xE0,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xF0, 0x7F, 0xF8, 0x00, 0xFF,
  0x80, 0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xFC, 0x03, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xFC, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00,
  0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x00, 0x00, 0x00,
  0xFF, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x7F,
  0x00, 0x00, 0x00, 0xFE, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0xFF, 0x00,
  0x00, 0x03, 0xF8, 0xFF, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0x1F, 0xE0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x00, 0x3F, 0xC0, 0x3F, 0xE0, 0x00,
  0xFF, 0x80, 0x1F, 0xF0, 0x01, 0xFF, 0x80, 0x1F, 0xFF, 0x0F, 0xFF, 0x00,
  0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xE0,
  0x0F, 0xF8, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x3F,
  0x80, 0x07, 0xF0, 0x0F, 0xC0, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x7F, 0x01,
  0xFC, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC,
  0x07, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0, 0xFE, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xF0, 0x07,
  0xFE, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF,
  0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF,
  0xFF, 0xF0, 0x00, 0x3F, 0x80, 0xFC, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x03,
  0xF0, 0x0F, 0xE0, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x07, 0xF0, 0x0F, 0xE0, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFF, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xF8,
  0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00,
  0x00, 0x03, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xE1, 0xFE,
  0x01, 0xFF, 0x00, 0x1C, 0x01, 0xFC, 0x00, 0x04, 0x03, 0xFC, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x80, 0x00, 0x3F, 0xC0, 0xE0, 0x00, 0x7F, 0xC0,
  0xFE, 0x03, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xC0, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFE,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00,
  0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F, 0x01, 0xFC, 0x00,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x7F, 0x00,
  0x00, 0x3F, 0x80, 0xFC, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x1F, 0xC0,
  0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x3F,
  0x81, 0xFC, 0x00, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x03, 0xF8, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x0F,
  0xE0, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x0F,
  0xE0, 0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03,
  0xFE, 0x00, 0x3F, 0xFC, 0x7F, 0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x00, 0x3F, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0x7F, 0x00, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x03, 0xF9, 0xFC,
  0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0x07, 0xF0,
  0x7E, 0x00, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0x3F, 0x81, 0xF8, 0x00, 0x07,
  0xF0, 0x3F, 0x00, 0x01, 0xFC, 0x07, 0xE0, 0x00, 0x3F, 0x80, 0xFE, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x0F, 0xE0, 0x07, 0xE0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0x80, 0x1F, 0xC0, 0x03, 0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x00,
  0xFC, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0x0F,
  0xC1, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00,
  0x07, 0xE1, 0xF8, 0x00, 0x00, 0xFC, 0x7F, 0x00, 0x00, 0x1F, 0x8F, 0xC0,
  0x00, 0x03, 0xF3, 0xF8, 0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x0F, 0xDF,
  0xC0, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03,
  0xFF, 0x80, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x1F, 0xE0,
  0x00, 0x3F, 0x9F, 0x80, 0x00, 0xFF, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x03,
  0xFE, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x1F, 0xF8, 0x00, 0x1F, 0xC7, 0xE0,
  0x00, 0x7F, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x01, 0xFF, 0x80, 0x03, 0xF8,
  0x7E, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x3F, 0xF8, 0x00,
  0x7F, 0x07, 0xE0, 0x01, 0xFF, 0xE0, 0x01, 0xFC, 0x1F, 0x80, 0x07, 0xDF,
  0x80, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x81, 0xF8, 0x00,
  0xFD, 0xF8, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xE3, 0xE0, 0x07, 0xF0, 0x1F,
  0x80, 0x1F, 0x8F, 0x80, 0x1F, 0x80, 0x7E, 0x00, 0xFC, 0x3E, 0x00, 0xFE,
  0x01, 0xF8, 0x03, 0xF0, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0xC3, 0xE0,
  0x1F, 0xC0, 0x1F, 0x80, 0x7E, 0x0F, 0x80, 0x7E, 0x00, 0x7E, 0x01, 0xF8,
  0x3E, 0x03, 0xF8, 0x01, 0xF8, 0x0F, 0xC0, 0xF8, 0x0F, 0xE0, 0x07, 0xF0,
  0x3F, 0x03, 0xE0, 0x3F, 0x00, 0x1F, 0xC1, 0xF8, 0x0F, 0xC1, 0xFC, 0x00,
  0x7F, 0x07, 0xE0, 0x3F, 0x07, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0xFC, 0x03, 0xF0, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x0F,
  0xC7, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x3F, 0x1F, 0x80, 0x00, 0xFC, 0xFC,
  0x00, 0xFC, 0x7E, 0x00, 0x03, 0xF3, 0xF0, 0x03, 0xF3, 0xF8, 0x00, 0x0F,
  0xCF, 0xC0, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x3F, 0x3F, 0x00,
  0x00, 0xFD, 0xF8, 0x00, 0xFD, 0xF8, 0x00, 0x03, 0xEF, 0xC0, 0x03, 0xF7,
  0xE0, 0x00, 0x0F, 0xBF, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x3E, 0xF8, 0x00,
  0x3F, 0xFC, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x00, 0x01, 0xFF, 0x80, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x7F, 0xC0,
  0x00, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x1F, 0xE0, 0x03, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x7F, 0x00,
  0x01, 0xFE, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00,
  0x00, 0x3F, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x00,
  0x7E, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x7F, 0x80, 0x00, 0x01, 0xFC,
  0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xE7, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00,
  0x03, 0xFB, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x3F, 0x00, 0x00, 0x00, 0x3F,
  0xC7, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x0F,
  0xC0, 0x00, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x3F, 0x80,
  0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00,
  0x3F, 0x80, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F,
  0x8F, 0xC0, 0x00, 0x3F, 0xC7, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0x1F, 0xC0, 0x7E, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x0F,
  0xE0, 0x1F, 0xC0, 0x0F, 0xE0, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x07,
  0xF0, 0x01, 0xF8, 0x07, 0xF0, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x3F, 0x03,
  0xF8, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFC, 0xFE, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x01,
  0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x7F,
  0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00,
  0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xE0,
  0x01, 0xFF, 0xF0, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F,
  0xFF, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xC0, 0x03,
  0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC, 0x07, 0xE0,
  0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3F, 0x03, 0xF0,
  0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF8, 0x1F, 0x81, 0xF8,
  0x1F, 0x81, 0xF8, 0x1F, 0x80, 0xFC, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xFC,
  0x0F, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E, 0x07, 0xE0, 0x7E,
  0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x3F, 0x03, 0xF0, 0x3F, 0x01, 0xF0, 0x00,
  0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x3F, 0xFE, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00,
  0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x07, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF,
  0xF8, 0x00, 0xFF, 0xF8, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xE0, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x1F, 0xFC, 0x00,
  0x00, 0x1F, 0x7C, 0x00, 0x00, 0x3F, 0x7E, 0x00, 0x00, 0x3E, 0x3E, 0x00,
  0x00, 0x7E, 0x3E, 0x00, 0x00, 0x7C, 0x1F, 0x00, 0x00, 0xFC, 0x1F, 0x00,
  0x00, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x0F, 0xC0,
  0x03, 0xF0, 0x07, 0xC0, 0x03, 0xE0, 0x07, 0xE0, 0x07, 0xE0, 0x03, 0xE0,
  0x07, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x03, 0xF0, 0x0F, 0x80, 0x01, 0xF0,
  0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x00, 0x00, 0xF8, 0x3F, 0x00, 0x00, 0xFC,
  0x3E, 0x00, 0x00, 0x7C, 0x7E, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x3F,
  0x7F, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFE, 0xFE, 0x0F, 0xE1, 0xFC, 0x1F, 0xC1, 0xF8, 0x1F, 0x03, 0xF0, 0x3F,
  0x03, 0xE0, 0x3C, 0x00, 0x00, 0x80, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0x00,
  0x7F, 0xFC, 0x3F, 0x00, 0xFF, 0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0x3E, 0x03,
  0xFF, 0xFF, 0x7E, 0x07, 0xFE, 0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F,
  0xF0, 0x03, 0xFE, 0x1F, 0xE0, 0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F,
  0xC0, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F,
  0x00, 0x01, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7E,
  0x00, 0x03, 0xF8, 0xFE, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x03, 0xF0, 0xFE,
  0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0xC0, 0x7F,
  0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xC0, 0x3F, 0xFF, 0xCF, 0xC0, 0x3F,
  0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0x0F, 0x80, 0x07, 0xFC, 0x0F, 0x80, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x02, 0x00, 0x01,
  0xF8, 0x3F, 0xE0, 0x03, 0xF8, 0xFF, 0xF0, 0x03, 0xF9, 0xFF, 0xF8, 0x03,
  0xF3, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFC, 0x03, 0xFF, 0xC1, 0xFE, 0x07,
  0xFF, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0xFE, 0x07, 0xFC, 0x00, 0x7F, 0x07,
  0xF8, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x0F, 0xC0, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0xFE, 0x1F,
  0x80, 0x00, 0xFE, 0x1F, 0x80, 0x00, 0xFE, 0x3F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x7F, 0x80, 0x07, 0xF8, 0x7F, 0xC0, 0x0F, 0xF0, 0x7F,
  0xC0, 0x1F, 0xE0, 0x7F, 0xF0, 0x7F, 0xE0, 0x7D, 0xFF, 0xFF, 0xC0, 0xFC,
  0xFF, 0xFF, 0x80, 0xFC, 0xFF, 0xFF, 0x00, 0xF8, 0x7F, 0xFC, 0x00, 0xF8,
  0x1F, 0xF8, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00, 0x00, 0x60, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC,
  0x07, 0xFF, 0xFF, 0x01, 0xFF, 0x80, 0xE0, 0x7F, 0xC0, 0x04, 0x0F, 0xF0,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0xC0, 0xFF, 0x80, 0x78,
  0x0F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0x80, 0x07, 0xFF, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x01, 0x00, 0x7E, 0x00, 0x07,
  0xFE, 0x0F, 0xC0, 0x03, 0xFF, 0xE3, 0xF8, 0x00, 0xFF, 0xFE, 0x7F, 0x00,
  0x3F, 0xFF, 0xEF, 0xC0, 0x0F, 0xFF, 0xFD, 0xF8, 0x03, 0xFE, 0x07, 0xFF,
  0x00, 0xFF, 0x80, 0x7F, 0xE0, 0x1F, 0xE0, 0x07, 0xFC, 0x07, 0xF8, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x01, 0xFC, 0x07, 0xF0,
  0x00, 0x3F, 0x80, 0xFE, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0xFC, 0x07,
  0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0x80, 0x00, 0xFE,
  0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x03, 0xF0, 0x1F, 0xC0, 0x00,
  0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x07, 0xF8, 0x07,
  0xF0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xE0, 0x1F, 0xE0, 0x1F, 0xF8,
  0x01, 0xFE, 0x0F, 0xFF, 0x00, 0x3F, 0xFF, 0xF7, 0xE0, 0x03, 0xFF, 0xFC,
  0xFC, 0x00, 0x7F, 0xFF, 0x1F, 0x00, 0x07, 0xFF, 0xC3, 0xE0, 0x00, 0x3F,
  0xE0, 0x7C, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x60, 0x00,
  0x00, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFF, 0xFE, 0x07, 0xFC, 0x0F, 0xE0, 0x7F, 0x00, 0x7F,
  0x0F, 0xE0, 0x07, 0xF1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0, 0x07, 0xF3, 0xF8,
  0x00, 0x7E, 0x3F, 0x80, 0x0F, 0xE7, 0xF0, 0x01, 0xFE, 0x7F, 0x00, 0x7F,
  0xC7, 0xF0, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0, 0xFF,
  0xFF, 0xF8, 0x0F, 0xFF, 0xFC, 0x00, 0xFF, 0xE0, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80,
  0x02, 0x07, 0xFC, 0x01, 0xE0, 0x3F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0,
  0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x01,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x07, 0xFF, 0xE0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0x0C, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00,
  0x3F, 0xFF, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0C, 0xFF, 0xC0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x01, 0xFF, 0x81, 0xF0, 0x01, 0xFF, 0xF0, 0xFC, 0x00,
  0xFF, 0xFE, 0x3F, 0x00, 0x7F, 0xFF, 0xCF, 0x80, 0x3F, 0xFF, 0xF7, 0xE0,
  0x1F, 0xF8, 0x3F, 0xF8, 0x0F, 0xF8, 0x07, 0xFE, 0x03, 0xFC, 0x00, 0xFF,
  0x81, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00, 0x07, 0xF0, 0x3F, 0xC0, 0x01,
  0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0xFE, 0x07, 0xF0,
  0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x03, 0xF0, 0x3F,
  0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0xC0,
  0xFE, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x07, 0xF8, 0x0F, 0xE0, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0xFF, 0x80, 0xFE, 0x00, 0x7F, 0xE0, 0x3F, 0xC0, 0x3F,
  0xF0, 0x07, 0xF8, 0x3F, 0xFC, 0x01, 0xFF, 0xFF, 0xBF, 0x00, 0x3F, 0xFF,
  0xDF, 0xC0, 0x0F, 0xFF, 0xE7, 0xE0, 0x01, 0xFF, 0xE1, 0xF8, 0x00, 0x1F,
  0xF0, 0x7E, 0x00, 0x00, 0x60, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x08, 0x00, 0x07, 0xF8,
  0x03, 0xC0, 0x03, 0xFC, 0x00, 0xFF, 0x0F, 0xFE, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x0F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x01,
  0xF8, 0x02, 0x00, 0x01, 0xF8, 0x3F, 0xF0, 0x03, 0xF8, 0xFF, 0xF8, 0x03,
  0xF9, 0xFF, 0xFC, 0x03, 0xF3, 0xFF, 0xFC, 0x03, 0xF7, 0xFF, 0xFE, 0x03,
  0xFF, 0xC1, 0xFE, 0x07, 0xFF, 0x00, 0xFE, 0x07, 0xFE, 0x00, 0x7E, 0x07,
  0xFC, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x7E, 0x07, 0xF8, 0x00, 0x7E, 0x0F,
  0xF0, 0x00, 0x7E, 0x0F, 0xF0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x00, 0xFC, 0x1F,
  0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x07, 0xF0, 0x7E,
  0x00, 0x07, 0xE0, 0xFE, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE,
  0x00, 0x0F, 0xE0, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x1C, 0x00, 0x7E, 0x00,
  0x7F, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0xFF, 0x00, 0x7E, 0x00, 0x38, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x07, 0xF0, 0x07,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F,
  0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x00, 0x7F,
  0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F,
  0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x38, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0xC7, 0xFC, 0x00, 0x3F, 0xFE,
  0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0xFF, 0xC0, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x07, 0xE0, 0x01, 0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x01, 0xFC, 0x00, 0x7E, 0x01,
  0xFC, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x07, 0xF1,
  0xFC, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0xFD,
  0xFC, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x0F, 0xFB, 0xF8, 0x00, 0x0F,
  0xF8, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x01,
  0xF8, 0x0F, 0xE0, 0x00, 0xFC, 0x07, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x1F, 0xC0,
  0x1F, 0xC0, 0x07, 0xF0, 0x0F, 0xE0, 0x03, 0xF8, 0x07, 0xF0, 0x01, 0xFE,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x00, 0x3F, 0x00,
  0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00,
  0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01, 0xFC, 0x01,
  0xFC, 0x01, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF8, 0x03, 0xF0, 0x03,
  0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x0F,
  0xE0, 0x0F, 0xE0, 0x0F, 0xE0, 0x0F, 0xC0, 0x1F, 0xC0, 0x1F, 0xC0, 0x1F,
  0xC0, 0x1F, 0xC0, 0x1F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F, 0x80, 0x3F,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0xFE,
  0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x02,
  0x00, 0x00, 0x60, 0x00, 0x7C, 0x0F, 0xF8, 0x01, 0xFF, 0x80, 0x3F, 0x0F,
  0xFF, 0x00, 0xFF, 0xF0, 0x0F, 0xC7, 0xFF, 0xE0, 0xFF, 0xFE, 0x03, 0xF3,
  0xFF, 0xF8, 0x7F, 0xFF, 0x80, 0xFD, 0xFF, 0xFF, 0x3F, 0xFF, 0xF0, 0x3F,
  0xFC, 0x1F, 0xDF, 0x83, 0xFC, 0x1F, 0xFC, 0x07, 0xF7, 0xC0, 0x7F, 0x07,
  0xFE, 0x00, 0xFF, 0xC0, 0x1F, 0xC1, 0xFF, 0x00, 0x3F, 0xE0, 0x03, 0xF0,
  0x7F, 0x80, 0x0F, 0xF8, 0x00, 0xFC, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x3F,
  0x0F, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x3F, 0x80, 0x07,
  0xF0, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x07, 0xF0, 0x00,
  0x7E, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x00,
  0x0F, 0xE1, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0,
  0x00, 0xFE, 0x1F, 0x80, 0x03, 0xF8, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0xFE,
  0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F,
  0xC0, 0x01, 0xFC, 0x3F, 0x00, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01,
  0xFC, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x7F, 0x00, 0x0F, 0xE1, 0xFC, 0x00,
  0x1F, 0x80, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x1F, 0x80,
  0x03, 0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x0F, 0xC3, 0xF8,
  0x00, 0x3F, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x3F,
  0x80, 0x07, 0xF0, 0x00, 0x7F, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x03, 0xC0, 0x00, 0x7C, 0x0F, 0xFC, 0x00, 0x7E, 0x1F, 0xFF,
  0x00, 0x3F, 0x1F, 0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0xF0, 0x0F, 0xDF, 0xFF,
  0xF8, 0x0F, 0xFF, 0x83, 0xFC, 0x07, 0xFF, 0x80, 0xFF, 0x03, 0xFF, 0x00,
  0x7F, 0x81, 0xFF, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x0F, 0xE0, 0xFF, 0x80,
  0x07, 0xF0, 0x7F, 0x80, 0x07, 0xF0, 0x3F, 0xC0, 0x03, 0xF8, 0x1F, 0xC0,
  0x01, 0xFC, 0x0F, 0xE0, 0x00, 0xFE, 0x0F, 0xF0, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x3F,
  0x80, 0x03, 0xF8, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xE0,
  0x7F, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x80, 0x7F, 0x83, 0xF8, 0x00, 0xFE, 0x1F, 0xE0, 0x01, 0xF8, 0x7F,
  0x00, 0x07, 0xF3, 0xF8, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x7F, 0x7F, 0x00,
  0x01, 0xFD, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xDF, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x1F,
  0xBF, 0x80, 0x00, 0xFE, 0xFE, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x0F, 0xEF,
  0xE0, 0x00, 0x7F, 0x3F, 0x80, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xE3, 0xF8,
  0x00, 0x3F, 0x87, 0xF0, 0x01, 0xFC, 0x1F, 0xE0, 0x0F, 0xF0, 0x3F, 0xC0,
  0xFF, 0x80, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF,
  0x00, 0x07, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x80, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01, 0xF0, 0x3F, 0xE0, 0x00, 0x3F,
  0x0F, 0xFF, 0x00, 0x03, 0xF1, 0xFF, 0xF8, 0x00, 0x3F, 0x3F, 0xFF, 0xC0,
  0x03, 0xF7, 0xFF, 0xFC, 0x00, 0x3E, 0xFC, 0x1F, 0xE0, 0x07, 0xFF, 0x00,
  0xFE, 0x00, 0x7F, 0xE0, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x7F,
  0x80, 0x07, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x00, 0xFF, 0x00, 0x07, 0xF0,
  0x0F, 0xE0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x0F, 0xC0, 0x00,
  0x7F, 0x00, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0x1F, 0x80, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x01,
  0xFC, 0x03, 0xF8, 0x00, 0x3F, 0x80, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xF8,
  0x00, 0x7F, 0x80, 0x7F, 0xC0, 0x0F, 0xF0, 0x07, 0xFC, 0x01, 0xFE, 0x00,
  0x7F, 0xF0, 0x7F, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0xFF, 0xFF,
  0x80, 0x0F, 0xE7, 0xFF, 0xF0, 0x00, 0xFC, 0x3F, 0xFE, 0x00, 0x0F, 0xC1,
  0xFF, 0x80, 0x01, 0xFC, 0x03, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x80, 0x00, 0x00, 0x1F, 0xF8, 0x1F, 0x00, 0x7F, 0xFC, 0x1F, 0x00, 0xFF,
  0xFE, 0x3F, 0x01, 0xFF, 0xFF, 0x3E, 0x03, 0xFF, 0xFF, 0xFE, 0x07, 0xFC,
  0x0F, 0xFE, 0x0F, 0xF8, 0x07, 0xFE, 0x0F, 0xF0, 0x03, 0xFE, 0x1F, 0xE0,
  0x03, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0x80,
  0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFC, 0x7F, 0x00, 0x01, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x07, 0xF0, 0xFE, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x3F, 0xE0, 0xFE, 0x00,
  0x7F, 0xE0, 0xFF, 0x00, 0xFF, 0xC0, 0x7F, 0x83, 0xFF, 0xC0, 0x7F, 0xFF,
  0xEF, 0xC0, 0x3F, 0xFF, 0xDF, 0xC0, 0x3F, 0xFF, 0x9F, 0x80, 0x1F, 0xFE,
  0x1F, 0x80, 0x07, 0xFC, 0x1F, 0x80, 0x01, 0xC0, 0x3F, 0x80, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0x40, 0x7C, 0x0F,
  0xE0, 0x3F, 0x0F, 0xF8, 0x0F, 0xC7, 0xFE, 0x03, 0xF3, 0xFF, 0x80, 0xFD,
  0xFF, 0xE0, 0x3F, 0xFF, 0xF0, 0x1F, 0xFE, 0x00, 0x07, 0xFF, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x0F, 0xF0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x81, 0xFE, 0x01, 0xE0,
  0x3F, 0x80, 0x04, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x1F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x1F, 0xFE,
  0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x07, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x0C, 0x00,
  0x0F, 0xE1, 0xF0, 0x07, 0xFC, 0x3F, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFC, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x1F, 0x00, 0x01, 0xF8,
  0x00, 0x0F, 0x80, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x7F, 0x00, 0x0F,
  0xFF, 0xF9, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF,
  0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F,
  0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x7F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x00, 0x0F,
  0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0xFE, 0x00,
  0x07, 0xF0, 0x20, 0x3F, 0xFF, 0x01, 0xFF, 0xF8, 0x07, 0xFF, 0xC0, 0x3F,
  0xFE, 0x00, 0x7F, 0xF0, 0x00, 0x30, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x07,
  0xF0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0xFE, 0x0F, 0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x01, 0xFC, 0x1F,
  0x80, 0x01, 0xF8, 0x3F, 0x80, 0x01, 0xF8, 0x3F, 0x80, 0x03, 0xF8, 0x3F,
  0x80, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7E,
  0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0xFE,
  0x00, 0x3F, 0xE0, 0xFE, 0x00, 0x7F, 0xE0, 0x7F, 0x00, 0xFF, 0xE0, 0x7F,
  0x83, 0xFF, 0xC0, 0x7F, 0xFF, 0xEF, 0xC0, 0x7F, 0xFF, 0xCF, 0xC0, 0x3F,
  0xFF, 0x8F, 0xC0, 0x1F, 0xFF, 0x0F, 0x80, 0x0F, 0xFC, 0x0F, 0x80, 0x00,
  0xC0, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x3F, 0xBF, 0x80, 0x00, 0xFE, 0x7E, 0x00, 0x07, 0xF1, 0xF8, 0x00,
  0x3F, 0xC7, 0xE0, 0x00, 0xFE, 0x1F, 0x80, 0x07, 0xF0, 0x7E, 0x00, 0x1F,
  0xC1, 0xFC, 0x00, 0xFE, 0x07, 0xF0, 0x03, 0xF8, 0x1F, 0xC0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x0F,
  0xC0, 0x7F, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0,
  0x3F, 0x80, 0x0F, 0xC1, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x00, 0x7E, 0x3F,
  0x80, 0x01, 0xF8, 0xFC, 0x00, 0x07, 0xE7, 0xF0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x7E, 0xFE, 0x00, 0x01, 0xFB, 0xF0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFE, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0xFC,
  0x00, 0x3F, 0xC0, 0x03, 0xFF, 0xE0, 0x01, 0xFE, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xF0, 0x01, 0xFD, 0xF8, 0x00, 0xFF, 0x80, 0x0F, 0xEF, 0xC0, 0x07,
  0xFC, 0x00, 0xFE, 0x7E, 0x00, 0x7F, 0xE0, 0x07, 0xF3, 0xF0, 0x03, 0xFF,
  0x00, 0x3F, 0x1F, 0x80, 0x3E, 0xF8, 0x03, 0xF8, 0xFC, 0x01, 0xF7, 0xC0,
  0x1F, 0x87, 0xE0, 0x1F, 0xBE, 0x01, 0xFC, 0x3F, 0x00, 0xF9, 0xF0, 0x0F,
  0xE1, 0xF8, 0x0F, 0xCF, 0x80, 0xFE, 0x0F, 0xC0, 0x7C, 0x7C, 0x07, 0xF0,
  0x7E, 0x07, 0xE3, 0xE0, 0x7F, 0x03, 0xF0, 0x3F, 0x1F, 0x03, 0xF8, 0x1F,
  0x81, 0xF0, 0xF8, 0x1F, 0x80, 0xFC, 0x1F, 0x87, 0xE1, 0xFC, 0x07, 0xE0,
  0xF8, 0x3F, 0x0F, 0xC0, 0x3F, 0x0F, 0xC1, 0xF8, 0xFE, 0x01, 0xF8, 0x7C,
  0x0F, 0xC7, 0xE0, 0x07, 0xC7, 0xE0, 0x7E, 0x3F, 0x00, 0x3E, 0x3E, 0x03,
  0xF3, 0xF0, 0x01, 0xF3, 0xF0, 0x1F, 0x9F, 0x80, 0x0F, 0x9F, 0x00, 0xFD,
  0xF8, 0x00, 0x7C, 0xF8, 0x07, 0xEF, 0xC0, 0x03, 0xEF, 0xC0, 0x1F, 0x7E,
  0x00, 0x1F, 0x7C, 0x00, 0xFF, 0xE0, 0x00, 0xFB, 0xE0, 0x07, 0xFF, 0x00,
  0x07, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x01,
  0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x03, 0xFC, 0x00, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xF8, 0x03, 0xF0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07,
  0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0x3F, 0x80, 0x00, 0x7E, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x03, 0xF9,
  0xFC, 0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0xFE, 0xFE, 0x00, 0x00, 0x0F, 0xE3,
  0xF0, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7E, 0x00, 0x00,
  0x7F, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x7F,
  0x00, 0x07, 0xF8, 0x03, 0xF8, 0x00, 0x7F, 0x80, 0x0F, 0xC0, 0x03, 0xF8,
  0x00, 0x7F, 0x00, 0x3F, 0x80, 0x03, 0xF8, 0x07, 0xFC, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xFE, 0x00, 0x1F, 0x80, 0x03, 0xF8, 0x00,
  0x3F, 0x80, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x00, 0xFC, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x03, 0xF8, 0x00,
  0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00, 0x0F, 0xC0,
  0x3F, 0x80, 0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x81, 0xFC, 0x00,
  0x00, 0x3F, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x00, 0xFC,
  0x3F, 0x80, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x00, 0x03, 0xF1, 0xFC, 0x00,
  0x00, 0x07, 0xE3, 0xF0, 0x00, 0x00, 0x07, 0xCF, 0xE0, 0x00, 0x00, 0x0F,
  0x9F, 0x80, 0x00, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00,
  0x00, 0x00, 0x7D, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x04, 0x3F, 0xF0, 0x00, 0x00, 0x0F,
  0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0xF0, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0xFF,
  0x81, 0xFF, 0xFF, 0xFC, 0x1F, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFE, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00,
  0x1F, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0xFF, 0xC0, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xE0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03,
  0xF8, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x07, 0xE0, 0x00,
  0x1F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x3F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x07, 0xF0,
  0x00, 0x07, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x0F, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x04, 0x7F, 0xF0, 0x00, 0x17, 0xFF, 0xF0, 0x01, 0xFF, 0xFF,
  0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xB0, 0x00, 0x7F, 0xFC, 0x80, 0x00, 0x7F, 0xC0,
};

const GFXglyph NotoSans_MediumItalic63pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 16, 0, -1 },
  { 1, 17, 46, 17, 1, -45 },
  { 99, 20, 16, 26, 7, -45 },
  { 139, 39, 45, 41, 2, -45 },
  { 359, 31, 52, 35, 2, -48 },
  { 561, 44, 47, 51, 5, -46 },
  { 820, 40, 47, 43, 2, -46 },
  { 1055, 9, 16, 14, 7, -45 },
  { 1073, 22, 55, 19, 2, -45 },
  { 1225, 22, 55, 19, -5, -45 },
  { 1377, 30, 29, 35, 6, -48 },
  { 1486, 30, 30, 36, 4, -37 },
  { 1599, 14, 15, 17, -3, -7 },
  { 1626, 17, 6, 20, 1, -20 },
  { 1639, 9, 9, 17, 1, -8 },
  { 1650, 32, 45, 24, -3, -45 },
  { 1830, 31, 47, 35, 3, -46 },
  { 2013, 21, 45, 35, 8, -45 },
  { 2132, 33, 46, 35, 0, -46 },
  { 2322, 32, 47, 35, 1, -46 },
  { 2510, 34, 45, 35, 0, -45 },
  { 2702, 32, 46, 35, 2, -45 },
  { 2886, 31, 47, 35, 4, -46 },
  { 3069, 32, 45, 35, 4, -45 },
  { 3249, 31, 47, 35, 3, -46 },
  { 3432, 30, 47, 35, 3, -46 },
  { 3609, 14, 36, 17, 1, -35 },
  { 3672, 18, 43, 17, -3, -35 },
  { 3769, 30, 32, 36, 4, -39 },
  { 3889, 30, 18, 36, 4, -31 },
  { 3957, 30, 32, 36, 4, -39 },
  { 4077, 24, 47, 28, 5, -46 },
  { 4218, 49, 51, 54, 3, -45 },
  { 4531, 37, 45, 37, -4, -45 },
  { 4740, 35, 45, 38, 2, -45 },
  { 4937, 36, 47, 37, 4, -46 },
  { 5149, 38, 45, 42, 2, -45 },
  { 5363, 33, 45, 33, 2, -45 },
  { 5549, 33, 45, 31, 2, -45 },
  { 5735, 38, 47, 43, 4, -46 },
  { 5959, 41, 45, 43, 2, -45 },
  { 6190, 26, 45, 21, -1, -45 },
  { 6337, 29, 57, 18, -10, -45 },
  { 6544, 40, 45, 36, 2, -45 },
  { 6769, 25, 45, 31, 2, -45 },
  { 6910, 52, 45, 54, 2, -45 },
  { 7203, 44, 45, 45, 2, -45 },
  { 7451, 40, 47, 46, 4, -46 },
  { 7686, 35, 45, 37, 2, -45 },
  { 7883, 40, 57, 46, 4, -46 },
  { 8168, 34, 45, 37, 2, -45 },
  { 8360, 32, 47, 32, 1, -46 },
  { 8548, 32, 45, 32, 5, -45 },
  { 8728, 39, 46, 43, 5, -45 },
  { 8953, 35, 45, 35, 6, -45 },
  { 9150, 54, 45, 55, 6, -45 },
  { 9454, 43, 45, 35, -3, -45 },
  { 9696, 33, 45, 33, 6, -45 },
  { 9882, 37, 45, 34, -1, -45 },
  { 10091, 25, 55, 19, -1, -45 },
  { 10263, 12, 45, 24, 7, -45 },
  { 10331, 24, 55, 19, -4, -45 },
  { 10496, 32, 28, 36, 2, -45 },
  { 10608, 26, 4, 25, -6, 6 },
  { 10621, 11, 10, 18, 9, -48 },
  { 10635, 32, 36, 36, 3, -35 },
  { 10779, 32, 49, 37, 2, -48 },
  { 10975, 27, 36, 29, 3, -35 },
  { 11097, 35, 49, 37, 3, -48 },
  { 11312, 28, 36, 33, 3, -35 },
  { 11438, 36, 63, 21, -7, -48 },
  { 11722, 34, 50, 37, 1, -35 },
  { 11935, 32, 48, 37, 2, -48 },
  { 12127, 16, 47, 17, 2, -47 },
  { 12221, 26, 62, 17, -8, -47 },
  { 12423, 33, 48, 33, 2, -48 },
  { 12621, 16, 48, 17, 2, -48 },
  { 12717, 50, 35, 56, 2, -35 },
  { 12936, 33, 35, 37, 1, -35 },
  { 13081, 30, 35, 36, 3, -34 },
  { 13213, 36, 50, 37, -2, -35 },
  { 13438, 32, 50, 37, 3, -35 },
  { 13638, 26, 35, 26, 2, -35 },
  { 13752, 27, 36, 28, 0, -35 },
  { 13874, 21, 43, 22, 3, -42 },
  { 13987, 32, 35, 37, 3, -34 },
  { 14127, 30, 34, 30, 3, -34 },
  { 14255, 45, 34, 47, 4, -34 },
  { 14447, 37, 34, 31, -3, -34 },
  { 14605, 39, 49, 30, -5, -34 },
  { 14844, 29, 34, 28, -1, -34 },
  { 14968, 26, 55, 22, 0, -45 },
  { 15147, 5, 63, 35, 16, -48 },
  { 15187, 25, 55, 22, -3, -45 },
  { 15359, 30, 9, 36, 4, -27 },
};

const GFXfont NotoSans_MediumItalic63pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic63pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic63pt7bGlyphs,
  0x20, 0x7E, 86
};

#endif // _NOTOSANS_MEDIUMITALIC63PT7B_H_
