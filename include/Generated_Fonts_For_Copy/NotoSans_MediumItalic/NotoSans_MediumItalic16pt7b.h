#ifndef _NOTOSANS_MEDIUMITALIC16PT7B_H_
#define _NOTOSANS_MEDIUMITALIC16PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 16pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic16pt7bBitmaps[] PROGMEM = {
  0x00, 0x39, 0x8C, 0x62, 0x11, 0x8C, 0x07, 0x30, 0xDC, 0xA5, 0x20, 0x0C,
  0x82, 0x20, 0x99, 0xFF, 0x19, 0x04, 0xC7, 0xFF, 0xFE, 0x22, 0x09, 0x86,
  0x40, 0x06, 0x07, 0xCF, 0xC4, 0x82, 0x41, 0xC0, 0x38, 0x16, 0x0B, 0x4F,
  0x3F, 0x02, 0x01, 0x00, 0x10, 0x2F, 0x09, 0x22, 0x64, 0xCC, 0xB1, 0xB5,
  0xFD, 0x6B, 0x69, 0x1B, 0x22, 0x64, 0x8D, 0xB0, 0xE0, 0x0C, 0x0F, 0x83,
  0x30, 0x88, 0x36, 0x0E, 0x07, 0x8F, 0x36, 0x8D, 0x21, 0xCC, 0xF3, 0xE6,
  0xEA, 0x19, 0x98, 0x8C, 0x62, 0x10, 0x84, 0x21, 0x0C, 0x20, 0x18, 0xC2,
  0x10, 0x84, 0x63, 0x18, 0x8C, 0xC4, 0x40, 0x19, 0x23, 0x41, 0xF7, 0x1B,
  0x12, 0x00, 0x10, 0x10, 0x10, 0x10, 0xFF, 0x10, 0x10, 0x10, 0x36, 0x6C,
  0xF8, 0xF8, 0x03, 0x02, 0x06, 0x0C, 0x0C, 0x18, 0x10, 0x30, 0x20, 0x60,
  0xC0, 0x0C, 0x3E, 0x62, 0x63, 0xC3, 0xC3, 0xC2, 0xC6, 0xC6, 0xC4, 0xCC,
  0x78, 0x3B, 0xF6, 0x21, 0x18, 0xC6, 0x23, 0x18, 0x04, 0x3F, 0x21, 0x01,
  0x03, 0x03, 0x06, 0x0C, 0x18, 0x70, 0xFE, 0xFE, 0x0C, 0x3F, 0x21, 0x01,
  0x03, 0x1E, 0x1C, 0x02, 0x03, 0x03, 0xC6, 0xFC, 0x03, 0x03, 0x83, 0xC3,
  0x63, 0x21, 0x11, 0x19, 0xFF, 0x06, 0x02, 0x03, 0x00, 0x1F, 0x88, 0x0C,
  0x06, 0x03, 0xE1, 0x38, 0x0C, 0x06, 0x03, 0x63, 0x3F, 0x00, 0x06, 0x1F,
  0x30, 0x60, 0x40, 0xFC, 0xE6, 0xC6, 0xC6, 0xC6, 0xCC, 0x78, 0x7F, 0x02,
  0x06, 0x04, 0x0C, 0x18, 0x18, 0x30, 0x20, 0x60, 0xC0, 0x0C, 0x3E, 0x63,
  0x63, 0x66, 0x3C, 0x7C, 0xC6, 0x86, 0x86, 0xCC, 0x7C, 0x18, 0x7D, 0x9E,
  0x1C, 0x38, 0xDF, 0x9B, 0x06, 0x1A, 0x67, 0x80, 0x33, 0x00, 0x00, 0x0E,
  0xC0, 0x18, 0xC0, 0x00, 0x00, 0x06, 0x62, 0x30, 0x01, 0x07, 0x1C, 0x70,
  0xC0, 0x78, 0x0E, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0xE0, 0x38,
  0x0E, 0x03, 0x1C, 0x70, 0xC0, 0x13, 0xF4, 0x41, 0x0C, 0x63, 0x18, 0x40,
  0x0C, 0x30, 0x0F, 0xC3, 0x02, 0x60, 0x14, 0xF9, 0xC9, 0x99, 0x19, 0x91,
  0x19, 0x33, 0x9F, 0xEC, 0x00, 0x60, 0x03, 0xF8, 0x03, 0x03, 0x81, 0x41,
  0xB0, 0x98, 0xCC, 0xFE, 0x7F, 0x60, 0xB0, 0x70, 0x20, 0x3F, 0x11, 0x98,
  0x6C, 0x67, 0xE3, 0xF1, 0x0D, 0x86, 0xC3, 0x67, 0x3F, 0x00, 0x06, 0x0F,
  0xCC, 0x2C, 0x06, 0x06, 0x03, 0x01, 0x80, 0xC0, 0x60, 0x18, 0x87, 0xC0,
  0x3F, 0x11, 0xD8, 0x6C, 0x36, 0x1A, 0x0D, 0x07, 0x83, 0xC3, 0x6F, 0x3E,
  0x00, 0x3F, 0x20, 0x60, 0x60, 0x7E, 0x7C, 0x40, 0xC0, 0xC0, 0xC0, 0xFC,
  0x3F, 0x20, 0x60, 0x60, 0x60, 0x7E, 0x40, 0xC0, 0xC0, 0xC0, 0x80, 0x07,
  0x07, 0xF3, 0x09, 0x80, 0x60, 0x30, 0x0C, 0x7B, 0x06, 0xC1, 0xB0, 0x47,
  0x30, 0xFC, 0x30, 0xC8, 0x36, 0x09, 0x82, 0x7F, 0x9F, 0xE4, 0x1B, 0x04,
  0xC3, 0x30, 0xC8, 0x30, 0x3C, 0x61, 0x04, 0x30, 0xC3, 0x08, 0x61, 0x8F,
  0x00, 0x03, 0x02, 0x06, 0x06, 0x06, 0x06, 0x04, 0x0C, 0x0C, 0x0C, 0x08,
  0x18, 0xB8, 0xF0, 0x31, 0xC8, 0xC6, 0x61, 0xB0, 0x78, 0x1E, 0x04, 0xC3,
  0x30, 0xC4, 0x31, 0x88, 0x60, 0x30, 0x86, 0x18, 0x61, 0x04, 0x30, 0xC3,
  0x0F, 0xC0, 0x30, 0x39, 0xC3, 0x9E, 0x1C, 0xF1, 0xE7, 0x8B, 0x24, 0xD1,
  0x24, 0x99, 0x4C, 0xCE, 0x64, 0x63, 0x23, 0x10, 0x30, 0x67, 0x09, 0xE3,
  0x34, 0x66, 0xCC, 0x99, 0x11, 0x26, 0x3C, 0xC7, 0x90, 0x72, 0x0C, 0x00,
  0x06, 0x07, 0xE3, 0x1D, 0x83, 0x40, 0xF0, 0x3C, 0x0F, 0x03, 0xC1, 0xB0,
  0x66, 0x70, 0xF8, 0x3F, 0x23, 0x61, 0x63, 0x63, 0x7E, 0x78, 0xC0, 0xC0,
  0xC0, 0x80, 0x06, 0x07, 0xE3, 0x1D, 0x83, 0x40, 0xF0, 0x3C, 0x0F, 0x03,
  0xC0, 0xB0, 0x66, 0x70, 0xF8, 0x06, 0x01, 0x80, 0x30, 0x3F, 0x23, 0x63,
  0x63, 0x63, 0x7E, 0x4C, 0xCC, 0xC4, 0xC6, 0x86, 0x06, 0x1F, 0x31, 0x20,
  0x30, 0x38, 0x1C, 0x06, 0x06, 0x06, 0xCE, 0xFC, 0xFF, 0x18, 0x18, 0x18,
  0x10, 0x30, 0x30, 0x30, 0x30, 0x20, 0x60, 0x30, 0xD8, 0x36, 0x09, 0x82,
  0x61, 0x90, 0x6C, 0x1B, 0x04, 0xC3, 0x19, 0xC7, 0xC0, 0xC1, 0xA0, 0x90,
  0xC8, 0x46, 0x63, 0x21, 0xB0, 0xD0, 0x78, 0x38, 0x0C, 0x00, 0x86, 0x1C,
  0x30, 0xA3, 0x8D, 0x14, 0x69, 0xA6, 0x49, 0xB2, 0xCD, 0x16, 0x78, 0xA3,
  0x87, 0x1C, 0x30, 0xC0, 0x18, 0xE3, 0x18, 0x36, 0x07, 0x80, 0x60, 0x1C,
  0x02, 0x80, 0xD8, 0x33, 0x0C, 0x23, 0x06, 0x00, 0xC3, 0xB1, 0x99, 0x8D,
  0x82, 0xC1, 0xC0, 0xC0, 0x60, 0x30, 0x10, 0x18, 0x00, 0x3F, 0x81, 0x80,
  0xC0, 0xC0, 0xC0, 0xC0, 0x60, 0x60, 0x60, 0x60, 0x3F, 0x80, 0x1C, 0xC3,
  0x08, 0x20, 0x86, 0x18, 0x41, 0x0C, 0x30, 0xE3, 0x80, 0x9B, 0x6C, 0x92,
  0x6D, 0x80, 0x1C, 0x30, 0x82, 0x08, 0x61, 0x84, 0x10, 0xC3, 0x0C, 0xE3,
  0x80, 0x10, 0x18, 0x38, 0x2C, 0x64, 0x44, 0xC2, 0x83, 0xFF, 0xF0, 0xCC,
  0x19, 0x7F, 0x66, 0xC2, 0xC6, 0xC6, 0xC6, 0xCC, 0xF4, 0x18, 0x08, 0x0C,
  0x06, 0xC3, 0xF1, 0x8C, 0x86, 0xC2, 0x61, 0x31, 0x99, 0x9B, 0x80, 0x1E,
  0xF9, 0x86, 0x0C, 0x10, 0x30, 0x64, 0x78, 0x01, 0x80, 0x80, 0xC3, 0x67,
  0xF3, 0x33, 0x09, 0x8C, 0x86, 0x43, 0x33, 0x1E, 0x80, 0x1C, 0xFD, 0x1E,
  0x3F, 0xD0, 0x30, 0x62, 0x7C, 0x03, 0x83, 0x01, 0x01, 0xE1, 0xF0, 0x60,
  0x30, 0x10, 0x18, 0x0C, 0x06, 0x02, 0x01, 0x01, 0x83, 0xC1, 0xC0, 0x0C,
  0x9F, 0xCC, 0xCC, 0x26, 0x33, 0x19, 0x8C, 0xCC, 0x7A, 0x03, 0x01, 0x9F,
  0x87, 0x80, 0x18, 0x08, 0x0C, 0x06, 0xE3, 0xF1, 0x8C, 0x84, 0xC2, 0x63,
  0x31, 0x90, 0xD8, 0x40, 0x18, 0x80, 0x63, 0x10, 0x8C, 0x63, 0x11, 0x80,
  0x06, 0x08, 0x00, 0x60, 0xC1, 0x02, 0x0C, 0x18, 0x30, 0x40, 0x83, 0x06,
  0x38, 0x60, 0x18, 0x08, 0x0C, 0x06, 0x33, 0x31, 0x30, 0xB0, 0xF0, 0x6C,
  0x36, 0x11, 0x98, 0xC0, 0x18, 0x8C, 0x63, 0x10, 0x8C, 0x63, 0x11, 0x80,
  0x36, 0x31, 0x7B, 0xCC, 0x62, 0x42, 0x36, 0x31, 0xB1, 0x8D, 0x8C, 0x68,
  0x42, 0xC6, 0x30, 0x37, 0x17, 0x8C, 0x66, 0x26, 0x33, 0x19, 0x8C, 0x86,
  0xC6, 0x00, 0x1C, 0xFD, 0x1E, 0x1C, 0x30, 0xF1, 0xE6, 0x78, 0x36, 0x17,
  0x8C, 0x64, 0x36, 0x13, 0x09, 0x8C, 0xCC, 0x5C, 0x60, 0x30, 0x18, 0x08,
  0x00, 0x19, 0x7F, 0x66, 0xC2, 0xC6, 0x86, 0x86, 0xCC, 0xF4, 0x0C, 0x0C,
  0x0C, 0x08, 0x36, 0x5C, 0xC1, 0x06, 0x0C, 0x18, 0x20, 0xC0, 0x1C, 0xFD,
  0x83, 0x03, 0x81, 0x83, 0x46, 0xF8, 0x21, 0x1F, 0xF6, 0x23, 0x18, 0xC6,
  0x3C, 0x63, 0x63, 0x43, 0xC2, 0xC6, 0xC6, 0xC6, 0xCC, 0xF4, 0x83, 0xC6,
  0xC4, 0xCC, 0xC8, 0xD8, 0x50, 0x70, 0x60, 0xC6, 0x3C, 0xE6, 0xCE, 0x6D,
  0xEC, 0xD6, 0xCF, 0x68, 0xE7, 0x8E, 0x30, 0xC3, 0x00, 0x31, 0xC4, 0x61,
  0xB0, 0x38, 0x0C, 0x07, 0x03, 0x60, 0x98, 0xE3, 0x00, 0x20, 0xCC, 0x63,
  0x10, 0xCC, 0x32, 0x05, 0x81, 0x40, 0x70, 0x18, 0x06, 0x03, 0x03, 0x80,
  0xC0, 0x00, 0x3E, 0x7C, 0x30, 0x41, 0x86, 0x18, 0x60, 0xFC, 0x0E, 0x30,
  0x40, 0x81, 0x06, 0x30, 0x30, 0x20, 0xC1, 0x83, 0x07, 0x02, 0x00, 0xFF,
  0xFF, 0x18, 0x18, 0x20, 0x41, 0x81, 0x01, 0x8C, 0x10, 0x60, 0xC1, 0x8E,
  0x10, 0x00, 0x61, 0xFF,
};

const GFXglyph NotoSans_MediumItalic16pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 4, 0, -1 },
  { 1, 5, 11, 4, 0, -11 },
  { 8, 5, 4, 7, 2, -11 },
  { 11, 10, 11, 10, 0, -11 },
  { 25, 9, 13, 9, 0, -12 },
  { 40, 11, 12, 13, 1, -12 },
  { 57, 10, 12, 11, 1, -12 },
  { 72, 2, 4, 4, 2, -11 },
  { 73, 5, 14, 5, 1, -11 },
  { 82, 5, 14, 5, -1, -11 },
  { 91, 7, 7, 9, 2, -12 },
  { 98, 8, 8, 9, 1, -10 },
  { 106, 4, 4, 4, -1, -2 },
  { 108, 5, 1, 5, 0, -5 },
  { 109, 3, 2, 4, 0, -2 },
  { 110, 8, 11, 6, -1, -11 },
  { 121, 8, 12, 9, 1, -12 },
  { 133, 5, 11, 9, 2, -11 },
  { 140, 8, 12, 9, 0, -12 },
  { 152, 8, 12, 9, 0, -12 },
  { 164, 9, 11, 9, 0, -11 },
  { 177, 9, 11, 9, 0, -11 },
  { 190, 8, 12, 9, 1, -12 },
  { 202, 8, 11, 9, 1, -11 },
  { 213, 8, 12, 9, 1, -12 },
  { 225, 7, 12, 9, 1, -12 },
  { 236, 4, 9, 4, 0, -9 },
  { 241, 5, 11, 4, -1, -9 },
  { 248, 8, 8, 9, 1, -10 },
  { 256, 8, 5, 9, 1, -8 },
  { 261, 8, 8, 9, 1, -10 },
  { 269, 6, 12, 7, 1, -12 },
  { 278, 12, 12, 14, 1, -11 },
  { 296, 9, 11, 9, -1, -11 },
  { 309, 9, 11, 10, 1, -11 },
  { 322, 9, 12, 10, 1, -12 },
  { 336, 9, 11, 11, 1, -11 },
  { 349, 8, 11, 8, 1, -11 },
  { 360, 8, 11, 8, 1, -11 },
  { 371, 10, 12, 11, 1, -12 },
  { 386, 10, 11, 11, 1, -11 },
  { 400, 6, 11, 5, 0, -11 },
  { 409, 8, 14, 5, -3, -11 },
  { 423, 10, 11, 9, 1, -11 },
  { 437, 6, 11, 8, 1, -11 },
  { 446, 13, 11, 14, 1, -11 },
  { 464, 11, 11, 12, 1, -11 },
  { 480, 10, 12, 12, 1, -12 },
  { 495, 8, 11, 9, 1, -11 },
  { 506, 10, 15, 12, 1, -12 },
  { 525, 8, 11, 9, 1, -11 },
  { 536, 8, 12, 8, 0, -12 },
  { 548, 8, 11, 8, 1, -11 },
  { 559, 10, 11, 11, 1, -11 },
  { 573, 9, 11, 9, 1, -11 },
  { 586, 13, 11, 14, 2, -11 },
  { 604, 11, 11, 9, -1, -11 },
  { 620, 9, 11, 8, 1, -11 },
  { 633, 9, 11, 9, 0, -11 },
  { 646, 6, 14, 5, 0, -11 },
  { 657, 3, 11, 6, 2, -11 },
  { 662, 6, 14, 5, -1, -11 },
  { 673, 8, 8, 9, 1, -12 },
  { 681, 6, 2, 6, -1, 1 },
  { 683, 3, 2, 5, 2, -12 },
  { 684, 8, 9, 9, 1, -9 },
  { 693, 9, 12, 9, 0, -12 },
  { 707, 7, 9, 7, 1, -9 },
  { 715, 9, 12, 9, 1, -12 },
  { 729, 7, 9, 8, 1, -9 },
  { 737, 9, 16, 5, -2, -12 },
  { 755, 9, 13, 9, 0, -9 },
  { 770, 9, 12, 9, 0, -12 },
  { 784, 5, 12, 4, 0, -12 },
  { 792, 7, 16, 4, -2, -12 },
  { 806, 9, 12, 8, 0, -12 },
  { 820, 5, 12, 4, 0, -12 },
  { 828, 13, 9, 14, 0, -9 },
  { 843, 9, 9, 9, 0, -9 },
  { 854, 7, 9, 9, 1, -9 },
  { 862, 9, 13, 9, 0, -9 },
  { 877, 8, 13, 9, 1, -9 },
  { 890, 7, 9, 6, 0, -9 },
  { 898, 7, 9, 7, 0, -9 },
  { 906, 5, 11, 6, 1, -11 },
  { 913, 8, 9, 9, 1, -9 },
  { 922, 8, 9, 8, 1, -9 },
  { 931, 12, 9, 12, 1, -9 },
  { 945, 10, 9, 8, -1, -9 },
  { 957, 10, 13, 8, -1, -9 },
  { 974, 7, 9, 7, 0, -9 },
  { 982, 7, 14, 6, 0, -11 },
  { 995, 1, 16, 9, 4, -12 },
  { 997, 7, 14, 6, -1, -11 },
  { 1010, 8, 2, 9, 1, -7 },
};

const GFXfont NotoSans_MediumItalic16pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic16pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic16pt7bGlyphs,
  0x20, 0x7E, 22
};

#endif // _NOTOSANS_MEDIUMITALIC16PT7B_H_
