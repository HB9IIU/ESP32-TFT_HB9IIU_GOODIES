#ifndef _NOTOSANS_MEDIUMITALIC57PT7B_H_
#define _NOTOSANS_MEDIUMITALIC57PT7B_H_

#include <pgmspace.h>
#include <TFT_eSPI.h>  // provides GFXfont and GFXglyph

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 57pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic57pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0xFE, 0x01, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F,
  0x80, 0x7F, 0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x3F, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F,
  0x80, 0x3F, 0x00, 0x7C, 0x00, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0x00, 0x3E, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0xF8, 0x03, 0xF8, 0x0F, 0xF0, 0x1F, 0xE0,
  0x3F, 0xC0, 0x7F, 0x00, 0x7E, 0x00, 0x70, 0x00, 0x3F, 0x0F, 0xCF, 0xC3,
  0xF3, 0xF0, 0xFC, 0xF8, 0x3E, 0x7E, 0x0F, 0x9F, 0x83, 0xE7, 0xC1, 0xF9,
  0xF0, 0x7C, 0x7C, 0x1F, 0x1F, 0x07, 0xC7, 0x81, 0xE3, 0xE0, 0x78, 0xF8,
  0x1E, 0x3C, 0x0F, 0x8F, 0x03, 0xC0, 0x00, 0x01, 0xF0, 0x1E, 0x00, 0x00,
  0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F, 0x00,
  0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x1F,
  0x00, 0x00, 0x3C, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x78, 0x00, 0x01, 0xF0,
  0x1F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x78, 0x01, 0xFF,
  0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x3E, 0x03, 0xE0, 0x00, 0x07, 0xC0,
  0x7C, 0x00, 0x00, 0xF0, 0x0F, 0x00, 0x00, 0x1E, 0x01, 0xE0, 0x00, 0x07,
  0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0xFF, 0xFF, 0xFF, 0xE3,
  0xFF, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFF,
  0xF0, 0x07, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F, 0x01,
  0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00, 0x1F,
  0x01, 0xF0, 0x00, 0x03, 0xC0, 0x3C, 0x00, 0x00, 0xF8, 0x0F, 0x80, 0x00,
  0x1F, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x3E, 0x00, 0x00, 0x78, 0x07, 0x80,
  0x00, 0x1F, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07,
  0x80, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0xF8, 0x00,
  0x01, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0xE0, 0x3F, 0xFE, 0xFE, 0x07, 0xF1, 0xE0, 0xE0, 0x7E, 0x1E, 0x00,
  0x07, 0xE1, 0xE0, 0x00, 0x7C, 0x1C, 0x00, 0x0F, 0xC3, 0xC0, 0x00, 0x7C,
  0x3C, 0x00, 0x07, 0xE3, 0xC0, 0x00, 0x7E, 0x3C, 0x00, 0x07, 0xFB, 0x80,
  0x00, 0x3F, 0xF8, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x0F, 0x3F, 0x80, 0x00, 0xE1, 0xF8, 0x00, 0x1E, 0x1F, 0x80,
  0x01, 0xE1, 0xF8, 0x00, 0x1E, 0x1F, 0x80, 0x01, 0xE1, 0xF8, 0x00, 0x1C,
  0x1F, 0x88, 0x03, 0xC3, 0xF0, 0xF0, 0x3C, 0xFF, 0x0F, 0xFF, 0xFF, 0xE0,
  0xFF, 0xFF, 0xFC, 0x0F, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x07, 0x00, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x0F, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x0F, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFF, 0x00, 0x00, 0xF8, 0x07, 0xFF, 0x80,
  0x01, 0xF0, 0x0F, 0xFF, 0x80, 0x03, 0xE0, 0x1F, 0x8F, 0xC0, 0x03, 0xE0,
  0x1F, 0x07, 0xC0, 0x07, 0xC0, 0x3E, 0x07, 0xC0, 0x0F, 0x80, 0x3E, 0x07,
  0xC0, 0x1F, 0x00, 0x7E, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x3E,
  0x00, 0x7C, 0x07, 0xC0, 0x7C, 0x00, 0x7C, 0x07, 0xC0, 0xF8, 0x00, 0xF8,
  0x07, 0xC0, 0xF8, 0x00, 0xF8, 0x07, 0xC1, 0xF0, 0x00, 0xF8, 0x0F, 0x83,
  0xE0, 0x00, 0xF8, 0x0F, 0x87, 0xC0, 0x00, 0xF8, 0x0F, 0x87, 0xC3, 0xF0,
  0xF8, 0x1F, 0x0F, 0x8F, 0xFC, 0xF8, 0x1F, 0x1F, 0x1F, 0xFE, 0xF8, 0x3E,
  0x3F, 0x3F, 0xFE, 0x7C, 0x7E, 0x3E, 0x7F, 0x7F, 0x7F, 0xFC, 0x7C, 0x7C,
  0x1F, 0x3F, 0xF8, 0xF8, 0xF8, 0x1F, 0x3F, 0xF1, 0xF8, 0xF8, 0x1F, 0x0F,
  0xE1, 0xF1, 0xF0, 0x1F, 0x00, 0x03, 0xE1, 0xF0, 0x1F, 0x00, 0x07, 0xC1,
  0xF0, 0x1F, 0x00, 0x0F, 0xC3, 0xF0, 0x1F, 0x00, 0x0F, 0x83, 0xE0, 0x1F,
  0x00, 0x1F, 0x03, 0xE0, 0x1F, 0x00, 0x3E, 0x03, 0xE0, 0x3E, 0x00, 0x7E,
  0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF8, 0x03, 0xE0,
  0x7C, 0x01, 0xF0, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x03, 0xE0, 0xFC, 0x03,
  0xE0, 0x03, 0xF1, 0xF8, 0x07, 0xC0, 0x01, 0xFF, 0xF0, 0x0F, 0x80, 0x01,
  0xFF, 0xF0, 0x0F, 0x80, 0x00, 0xFF, 0xE0, 0x3F, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x08, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x00,
  0x7F, 0xDF, 0xF0, 0x00, 0x07, 0xE0, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0x1F, 0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x0F, 0x80,
  0x1F, 0x00, 0x00, 0xF8, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00,
  0xFC, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0xFC, 0x3F, 0xC0,
  0x00, 0x07, 0xEF, 0xF8, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7F, 0x0F, 0xF7, 0xF0, 0x07,
  0xE1, 0xFE, 0x3F, 0x00, 0x7E, 0x3F, 0x83, 0xF8, 0x0F, 0xC7, 0xF0, 0x1F,
  0xC1, 0xF8, 0x7E, 0x00, 0xFE, 0x1F, 0x8F, 0xE0, 0x07, 0xE3, 0xF0, 0xFC,
  0x00, 0x7F, 0x7F, 0x0F, 0xC0, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0xFC,
  0x0F, 0xC0, 0x01, 0xFF, 0x80, 0xFC, 0x00, 0x0F, 0xF0, 0x0F, 0xC0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x3F, 0xF0, 0x0F, 0xF0, 0x07, 0xFF, 0x80, 0x7F,
  0xEF, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0xEF, 0xE0, 0x3F, 0xFF, 0xF8, 0xFE,
  0x01, 0xFF, 0xFE, 0x07, 0xF0, 0x07, 0xFF, 0x80, 0x3F, 0x80, 0x03, 0x80,
  0x00, 0x00, 0x3F, 0x3F, 0x3F, 0x3E, 0x7E, 0x7E, 0x7C, 0x7C, 0x7C, 0x7C,
  0x78, 0xF8, 0xF8, 0xF0, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x07,
  0xE0, 0x00, 0x7C, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x01,
  0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x03, 0xE0, 0x00,
  0x7E, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00,
  0x07, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0,
  0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x0F, 0xC0, 0x00, 0xFC,
  0x00, 0x0F, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0xC0, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00,
  0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x3E,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0x7E,
  0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x00, 0x07, 0xE0,
  0x00, 0xFC, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x3F, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0x0F, 0x80, 0x03, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x00, 0x07,
  0xC0, 0x01, 0xF0, 0x00, 0x7E, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x08, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F,
  0x80, 0x00, 0x03, 0xE0, 0x04, 0x00, 0xF8, 0x01, 0xC0, 0x3C, 0x00, 0x7C,
  0x0F, 0x00, 0x3F, 0xC3, 0xC0, 0x0F, 0xFD, 0xE0, 0x03, 0xFF, 0xF8, 0x0F,
  0x0F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xF0, 0x07, 0xFF, 0xFC, 0x03, 0xFB,
  0xFF, 0x01, 0xFF, 0x00, 0xC0, 0xFB, 0xC0, 0x00, 0x7E, 0xF8, 0x00, 0x3F,
  0x1E, 0x00, 0x1F, 0x87, 0xC0, 0x1F, 0xC1, 0xF0, 0x03, 0xF0, 0x3E, 0x00,
  0x78, 0x0F, 0x80, 0x0C, 0x03, 0xF0, 0x01, 0x00, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x0F, 0x80, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0x3E, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x03, 0xF0, 0x1F, 0xC1, 0xFC, 0x0F, 0xC0, 0xFE, 0x07, 0xE0, 0x3F, 0x03,
  0xF0, 0x1F, 0x80, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x7E, 0x00, 0x7F,
  0xFE, 0xFF, 0xFD, 0xFF, 0xFB, 0xFF, 0xFF, 0xFF, 0xC0, 0x3E, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFE, 0xFE, 0x38, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F,
  0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0xF8,
  0x01, 0xFF, 0xFF, 0xC0, 0x3F, 0xC1, 0xFC, 0x07, 0xF8, 0x0F, 0xE0, 0x7F,
  0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x07,
  0xE1, 0xF8, 0x00, 0x7F, 0x3F, 0x80, 0x07, 0xF3, 0xF0, 0x00, 0x7F, 0x3F,
  0x00, 0x07, 0xF7, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00,
  0x7E, 0x7E, 0x00, 0x07, 0xE7, 0xE0, 0x00, 0x7E, 0xFE, 0x00, 0x07, 0xEF,
  0xC0, 0x00, 0x7E, 0xFC, 0x00, 0x0F, 0xEF, 0xC0, 0x00, 0xFE, 0xFC, 0x00,
  0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0xCF, 0xC0, 0x01, 0xF8,
  0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x03, 0xF8, 0xFC, 0x00, 0x3F, 0x0F, 0xC0,
  0x07, 0xF0, 0xFC, 0x00, 0x7E, 0x0F, 0xE0, 0x0F, 0xE0, 0x7E, 0x01, 0xFC,
  0x07, 0xF0, 0x3F, 0xC0, 0x3F, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x02, 0x00,
  0x00, 0x00, 0x03, 0xE0, 0x01, 0xFC, 0x00, 0xFF, 0x80, 0x3F, 0xE0, 0x1F,
  0xFC, 0x07, 0xFF, 0x83, 0xFF, 0xF1, 0xFF, 0xFE, 0xFF, 0xDF, 0x8F, 0xF3,
  0xF1, 0xF8, 0x7E, 0x1E, 0x0F, 0xC3, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F,
  0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F,
  0x00, 0x07, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0x80, 0x07, 0xE0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0,
  0x00, 0x7E, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0,
  0x03, 0xF8, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF8, 0x03, 0xF8,
  0x1F, 0xF0, 0x0F, 0x80, 0x1F, 0xC0, 0x18, 0x00, 0x7F, 0x00, 0x40, 0x00,
  0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF,
  0xFF, 0x0F, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x07, 0xFE, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xF8,
  0x07, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFC, 0x03, 0xFC, 0x03,
  0x80, 0x0F, 0xE0, 0x10, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0xFF,
  0xF0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x02, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0xFC, 0x30, 0x00, 0x0F, 0xE1, 0xE0, 0x01, 0xFE, 0x0F,
  0xFD, 0xFF, 0xF0, 0x7F, 0xFF, 0xFF, 0x03, 0xFF, 0xFF, 0xF0, 0x1F, 0xFF,
  0xFE, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x03, 0xF7, 0xC0,
  0x00, 0x1F, 0x9F, 0x00, 0x00, 0xFC, 0xFC, 0x00, 0x07, 0xE3, 0xF0, 0x00,
  0x3F, 0x0F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x0F, 0xC0, 0x7C, 0x00, 0x7E, 0x03,
  0xF0, 0x03, 0xF0, 0x0F, 0xC0, 0x0F, 0xC0, 0x3F, 0x00, 0x7E, 0x00, 0xFC,
  0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x1F, 0x80, 0xFC, 0x00, 0x7E, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0xFF, 0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xFD, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0xFF, 0xF8,
  0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xE0, 0x0F,
  0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF8, 0x03, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00, 0x7F, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xF0,
  0x01, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x20,
  0x00, 0x3F, 0xC1, 0xC0, 0x03, 0xFC, 0x0F, 0xFB, 0xFF, 0xE0, 0x7F, 0xFF,
  0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x0E, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x0F, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xE0, 0x0F,
  0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF8, 0x3E,
  0x00, 0x3F, 0x1F, 0xFC, 0x03, 0xF3, 0xFF, 0xE0, 0x3F, 0x7F, 0xFF, 0x07,
  0xEF, 0xFF, 0xF0, 0x7F, 0xF0, 0x7F, 0x87, 0xFC, 0x03, 0xF8, 0x7F, 0x80,
  0x1F, 0x87, 0xF0, 0x01, 0xFC, 0xFE, 0x00, 0x0F, 0xCF, 0xE0, 0x00, 0xFC,
  0xFC, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0xFC, 0xFC, 0x00, 0x0F, 0x8F, 0xC0,
  0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x8F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x3F,
  0x07, 0xE0, 0x03, 0xF0, 0x7F, 0x00, 0x7E, 0x07, 0xF8, 0x1F, 0xE0, 0x3F,
  0xEF, 0xFC, 0x03, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xF0, 0x00, 0xFF, 0xFE,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xF8,
  0xFF, 0xFF, 0xFF, 0x8F, 0xFF, 0xFF, 0xFC, 0x7F, 0xFF, 0xFF, 0xE3, 0xFF,
  0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xF8,
  0x00, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0x00, 0xFE, 0x03, 0xF8, 0x07,
  0xE0, 0x0F, 0xE0, 0x7E, 0x00, 0x3F, 0x03, 0xF0, 0x01, 0xF8, 0x1F, 0x80,
  0x0F, 0xC0, 0xFC, 0x00, 0x7E, 0x07, 0xE0, 0x03, 0xF0, 0x3F, 0x00, 0x3F,
  0x01, 0xF8, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x83, 0xFC, 0x00,
  0xFE, 0x3F, 0x80, 0x03, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F,
  0xE0, 0x00, 0x0F, 0xFF, 0x80, 0x01, 0xFF, 0xFE, 0x00, 0x1F, 0xF7, 0xF8,
  0x03, 0xFC, 0x0F, 0xE0, 0x1F, 0xC0, 0x3F, 0x81, 0xF8, 0x00, 0xFC, 0x1F,
  0xC0, 0x07, 0xF0, 0xFC, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x7E, 0x00,
  0x07, 0xE3, 0xF0, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFE, 0x00, 0x0F,
  0xC7, 0xF0, 0x00, 0xFE, 0x1F, 0x80, 0x0F, 0xE0, 0xFF, 0x00, 0xFF, 0x03,
  0xFE, 0x1F, 0xF0, 0x1F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xF0, 0x01, 0xFF,
  0xFF, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xC0,
  0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x83, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0x7E, 0x1F, 0x80, 0x07, 0xE7, 0xF0, 0x00, 0xFC, 0xFC, 0x00, 0x1F, 0x9F,
  0x80, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x01,
  0xFB, 0xF0, 0x00, 0x7F, 0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xFC, 0xFC,
  0x00, 0x7F, 0x1F, 0xC0, 0x1F, 0xE3, 0xFC, 0x0F, 0xFC, 0x3F, 0xFF, 0xFF,
  0x87, 0xFF, 0xFB, 0xF0, 0x7F, 0xFE, 0x7E, 0x07, 0xFF, 0x9F, 0x80, 0x3F,
  0xC3, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xE0, 0x40, 0x0F, 0xF8, 0x0F,
  0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xE0, 0x07, 0xFF, 0xF0,
  0x00, 0xFF, 0xF8, 0x00, 0x01, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x3F, 0x81,
  0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x1F, 0x80, 0x78, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3E,
  0x03, 0xF8, 0x3F, 0xC1, 0xFE, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x07, 0x00,
  0x00, 0x3F, 0x00, 0x3F, 0x80, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0, 0x03,
  0xF8, 0x01, 0xF8, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0xFC, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x1F, 0x00, 0x1F, 0x80,
  0x0F, 0x80, 0x0F, 0x80, 0x07, 0xC0, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x20, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xF0, 0x00,
  0x03, 0xFE, 0x00, 0x01, 0xFF, 0x80, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xF0, 0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xF8, 0x00, 0x07, 0xFC,
  0x00, 0x03, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x70, 0x00, 0x00, 0x02, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x03,
  0xE0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x01, 0xFF, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x1F,
  0xF8, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xF0, 0x00, 0x3F, 0xF8, 0x00, 0x3F, 0xFC,
  0x00, 0x1F, 0xFC, 0x00, 0x0F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x07, 0xFF,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x60, 0x00, 0x00, 0x08, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x1F, 0xFF,
  0xC1, 0xFF, 0xFF, 0xC1, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xC3, 0xE0, 0x3F,
  0x86, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x01,
  0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0x7E, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xF0,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x00, 0x01, 0xFC, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00,
  0x00, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xE0, 0x7C, 0x00, 0x1C,
  0x00, 0x3E, 0x0F, 0x80, 0x0F, 0xFF, 0x01, 0xF1, 0xF0, 0x03, 0xFF, 0xF8,
  0x1F, 0x1F, 0x00, 0xFF, 0xFF, 0x81, 0xF3, 0xE0, 0x1F, 0xE3, 0xF8, 0x1F,
  0x3E, 0x03, 0xF8, 0x1F, 0x01, 0xF7, 0xC0, 0x7E, 0x01, 0xF0, 0x0F, 0x7C,
  0x07, 0xC0, 0x1F, 0x01, 0xF7, 0xC0, 0xF8, 0x01, 0xF0, 0x1F, 0x78, 0x0F,
  0x80, 0x3E, 0x01, 0xFF, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0x1F, 0x00,
  0x3E, 0x01, 0xFF, 0x81, 0xF0, 0x03, 0xE0, 0x1F, 0xF8, 0x1F, 0x00, 0x7C,
  0x03, 0xEF, 0x81, 0xF0, 0x07, 0xC0, 0x3E, 0xF8, 0x1F, 0x00, 0xFC, 0x03,
  0xEF, 0x81, 0xF0, 0x0F, 0xC0, 0x7C, 0xF8, 0x1F, 0x01, 0xFC, 0x0F, 0xCF,
  0x81, 0xF0, 0x3F, 0xC0, 0xF8, 0xF8, 0x1F, 0x87, 0xBC, 0x3F, 0x0F, 0x81,
  0xFF, 0xFB, 0xFF, 0xE0, 0xFC, 0x0F, 0xFF, 0x3F, 0xFC, 0x07, 0xC0, 0x7F,
  0xE1, 0xFF, 0x80, 0x7C, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0x00, 0x00, 0x3F, 0xF0, 0x07, 0xF0, 0x00, 0x01,
  0xFF, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x3F,
  0xFF, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x7D, 0xF0, 0x00, 0x00, 0x7E, 0xF8, 0x00, 0x00,
  0x3E, 0x7C, 0x00, 0x00, 0x3F, 0x3F, 0x00, 0x00, 0x1F, 0x1F, 0x80, 0x00,
  0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xC1, 0xF0, 0x00,
  0x0F, 0xC0, 0xF8, 0x00, 0x07, 0xE0, 0x7C, 0x00, 0x07, 0xE0, 0x3E, 0x00,
  0x03, 0xF0, 0x1F, 0x80, 0x03, 0xF0, 0x0F, 0xC0, 0x01, 0xF8, 0x07, 0xE0,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0xFC,
  0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF,
  0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xF0, 0x1F, 0x80, 0x01,
  0xF8, 0x1F, 0xC0, 0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0x3F, 0x07, 0xE0, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x0F, 0xC3, 0xF0, 0x00,
  0x03, 0xF3, 0xF8, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x7F, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFC, 0x1F, 0xFE, 0x01,
  0xF8, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x01,
  0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x3F, 0x03,
  0xF0, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFE, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x03, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x07,
  0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F,
  0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x3F, 0xE0, 0x0F, 0xC0, 0x07, 0xF0, 0x0F,
  0xC0, 0x03, 0xF8, 0x1F, 0x80, 0x03, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F,
  0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x1F, 0x80, 0x01, 0xF8, 0x3F,
  0x00, 0x01, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F, 0x00, 0x03, 0xF8, 0x3F,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xF0, 0x7E, 0x00, 0x7F, 0xE0, 0x7F,
  0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0xFF,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x07, 0xFF, 0xFE, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0x00,
  0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xC0, 0x3E, 0x01, 0xFF, 0x00, 0x0C, 0x03,
  0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x80, 0x3F, 0xF0, 0x07, 0x80, 0x1F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x80, 0x00,
  0xFF, 0xFC, 0x00, 0x00, 0x02, 0x00, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00,
  0x3F, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0x0F, 0xFF, 0x80, 0x1F, 0xC0, 0x1F,
  0xF0, 0x07, 0xE0, 0x01, 0xFE, 0x01, 0xF8, 0x00, 0x3F, 0x80, 0x7E, 0x00,
  0x0F, 0xE0, 0x1F, 0x80, 0x01, 0xFC, 0x0F, 0xC0, 0x00, 0x7F, 0x03, 0xF0,
  0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0xFC, 0x1F,
  0xC0, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0,
  0x7E, 0x00, 0x00, 0xFC, 0x1F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x01, 0xFC, 0x3F, 0x00, 0x00,
  0x7F, 0x0F, 0xC0, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0x0F, 0xE1, 0xF8, 0x00,
  0x03, 0xF8, 0x7E, 0x00, 0x01, 0xFC, 0x1F, 0x80, 0x00, 0x7F, 0x07, 0xE0,
  0x00, 0x3F, 0xC3, 0xF0, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x0F, 0xF0, 0x3F,
  0x00, 0x07, 0xFC, 0x0F, 0xC0, 0x03, 0xFE, 0x07, 0xF0, 0x03, 0xFF, 0x01,
  0xF8, 0x0F, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0x00,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF,
  0xE0, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF,
  0xF8, 0x01, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE,
  0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x80, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xF0,
  0x07, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x00,
  0x00, 0x7F, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xE0, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xF0, 0x03, 0xFF, 0xFF, 0xC0, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x3F, 0xF8, 0x0F, 0xE0,
  0x1F, 0xF0, 0x00, 0x30, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0xFC, 0xFE,
  0x00, 0x3F, 0xFF, 0x3F, 0x80, 0x0F, 0xFF, 0xCF, 0xC0, 0x03, 0xFF, 0xE3,
  0xF0, 0x01, 0xFF, 0xF8, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F,
  0x8F, 0xC0, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x03, 0xF0, 0xFE, 0x00, 0x00,
  0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x1F, 0xC1, 0xFC, 0x00,
  0x07, 0xE0, 0x7F, 0x00, 0x01, 0xF8, 0x1F, 0xE0, 0x00, 0x7E, 0x03, 0xFC,
  0x00, 0x1F, 0x80, 0xFF, 0xC0, 0x0F, 0xE0, 0x1F, 0xFF, 0xFF, 0xF0, 0x03,
  0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0x80,
  0x00, 0x7F, 0xFF, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x01, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01,
  0xF8, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00,
  0x07, 0xF0, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x0F, 0xC0, 0x3F, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xFF,
  0xE0, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x07, 0xFF,
  0xFF, 0xFF, 0xC0, 0x3F, 0x00, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0x07, 0xE0,
  0x0F, 0xC0, 0x00, 0x3F, 0x00, 0xFE, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0x0F, 0xC0,
  0x3F, 0x00, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x1F, 0xC0, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xF0, 0x00, 0x0F,
  0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F,
  0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0xFF,
  0x00, 0xFF, 0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x1F, 0xC0, 0x08, 0x1F, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0xFF, 0xFC,
  0x00, 0x3F, 0xFE, 0x00, 0x0F, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFC, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x0F, 0xE0, 0x01, 0xF8, 0x01, 0xFC, 0x00, 0x1F, 0x80, 0x3F, 0x80, 0x01,
  0xF8, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x1F, 0xC0,
  0x00, 0x3F, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x0F,
  0xF0, 0x00, 0x03, 0xF1, 0xFE, 0x00, 0x00, 0x7F, 0x3F, 0xC0, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x7F, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00,
  0x00, 0x7F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x0F, 0xFB, 0xF0, 0x00, 0x00, 0xFF, 0x3F, 0x80, 0x00, 0x0F,
  0xE1, 0xF8, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0xFC, 0x00,
  0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x01, 0xF8, 0x07,
  0xE0, 0x00, 0x3F, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x03, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80,
  0x07, 0xE0, 0x01, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00,
  0xFC, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0, 0x00, 0x7E, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xC0,
  0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0xFC,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0,
  0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00,
  0x7E, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0xFF, 0xFD, 0xFF, 0xFF,
  0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0x80,
  0x00, 0x03, 0xFE, 0x01, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0x1F, 0xF0, 0x07, 0xFC, 0x00, 0x00, 0x7F, 0xE0, 0x0F, 0xF8, 0x00,
  0x00, 0xFF, 0xC0, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x80, 0x7F, 0xF0, 0x00,
  0x0F, 0xFF, 0x00, 0xFB, 0xE0, 0x00, 0x1F, 0x7C, 0x01, 0xF7, 0xC0, 0x00,
  0x7F, 0xF8, 0x03, 0xEF, 0x80, 0x00, 0xFB, 0xF0, 0x0F, 0xDF, 0x00, 0x03,
  0xF7, 0xE0, 0x1F, 0xBE, 0x00, 0x07, 0xCF, 0x80, 0x3F, 0x7C, 0x00, 0x1F,
  0xBF, 0x00, 0x7C, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0xF9, 0xF0, 0x00, 0xFC,
  0xFC, 0x03, 0xF1, 0xF0, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xE0, 0x07, 0xE3,
  0xE0, 0x0F, 0xC7, 0xC0, 0x0F, 0x8F, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F,
  0x80, 0x3E, 0x1F, 0x00, 0x7C, 0x3F, 0x00, 0xFC, 0x3E, 0x01, 0xF0, 0x7E,
  0x01, 0xF8, 0x7C, 0x03, 0xE0, 0xF8, 0x03, 0xF0, 0xF8, 0x0F, 0x83, 0xF0,
  0x07, 0xC1, 0xF0, 0x3F, 0x07, 0xE0, 0x0F, 0x81, 0xE0, 0x7C, 0x0F, 0xC0,
  0x3F, 0x03, 0xE1, 0xF8, 0x1F, 0x80, 0x7E, 0x07, 0xC3, 0xE0, 0x7E, 0x00,
  0xFC, 0x0F, 0x8F, 0xC0, 0xFC, 0x01, 0xF0, 0x1F, 0x1F, 0x01, 0xF8, 0x07,
  0xE0, 0x3E, 0x7E, 0x03, 0xF0, 0x0F, 0xC0, 0x7C, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0xFB, 0xE0, 0x1F, 0x80, 0x3E, 0x01, 0xF7, 0xC0, 0x3F, 0x00, 0x7C,
  0x03, 0xFF, 0x00, 0x7E, 0x01, 0xF8, 0x03, 0xFE, 0x00, 0xFC, 0x03, 0xF0,
  0x07, 0xF8, 0x01, 0xF0, 0x07, 0xE0, 0x0F, 0xF0, 0x07, 0xE0, 0x0F, 0x80,
  0x1F, 0xC0, 0x0F, 0xC0, 0x1F, 0x00, 0x3F, 0x80, 0x1F, 0x80, 0x7E, 0x00,
  0x7E, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x3E, 0x01, 0xFE, 0x00, 0x00, 0xFC, 0x03, 0xFC, 0x00, 0x01,
  0xF8, 0x07, 0xFC, 0x00, 0x03, 0xF0, 0x0F, 0xF8, 0x00, 0x07, 0xE0, 0x1F,
  0xF0, 0x00, 0x0F, 0x80, 0x7F, 0xF0, 0x00, 0x3F, 0x00, 0xFF, 0xE0, 0x00,
  0x7E, 0x01, 0xFF, 0xC0, 0x00, 0xFC, 0x03, 0xEF, 0xC0, 0x01, 0xF8, 0x0F,
  0xDF, 0x80, 0x03, 0xE0, 0x1F, 0x9F, 0x00, 0x0F, 0xC0, 0x3F, 0x3F, 0x00,
  0x1F, 0x80, 0x7C, 0x7E, 0x00, 0x3F, 0x00, 0xF8, 0x7C, 0x00, 0x7C, 0x03,
  0xF0, 0xFC, 0x01, 0xF8, 0x07, 0xE1, 0xF8, 0x03, 0xF0, 0x0F, 0xC1, 0xF8,
  0x07, 0xE0, 0x1F, 0x03, 0xF0, 0x0F, 0xC0, 0x3E, 0x07, 0xE0, 0x1F, 0x00,
  0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xF8, 0x0F, 0xC0, 0xFC, 0x03, 0xF0, 0x1F,
  0x81, 0xF8, 0x07, 0xC0, 0x1F, 0x83, 0xF0, 0x0F, 0x80, 0x3F, 0x07, 0xC0,
  0x3F, 0x00, 0x3E, 0x1F, 0x80, 0x7E, 0x00, 0x7E, 0x3F, 0x00, 0xFC, 0x00,
  0xFC, 0x7E, 0x01, 0xF0, 0x00, 0xF8, 0xF8, 0x07, 0xE0, 0x01, 0xF9, 0xF0,
  0x0F, 0xC0, 0x03, 0xF3, 0xE0, 0x1F, 0x80, 0x03, 0xFF, 0xC0, 0x3F, 0x00,
  0x07, 0xFF, 0x80, 0x7C, 0x00, 0x0F, 0xFE, 0x01, 0xF8, 0x00, 0x0F, 0xFC,
  0x03, 0xF0, 0x00, 0x1F, 0xF8, 0x07, 0xE0, 0x00, 0x1F, 0xF0, 0x0F, 0x80,
  0x00, 0x3F, 0xE0, 0x1F, 0x00, 0x00, 0x7F, 0x80, 0x7E, 0x00, 0x00, 0x7F,
  0x00, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x01, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x30, 0x00, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0x80, 0x1F,
  0x87, 0xFF, 0x80, 0x7E, 0x00, 0x7F, 0x00, 0xFC, 0x00, 0x7F, 0x01, 0xF8,
  0x00, 0xFE, 0x03, 0xF0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xF8, 0x1F, 0x80,
  0x03, 0xF0, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00,
  0x1F, 0x83, 0xF8, 0x00, 0x7F, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x03,
  0xF8, 0x1F, 0x80, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0xC0, 0xFF, 0xFF, 0xFF,
  0x01, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F,
  0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00,
  0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xF8, 0x1F, 0xF8, 0x03, 0xFE, 0x00,
  0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0xFE,
  0x00, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x00, 0x7E,
  0x3F, 0x80, 0x00, 0x07, 0xE3, 0xF8, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00,
  0x07, 0xE7, 0xF0, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x00, 0x7E, 0x7E, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E,
  0xFE, 0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x0F, 0xEF, 0xC0, 0x00, 0x00, 0xFE, 0xFC, 0x00, 0x00, 0x0F, 0xCF, 0xC0,
  0x00, 0x00, 0xFC, 0xFC, 0x00, 0x00, 0x1F, 0xCF, 0xC0, 0x00, 0x01, 0xFC,
  0xFE, 0x00, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x03, 0xF8, 0xFE, 0x00, 0x00,
  0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF8,
  0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x07, 0xFC, 0x03, 0xFF, 0x01, 0xFF, 0x80,
  0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF,
  0x80, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0x80,
  0x0F, 0xFF, 0xFF, 0x80, 0x1F, 0x87, 0xFF, 0x80, 0x7F, 0x00, 0xFF, 0x00,
  0xFC, 0x00, 0x7E, 0x01, 0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07,
  0xE0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0x7E,
  0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xE0,
  0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xF0, 0x1F, 0x80, 0x3F, 0xE0, 0x3F, 0x0F,
  0xFF, 0x80, 0xFF, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xF0, 0x03, 0xFF, 0xFF,
  0x80, 0x07, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x03, 0xF0, 0x01, 0xF8, 0x07, 0xE0,
  0x03, 0xF0, 0x0F, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x1F, 0x80, 0x1F, 0x80,
  0x3F, 0x00, 0x3F, 0x80, 0x7E, 0x00, 0x3F, 0x01, 0xFC, 0x00, 0x7E, 0x03,
  0xF0, 0x00, 0xFE, 0x07, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x01, 0xFC, 0x1F,
  0x80, 0x03, 0xF8, 0x7F, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x07, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFE, 0x01, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x00, 0xFF, 0x01, 0xF0, 0x0F, 0xF0, 0x01,
  0x80, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x03, 0xF8, 0x30, 0x00, 0x3F, 0xC1, 0xE0, 0x07, 0xFC, 0x0F, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFB,
  0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF,
  0xFF, 0xFF, 0x7F, 0xFF, 0xFF, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00, 0xFC, 0x0F, 0xC0,
  0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x00, 0xFE, 0x0F,
  0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00, 0x7E,
  0x0F, 0xE0, 0x00, 0x0F, 0xC1, 0xF8, 0x00, 0x03, 0xF0, 0x3F, 0x00, 0x00,
  0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x3F, 0x80,
  0x00, 0x7F, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x01, 0xF8, 0x1F,
  0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0xFE, 0x00, 0x01, 0xFC,
  0x1F, 0x80, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x00,
  0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xF0, 0x7E, 0x00,
  0x00, 0xFC, 0x0F, 0xC0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0, 0x7F,
  0x00, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x03, 0xF0,
  0x3F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xC0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0xE0,
  0x1F, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x07,
  0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x01, 0xFF, 0xF0, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00,
  0x7F, 0xFC, 0x00, 0x00, 0x7E, 0x7C, 0x00, 0x00, 0xFE, 0x7E, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03,
  0xF8, 0x7E, 0x00, 0x03, 0xF0, 0x7E, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0x7E, 0x00, 0x0F, 0xC0, 0x3E, 0x00, 0x1F,
  0x80, 0x3E, 0x00, 0x1F, 0x80, 0x3E, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F,
  0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x01, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0x3F, 0x03, 0xF8,
  0x00, 0x1F, 0x03, 0xF0, 0x00, 0x1F, 0x07, 0xF0, 0x00, 0x1F, 0x07, 0xE0,
  0x00, 0x1F, 0x0F, 0xE0, 0x00, 0x1F, 0x8F, 0xC0, 0x00, 0x1F, 0x9F, 0x80,
  0x00, 0x1F, 0x9F, 0x80, 0x00, 0x1F, 0x9F, 0x00, 0x00, 0x1F, 0xBF, 0x00,
  0x00, 0x1F, 0xBE, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x0F, 0xFC, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xE0, 0x00,
  0x3F, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7E, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0xFC, 0x00, 0x1F, 0xE0, 0x00,
  0xFC, 0xFC, 0x00, 0x3F, 0xE0, 0x01, 0xFC, 0xFC, 0x00, 0x3F, 0xE0, 0x01,
  0xF8, 0xFC, 0x00, 0x7F, 0xE0, 0x01, 0xF8, 0xFC, 0x00, 0x7F, 0xE0, 0x03,
  0xF0, 0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF0, 0xFC, 0x00, 0xFB, 0xF0, 0x07,
  0xE0, 0xFC, 0x00, 0xFB, 0xF0, 0x07, 0xE0, 0xFC, 0x01, 0xF1, 0xF0, 0x0F,
  0xE0, 0xFC, 0x01, 0xF1, 0xF0, 0x0F, 0xC0, 0xFC, 0x03, 0xF1, 0xF0, 0x0F,
  0xC0, 0xFC, 0x03, 0xE1, 0xF0, 0x1F, 0x80, 0xFC, 0x07, 0xE1, 0xF0, 0x1F,
  0x80, 0x7C, 0x07, 0xC1, 0xF0, 0x3F, 0x00, 0x7C, 0x0F, 0xC1, 0xF0, 0x3F,
  0x00, 0x7C, 0x0F, 0x81, 0xF0, 0x7E, 0x00, 0x7C, 0x1F, 0x81, 0xF0, 0x7E,
  0x00, 0x7C, 0x1F, 0x01, 0xF0, 0x7E, 0x00, 0x7C, 0x3F, 0x01, 0xF0, 0xFC,
  0x00, 0x7C, 0x3E, 0x01, 0xF0, 0xFC, 0x00, 0x7C, 0x3E, 0x01, 0xF1, 0xF8,
  0x00, 0x7C, 0x7E, 0x01, 0xF1, 0xF8, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xF0,
  0x00, 0x7C, 0xFC, 0x01, 0xF3, 0xF0, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0,
  0x00, 0x7D, 0xF8, 0x01, 0xF7, 0xE0, 0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0,
  0x00, 0x7D, 0xF0, 0x01, 0xF7, 0xC0, 0x00, 0x7F, 0xE0, 0x01, 0xFF, 0xC0,
  0x00, 0x7F, 0xE0, 0x01, 0xFF, 0x80, 0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x80,
  0x00, 0x7F, 0xC0, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0xFE,
  0x00, 0x7E, 0x00, 0x03, 0xF8, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFC,
  0x00, 0x1F, 0xC0, 0x01, 0xF8, 0x00, 0x7F, 0x00, 0x03, 0xF0, 0x01, 0xFC,
  0x00, 0x03, 0xF0, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x0F, 0xC0, 0x00, 0x0F,
  0xC0, 0x3F, 0x80, 0x00, 0x0F, 0xC0, 0xFE, 0x00, 0x00, 0x1F, 0x83, 0xF8,
  0x00, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0x00, 0x3F, 0x1F, 0x80, 0x00, 0x00,
  0x7E, 0x7F, 0x00, 0x00, 0x00, 0x7D, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0x9F,
  0x80, 0x00, 0x00, 0x7F, 0x3F, 0x00, 0x00, 0x01, 0xFC, 0x7E, 0x00, 0x00,
  0x07, 0xF0, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x00, 0x7F, 0x00,
  0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x1F, 0x80,
  0x0F, 0xE0, 0x00, 0x3F, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0x01, 0xFD, 0xF8, 0x00, 0x07, 0xE7, 0xE0,
  0x00, 0x3F, 0x9F, 0x80, 0x01, 0xFC, 0x7E, 0x00, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x0F, 0xC0, 0x07, 0xE0, 0x3F, 0x00, 0x3F,
  0x80, 0x7C, 0x01, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x07, 0xE0, 0x3F, 0x80,
  0x1F, 0x81, 0xFC, 0x00, 0x3E, 0x07, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x03,
  0xF1, 0xFC, 0x00, 0x0F, 0xC7, 0xE0, 0x00, 0x1F, 0x3F, 0x00, 0x00, 0x7E,
  0xFC, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF,
  0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F,
  0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0xFF,
  0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0xFC, 0x03, 0xFF,
  0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x3F, 0xF8, 0x00, 0xFF, 0xF0, 0x01, 0xFF, 0xE0, 0x03, 0xFF, 0xC0, 0x07,
  0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFC, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x80, 0x00, 0x3F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0x00, 0x1F, 0xFE, 0x00, 0x3F,
  0xFC, 0x00, 0x7F, 0xF0, 0x01, 0xFF, 0xE0, 0x00, 0xFC, 0x0F, 0xC0, 0x7C,
  0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xE0, 0x7E, 0x03, 0xE0, 0x3E,
  0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0x01, 0xF0, 0x1F,
  0x01, 0xF0, 0x1F, 0x81, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F,
  0x80, 0xFC, 0x0F, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0xE0, 0x7E, 0x03, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xF0, 0x00, 0x3F,
  0xFC, 0x00, 0xFF, 0xF0, 0x03, 0xFF, 0xC0, 0x0F, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x01, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00,
  0x0F, 0xC0, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F,
  0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFC, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x01,
  0xF8, 0x01, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x3F, 0xFC, 0x00, 0xFF, 0xF0,
  0x03, 0xFF, 0xC0, 0x00, 0x00, 0x07, 0x80, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x00, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xDF, 0x00, 0x00, 0x7C, 0xF0, 0x00,
  0x0F, 0x8F, 0x80, 0x00, 0xF8, 0x78, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x3E, 0x03, 0xE0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x01, 0xF0,
  0x07, 0xC0, 0x1F, 0x00, 0xF8, 0x00, 0xF8, 0x0F, 0x80, 0x0F, 0x81, 0xF0,
  0x00, 0xF8, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0x7C, 0x3E, 0x00, 0x03,
  0xE7, 0xC0, 0x00, 0x3E, 0x7C, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x1F, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0, 0xFE,
  0x1F, 0x87, 0xE0, 0xFC, 0x1F, 0x07, 0xE0, 0xF8, 0x1F, 0x03, 0xC0, 0x00,
  0x3F, 0xC0, 0xF8, 0x07, 0xFF, 0x87, 0xC0, 0x7F, 0xFE, 0x7C, 0x07, 0xFF,
  0xF3, 0xE0, 0x7F, 0xFF, 0xFF, 0x07, 0xF8, 0x1F, 0xF8, 0x3F, 0x80, 0x7F,
  0xC3, 0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F,
  0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F,
  0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xFC, 0x1F, 0x80,
  0x1F, 0xE0, 0xFE, 0x01, 0xFF, 0x07, 0xF0, 0x3F, 0xF0, 0x1F, 0xF7, 0xEF,
  0x80, 0xFF, 0xFE, 0x7C, 0x03, 0xFF, 0xE3, 0xE0, 0x0F, 0xFE, 0x1F, 0x00,
  0x3F, 0xC1, 0xF0, 0x00, 0x10, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x7F, 0x80, 0x07, 0xE3, 0xFF, 0x00,
  0x3F, 0x3F, 0xFE, 0x00, 0xFD, 0xFF, 0xFC, 0x03, 0xFF, 0xFF, 0xF0, 0x0F,
  0xBC, 0x0F, 0xE0, 0x3F, 0xE0, 0x1F, 0x81, 0xFF, 0x00, 0x7E, 0x07, 0xF8,
  0x01, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x7F, 0x00, 0x1F, 0xC1, 0xF8, 0x00,
  0x7F, 0x0F, 0xE0, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0xFC, 0x00, 0x1F,
  0x83, 0xF0, 0x00, 0x7E, 0x1F, 0x80, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xE1,
  0xF8, 0x00, 0x3F, 0x07, 0xE0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xF0, 0xFE,
  0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x03, 0xF8, 0x3F, 0xC0,
  0x1F, 0xC0, 0xFF, 0x80, 0xFE, 0x07, 0xFF, 0x9F, 0xF8, 0x1F, 0x3F, 0xFF,
  0xC0, 0x7C, 0xFF, 0xFE, 0x01, 0xF1, 0xFF, 0xE0, 0x0F, 0x83, 0xFF, 0x00,
  0x00, 0x01, 0x80, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0x01, 0xFF,
  0xFE, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFE, 0x0F, 0xF8, 0x0C, 0x1F, 0xE0,
  0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x60, 0x7F, 0xE7,
  0xE0, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF, 0xE0, 0x0F, 0xFF, 0xE0, 0x03, 0xFF,
  0x80, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00,
  0x00, 0x0F, 0xC0, 0x03, 0xFC, 0x1F, 0x80, 0x1F, 0xFE, 0x3F, 0x00, 0x7F,
  0xFE, 0x7C, 0x01, 0xFF, 0xFD, 0xF8, 0x07, 0xFF, 0xFF, 0xF0, 0x1F, 0xE0,
  0x7F, 0xE0, 0x7F, 0x80, 0x7F, 0x80, 0xFE, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0xFE, 0x07, 0xF0, 0x01, 0xFC, 0x1F, 0xC0, 0x03, 0xF8, 0x3F, 0x80, 0x07,
  0xE0, 0x7E, 0x00, 0x0F, 0xC0, 0xFC, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0x3F,
  0x07, 0xE0, 0x00, 0x7E, 0x0F, 0xC0, 0x01, 0xF8, 0x1F, 0x80, 0x03, 0xF0,
  0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x1F, 0xC0, 0xFC, 0x00, 0x3F, 0x01,
  0xF8, 0x00, 0xFE, 0x03, 0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x07, 0xF8, 0x0F,
  0xC0, 0x1F, 0xF0, 0x1F, 0xC0, 0x7F, 0xC0, 0x1F, 0xF7, 0xEF, 0x80, 0x3F,
  0xFF, 0x9F, 0x00, 0x3F, 0xFE, 0x3E, 0x00, 0x3F, 0xF8, 0x7C, 0x00, 0x3F,
  0xE0, 0xF0, 0x00, 0x04, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x3F,
  0xFE, 0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xE0, 0x7F, 0xEF, 0xF0, 0x7F,
  0x81, 0xFC, 0x3F, 0x00, 0x7E, 0x3F, 0x80, 0x3F, 0x3F, 0x80, 0x1F, 0x9F,
  0x80, 0x0F, 0xDF, 0xC0, 0x0F, 0xCF, 0xC0, 0x0F, 0xE7, 0xE0, 0x1F, 0xE7,
  0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0x80,
  0x7F, 0xFE, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0, 0x00,
  0x07, 0xE0, 0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x08, 0x3F, 0x80, 0x1C, 0x1F, 0xF8, 0x7E, 0x07, 0xFF, 0xFF, 0x01, 0xFF,
  0xFF, 0x80, 0x7F, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x00, 0xE0, 0x00, 0x00,
  0x00, 0x00, 0xE0, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0xFF, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x7F, 0x86, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x7F, 0xFF, 0xC0, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00,
  0x0F, 0xC0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x8F, 0xF0, 0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x78,
  0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x3E, 0x00, 0x7F, 0xF8, 0x7C, 0x01,
  0xFF, 0xF9, 0xF0, 0x07, 0xFF, 0xF3, 0xE0, 0x1F, 0xFF, 0xFF, 0xC0, 0x7F,
  0x81, 0xFF, 0x81, 0xFE, 0x01, 0xFF, 0x03, 0xF8, 0x01, 0xFC, 0x0F, 0xE0,
  0x03, 0xF8, 0x1F, 0xC0, 0x07, 0xF0, 0x3F, 0x00, 0x0F, 0xE0, 0xFE, 0x00,
  0x1F, 0x81, 0xF8, 0x00, 0x3F, 0x03, 0xF0, 0x00, 0x7E, 0x0F, 0xE0, 0x00,
  0xFC, 0x1F, 0x80, 0x01, 0xF8, 0x3F, 0x00, 0x07, 0xE0, 0x7E, 0x00, 0x0F,
  0xC0, 0xFC, 0x00, 0x1F, 0x81, 0xF8, 0x00, 0x7F, 0x03, 0xF0, 0x00, 0xFE,
  0x07, 0xE0, 0x03, 0xF8, 0x0F, 0xC0, 0x0F, 0xF0, 0x1F, 0x80, 0x1F, 0xE0,
  0x3F, 0x80, 0x7F, 0xC0, 0x7F, 0x03, 0xFF, 0x00, 0x7F, 0xDF, 0xBE, 0x00,
  0xFF, 0xFE, 0xFC, 0x00, 0xFF, 0xF9, 0xF8, 0x00, 0xFF, 0xE3, 0xF0, 0x00,
  0xFF, 0x0F, 0xC0, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x0F, 0xE0, 0x10, 0x00, 0x1F, 0x80, 0x38, 0x00, 0xFF, 0x00, 0x7E, 0x07,
  0xFC, 0x00, 0xFF, 0xFF, 0xF0, 0x01, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x7F,
  0xF0, 0x0F, 0xC7, 0xFF, 0xC0, 0x7E, 0xFF, 0xFE, 0x03, 0xF7, 0xFF, 0xF8,
  0x1F, 0x7C, 0x1F, 0xC0, 0xFF, 0x80, 0x7E, 0x0F, 0xF8, 0x03, 0xF0, 0x7F,
  0x80, 0x1F, 0x83, 0xF8, 0x00, 0xFC, 0x1F, 0xC0, 0x07, 0xE0, 0xFC, 0x00,
  0x3F, 0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC3, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE1, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00,
  0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC,
  0x1F, 0x80, 0x07, 0xE1, 0xF8, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E,
  0x00, 0x1F, 0x83, 0xF0, 0x00, 0xFC, 0x3F, 0x80, 0x07, 0xE0, 0x00, 0x3E,
  0x00, 0xFC, 0x03, 0xF8, 0x07, 0xF0, 0x0F, 0xE0, 0x0F, 0x80, 0x04, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xC0, 0x1F, 0x80, 0x7F,
  0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x1F, 0x80, 0x3F, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x07, 0xE0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0xFE, 0x01, 0xF8, 0x03, 0xF0, 0x07, 0xE0, 0x0F, 0xC0, 0x3F, 0x80,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x03, 0xF0, 0x0F, 0xC0, 0x1F, 0x80, 0x3F,
  0x00, 0x7E, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0x80, 0x00,
  0x04, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFC,
  0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80,
  0x00, 0x3F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFC, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xF0, 0x02, 0x3F, 0xC0, 0x07, 0xFF, 0x80, 0x0F, 0xFE,
  0x00, 0x1F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF8, 0x01, 0xFC, 0x07,
  0xE0, 0x0F, 0xE0, 0x3F, 0x00, 0x7F, 0x00, 0xFC, 0x03, 0xF8, 0x03, 0xF0,
  0x1F, 0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x07, 0xF0, 0x01, 0xF8, 0x3F,
  0x80, 0x07, 0xE1, 0xFC, 0x00, 0x1F, 0x8F, 0xE0, 0x00, 0x7E, 0x3F, 0x00,
  0x03, 0xF1, 0xF8, 0x00, 0x0F, 0xCF, 0xC0, 0x00, 0x3F, 0x7E, 0x00, 0x00,
  0xFB, 0xFC, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x1F, 0xFF, 0xC0, 0x00, 0x7F,
  0xFF, 0x80, 0x01, 0xFE, 0x7E, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x1F, 0x83,
  0xF0, 0x00, 0xFC, 0x0F, 0xE0, 0x03, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x7F,
  0x00, 0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x07, 0xE0, 0x07, 0xE0,
  0x1F, 0x80, 0x1F, 0xC0, 0x7E, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x0F,
  0xE0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x7E,
  0x00, 0x7E, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0xFC,
  0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x03, 0xF0, 0x03, 0xF0,
  0x03, 0xF0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xE0, 0x07, 0xE0, 0x07, 0xE0,
  0x07, 0xE0, 0x07, 0xE0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0, 0x0F, 0xC0,
  0x1F, 0xC0, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x00,
  0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x7E, 0x00,
  0x7E, 0x00, 0x7E, 0x00, 0xFE, 0x00, 0x01, 0xF0, 0x7F, 0x80, 0x1F, 0xE0,
  0x07, 0xC3, 0xFF, 0x01, 0xFF, 0xC0, 0x3F, 0x3F, 0xFE, 0x0F, 0xFF, 0x80,
  0xF9, 0xFF, 0xF8, 0x7F, 0xFE, 0x03, 0xEF, 0xFF, 0xF3, 0xFF, 0xFC, 0x0F,
  0xBC, 0x0F, 0xDF, 0x07, 0xF0, 0x3F, 0xE0, 0x3F, 0xF0, 0x0F, 0xC1, 0xFF,
  0x00, 0xFF, 0x80, 0x3F, 0x07, 0xF8, 0x01, 0xFE, 0x00, 0xFC, 0x1F, 0xC0,
  0x0F, 0xF0, 0x03, 0xF0, 0x7F, 0x00, 0x3F, 0x80, 0x0F, 0xC1, 0xF8, 0x00,
  0xFE, 0x00, 0x3F, 0x0F, 0xE0, 0x03, 0xF0, 0x00, 0xFC, 0x3F, 0x00, 0x0F,
  0xC0, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x00, 0x1F, 0x83, 0xF0, 0x01, 0xF8,
  0x00, 0x7E, 0x0F, 0xC0, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0x80,
  0x07, 0xE1, 0xF8, 0x00, 0x7E, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x00,
  0xFC, 0x1F, 0x80, 0x0F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x00, 0x0F,
  0xC3, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x03, 0xF0, 0x01, 0xF8,
  0x3F, 0x00, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7E, 0x00, 0x1F, 0x87,
  0xE0, 0x01, 0xF8, 0x00, 0x7E, 0x1F, 0x80, 0x07, 0xE0, 0x03, 0xF8, 0x7E,
  0x00, 0x1F, 0x80, 0x0F, 0xC1, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x0F, 0xE0,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x01, 0xF0, 0x7F, 0xC0, 0x0F, 0x87, 0xFF,
  0x00, 0xFC, 0xFF, 0xFC, 0x07, 0xEF, 0xFF, 0xF0, 0x3E, 0xFF, 0xFF, 0x81,
  0xF7, 0xC1, 0xFC, 0x1F, 0xF8, 0x07, 0xE0, 0xFF, 0x80, 0x3F, 0x07, 0xF8,
  0x01, 0xF8, 0x3F, 0xC0, 0x0F, 0xC1, 0xFC, 0x00, 0x7E, 0x1F, 0xC0, 0x03,
  0xF0, 0xFE, 0x00, 0x1F, 0x87, 0xF0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0,
  0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03,
  0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0, 0x01, 0xFC, 0x3F, 0x00, 0x0F, 0xC3,
  0xF8, 0x00, 0x7E, 0x1F, 0xC0, 0x03, 0xF0, 0xFC, 0x00, 0x3F, 0x87, 0xE0,
  0x01, 0xF8, 0x3F, 0x00, 0x0F, 0xC3, 0xF8, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x0F, 0xFF, 0x80, 0x07, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80,
  0x7F, 0xFF, 0xF8, 0x1F, 0xE0, 0x7F, 0x07, 0xF8, 0x07, 0xF0, 0xFE, 0x00,
  0x7E, 0x3F, 0x80, 0x0F, 0xC7, 0xE0, 0x00, 0xFD, 0xFC, 0x00, 0x1F, 0xBF,
  0x00, 0x03, 0xF7, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x7F, 0xFC, 0x00, 0x0F, 0xDF, 0x80, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01, 0xF9, 0xF8, 0x00, 0x3F,
  0x3F, 0x00, 0x0F, 0xE7, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0xFE, 0x0F, 0xE0,
  0x3F, 0xC1, 0xFF, 0xBF, 0xF0, 0x1F, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0x00,
  0x1F, 0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x80, 0x00, 0x00, 0x7C,
  0x0F, 0xE0, 0x00, 0x7C, 0x3F, 0xF0, 0x00, 0x7C, 0xFF, 0xF8, 0x00, 0xF9,
  0xFF, 0xFC, 0x00, 0xFB, 0xFF, 0xFC, 0x00, 0xFB, 0xC0, 0xFE, 0x00, 0xFF,
  0x80, 0x7E, 0x01, 0xFF, 0x00, 0x7E, 0x01, 0xFE, 0x00, 0x7E, 0x01, 0xFC,
  0x00, 0x7F, 0x01, 0xFC, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0, 0x00, 0x7E, 0x03, 0xF0,
  0x00, 0x7E, 0x03, 0xE0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0xFE, 0x07, 0xE0,
  0x00, 0xFC, 0x07, 0xE0, 0x00, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x0F, 0xE0,
  0x01, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xE0, 0x03, 0xF8, 0x0F, 0xF0,
  0x07, 0xF0, 0x0F, 0xF8, 0x0F, 0xE0, 0x1F, 0xFE, 0x7F, 0xE0, 0x1F, 0xBF,
  0xFF, 0xC0, 0x1F, 0x9F, 0xFF, 0x80, 0x1F, 0x9F, 0xFE, 0x00, 0x1F, 0x07,
  0xFC, 0x00, 0x3F, 0x01, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0xF8, 0x07, 0xFF, 0x87, 0xC0, 0x7F, 0xFE, 0x7C, 0x07, 0xFF, 0xF3,
  0xE0, 0x7F, 0xFF, 0xDF, 0x07, 0xF8, 0x1F, 0xF8, 0x7F, 0x80, 0x7F, 0xC3,
  0xF8, 0x01, 0xFC, 0x3F, 0x80, 0x0F, 0xE1, 0xFC, 0x00, 0x7F, 0x1F, 0xC0,
  0x03, 0xF8, 0xFE, 0x00, 0x1F, 0x87, 0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07,
  0xE3, 0xF8, 0x00, 0x3F, 0x1F, 0x80, 0x01, 0xF8, 0xFC, 0x00, 0x1F, 0x87,
  0xE0, 0x00, 0xFC, 0x3F, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x7F, 0x0F, 0xC0,
  0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x01, 0xFC, 0x1F, 0x80, 0x1F,
  0xE0, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x1F, 0xF0, 0x1F, 0xF7, 0xEF, 0x80,
  0xFF, 0xFE, 0xFC, 0x03, 0xFF, 0xE7, 0xE0, 0x0F, 0xFE, 0x3F, 0x00, 0x3F,
  0xC3, 0xF0, 0x00, 0x10, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80,
  0x00, 0x00, 0xFC, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x07,
  0xE0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x01, 0xF0, 0x7F, 0x01, 0xF1, 0xFF,
  0x03, 0xF3, 0xFE, 0x03, 0xF7, 0xFE, 0x03, 0xE7, 0xFE, 0x03, 0xEF, 0xC2,
  0x03, 0xFF, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xF8, 0x00, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0xFF, 0xFE, 0x03, 0xFF, 0xFF,
  0x07, 0xFF, 0xFF, 0x07, 0xFF, 0xFE, 0x0F, 0xE0, 0x0E, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x0F, 0xE0, 0x00,
  0x0F, 0xF0, 0x00, 0x07, 0xFC, 0x00, 0x07, 0xFE, 0x00, 0x03, 0xFF, 0x80,
  0x00, 0xFF, 0xC0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF8,
  0x00, 0x03, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8, 0x00, 0x01, 0xF8,
  0x00, 0x01, 0xF8, 0x80, 0x01, 0xF8, 0xE0, 0x03, 0xF8, 0xFC, 0x1F, 0xF0,
  0xFF, 0xFF, 0xF0, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0x00,
  0x00, 0xC0, 0x00, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8,
  0x00, 0x1F, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x7F, 0xFF, 0x7F, 0xFF,
  0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0x7F, 0xFF, 0xE0, 0xFC, 0x00, 0x1F, 0x80,
  0x03, 0xF0, 0x00, 0xFC, 0x00, 0x1F, 0x80, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0x1F, 0xC0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00,
  0x7F, 0x00, 0x0F, 0xC0, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x01,
  0xF8, 0x00, 0x3F, 0x00, 0x07, 0xE0, 0x00, 0xFE, 0x00, 0x1F, 0xE3, 0x01,
  0xFF, 0xE0, 0x3F, 0xFC, 0x03, 0xFF, 0x80, 0x3F, 0xF0, 0x00, 0x40, 0x00,
  0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0x7E, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x07, 0xE0, 0x01, 0xF8, 0x7E, 0x00,
  0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F,
  0x0F, 0xE0, 0x01, 0xF8, 0x7E, 0x00, 0x0F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F,
  0x80, 0x07, 0xE0, 0xFC, 0x00, 0x3F, 0x0F, 0xC0, 0x01, 0xF8, 0x7E, 0x00,
  0x1F, 0xC3, 0xF0, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xE0, 0xFC, 0x00, 0x7F,
  0x0F, 0xC0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x83, 0xF0, 0x03, 0xFC, 0x1F,
  0x80, 0x1F, 0xE0, 0xFC, 0x01, 0xFF, 0x07, 0xF0, 0x3F, 0xF8, 0x3F, 0xEF,
  0xEF, 0x80, 0xFF, 0xFE, 0x7C, 0x07, 0xFF, 0xE3, 0xE0, 0x1F, 0xFE, 0x1F,
  0x00, 0x7F, 0xC0, 0xF8, 0x00, 0x60, 0x00, 0x00, 0xFC, 0x00, 0x07, 0xFF,
  0x80, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xEF, 0xC0, 0x01,
  0xF9, 0xF8, 0x00, 0x7E, 0x1F, 0x00, 0x0F, 0xC3, 0xE0, 0x03, 0xF0, 0x7C,
  0x00, 0x7E, 0x0F, 0xC0, 0x1F, 0x81, 0xF8, 0x07, 0xF0, 0x3F, 0x00, 0xFC,
  0x07, 0xE0, 0x3F, 0x80, 0xFC, 0x07, 0xE0, 0x1F, 0x81, 0xFC, 0x01, 0xF0,
  0x3F, 0x00, 0x3E, 0x0F, 0xE0, 0x07, 0xC1, 0xF8, 0x00, 0xF8, 0x7E, 0x00,
  0x1F, 0x8F, 0xC0, 0x03, 0xF3, 0xF0, 0x00, 0x7E, 0x7E, 0x00, 0x0F, 0xDF,
  0x80, 0x00, 0xFB, 0xF0, 0x00, 0x1F, 0x7C, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xFF, 0x00,
  0x1F, 0xC0, 0x07, 0xEF, 0xC0, 0x0F, 0xF0, 0x03, 0xFB, 0xF0, 0x03, 0xFC,
  0x00, 0xFC, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x1F, 0x00, 0x7F, 0xC0, 0x1F,
  0x87, 0xC0, 0x1E, 0xF0, 0x07, 0xE1, 0xF0, 0x0F, 0xBC, 0x03, 0xF0, 0x7C,
  0x03, 0xEF, 0x00, 0xFC, 0x1F, 0x01, 0xF3, 0xC0, 0x7E, 0x07, 0xC0, 0x7C,
  0xF0, 0x1F, 0x81, 0xF0, 0x3E, 0x3C, 0x0F, 0xC0, 0x7C, 0x0F, 0x8F, 0x03,
  0xF0, 0x1F, 0x07, 0xC3, 0xE0, 0xFC, 0x07, 0xC1, 0xF0, 0xF8, 0x7E, 0x01,
  0xF0, 0xFC, 0x3E, 0x1F, 0x80, 0x7C, 0x3E, 0x0F, 0x8F, 0xC0, 0x1F, 0x0F,
  0x83, 0xE3, 0xF0, 0x07, 0xC7, 0xC0, 0xF9, 0xF8, 0x01, 0xF1, 0xF0, 0x3E,
  0x7E, 0x00, 0x7C, 0xF8, 0x0F, 0x9F, 0x00, 0x1F, 0x3E, 0x03, 0xEF, 0xC0,
  0x07, 0xCF, 0x00, 0xFB, 0xE0, 0x01, 0xF7, 0xC0, 0x3E, 0xF8, 0x00, 0x7D,
  0xE0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x03, 0xFF, 0x00, 0x07, 0xFE, 0x00,
  0xFF, 0x80, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x00, 0x3F, 0xC0, 0x0F, 0xF8,
  0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0xFF, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x7F, 0x01, 0xF8, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFC,
  0x00, 0xFC, 0x01, 0xFC, 0x00, 0xFC, 0x03, 0xF8, 0x00, 0x7E, 0x07, 0xF0,
  0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x3F, 0x1F, 0x80,
  0x00, 0x3F, 0x3F, 0x80, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x3F, 0xF8, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0xFE, 0xFC, 0x00,
  0x00, 0xFC, 0xFC, 0x00, 0x01, 0xF8, 0x7E, 0x00, 0x03, 0xF8, 0x7E, 0x00,
  0x07, 0xF0, 0x7F, 0x00, 0x0F, 0xE0, 0x3F, 0x00, 0x1F, 0xC0, 0x3F, 0x00,
  0x1F, 0x80, 0x1F, 0x80, 0x3F, 0x80, 0x1F, 0x80, 0x7F, 0x00, 0x0F, 0xC0,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xFC, 0x00, 0x07, 0xE0, 0x1F, 0x80, 0x01,
  0xFC, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xE0, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0xF8, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x0F, 0xC0, 0x03,
  0xF0, 0x03, 0xF0, 0x00, 0x7E, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x1F, 0x80,
  0x01, 0xF8, 0x03, 0xF0, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x03, 0xE0, 0x1F,
  0x80, 0x00, 0x7C, 0x07, 0xE0, 0x00, 0x0F, 0xC1, 0xFC, 0x00, 0x01, 0xF8,
  0x3F, 0x00, 0x00, 0x3F, 0x0F, 0xE0, 0x00, 0x07, 0xE1, 0xF8, 0x00, 0x00,
  0xFC, 0x7E, 0x00, 0x00, 0x0F, 0x8F, 0xC0, 0x00, 0x01, 0xF3, 0xF0, 0x00,
  0x00, 0x3E, 0x7E, 0x00, 0x00, 0x07, 0xCF, 0x80, 0x00, 0x00, 0xFB, 0xF0,
  0x00, 0x00, 0x1F, 0x7C, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00,
  0x00, 0x0F, 0xC0, 0x00, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x04, 0x3F, 0xE0, 0x00, 0x00, 0xFF,
  0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x03, 0xC0, 0x00, 0x00, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x3F, 0xFF, 0xF8, 0x07, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x3F,
  0xFF, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x81, 0xFF,
  0xFF, 0xF0, 0x3F, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x1E, 0x00, 0x03, 0xFC,
  0x00, 0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFF, 0xC0, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x7F, 0x00, 0x1F, 0xFC, 0x00,
  0x3F, 0xF0, 0x00, 0x7F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFF, 0x00, 0x04,
  0xFE, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xE0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xFF, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x03, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x78, 0x00, 0x01, 0xFC, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0xFF, 0xC0, 0x00, 0x7F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C,
  0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8, 0x00,
  0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xFF,
  0x00, 0x03, 0xFC, 0x00, 0x07, 0xE0, 0x00, 0xFF, 0x80, 0x0F, 0xFE, 0x00,
  0x3F, 0x80, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x3F, 0x00, 0x00, 0xFC, 0x00, 0x03, 0xF0, 0x00, 0x0F,
  0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8, 0x00, 0x0F, 0xC0, 0x03, 0xFF, 0x00,
  0x0F, 0xF8, 0x00, 0x3F, 0xE0, 0x00, 0xFE, 0x00, 0x03, 0xE0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x2F, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xA0, 0x01, 0xFF, 0xE4,
  0x00, 0x07, 0xF0,
};

const GFXglyph NotoSans_MediumItalic57pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 15, 0, -1 },
  { 1, 15, 42, 15, 1, -41 },
  { 80, 18, 15, 23, 6, -41 },
  { 114, 35, 41, 37, 2, -41 },
  { 294, 28, 46, 31, 2, -43 },
  { 455, 40, 42, 47, 4, -41 },
  { 665, 36, 42, 39, 2, -41 },
  { 854, 8, 15, 13, 6, -41 },
  { 869, 20, 50, 17, 2, -41 },
  { 994, 19, 50, 17, -4, -41 },
  { 1113, 26, 27, 31, 6, -44 },
  { 1201, 27, 28, 33, 4, -34 },
  { 1296, 13, 14, 15, -3, -7 },
  { 1319, 15, 5, 18, 1, -18 },
  { 1329, 8, 8, 15, 1, -7 },
  { 1337, 29, 41, 21, -3, -41 },
  { 1486, 28, 42, 31, 3, -41 },
  { 1633, 19, 41, 31, 7, -41 },
  { 1731, 30, 41, 31, 0, -41 },
  { 1885, 29, 42, 31, 1, -41 },
  { 2038, 30, 41, 31, 0, -41 },
  { 2192, 29, 42, 31, 2, -41 },
  { 2345, 28, 42, 31, 3, -41 },
  { 2492, 29, 41, 31, 4, -41 },
  { 2641, 29, 42, 31, 2, -41 },
  { 2794, 27, 42, 31, 3, -41 },
  { 2936, 13, 32, 15, 1, -31 },
  { 2988, 17, 38, 15, -3, -31 },
  { 3069, 27, 29, 33, 4, -35 },
  { 3167, 27, 16, 33, 4, -28 },
  { 3221, 27, 29, 33, 4, -35 },
  { 3319, 23, 42, 25, 4, -41 },
  { 3440, 44, 46, 48, 3, -41 },
  { 3693, 33, 41, 33, -3, -41 },
  { 3863, 32, 41, 35, 2, -41 },
  { 4027, 32, 42, 34, 4, -41 },
  { 4195, 34, 41, 38, 2, -41 },
  { 4370, 30, 41, 30, 2, -41 },
  { 4524, 30, 41, 28, 2, -41 },
  { 4678, 34, 42, 39, 4, -41 },
  { 4857, 37, 41, 39, 2, -41 },
  { 5047, 24, 41, 19, -1, -41 },
  { 5170, 26, 52, 17, -9, -41 },
  { 5339, 36, 41, 33, 2, -41 },
  { 5524, 22, 41, 28, 2, -41 },
  { 5637, 47, 41, 49, 2, -41 },
  { 5878, 39, 41, 41, 2, -41 },
  { 6078, 36, 42, 41, 4, -41 },
  { 6267, 31, 41, 33, 2, -41 },
  { 6426, 36, 51, 41, 4, -41 },
  { 6656, 31, 41, 33, 2, -41 },
  { 6815, 29, 42, 29, 1, -41 },
  { 6968, 29, 41, 29, 5, -41 },
  { 7117, 35, 42, 39, 4, -41 },
  { 7301, 32, 41, 32, 5, -41 },
  { 7465, 48, 41, 49, 6, -41 },
  { 7711, 39, 41, 31, -3, -41 },
  { 7911, 30, 41, 30, 5, -41 },
  { 8065, 34, 41, 30, -1, -41 },
  { 8240, 23, 50, 17, -1, -41 },
  { 8384, 12, 41, 21, 6, -41 },
  { 8446, 22, 50, 17, -4, -41 },
  { 8584, 28, 26, 32, 2, -41 },
  { 8675, 23, 4, 23, -5, 5 },
  { 8687, 10, 9, 17, 8, -44 },
  { 8699, 29, 32, 33, 3, -31 },
  { 8815, 30, 44, 33, 1, -43 },
  { 8980, 24, 32, 26, 3, -31 },
  { 9076, 31, 44, 33, 3, -43 },
  { 9247, 25, 32, 29, 3, -31 },
  { 9347, 32, 58, 19, -6, -44 },
  { 9579, 31, 45, 33, 1, -31 },
  { 9754, 29, 43, 33, 1, -43 },
  { 9910, 15, 42, 15, 1, -42 },
  { 9989, 23, 56, 15, -7, -42 },
  { 10150, 30, 43, 29, 1, -43 },
  { 10312, 16, 43, 15, 1, -43 },
  { 10398, 46, 31, 50, 1, -31 },
  { 10577, 29, 31, 33, 1, -31 },
  { 10690, 27, 32, 32, 3, -31 },
  { 10798, 32, 45, 33, -1, -31 },
  { 10978, 29, 45, 33, 3, -31 },
  { 11142, 24, 31, 23, 1, -31 },
  { 11235, 24, 32, 25, 0, -31 },
  { 11331, 19, 39, 20, 3, -38 },
  { 11424, 29, 32, 33, 3, -31 },
  { 11540, 27, 31, 27, 3, -31 },
  { 11645, 42, 31, 42, 3, -31 },
  { 11808, 32, 31, 28, -2, -31 },
  { 11932, 35, 45, 27, -5, -31 },
  { 12129, 27, 31, 26, -1, -31 },
  { 12234, 23, 50, 20, 0, -41 },
  { 12378, 5, 57, 31, 14, -43 },
  { 12414, 22, 50, 20, -2, -41 },
  { 12552, 27, 8, 33, 4, -24 },
};

const GFXfont NotoSans_MediumItalic57pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic57pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic57pt7bGlyphs,
  0x20, 0x7E, 78
};

#endif // _NOTOSANS_MEDIUMITALIC57PT7B_H_
