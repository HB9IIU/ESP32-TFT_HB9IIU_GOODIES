#ifndef _NOTOSANS_MEDIUMITALIC68PT7B_H_
#define _NOTOSANS_MEDIUMITALIC68PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 68pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic68pt7bBitmaps[] PROGMEM = {
  0x00, 0x00, 0x3F, 0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x3F, 0xE0, 0x07,
  0xFC, 0x00, 0xFF, 0x00, 0x1F, 0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x1F,
  0xE0, 0x03, 0xFC, 0x00, 0x7F, 0x80, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F,
  0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x3F, 0x80, 0x07, 0xF0, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x03, 0xF8,
  0x00, 0x7E, 0x00, 0x1F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xC0,
  0x01, 0xF8, 0x00, 0x3F, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x07, 0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xE0, 0x0F, 0xFC, 0x01,
  0xFF, 0x80, 0x3F, 0xE0, 0x07, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0xC1, 0xFC, 0xFF, 0x07, 0xF3, 0xF8, 0x3F, 0xCF, 0xE0, 0xFE, 0x3F,
  0x83, 0xF8, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x0F, 0xC0, 0xFC, 0x7F, 0x03,
  0xF1, 0xF8, 0x0F, 0x87, 0xE0, 0x7E, 0x1F, 0x81, 0xF8, 0x7C, 0x07, 0xE1,
  0xF0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x01, 0xF0, 0xF8, 0x07, 0x83, 0xE0,
  0x3E, 0x00, 0x00, 0x00, 0x3F, 0x00, 0x7C, 0x00, 0x00, 0x0F, 0x80, 0x3F,
  0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF8, 0x03, 0xE0, 0x00,
  0x00, 0x7E, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7E, 0x00, 0x00, 0x0F,
  0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x07, 0xC0, 0x00, 0x00, 0xF8, 0x03,
  0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3E, 0x00,
  0x00, 0x07, 0xE0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0xFF, 0xFF,
  0xFF, 0xFF, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC3, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF, 0x00,
  0x0F, 0xC0, 0x1F, 0x00, 0x00, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00, 0xF8,
  0x03, 0xF0, 0x00, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80, 0x3E,
  0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0, 0x00,
  0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00, 0x0F,
  0x80, 0x3F, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF,
  0xFF, 0xF0, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC, 0x3F, 0xFF, 0xFF, 0xFF, 0xFF,
  0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xC0, 0x03, 0xF0, 0x0F, 0xC0, 0x00, 0x00,
  0xF8, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0xF8, 0x00, 0x00, 0x1F, 0x80,
  0x7E, 0x00, 0x00, 0x07, 0xC0, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x07, 0xC0,
  0x00, 0x00, 0xFC, 0x01, 0xF0, 0x00, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x00,
  0x0F, 0x80, 0x3F, 0x00, 0x00, 0x03, 0xE0, 0x0F, 0x80, 0x00, 0x01, 0xF8,
  0x07, 0xE0, 0x00, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x7C,
  0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x1E,
  0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x07,
  0xFF, 0x00, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0xC0, 0x0F,
  0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFE, 0x01,
  0xFF, 0x1E, 0x1F, 0x00, 0x7F, 0x87, 0x80, 0xC0, 0x3F, 0xC3, 0xE0, 0x00,
  0x0F, 0xE0, 0xF8, 0x00, 0x03, 0xF8, 0x3C, 0x00, 0x00, 0xFE, 0x0F, 0x00,
  0x00, 0x3F, 0x07, 0xC0, 0x00, 0x0F, 0xE1, 0xF0, 0x00, 0x03, 0xF8, 0x7C,
  0x00, 0x00, 0xFF, 0x1E, 0x00, 0x00, 0x3F, 0xE7, 0x80, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x07,
  0xFF, 0xF0, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xBF, 0xF0,
  0x00, 0x01, 0xE3, 0xFC, 0x00, 0x00, 0xF8, 0x7F, 0x00, 0x00, 0x3E, 0x1F,
  0xC0, 0x00, 0x0F, 0x07, 0xF0, 0x00, 0x03, 0xC1, 0xFC, 0x00, 0x01, 0xF0,
  0x7F, 0x00, 0x00, 0x7C, 0x1F, 0xC0, 0x00, 0x1F, 0x07, 0xF0, 0xC0, 0x07,
  0x83, 0xF8, 0x3C, 0x01, 0xE1, 0xFE, 0x0F, 0xF0, 0xFB, 0xFF, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x03, 0xC0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01, 0xF8,
  0x01, 0xFF, 0xE0, 0x00, 0x03, 0xF0, 0x03, 0xFF, 0xF0, 0x00, 0x07, 0xE0,
  0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xE0, 0x0F, 0xFF, 0xF8, 0x00, 0x0F, 0xC0,
  0x0F, 0xE3, 0xF8, 0x00, 0x1F, 0x80, 0x1F, 0xC1, 0xF8, 0x00, 0x3F, 0x00,
  0x1F, 0x80, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00,
  0x3F, 0x00, 0xFC, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00,
  0x7E, 0x00, 0xFC, 0x01, 0xF8, 0x00, 0x7E, 0x00, 0xF8, 0x03, 0xF0, 0x00,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x00, 0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x00,
  0xFC, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0xFC, 0x01, 0xF8, 0x1F, 0x80, 0x00,
  0xFC, 0x01, 0xF8, 0x3F, 0x00, 0x00, 0xFC, 0x03, 0xF0, 0x7E, 0x00, 0x00,
  0xFC, 0x03, 0xF0, 0x7E, 0x07, 0xC0, 0xFC, 0x03, 0xF0, 0xFC, 0x3F, 0xF0,
  0xFC, 0x07, 0xE1, 0xF8, 0x7F, 0xF8, 0xFC, 0x07, 0xE3, 0xF1, 0xFF, 0xFC,
  0xFC, 0x0F, 0xC3, 0xF1, 0xFF, 0xFE, 0x7E, 0x1F, 0xC7, 0xE3, 0xFD, 0xFE,
  0x7F, 0xFF, 0x8F, 0xC7, 0xF0, 0x7E, 0x7F, 0xFF, 0x1F, 0x87, 0xE0, 0x7E,
  0x3F, 0xFE, 0x1F, 0x8F, 0xE0, 0x3F, 0x1F, 0xFC, 0x3F, 0x0F, 0xC0, 0x3F,
  0x0F, 0xF0, 0x7E, 0x0F, 0xC0, 0x3F, 0x00, 0x00, 0xFE, 0x1F, 0x80, 0x3F,
  0x00, 0x00, 0xFC, 0x1F, 0x80, 0x3E, 0x00, 0x01, 0xF8, 0x1F, 0x80, 0x7E,
  0x00, 0x03, 0xF0, 0x3F, 0x80, 0x7E, 0x00, 0x07, 0xF0, 0x3F, 0x00, 0x7E,
  0x00, 0x07, 0xE0, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F, 0x00, 0x7E,
  0x00, 0x1F, 0x80, 0x3F, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x3F, 0x00, 0xFC,
  0x00, 0x3F, 0x00, 0x3F, 0x00, 0xFC, 0x00, 0x7E, 0x00, 0x3F, 0x01, 0xF8,
  0x00, 0xFC, 0x00, 0x3F, 0x01, 0xF8, 0x00, 0xFC, 0x00, 0x3F, 0x03, 0xF0,
  0x01, 0xF8, 0x00, 0x3F, 0x87, 0xF0, 0x03, 0xF0, 0x00, 0x1F, 0xFF, 0xE0,
  0x07, 0xE0, 0x00, 0x1F, 0xFF, 0xE0, 0x07, 0xE0, 0x00, 0x0F, 0xFF, 0xC0,
  0x0F, 0xC0, 0x00, 0x0F, 0xFF, 0x80, 0x1F, 0x80, 0x00, 0x03, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00,
  0x00, 0x1F, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00, 0x3F, 0xFB,
  0xFF, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0x80, 0x0F, 0xE0, 0x00, 0x03,
  0xF0, 0x01, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x81, 0xFF,
  0x00, 0x00, 0x03, 0xF8, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0x3F, 0xF0, 0x00,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0,
  0x01, 0xFC, 0x0F, 0xFF, 0xFC, 0x00, 0x7F, 0x07, 0xFE, 0x7F, 0x80, 0x0F,
  0xE1, 0xFF, 0x07, 0xF8, 0x03, 0xF8, 0x3F, 0xC0, 0x7F, 0x80, 0x7F, 0x0F,
  0xF0, 0x0F, 0xF0, 0x1F, 0xC3, 0xFC, 0x00, 0xFF, 0x07, 0xF8, 0x7F, 0x80,
  0x0F, 0xF0, 0xFE, 0x0F, 0xE0, 0x00, 0xFF, 0x3F, 0x83, 0xFC, 0x00, 0x1F,
  0xEF, 0xF0, 0x7F, 0x80, 0x01, 0xFF, 0xFC, 0x0F, 0xE0, 0x00, 0x1F, 0xFF,
  0x01, 0xFC, 0x00, 0x03, 0xFF, 0xC0, 0x3F, 0xC0, 0x00, 0x3F, 0xF8, 0x07,
  0xF8, 0x00, 0x03, 0xFE, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xF0,
  0x00, 0x7F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x3F, 0xFC, 0x3F,
  0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xCF,
  0xF0, 0x03, 0xFF, 0xFF, 0xE0, 0xFF, 0x00, 0x3F, 0xFF, 0xF0, 0x0F, 0xF0,
  0x01, 0xFF, 0xF8, 0x01, 0xFF, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x1F,
  0xCF, 0xF3, 0xF8, 0xFE, 0x3F, 0x8F, 0xC3, 0xF0, 0xFC, 0x7F, 0x1F, 0x87,
  0xE1, 0xF8, 0x7C, 0x1F, 0x07, 0xC1, 0xF0, 0xF8, 0x3E, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x00,
  0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x1F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8,
  0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F,
  0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80,
  0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00,
  0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80,
  0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x7E, 0x00,
  0x00, 0xFC, 0x00, 0x01, 0xF8, 0x00, 0x03, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x80, 0x00,
  0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F,
  0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFE, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E,
  0x00, 0x01, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x10,
  0x01, 0xF8, 0x00, 0x78, 0x03, 0xE0, 0x00, 0xFC, 0x07, 0xC0, 0x01, 0xFE,
  0x0F, 0x80, 0x07, 0xFF, 0x1E, 0x00, 0x0F, 0xFF, 0xBC, 0x00, 0x0F, 0xFF,
  0xF8, 0x7F, 0xC1, 0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFC, 0x01, 0xFF, 0x83, 0xF8, 0x07, 0xFF,
  0x00, 0x00, 0x1F, 0xDF, 0x00, 0x00, 0x7F, 0x3E, 0x00, 0x01, 0xFC, 0x7E,
  0x00, 0x07, 0xF0, 0x7C, 0x00, 0x1F, 0xE0, 0xFC, 0x00, 0x7F, 0x81, 0xF8,
  0x00, 0x7E, 0x03, 0xF8, 0x00, 0x78, 0x03, 0xF0, 0x00, 0x70, 0x07, 0xF0,
  0x00, 0x40, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x18, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0,
  0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x7C, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00,
  0x07, 0xC0, 0x00, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xFC, 0x0F, 0xF0, 0x3F, 0xC1, 0xFE, 0x07, 0xF8, 0x1F, 0xC0, 0xFF,
  0x03, 0xF8, 0x1F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0x01, 0xF8,
  0x07, 0xE0, 0x1F, 0x00, 0xFC, 0x00, 0x7F, 0xFF, 0xBF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xF8, 0x1F, 0x0F, 0xE7, 0xF9, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFB, 0xFE, 0x7F, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x01, 0xFF, 0xF8, 0x00, 0x03, 0xFF,
  0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xFF, 0xF8, 0x03, 0xFE, 0x07, 0xFC, 0x03, 0xFE, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x7F, 0x81, 0xFE, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xE0, 0xFF,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x01, 0xFC, 0x3F,
  0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x3F, 0x8F,
  0xE0, 0x00, 0x1F, 0xCF, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3,
  0xF8, 0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFD, 0xFE, 0x00, 0x00, 0xFE,
  0xFF, 0x00, 0x00, 0x7F, 0x7F, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x3F,
  0xDF, 0xC0, 0x00, 0x1F, 0xCF, 0xE0, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x07,
  0xF3, 0xF8, 0x00, 0x07, 0xFB, 0xFC, 0x00, 0x03, 0xFD, 0xFE, 0x00, 0x01,
  0xFC, 0xFF, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x7F, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x3F, 0xC3, 0xF8, 0x00,
  0x3F, 0xC1, 0xFC, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x1F, 0xE0, 0x7F, 0x80,
  0x1F, 0xF0, 0x1F, 0xC0, 0x0F, 0xF0, 0x0F, 0xF0, 0x1F, 0xF0, 0x07, 0xFF,
  0x7F, 0xF8, 0x01, 0xFF, 0xFF, 0xF8, 0x00, 0x7F, 0xFF, 0xF8, 0x00, 0x3F,
  0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0xF8, 0x03, 0xFF, 0xE0, 0x3F, 0xFF, 0x81,
  0xFF, 0xFE, 0x1F, 0xFF, 0xF1, 0xFF, 0xFF, 0xCF, 0xFE, 0x7F, 0x3F, 0xF1,
  0xFC, 0x7F, 0x0F, 0xF1, 0xF8, 0x3F, 0x83, 0x80, 0xFE, 0x04, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x00, 0x01, 0xFC, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00,
  0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFE, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x3F, 0x80, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x7F,
  0x00, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x1F, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x03, 0xF0, 0x01, 0xFF, 0x00, 0x3C, 0x00, 0x0F, 0xF0,
  0x01, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0x07, 0xFF, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF,
  0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFF, 0xE0, 0xFF, 0xFF, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF,
  0xF8, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x01, 0xFF,
  0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x1F, 0xF0, 0x03, 0xE0, 0x01, 0xFF, 0x00,
  0x30, 0x00, 0x1F, 0xE0, 0x04, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xFF, 0xF0,
  0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x80, 0x00, 0x03, 0xFC, 0x1C,
  0x00, 0x00, 0xFF, 0x83, 0xE0, 0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x7F, 0xF8,
  0x0F, 0xFF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xC0, 0x00, 0x00, 0xFE, 0xFC,
  0x00, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x00, 0x3F,
  0x9F, 0x80, 0x00, 0x07, 0xF1, 0xF8, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00,
  0x1F, 0xE3, 0xF8, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x00, 0x3F, 0x83, 0xF0,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0xFE, 0x00, 0x07,
  0xF0, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xC0, 0x0F, 0xE0,
  0x03, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x01,
  0xFC, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x03, 0xF8,
  0x00, 0x3F, 0x80, 0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF,
  0x7F, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF,
  0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xF8, 0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFC,
  0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF, 0xF8, 0x00, 0x30, 0x01,
  0xFF, 0x80, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x80, 0x00, 0x07, 0xF8, 0x18, 0x00, 0x01, 0xFF, 0x03,
  0xE0, 0x00, 0xFF, 0xC0, 0x7F, 0xC1, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF, 0xFF,
  0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0xE0,
  0x00, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8,
  0x00, 0xFF, 0xE0, 0x04, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0xFF, 0x80, 0x00,
  0x00, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0x00, 0x07, 0xF0, 0x7F, 0xF0, 0x03, 0xF8, 0xFF,
  0xFC, 0x01, 0xFD, 0xFF, 0xFF, 0x01, 0xFD, 0xFF, 0xFF, 0xC0, 0xFE, 0xFF,
  0xFF, 0xF0, 0x7F, 0xFC, 0x0F, 0xF8, 0x3F, 0xF8, 0x03, 0xFE, 0x1F, 0xF0,
  0x00, 0xFF, 0x1F, 0xF0, 0x00, 0x3F, 0x8F, 0xF8, 0x00, 0x1F, 0xC7, 0xF8,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xF8, 0xFE,
  0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x1F,
  0xC0, 0x00, 0x3F, 0x8F, 0xE0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x0F, 0xF0,
  0x3F, 0xC0, 0x0F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFE, 0x3F, 0xF8,
  0x03, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x0F, 0x00,
  0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xC7, 0xFF, 0xFF, 0xFF, 0xF1, 0xFF,
  0xFF, 0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0xFE, 0x3F, 0xFF, 0xFF, 0xFF, 0x8F,
  0xFF, 0xFF, 0xFF, 0xE3, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00,
  0x01, 0xFF, 0xFE, 0x00, 0x00, 0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xE0, 0x0F, 0xF8, 0x07,
  0xF8, 0x07, 0xF8, 0x00, 0xFF, 0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x7F, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x01, 0xFC, 0x0F, 0xF0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xC0, 0xFE, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x03, 0xF8, 0x07,
  0xF0, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x3F, 0xC0,
  0x0F, 0xF0, 0x1F, 0xE0, 0x01, 0xFE, 0x1F, 0xF0, 0x00, 0x7F, 0xDF, 0xF8,
  0x00, 0x0F, 0xFF, 0xF8, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xF8,
  0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xF0, 0x00, 0x7F, 0xFF,
  0xFE, 0x00, 0x3F, 0xF0, 0x7F, 0xC0, 0x1F, 0xF0, 0x0F, 0xF0, 0x0F, 0xF8,
  0x01, 0xFE, 0x03, 0xFC, 0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x0F, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x1F, 0xC3,
  0xF8, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x01, 0xFE, 0x3F, 0x80, 0x00, 0x7F,
  0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03,
  0xFC, 0x3F, 0xE0, 0x01, 0xFE, 0x07, 0xFC, 0x00, 0xFF, 0x81, 0xFF, 0xC0,
  0xFF, 0xC0, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xF8, 0x00, 0x1F, 0xFF, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x07, 0xFF, 0xF0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFC, 0x0F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFE, 0x07, 0xF8, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x3F, 0x83, 0xF8, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x03, 0xF8, 0xFE, 0x00,
  0x01, 0xFC, 0x7F, 0x00, 0x00, 0xFE, 0x3F, 0x80, 0x00, 0x7F, 0x3F, 0xC0,
  0x00, 0x7F, 0x9F, 0xE0, 0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x1F, 0xE7, 0xF8,
  0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x0F, 0xF8, 0x7F,
  0x00, 0x07, 0xFC, 0x3F, 0xC0, 0x07, 0xFE, 0x1F, 0xF0, 0x0F, 0xFF, 0x07,
  0xFF, 0x7F, 0xFF, 0x83, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xDF, 0xC0,
  0x3F, 0xFF, 0xCF, 0xE0, 0x0F, 0xFF, 0x87, 0xF0, 0x01, 0xFF, 0x07, 0xF0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x7F, 0xC0, 0x20, 0x00, 0xFF,
  0xC0, 0x1F, 0xCF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF,
  0xC0, 0x03, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x10, 0x01, 0xF8, 0x07,
  0xF8, 0x1F, 0xF0, 0x3F, 0xE0, 0x7F, 0xC0, 0xFF, 0x81, 0xFF, 0x03, 0xFC,
  0x03, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x0F, 0xE0, 0x3F, 0xC0, 0x7F, 0xC1, 0xFF, 0x83, 0xFF,
  0x07, 0xFC, 0x0F, 0xF8, 0x0F, 0xE0, 0x0F, 0x80, 0x00, 0x00, 0x01, 0x00,
  0x01, 0xF8, 0x00, 0x7F, 0x80, 0x1F, 0xF0, 0x03, 0xFE, 0x00, 0x7F, 0xC0,
  0x0F, 0xF8, 0x01, 0xFF, 0x00, 0x3F, 0xC0, 0x03, 0xF0, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x1F,
  0xE0, 0x07, 0xF8, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x07, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00, 0xFC, 0x00, 0x3F, 0x80, 0x07, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0x00, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0x3E, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x01, 0xC0, 0x00, 0x00,
  0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00,
  0x1F, 0xFC, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x7F,
  0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xC0, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x01, 0xFF,
  0xF8, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0xC0, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF8,
  0x80, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x00,
  0x01, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x00, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x03, 0xFF,
  0xC0, 0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFC, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x01, 0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0xC0, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0x01,
  0xFF, 0xF0, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x07,
  0xFF, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0xF8, 0x00, 0x00, 0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0,
  0x00, 0x7F, 0xFF, 0x80, 0x7F, 0xFF, 0xF8, 0x3F, 0xFF, 0xFF, 0x83, 0xFF,
  0xFF, 0xF8, 0x7F, 0xFF, 0xFF, 0x87, 0xE0, 0x1F, 0xF0, 0xF0, 0x01, 0xFE,
  0x10, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x00, 0x03,
  0xFC, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x1F, 0xF0, 0x00,
  0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xE0,
  0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x07,
  0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0x00,
  0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x0F, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xF8,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0x80, 0x01,
  0xFF, 0x80, 0x00, 0x3F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x1F, 0xE0, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFC, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x07, 0xE0, 0x3F, 0x80, 0x00, 0x00, 0x00, 0x3F,
  0x03, 0xF8, 0x00, 0x3F, 0xFC, 0x00, 0xFC, 0x1F, 0x80, 0x07, 0xFF, 0xFC,
  0x07, 0xE1, 0xF8, 0x00, 0xFF, 0xFF, 0xE0, 0x3F, 0x0F, 0xC0, 0x0F, 0xFF,
  0xFF, 0x01, 0xF8, 0xFC, 0x00, 0xFF, 0xCF, 0xF8, 0x07, 0xC7, 0xE0, 0x0F,
  0xF0, 0x1F, 0x80, 0x3E, 0x7E, 0x00, 0xFE, 0x00, 0xFC, 0x01, 0xF3, 0xF0,
  0x0F, 0xE0, 0x07, 0xE0, 0x0F, 0x9F, 0x80, 0x7E, 0x00, 0x3E, 0x00, 0x7C,
  0xF8, 0x07, 0xE0, 0x03, 0xF0, 0x03, 0xEF, 0xC0, 0x3F, 0x00, 0x1F, 0x80,
  0x3F, 0x7E, 0x03, 0xF0, 0x00, 0xFC, 0x01, 0xFB, 0xF0, 0x1F, 0x80, 0x07,
  0xC0, 0x0F, 0xDF, 0x80, 0xFC, 0x00, 0x7E, 0x00, 0x7E, 0xF8, 0x0F, 0xC0,
  0x03, 0xF0, 0x03, 0xE7, 0xC0, 0x7E, 0x00, 0x1F, 0x80, 0x3F, 0x7E, 0x03,
  0xF0, 0x01, 0xF8, 0x01, 0xFB, 0xF0, 0x1F, 0x80, 0x0F, 0xC0, 0x0F, 0x9F,
  0x80, 0xFC, 0x00, 0xFE, 0x00, 0xFC, 0xFC, 0x07, 0xE0, 0x07, 0xF0, 0x0F,
  0xE3, 0xE0, 0x3F, 0x00, 0x7F, 0x80, 0x7E, 0x1F, 0x00, 0xFC, 0x07, 0xFC,
  0x07, 0xE0, 0xFC, 0x07, 0xF0, 0x7F, 0xF0, 0xFF, 0x07, 0xE0, 0x3F, 0xFF,
  0xDF, 0xFF, 0xF0, 0x3F, 0x00, 0xFF, 0xFC, 0x7F, 0xFF, 0x01, 0xF8, 0x03,
  0xFF, 0xC1, 0xFF, 0xF0, 0x07, 0xE0, 0x0F, 0xFC, 0x0F, 0xFE, 0x00, 0x3F,
  0x00, 0x1F, 0x80, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x07, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x10, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x07, 0x80, 0x00, 0x01, 0xFF, 0xE0, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xFF, 0xFF, 0xFF, 0xE0, 0x00, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x00,
  0x00, 0x3F, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00,
  0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00,
  0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xE0,
  0x00, 0x00, 0x03, 0xF7, 0xE0, 0x00, 0x00, 0x07, 0xF7, 0xE0, 0x00, 0x00,
  0x07, 0xE7, 0xE0, 0x00, 0x00, 0x0F, 0xE7, 0xF0, 0x00, 0x00, 0x0F, 0xE7,
  0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x00, 0x1F, 0xC7, 0xF0, 0x00,
  0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x3F, 0x83, 0xF0, 0x00, 0x00, 0x7F,
  0x03, 0xF0, 0x00, 0x00, 0xFF, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x03, 0xF8,
  0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x03, 0xF8, 0x00, 0x03,
  0xFC, 0x03, 0xF8, 0x00, 0x03, 0xF8, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x01, 0xF8, 0x00,
  0x0F, 0xE0, 0x01, 0xF8, 0x00, 0x1F, 0xC0, 0x01, 0xFC, 0x00, 0x1F, 0xFF,
  0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFC,
  0x00, 0x7F, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xFF, 0xFC, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x0F, 0xF0, 0x00,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x00, 0xFE,
  0x3F, 0xC0, 0x00, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0x00, 0xFF, 0x7F, 0x80,
  0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xE0, 0x00, 0x1F,
  0xFF, 0xFF, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFE,
  0x00, 0x3F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF, 0xC0, 0x1F, 0xE0,
  0x03, 0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0xC0,
  0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00,
  0x3F, 0x80, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x7F,
  0x80, 0xFE, 0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x7F, 0xC0, 0x3F, 0x80,
  0x1F, 0xFC, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0xFF, 0xFF, 0xFC, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F, 0xFF, 0xFF,
  0xE0, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xC0, 0x03, 0xFE, 0x00, 0xFE,
  0x00, 0x07, 0xF8, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x00, 0xFF,
  0x03, 0xF8, 0x00, 0x07, 0xF8, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0xFE, 0x00,
  0x00, 0xFE, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00,
  0xFF, 0x07, 0xF0, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x83, 0xF8,
  0x00, 0x1F, 0xF8, 0x1F, 0xC0, 0x03, 0xFF, 0xC0, 0xFF, 0xFF, 0xFF, 0xFC,
  0x0F, 0xFF, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xFC, 0x03, 0xFF, 0xFF,
  0xFF, 0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x00,
  0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x3F,
  0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xC0, 0x3F, 0x80, 0x3F, 0xF8,
  0x00, 0x1C, 0x01, 0xFF, 0x80, 0x00, 0x10, 0x0F, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0xE0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0xE0,
  0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x20, 0x01, 0xFF, 0xC0, 0x07, 0x80,
  0x07, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFE, 0x00,
  0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F,
  0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFF, 0x80, 0x00, 0x7F, 0xFF, 0xFF, 0xE0, 0x00,
  0x7F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xFC, 0x00, 0xFE, 0x00, 0x07, 0xFE,
  0x00, 0xFE, 0x00, 0x03, 0xFE, 0x01, 0xFE, 0x00, 0x01, 0xFE, 0x01, 0xFE,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00,
  0xFF, 0x01, 0xFC, 0x00, 0x00, 0xFF, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x07, 0xF0,
  0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x0F, 0xF0, 0x00, 0x00,
  0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x0F,
  0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x03, 0xFE, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0x07, 0xFC,
  0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0x0F, 0xF8, 0x3F, 0x80,
  0x00, 0x1F, 0xF0, 0x3F, 0x80, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x00, 0x7F,
  0xE0, 0x3F, 0x80, 0x00, 0xFF, 0xC0, 0x7F, 0x80, 0x03, 0xFF, 0x80, 0x7F,
  0x00, 0x0F, 0xFF, 0x00, 0x7F, 0x00, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0xE0, 0x00,
  0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF,
  0xC0, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF,
  0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF,
  0xE0, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x1F, 0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F,
  0xFF, 0xFF, 0xE0, 0x0F, 0xFF, 0xFF, 0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF,
  0x80, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC, 0x01,
  0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xE0, 0x07, 0xFF, 0xFF, 0xFC,
  0x00, 0xFF, 0xFF, 0xFF, 0x80, 0x3F, 0xFF, 0xFF, 0xF0, 0x07, 0xF8, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x07,
  0xFF, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFF, 0xF8, 0x00, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x7F, 0xFF, 0xF8, 0x00,
  0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFE, 0x03, 0xFE,
  0x00, 0xFF, 0xF0, 0x00, 0x3C, 0x01, 0xFF, 0xC0, 0x00, 0x04, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x07, 0xFF,
  0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xFC, 0xFF, 0x00, 0x07, 0xFF, 0xF8, 0xFF,
  0x00, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x07, 0xFF, 0xF8, 0xFE, 0x00, 0x0F,
  0xFF, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0xFE, 0x00,
  0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x00, 0x00, 0x0F,
  0xE0, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x7F,
  0x80, 0x00, 0x1F, 0xE0, 0x7F, 0xC0, 0x00, 0x1F, 0xC0, 0x7F, 0xE0, 0x00,
  0x1F, 0xC0, 0x3F, 0xF0, 0x00, 0x1F, 0xC0, 0x1F, 0xFC, 0x00, 0x3F, 0xC0,
  0x1F, 0xFF, 0xFF, 0xFF, 0xC0, 0x0F, 0xFF, 0xFF, 0xFF, 0x80, 0x07, 0xFF,
  0xFF, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xF0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F,
  0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0xFF, 0x00, 0x00,
  0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x1F, 0xE0, 0x00, 0x03, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0,
  0x00, 0x07, 0xF8, 0x03, 0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0,
  0x07, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0xE0, 0x07,
  0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xE0, 0x0F, 0xFF,
  0xFF, 0xFF, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x1F, 0xE0, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xF8,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x03,
  0xFC, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x00, 0x7F, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0x00,
  0x03, 0xFF, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xFC, 0x00, 0x01, 0xFF, 0xFC, 0x00,
  0x3F, 0xFF, 0xF8, 0x01, 0xFF, 0xFF, 0x80, 0x0F, 0xFF, 0xFC, 0x00, 0xFF,
  0xFF, 0xE0, 0x00, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xF8,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xF8, 0x00,
  0x40, 0x7F, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0x01, 0xFF, 0xFF, 0x00, 0x03,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xF0, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x1F,
  0xFC, 0x00, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xC0, 0x0F, 0xE0,
  0x00, 0x1F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x07,
  0xF8, 0x00, 0x7F, 0x00, 0x03, 0xFE, 0x00, 0x1F, 0xC0, 0x01, 0xFF, 0x00,
  0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x00, 0x7F, 0xC0, 0x00, 0xFE,
  0x00, 0x3F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xF0, 0x00, 0x0F, 0xE0, 0x0F,
  0xF8, 0x00, 0x07, 0xF8, 0x07, 0xFC, 0x00, 0x01, 0xFC, 0x03, 0xFE, 0x00,
  0x00, 0x7F, 0x01, 0xFF, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x80, 0x00, 0x07,
  0xF0, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x00, 0x0F, 0xE3, 0xFC, 0x00,
  0x00, 0x03, 0xF9, 0xFE, 0x00, 0x00, 0x01, 0xFC, 0xFF, 0x00, 0x00, 0x00,
  0x7F, 0x7F, 0xC0, 0x00, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0xFF, 0xE0,
  0x00, 0x00, 0x3F, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x7F, 0x00, 0x00,
  0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x07,
  0xF0, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x00, 0xFF, 0x00, 0x7F, 0x80,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x1F, 0xE0, 0x00, 0x7F, 0x80,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x01, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00,
  0x3F, 0x80, 0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xF8,
  0x00, 0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07,
  0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x03, 0xFC, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0, 0x00, 0x03, 0xF8, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x0F, 0xE0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFF, 0xFE, 0xFF, 0xFF,
  0xFF, 0x80, 0x00, 0x1F, 0xF8, 0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x07, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00,
  0x3F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F,
  0xFE, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x7F, 0xF8, 0x00,
  0x00, 0x3F, 0xFE, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x7E,
  0xFC, 0x00, 0x00, 0x7F, 0xFE, 0x00, 0x7E, 0xFC, 0x00, 0x00, 0x7E, 0xFC,
  0x00, 0x7E, 0xFC, 0x00, 0x00, 0xFF, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x00,
  0xFD, 0xFC, 0x00, 0xFE, 0xFC, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0xFC, 0xFC,
  0x00, 0x01, 0xF9, 0xF8, 0x00, 0xFC, 0xFC, 0x00, 0x03, 0xF3, 0xF8, 0x00,
  0xFC, 0xFC, 0x00, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x07, 0xE3,
  0xF8, 0x01, 0xFC, 0xFC, 0x00, 0x0F, 0xE3, 0xF8, 0x01, 0xFC, 0x7E, 0x00,
  0x0F, 0xC7, 0xF0, 0x01, 0xF8, 0x7E, 0x00, 0x1F, 0xC7, 0xF0, 0x03, 0xF8,
  0x7E, 0x00, 0x1F, 0x87, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x87, 0xF0,
  0x03, 0xF8, 0x7E, 0x00, 0x3F, 0x07, 0xF0, 0x03, 0xF8, 0x7E, 0x00, 0x7F,
  0x0F, 0xE0, 0x03, 0xF0, 0x7E, 0x00, 0x7E, 0x0F, 0xE0, 0x07, 0xF0, 0x7E,
  0x00, 0xFE, 0x0F, 0xE0, 0x07, 0xF0, 0x7E, 0x00, 0xFC, 0x0F, 0xE0, 0x07,
  0xF0, 0x3E, 0x01, 0xF8, 0x0F, 0xE0, 0x07, 0xF0, 0x3F, 0x01, 0xF8, 0x1F,
  0xC0, 0x07, 0xE0, 0x3F, 0x03, 0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x07,
  0xF0, 0x1F, 0xC0, 0x0F, 0xE0, 0x3F, 0x07, 0xE0, 0x1F, 0xC0, 0x0F, 0xE0,
  0x3F, 0x0F, 0xE0, 0x1F, 0xC0, 0x0F, 0xC0, 0x3F, 0x0F, 0xC0, 0x3F, 0x80,
  0x0F, 0xC0, 0x3F, 0x1F, 0xC0, 0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x1F, 0x80,
  0x3F, 0x80, 0x1F, 0xC0, 0x3F, 0x3F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x1F,
  0x3F, 0x00, 0x7F, 0x00, 0x1F, 0x80, 0x1F, 0xFF, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x1F, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7F,
  0x00, 0x3F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xF8,
  0x00, 0xFE, 0x00, 0x3F, 0x00, 0x1F, 0xF8, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xF0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x0F, 0xE0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x0F, 0xC0, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x7E, 0x00, 0x7F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0xFF, 0x80,
  0x00, 0x03, 0xF8, 0x01, 0xFF, 0x80, 0x00, 0x07, 0xF0, 0x03, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x00, 0x00, 0x1F, 0x80, 0x1F, 0xFE, 0x00,
  0x00, 0x7F, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0xFE, 0x00, 0x7F, 0xFC, 0x00,
  0x01, 0xFC, 0x00, 0xFF, 0xF8, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xF0, 0x00,
  0x0F, 0xE0, 0x07, 0xF7, 0xF0, 0x00, 0x1F, 0xC0, 0x0F, 0xEF, 0xE0, 0x00,
  0x3F, 0x80, 0x1F, 0x9F, 0xC0, 0x00, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x00,
  0xFC, 0x00, 0x7E, 0x3F, 0x80, 0x03, 0xF8, 0x01, 0xFC, 0x7F, 0x00, 0x07,
  0xF0, 0x03, 0xF8, 0x7F, 0x00, 0x0F, 0xE0, 0x07, 0xF0, 0xFE, 0x00, 0x1F,
  0xC0, 0x0F, 0xC0, 0xFE, 0x00, 0x3F, 0x00, 0x3F, 0x81, 0xFC, 0x00, 0xFE,
  0x00, 0x7F, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x03, 0xF8, 0x03, 0xF8,
  0x01, 0xFC, 0x07, 0xF0, 0x07, 0xF0, 0x03, 0xF0, 0x0F, 0xE0, 0x1F, 0xC0,
  0x0F, 0xE0, 0x0F, 0xE0, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xC0, 0x7F, 0x00,
  0x3F, 0x80, 0x3F, 0x80, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0x81, 0xFC, 0x00,
  0xFC, 0x00, 0x7F, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x0F, 0xE0, 0x07,
  0xF0, 0x00, 0xFE, 0x1F, 0xC0, 0x0F, 0xE0, 0x01, 0xFC, 0x3F, 0x80, 0x1F,
  0x80, 0x01, 0xFC, 0x7E, 0x00, 0x3F, 0x00, 0x03, 0xF8, 0xFC, 0x00, 0xFE,
  0x00, 0x07, 0xF3, 0xF8, 0x01, 0xFC, 0x00, 0x07, 0xF7, 0xF0, 0x03, 0xF8,
  0x00, 0x0F, 0xEF, 0xE0, 0x07, 0xE0, 0x00, 0x1F, 0xDF, 0x80, 0x1F, 0xC0,
  0x00, 0x1F, 0xFF, 0x00, 0x3F, 0x80, 0x00, 0x3F, 0xFE, 0x00, 0x7F, 0x00,
  0x00, 0x7F, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0xF8, 0x01, 0xF8, 0x00,
  0x00, 0xFF, 0xE0, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0xC0, 0x0F, 0xE0, 0x00,
  0x01, 0xFF, 0x80, 0x1F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x3F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x3F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE,
  0x00, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00,
  0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF,
  0x00, 0x1F, 0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00,
  0x3F, 0xC0, 0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE,
  0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE,
  0x00, 0x00, 0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00,
  0x00, 0x3F, 0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03,
  0xFD, 0xFE, 0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xDF,
  0xC0, 0x00, 0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00,
  0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x01, 0xFE,
  0xFE, 0x00, 0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x1F, 0xEF, 0xE0,
  0x00, 0x00, 0x07, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00,
  0x00, 0xFF, 0x3F, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x1F,
  0xE3, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x3F,
  0xE0, 0x00, 0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0xC0, 0x1F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00,
  0x0F, 0xFF, 0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F,
  0xFF, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00,
  0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0x80, 0x00, 0xFF,
  0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0xFF, 0xE0,
  0x03, 0xFF, 0xFF, 0xFF, 0x80, 0x1F, 0xE0, 0x07, 0xFC, 0x00, 0xFE, 0x00,
  0x1F, 0xF0, 0x07, 0xF0, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x01, 0xFC, 0x03,
  0xFC, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xFC,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x03, 0xFC,
  0x07, 0xF0, 0x00, 0x1F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xFC, 0x00,
  0x1F, 0xF0, 0x1F, 0xC0, 0x01, 0xFF, 0x00, 0xFE, 0x00, 0x7F, 0xF8, 0x07,
  0xFF, 0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xFF,
  0x80, 0x1F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x07, 0xFF,
  0xFF, 0x80, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xFF, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0xFE, 0x00, 0x00,
  0x3F, 0xFF, 0xFF, 0xC0, 0x00, 0x1F, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x0F, 0xFF, 0x81, 0xFF, 0xE0, 0x07, 0xFF, 0x00, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x01, 0xFF, 0x00, 0xFF, 0x80, 0x00, 0x3F, 0xC0,
  0x7F, 0xC0, 0x00, 0x0F, 0xF8, 0x1F, 0xE0, 0x00, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x00, 0x7F, 0x87, 0xFC, 0x00, 0x00, 0x0F, 0xF1, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x3F, 0xC0, 0x00, 0x00, 0x3F,
  0xCF, 0xF0, 0x00, 0x00, 0x0F, 0xF7, 0xF8, 0x00, 0x00, 0x03, 0xFD, 0xFE,
  0x00, 0x00, 0x00, 0xFF, 0x7F, 0x80, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00,
  0x00, 0x0F, 0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00, 0x00, 0x0F, 0xFF,
  0xF0, 0x00, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0xFE, 0x00,
  0x00, 0x00, 0x7F, 0xBF, 0x80, 0x00, 0x00, 0x1F, 0xEF, 0xE0, 0x00, 0x00,
  0x07, 0xFB, 0xF8, 0x00, 0x00, 0x03, 0xFC, 0xFE, 0x00, 0x00, 0x00, 0xFF,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xCF, 0xF0, 0x00, 0x00, 0x1F, 0xE3, 0xFC,
  0x00, 0x00, 0x0F, 0xF8, 0xFF, 0x00, 0x00, 0x03, 0xFC, 0x3F, 0xE0, 0x00,
  0x01, 0xFF, 0x07, 0xF8, 0x00, 0x00, 0xFF, 0x81, 0xFF, 0x00, 0x00, 0x7F,
  0xC0, 0x7F, 0xE0, 0x00, 0x3F, 0xF0, 0x0F, 0xFC, 0x00, 0x1F, 0xF8, 0x01,
  0xFF, 0xC0, 0x3F, 0xFC, 0x00, 0x7F, 0xFF, 0xFF, 0xFE, 0x00, 0x0F, 0xFF,
  0xFF, 0xFF, 0x00, 0x01, 0xFF, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x00, 0x3F, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00,
  0x00, 0x3F, 0xE0, 0x00, 0x00, 0x3F, 0xFE, 0x00, 0x00, 0x03, 0xFF, 0xFF,
  0x00, 0x00, 0x7F, 0xFF, 0xFE, 0x00, 0x07, 0xFF, 0xFF, 0xF0, 0x00, 0x7F,
  0xFF, 0xFF, 0x80, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0xE0,
  0x0F, 0xF0, 0x03, 0xFE, 0x00, 0xFE, 0x00, 0x1F, 0xF0, 0x0F, 0xE0, 0x00,
  0xFF, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x1F, 0xE0, 0x00, 0x7F, 0x01, 0xFE,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x7F, 0x01, 0xFC, 0x00, 0x07, 0xF0,
  0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xFC, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00,
  0xFF, 0x03, 0xF8, 0x00, 0x0F, 0xE0, 0x3F, 0x80, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF0, 0x01, 0xFF, 0x80,
  0x7F, 0xFF, 0xFF, 0xF0, 0x07, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFC, 0x00, 0x0F, 0xFF,
  0xFF, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F, 0xC0, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xC0, 0x01, 0xFC, 0x01, 0xFE,
  0x00, 0x1F, 0xC0, 0x0F, 0xE0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0x80, 0x07, 0xF8, 0x03,
  0xF8, 0x00, 0x7F, 0x80, 0x7F, 0x80, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x3F,
  0xC0, 0x7F, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x1F, 0xE0, 0xFF, 0x00,
  0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0xFF, 0x0F,
  0xE0, 0x00, 0x0F, 0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x7F,
  0xF8, 0x00, 0x00, 0x7F, 0xFF, 0xE0, 0x00, 0x3F, 0xFF, 0xFF, 0x80, 0x0F,
  0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xFF, 0x80,
  0x3F, 0xF8, 0x0F, 0xE0, 0x07, 0xFC, 0x00, 0x3C, 0x01, 0xFF, 0x00, 0x01,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0xFF,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x00, 0x1F, 0xFF,
  0x00, 0x00, 0x01, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF, 0x00, 0x00, 0x00,
  0xFF, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xF0, 0x00,
  0x00, 0x07, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x03, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x80, 0x00, 0x0F, 0xF8, 0x1C, 0x00, 0x03, 0xFE,
  0x03, 0xE0, 0x01, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0xF0, 0x0F, 0xFF, 0xFF,
  0xFC, 0x01, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xC0, 0x03, 0xFF,
  0xFF, 0xE0, 0x00, 0x1F, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x7F, 0xFF, 0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0xFF, 0xF7, 0xFF, 0xFF, 0xFF,
  0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F,
  0x00, 0x00, 0x0F, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x00, 0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x07,
  0xF8, 0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00,
  0x00, 0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00,
  0xFE, 0x03, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0,
  0x3F, 0x80, 0x00, 0x07, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xF8,
  0x00, 0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x3F,
  0x80, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00,
  0x00, 0x7F, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x00, 0x07,
  0xF0, 0x1F, 0xC0, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x01,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x3F, 0xC0,
  0x00, 0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x03, 0xF8, 0x00, 0x00,
  0x7F, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x0F, 0xF0,
  0x0F, 0xF0, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x01, 0xFE, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x00, 0x1F, 0xF0, 0x00, 0x7F, 0xC0, 0x07, 0xFE, 0x00,
  0x7F, 0xE0, 0x00, 0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x3F, 0xFF, 0xFF, 0xFC,
  0x00, 0x07, 0xFF, 0xFF, 0xFC, 0x00, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00,
  0x0F, 0xFF, 0xFF, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x01,
  0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xFC, 0x00, 0x00,
  0x07, 0xFB, 0xFC, 0x00, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x00, 0x3F, 0xC7,
  0xF0, 0x00, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x3F, 0x80, 0x00, 0x0F, 0xF0, 0x7F, 0x00, 0x00, 0x1F, 0xC0,
  0xFE, 0x00, 0x00, 0x7F, 0x81, 0xFC, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00,
  0x03, 0xFC, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0x07, 0xE0, 0x00, 0x1F, 0xE0,
  0x0F, 0xE0, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x00, 0xFF, 0x00, 0x3F, 0x80,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00, 0x0F, 0xE0,
  0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03, 0xF8, 0x00, 0x7F, 0x00, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0x0F, 0xE0, 0x07, 0xF8, 0x00, 0x0F, 0xC0, 0x0F, 0xE0,
  0x00, 0x1F, 0x80, 0x3F, 0xC0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0x7F,
  0x01, 0xFE, 0x00, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x0F, 0xF0,
  0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0x0F,
  0xE0, 0xFE, 0x00, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x00, 0x1F, 0x87, 0xF0,
  0x00, 0x00, 0x3F, 0x1F, 0xE0, 0x00, 0x00, 0x7E, 0x3F, 0x80, 0x00, 0x00,
  0xFC, 0x7F, 0x00, 0x00, 0x01, 0xF9, 0xFC, 0x00, 0x00, 0x03, 0xF3, 0xF8,
  0x00, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0x0F, 0xDF, 0x80, 0x00, 0x00,
  0x1F, 0xFF, 0x00, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xF8,
  0x00, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xFF, 0x80,
  0x00, 0x1F, 0xC0, 0x00, 0x0F, 0xFF, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x03,
  0xFB, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x01, 0xFE, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x7F, 0x3F, 0x80, 0x00, 0x7F, 0xE0, 0x00, 0x3F, 0xCF, 0xE0,
  0x00, 0x1F, 0xF8, 0x00, 0x0F, 0xE3, 0xF8, 0x00, 0x0F, 0xFE, 0x00, 0x07,
  0xF8, 0xFE, 0x00, 0x03, 0xFF, 0x80, 0x01, 0xFC, 0x3F, 0x80, 0x01, 0xFF,
  0xE0, 0x00, 0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0xF8, 0x00, 0x3F, 0xC3, 0xF8,
  0x00, 0x3F, 0x7E, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x0F, 0xDF, 0x80, 0x07,
  0xF8, 0x3F, 0x80, 0x07, 0xF7, 0xE0, 0x01, 0xFC, 0x0F, 0xE0, 0x01, 0xF9,
  0xF8, 0x00, 0xFF, 0x01, 0xF8, 0x00, 0xFE, 0x7E, 0x00, 0x3F, 0x80, 0x7E,
  0x00, 0x3F, 0x1F, 0x80, 0x0F, 0xE0, 0x1F, 0x80, 0x0F, 0xC7, 0xE0, 0x07,
  0xF0, 0x07, 0xE0, 0x07, 0xF1, 0xF8, 0x01, 0xFC, 0x01, 0xF8, 0x01, 0xF8,
  0x7E, 0x00, 0xFE, 0x00, 0x7E, 0x00, 0xFE, 0x1F, 0x80, 0x3F, 0x80, 0x1F,
  0x80, 0x3F, 0x07, 0xE0, 0x1F, 0xE0, 0x07, 0xF0, 0x1F, 0xC1, 0xF8, 0x07,
  0xF0, 0x01, 0xFC, 0x07, 0xE0, 0x7E, 0x01, 0xFC, 0x00, 0x7F, 0x03, 0xF8,
  0x1F, 0x80, 0xFE, 0x00, 0x1F, 0xC0, 0xFC, 0x07, 0xE0, 0x3F, 0x80, 0x07,
  0xF0, 0x7F, 0x01, 0xFC, 0x1F, 0xC0, 0x01, 0xFC, 0x1F, 0x80, 0x3F, 0x07,
  0xF0, 0x00, 0x7F, 0x0F, 0xE0, 0x0F, 0xC3, 0xF8, 0x00, 0x1F, 0xC3, 0xF8,
  0x03, 0xF0, 0xFE, 0x00, 0x07, 0xF0, 0xFC, 0x00, 0xFC, 0x3F, 0x80, 0x01,
  0xFC, 0x7F, 0x00, 0x3F, 0x1F, 0xC0, 0x00, 0x7F, 0x1F, 0x80, 0x0F, 0xC7,
  0xF0, 0x00, 0x1F, 0xCF, 0xE0, 0x03, 0xF3, 0xF8, 0x00, 0x07, 0xF3, 0xF0,
  0x00, 0xFC, 0xFE, 0x00, 0x01, 0xFD, 0xFC, 0x00, 0x3F, 0x3F, 0x00, 0x00,
  0x7F, 0x7E, 0x00, 0x0F, 0xDF, 0xC0, 0x00, 0x1F, 0xDF, 0x80, 0x03, 0xF7,
  0xE0, 0x00, 0x07, 0xEF, 0xC0, 0x00, 0xFD, 0xF8, 0x00, 0x01, 0xFB, 0xF0,
  0x00, 0x3F, 0xFC, 0x00, 0x00, 0x3E, 0xF8, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x0F, 0xFE, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x3F, 0xF0,
  0x00, 0x0F, 0xFC, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0x03, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x3F,
  0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xC0, 0x00, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0xC0, 0x00,
  0x7F, 0x00, 0x00, 0xFF, 0x00, 0x00, 0xFF, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x00, 0x01,
  0xFC, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x00, 0x07,
  0xF0, 0x07, 0xF8, 0x00, 0x00, 0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x00, 0x0F,
  0xE0, 0x3F, 0xC0, 0x00, 0x00, 0x1F, 0xC0, 0xFF, 0x00, 0x00, 0x00, 0x1F,
  0xC3, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x00, 0x00, 0x7F,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF,
  0xFE, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0x01, 0xFF,
  0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xF8,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0xF0, 0x00, 0x00, 0x00, 0x00, 0xFF, 0xF0,
  0x00, 0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0xC0,
  0x00, 0x00, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x00, 0x00, 0xFF, 0x3F, 0x80,
  0x00, 0x00, 0x01, 0xFC, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x00, 0x00, 0x7F, 0x81, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x03, 0xF8, 0x00,
  0x00, 0x0F, 0xF0, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x80, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x00,
  0x07, 0xF8, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x00,
  0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFF, 0x00, 0x00, 0x7F, 0x00, 0x03,
  0xFC, 0x00, 0x00, 0xFF, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x3F,
  0xE0, 0x00, 0x03, 0xFC, 0x00, 0xFF, 0x80, 0x00, 0x03, 0xFC, 0x00, 0xFF,
  0x00, 0x00, 0x0F, 0xF7, 0xF0, 0x00, 0x01, 0xFE, 0x7F, 0x00, 0x00, 0x3F,
  0xE7, 0xF0, 0x00, 0x03, 0xFC, 0x7F, 0x00, 0x00, 0x7F, 0x83, 0xF8, 0x00,
  0x07, 0xF8, 0x3F, 0x80, 0x00, 0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x3F,
  0x80, 0x01, 0xFC, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8,
  0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x00, 0xFE, 0x01,
  0xFE, 0x00, 0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0xFE, 0x03, 0xFC, 0x00, 0x0F,
  0xE0, 0x7F, 0x80, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x07, 0xF0, 0xFF, 0x00,
  0x00, 0x7F, 0x1F, 0xE0, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x00, 0x3F, 0x3F,
  0xC0, 0x00, 0x03, 0xFB, 0xF8, 0x00, 0x00, 0x3F, 0xFF, 0x00, 0x00, 0x03,
  0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x01, 0xFF, 0xC0, 0x00,
  0x00, 0x1F, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0x00, 0x1F, 0xFF,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFF, 0xFF,
  0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xFF, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x01, 0xFF, 0x00,
  0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x00, 0x00, 0x00,
  0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01, 0xFF,
  0x00, 0x00, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00, 0x01,
  0xFF, 0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00,
  0x1F, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xFF, 0xFF,
  0x00, 0x7F, 0xFF, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xFF,
  0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF,
  0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0, 0x00,
  0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF, 0xC0,
  0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0xFE, 0x01, 0xF8, 0x07,
  0xE0, 0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00,
  0xFC, 0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x80, 0xFE, 0x03, 0xF8, 0x07, 0xE0,
  0x1F, 0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x3F, 0x00, 0xFC,
  0x03, 0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F,
  0x80, 0x7E, 0x01, 0xF8, 0x07, 0xF0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x03,
  0xF0, 0x0F, 0xC0, 0x3F, 0x00, 0xFE, 0x03, 0xF8, 0x07, 0xE0, 0x1F, 0x80,
  0x7E, 0x01, 0xF8, 0x07, 0xE0, 0x1F, 0xC0, 0x7F, 0x00, 0xFC, 0x00, 0x07,
  0xFF, 0xE0, 0x00, 0xFF, 0xF8, 0x00, 0x3F, 0xFF, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00,
  0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00,
  0x1F, 0xFF, 0x80, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x0F, 0xFF,
  0xC0, 0x03, 0xFF, 0xF0, 0x00, 0x7F, 0xFE, 0x00, 0x00, 0x00, 0x00, 0xF0,
  0x00, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x00,
  0x7F, 0xE0, 0x00, 0x00, 0x3F, 0xFC, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xE7, 0xC0, 0x00, 0x01, 0xF9, 0xF8, 0x00, 0x00, 0xFC, 0x3E, 0x00,
  0x00, 0x3F, 0x0F, 0xC0, 0x00, 0x1F, 0x83, 0xF0, 0x00, 0x07, 0xE0, 0x7E,
  0x00, 0x03, 0xF0, 0x1F, 0x80, 0x00, 0xFC, 0x03, 0xF0, 0x00, 0x7E, 0x00,
  0xFC, 0x00, 0x1F, 0x80, 0x1F, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF0,
  0x00, 0xF8, 0x01, 0xF8, 0x00, 0x3F, 0x00, 0x7E, 0x00, 0x0F, 0xC0, 0x3F,
  0x00, 0x01, 0xF8, 0x0F, 0xC0, 0x00, 0x7E, 0x07, 0xE0, 0x00, 0x0F, 0xC1,
  0xF8, 0x00, 0x03, 0xF0, 0xFC, 0x00, 0x00, 0x7E, 0x3F, 0x00, 0x00, 0x1F,
  0x9F, 0x80, 0x00, 0x07, 0xEF, 0xE0, 0x00, 0x00, 0xFC, 0x7F, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFE, 0xFF,
  0xFF, 0xFF, 0xE0, 0xFF, 0x0F, 0xF0, 0x7F, 0x03, 0xF8, 0x3F, 0x81, 0xFC,
  0x0F, 0xC0, 0x7E, 0x07, 0xE0, 0x3F, 0x01, 0xF0, 0x00, 0x07, 0xFC, 0x07,
  0xE0, 0x03, 0xFF, 0xE0, 0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x7F, 0xFF,
  0xE7, 0xE0, 0x1F, 0xFF, 0xFC, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF,
  0xC0, 0xFF, 0xF0, 0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81,
  0xFE, 0x00, 0x1F, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F,
  0xC3, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00,
  0x1F, 0xC3, 0xFC, 0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xE0,
  0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xF0, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F,
  0x07, 0xF8, 0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00,
  0xFF, 0x83, 0xFC, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0,
  0x01, 0xFF, 0x80, 0xFF, 0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFE, 0x03,
  0xFF, 0x1F, 0xDF, 0x80, 0x3F, 0xFF, 0xF3, 0xF0, 0x07, 0xFF, 0xFC, 0x7E,
  0x00, 0x7F, 0xFF, 0x0F, 0xC0, 0x07, 0xFF, 0xC1, 0xF8, 0x00, 0x7F, 0xE0,
  0x7E, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF8, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07,
  0xF8, 0x3F, 0xC0, 0x01, 0xFC, 0x3F, 0xFC, 0x00, 0x7F, 0x1F, 0xFF, 0x80,
  0x1F, 0xCF, 0xFF, 0xF0, 0x07, 0xE7, 0xFF, 0xFE, 0x03, 0xFB, 0xFF, 0xFF,
  0x80, 0xFF, 0xF8, 0x1F, 0xF0, 0x3F, 0xF8, 0x03, 0xFC, 0x0F, 0xFC, 0x00,
  0xFF, 0x03, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x07, 0xF0, 0x7F, 0xC0,
  0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x07, 0xF0, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0x80, 0x00, 0x7F, 0x0F,
  0xE0, 0x00, 0x1F, 0xC3, 0xF8, 0x00, 0x07, 0xF1, 0xFC, 0x00, 0x03, 0xFC,
  0x7F, 0x00, 0x00, 0xFF, 0x1F, 0xC0, 0x00, 0x3F, 0x87, 0xF0, 0x00, 0x1F,
  0xE1, 0xFC, 0x00, 0x07, 0xF8, 0xFF, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00,
  0xFF, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00, 0x1F, 0xE1, 0xFF, 0x80,
  0x0F, 0xF8, 0x7F, 0xE0, 0x07, 0xFC, 0x1F, 0xFC, 0x03, 0xFE, 0x07, 0xFF,
  0xE3, 0xFF, 0x81, 0xFB, 0xFF, 0xFF, 0xC0, 0xFE, 0x7F, 0xFF, 0xE0, 0x3F,
  0x1F, 0xFF, 0xF0, 0x0F, 0xC3, 0xFF, 0xF0, 0x03, 0xE0, 0x3F, 0xF8, 0x00,
  0x00, 0x01, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x7F, 0xFF,
  0xC0, 0x0F, 0xFF, 0xFE, 0x01, 0xFF, 0xFF, 0xE0, 0x1F, 0xFF, 0xFF, 0x01,
  0xFF, 0xFF, 0xF8, 0x0F, 0xFC, 0x01, 0x80, 0xFF, 0x80, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x07,
  0xF8, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x81, 0xFF, 0x00, 0x1C, 0x07, 0xFF, 0x07,
  0xE0, 0x3F, 0xFF, 0xFF, 0x00, 0xFF, 0xFF, 0xF8, 0x03, 0xFF, 0xFF, 0xC0,
  0x07, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00,
  0x1F, 0xC0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F,
  0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x01,
  0xFF, 0x03, 0xF8, 0x00, 0x1F, 0xFF, 0x0F, 0xE0, 0x00, 0xFF, 0xFE, 0x3F,
  0x00, 0x0F, 0xFF, 0xF9, 0xFC, 0x00, 0x7F, 0xFF, 0xF7, 0xF0, 0x03, 0xFF,
  0xFF, 0xFF, 0xC0, 0x0F, 0xF8, 0x0F, 0xFF, 0x00, 0x7F, 0xC0, 0x1F, 0xF8,
  0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x7F, 0x80,
  0x01, 0xFE, 0x01, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00, 0x01, 0xFC, 0x07, 0xF8, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x00, 0xFE, 0x01,
  0xFC, 0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x3F, 0xC0, 0x00,
  0x7F, 0x80, 0xFF, 0x00, 0x01, 0xFC, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07,
  0xFC, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x0F, 0xF0, 0x00, 0xFF, 0x80, 0x3F,
  0xC0, 0x07, 0xFE, 0x00, 0x7F, 0x00, 0x3F, 0xF8, 0x01, 0xFE, 0x01, 0xFF,
  0xE0, 0x07, 0xFE, 0x1F, 0xBF, 0x00, 0x0F, 0xFF, 0xFC, 0xFC, 0x00, 0x3F,
  0xFF, 0xE3, 0xF0, 0x00, 0x7F, 0xFF, 0x0F, 0xC0, 0x00, 0xFF, 0xF8, 0x3E,
  0x00, 0x01, 0xFF, 0x81, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x00, 0x00,
  0x03, 0xFF, 0x80, 0x00, 0x3F, 0xFF, 0x80, 0x03, 0xFF, 0xFF, 0x00, 0x1F,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x07, 0xFF, 0x3F, 0xF0, 0x3F, 0xE0,
  0x3F, 0xC1, 0xFE, 0x00, 0x7F, 0x0F, 0xF0, 0x01, 0xFC, 0x3F, 0xC0, 0x07,
  0xF1, 0xFE, 0x00, 0x1F, 0xC7, 0xF0, 0x00, 0x7F, 0x3F, 0xC0, 0x03, 0xF8,
  0xFE, 0x00, 0x1F, 0xE3, 0xF8, 0x01, 0xFF, 0x1F, 0xE0, 0x3F, 0xFC, 0x7F,
  0xFF, 0xFF, 0xE1, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x03, 0xFF, 0x80, 0x00, 0x0F, 0xE0, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x01,
  0xFE, 0x00, 0x02, 0x07, 0xFC, 0x00, 0x38, 0x0F, 0xFC, 0x07, 0xE0, 0x1F,
  0xFF, 0xFF, 0x80, 0x7F, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0xFF,
  0xFF, 0xC0, 0x01, 0xFF, 0xF8, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x1F, 0xFF,
  0xC0, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x07, 0xFF, 0xF8, 0x00, 0x00,
  0x1F, 0xFF, 0xE0, 0x00, 0x00, 0xFF, 0x81, 0x00, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01,
  0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x1F,
  0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFF, 0x00, 0x00, 0x7F, 0xFF, 0xFC, 0x00,
  0x01, 0xFF, 0xFF, 0xF0, 0x00, 0x07, 0xFF, 0xFF, 0xC0, 0x00, 0x3F, 0xFF,
  0xFE, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x3F, 0xC0,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00,
  0x0F, 0xF8, 0x00, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0x00, 0x3F, 0xFF, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00, 0x00, 0x0F,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x00, 0x00, 0x00, 0x03, 0xFE,
  0x03, 0xF0, 0x00, 0xFF, 0xF8, 0x3F, 0x00, 0x3F, 0xFF, 0xC3, 0xF0, 0x07,
  0xFF, 0xFE, 0x7E, 0x00, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF, 0xFF, 0xFE,
  0x01, 0xFF, 0x81, 0xFF, 0xE0, 0x3F, 0xE0, 0x0F, 0xFC, 0x07, 0xFC, 0x00,
  0x7F, 0xC0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0xFF,
  0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x03, 0xF8,
  0x1F, 0xC0, 0x00, 0x3F, 0x83, 0xFC, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00,
  0x7F, 0x83, 0xF8, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFF, 0x07, 0xF8, 0x00, 0x0F, 0xE0,
  0x7F, 0x80, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x01,
  0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x07, 0xF8,
  0x00, 0x7F, 0xC0, 0x7F, 0x80, 0x0F, 0xFC, 0x03, 0xFC, 0x01, 0xFF, 0xC0,
  0x3F, 0xC0, 0x7F, 0xFC, 0x03, 0xFF, 0x1F, 0xDF, 0x80, 0x1F, 0xFF, 0xFB,
  0xF8, 0x01, 0xFF, 0xFF, 0x3F, 0x80, 0x0F, 0xFF, 0xE3, 0xF8, 0x00, 0x7F,
  0xFC, 0x7F, 0x00, 0x03, 0xFF, 0x07, 0xF0, 0x00, 0x07, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x08, 0x00, 0x07, 0xF8, 0x00,
  0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFF, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0x0F, 0xFF, 0xFF, 0xC0, 0x00, 0xFF, 0xFF, 0xF8, 0x00, 0x0F, 0xFF,
  0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x1F,
  0xC0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0xFE, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x07, 0xF0, 0x1F, 0xE0, 0x01, 0xFC, 0x1F, 0xFE, 0x00, 0x7F, 0x1F, 0xFF,
  0xC0, 0x1F, 0xCF, 0xFF, 0xF8, 0x07, 0xE7, 0xFF, 0xFE, 0x03, 0xFB, 0xFF,
  0xFF, 0xC0, 0xFF, 0xF8, 0x0F, 0xF0, 0x3F, 0xFC, 0x03, 0xFC, 0x0F, 0xFC,
  0x00, 0x7F, 0x03, 0xFE, 0x00, 0x1F, 0xC1, 0xFF, 0x80, 0x07, 0xF0, 0x7F,
  0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x1F, 0xC3,
  0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFE,
  0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE1, 0xFE, 0x00, 0x07,
  0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07, 0xF0, 0x00,
  0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xF0, 0xFF, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE1, 0xFE,
  0x00, 0x07, 0xF8, 0x7F, 0x00, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x03, 0xFC,
  0x3F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x0F,
  0xE0, 0x00, 0x04, 0x00, 0x0F, 0xC0, 0x0F, 0xE0, 0x0F, 0xF0, 0x07, 0xF8,
  0x03, 0xFC, 0x01, 0xFE, 0x00, 0x7E, 0x00, 0x1C, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xF8, 0x03, 0xFC, 0x01,
  0xFC, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0,
  0x0F, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE,
  0x00, 0xFF, 0x00, 0x7F, 0x80, 0x3F, 0x80, 0x1F, 0xC0, 0x0F, 0xE0, 0x0F,
  0xF0, 0x07, 0xF0, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFF, 0x00,
  0x7F, 0x00, 0x3F, 0x80, 0x1F, 0xC0, 0x1F, 0xE0, 0x0F, 0xF0, 0x07, 0xF0,
  0x03, 0xF8, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x3F,
  0x80, 0x00, 0x00, 0x00, 0x00, 0x80, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x03, 0x80, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFC, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07,
  0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01,
  0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x07, 0xF8,
  0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x01, 0xFE, 0x00, 0x0F,
  0xFF, 0xE0, 0x00, 0xFF, 0xFC, 0x00, 0x0F, 0xFF, 0xC0, 0x00, 0xFF, 0xF8,
  0x00, 0x0F, 0xFF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x7F, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00,
  0x00, 0xFE, 0x00, 0x00, 0x00, 0x1F, 0xE0, 0x01, 0xFF, 0x01, 0xFC, 0x00,
  0x3F, 0xC0, 0x1F, 0xC0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F,
  0xC0, 0x1F, 0xE0, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x3F, 0x80, 0x7F, 0x80,
  0x03, 0xF8, 0x0F, 0xF0, 0x00, 0x3F, 0x81, 0xFE, 0x00, 0x07, 0xF8, 0x3F,
  0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00, 0x07, 0xF0, 0xFF, 0x00, 0x00, 0x7F,
  0x1F, 0xE0, 0x00, 0x07, 0xF3, 0xFC, 0x00, 0x00, 0xFE, 0x7F, 0x80, 0x00,
  0x0F, 0xEF, 0xF0, 0x00, 0x00, 0xFF, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xF0,
  0x00, 0x00, 0xFF, 0xFF, 0x80, 0x00, 0x1F, 0xFF, 0xF8, 0x00, 0x01, 0xFF,
  0xFF, 0xC0, 0x00, 0x1F, 0xFB, 0xFC, 0x00, 0x01, 0xFF, 0x1F, 0xE0, 0x00,
  0x3F, 0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x0F, 0xE0, 0x00, 0x3F, 0x80, 0xFF,
  0x00, 0x03, 0xF8, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x7F, 0x80, 0x07, 0xF8,
  0x03, 0xF8, 0x00, 0x7F, 0x00, 0x3F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00,
  0x7F, 0x00, 0x1F, 0xE0, 0x07, 0xF0, 0x01, 0xFE, 0x00, 0xFF, 0x00, 0x0F,
  0xF0, 0x0F, 0xE0, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x0F, 0xE0,
  0x00, 0x7F, 0x80, 0x00, 0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x07, 0xF8, 0x01, 0xFC, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x03, 0xFC, 0x00, 0xFE, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x07, 0xF8, 0x01,
  0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFE,
  0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00,
  0x1F, 0xC0, 0x07, 0xF0, 0x03, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F,
  0xE0, 0x03, 0xF8, 0x01, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x07, 0xF0,
  0x01, 0xFC, 0x00, 0xFF, 0x00, 0x3F, 0x80, 0x0F, 0xE0, 0x03, 0xF8, 0x00,
  0x01, 0xF8, 0x0F, 0xF8, 0x00, 0x7F, 0xC0, 0x07, 0xE0, 0xFF, 0xF0, 0x07,
  0xFF, 0x80, 0x1F, 0x87, 0xFF, 0xE0, 0x3F, 0xFF, 0x00, 0x7E, 0x3F, 0xFF,
  0xC1, 0xFF, 0xFE, 0x01, 0xF9, 0xFF, 0xFF, 0x0F, 0xFF, 0xFC, 0x0F, 0xEF,
  0xFF, 0xFC, 0x7F, 0xFF, 0xF0, 0x3F, 0xFE, 0x07, 0xFB, 0xF0, 0x3F, 0xC0,
  0xFF, 0xE0, 0x0F, 0xFF, 0x00, 0x7F, 0x03, 0xFF, 0x00, 0x3F, 0xF8, 0x01,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF0, 0x7F, 0xE0, 0x03, 0xFE,
  0x00, 0x1F, 0xC1, 0xFF, 0x00, 0x0F, 0xF8, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x3F, 0xC0, 0x01, 0xFC, 0x1F, 0xE0, 0x00, 0xFF, 0x00, 0x07, 0xF0, 0xFF,
  0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x1F, 0xE0, 0x00, 0xFF,
  0x0F, 0xF0, 0x00, 0x7F, 0x80, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x87, 0xF8, 0x00, 0x3F,
  0xC0, 0x00, 0xFE, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF8, 0x7F, 0x00,
  0x03, 0xF8, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x0F, 0xE0, 0x00, 0x7F, 0x07,
  0xF0, 0x00, 0x3F, 0x80, 0x01, 0xFC, 0x3F, 0xC0, 0x01, 0xFE, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xC0,
  0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01,
  0xFC, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F, 0xF0, 0x00, 0x7F, 0x87, 0xF0,
  0x00, 0x3F, 0x80, 0x01, 0xFC, 0x1F, 0xC0, 0x00, 0xFE, 0x00, 0x07, 0xF0,
  0x7F, 0x00, 0x03, 0xF8, 0x00, 0x1F, 0xC3, 0xFC, 0x00, 0x0F, 0xE0, 0x00,
  0x7F, 0x0F, 0xE0, 0x00, 0x7F, 0x00, 0x03, 0xFC, 0x3F, 0x80, 0x01, 0xFC,
  0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x07, 0xF0, 0x00, 0x3F, 0x80, 0x00, 0xFC,
  0x07, 0xFE, 0x00, 0x1F, 0x83, 0xFF, 0xE0, 0x03, 0xF0, 0xFF, 0xFE, 0x00,
  0x7E, 0x3F, 0xFF, 0xE0, 0x1F, 0xCF, 0xFF, 0xFC, 0x03, 0xFB, 0xFF, 0xFF,
  0xC0, 0x7F, 0xFC, 0x0F, 0xF8, 0x0F, 0xFF, 0x00, 0xFF, 0x01, 0xFF, 0xC0,
  0x0F, 0xE0, 0x7F, 0xF0, 0x01, 0xFC, 0x0F, 0xFC, 0x00, 0x3F, 0x81, 0xFF,
  0x00, 0x07, 0xF0, 0x3F, 0xE0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xC1,
  0xFF, 0x00, 0x07, 0xF8, 0x3F, 0xC0, 0x00, 0xFE, 0x07, 0xF8, 0x00, 0x1F,
  0xC0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0xFF, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xF8, 0x1F, 0xC0, 0x00, 0x7F, 0x03, 0xF8,
  0x00, 0x1F, 0xE0, 0xFF, 0x00, 0x03, 0xFC, 0x1F, 0xE0, 0x00, 0x7F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0x7F, 0x00, 0x01, 0xFC, 0x0F, 0xE0, 0x00, 0x7F,
  0x83, 0xFC, 0x00, 0x0F, 0xF0, 0x7F, 0x80, 0x01, 0xFC, 0x0F, 0xE0, 0x00,
  0x3F, 0x81, 0xFC, 0x00, 0x07, 0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0,
  0x00, 0x3F, 0xC1, 0xFE, 0x00, 0x07, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x0F,
  0xF0, 0x00, 0x3F, 0xC0, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x0F, 0xFF, 0xE0,
  0x00, 0x0F, 0xFF, 0xFC, 0x00, 0x1F, 0xFF, 0xFF, 0x00, 0x1F, 0xFF, 0xFF,
  0xC0, 0x1F, 0xFF, 0xFF, 0xE0, 0x1F, 0xF8, 0x0F, 0xF8, 0x0F, 0xF8, 0x03,
  0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x0F, 0xF8, 0x00, 0x3F, 0x87, 0xF8, 0x00,
  0x1F, 0xC3, 0xF8, 0x00, 0x0F, 0xE3, 0xFC, 0x00, 0x07, 0xF1, 0xFC, 0x00,
  0x03, 0xFD, 0xFE, 0x00, 0x01, 0xFE, 0xFF, 0x00, 0x00, 0xFF, 0x7F, 0x00,
  0x00, 0x7F, 0x3F, 0x80, 0x00, 0x3F, 0x9F, 0xC0, 0x00, 0x1F, 0xDF, 0xE0,
  0x00, 0x0F, 0xEF, 0xF0, 0x00, 0x07, 0xF7, 0xF0, 0x00, 0x07, 0xFB, 0xF8,
  0x00, 0x03, 0xF9, 0xFC, 0x00, 0x01, 0xFC, 0xFE, 0x00, 0x01, 0xFE, 0x7F,
  0x80, 0x00, 0xFE, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x7F, 0x87,
  0xF0, 0x00, 0x7F, 0x83, 0xFC, 0x00, 0x7F, 0x80, 0xFF, 0x00, 0x7F, 0xC0,
  0x7F, 0xF1, 0xFF, 0xC0, 0x1F, 0xFF, 0xFF, 0xC0, 0x07, 0xFF, 0xFF, 0xC0,
  0x01, 0xFF, 0xFF, 0xC0, 0x00, 0x7F, 0xFF, 0x80, 0x00, 0x0F, 0xFF, 0x00,
  0x00, 0x00, 0x30, 0x00, 0x00, 0x00, 0x1F, 0x80, 0xFF, 0x00, 0x00, 0x7E,
  0x0F, 0xFF, 0x00, 0x01, 0xF8, 0x7F, 0xFE, 0x00, 0x07, 0xE3, 0xFF, 0xFC,
  0x00, 0x1F, 0x9F, 0xFF, 0xF8, 0x00, 0xFE, 0xFF, 0xFF, 0xE0, 0x03, 0xFF,
  0xE0, 0x7F, 0xC0, 0x0F, 0xFE, 0x00, 0xFF, 0x00, 0x3F, 0xF0, 0x03, 0xFC,
  0x00, 0xFF, 0x80, 0x07, 0xF0, 0x07, 0xFC, 0x00, 0x1F, 0xC0, 0x1F, 0xF0,
  0x00, 0x7F, 0x00, 0x7F, 0x80, 0x01, 0xFC, 0x01, 0xFE, 0x00, 0x07, 0xF0,
  0x07, 0xF0, 0x00, 0x1F, 0xC0, 0x3F, 0xC0, 0x00, 0x7F, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x0F, 0xE0, 0x00, 0x1F, 0xC0,
  0x7F, 0x00, 0x00, 0xFF, 0x01, 0xFC, 0x00, 0x03, 0xFC, 0x07, 0xF0, 0x00,
  0x0F, 0xE0, 0x1F, 0xC0, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x01, 0xFE, 0x03,
  0xFC, 0x00, 0x07, 0xF0, 0x0F, 0xF0, 0x00, 0x3F, 0xC0, 0x3F, 0xC0, 0x00,
  0xFF, 0x00, 0xFF, 0x00, 0x07, 0xF8, 0x03, 0xFE, 0x00, 0x3F, 0xE0, 0x1F,
  0xF8, 0x01, 0xFF, 0x00, 0x7F, 0xF0, 0x0F, 0xF8, 0x01, 0xFF, 0xF8, 0xFF,
  0xE0, 0x07, 0xEF, 0xFF, 0xFF, 0x00, 0x3F, 0x9F, 0xFF, 0xF8, 0x00, 0xFE,
  0x3F, 0xFF, 0xC0, 0x03, 0xF8, 0x7F, 0xFC, 0x00, 0x0F, 0xE0, 0xFF, 0xE0,
  0x00, 0x3F, 0x80, 0x78, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x07, 0xF0,
  0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x00,
  0xFF, 0x00, 0x00, 0x00, 0x00, 0x00, 0x07, 0xFC, 0x07, 0xE0, 0x03, 0xFF,
  0xE0, 0xFC, 0x00, 0xFF, 0xFE, 0x1F, 0x00, 0x7F, 0xFF, 0xE7, 0xE0, 0x1F,
  0xFF, 0xFC, 0xFC, 0x07, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0x80, 0xFF, 0xF0,
  0x3F, 0xE0, 0x0F, 0xFC, 0x0F, 0xF8, 0x00, 0xFF, 0x81, 0xFE, 0x00, 0x1F,
  0xF0, 0x7F, 0x80, 0x01, 0xFE, 0x0F, 0xF0, 0x00, 0x3F, 0xC3, 0xFC, 0x00,
  0x07, 0xF0, 0x7F, 0x80, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x1F, 0xC3, 0xFC,
  0x00, 0x03, 0xF8, 0x7F, 0x80, 0x00, 0xFF, 0x0F, 0xE0, 0x00, 0x1F, 0xC1,
  0xFC, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x00, 0x7F, 0x0F, 0xF0, 0x00, 0x1F,
  0xE1, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0xC0, 0x00, 0x7F, 0x07, 0xF8, 0x00,
  0x1F, 0xE0, 0xFE, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x83, 0xFC,
  0x00, 0x1F, 0xE0, 0x7F, 0x80, 0x07, 0xFC, 0x0F, 0xF0, 0x01, 0xFF, 0x80,
  0xFE, 0x00, 0x7F, 0xF0, 0x1F, 0xE0, 0x1F, 0xFE, 0x03, 0xFF, 0x0F, 0xDF,
  0x80, 0x3F, 0xFF, 0xF7, 0xF0, 0x07, 0xFF, 0xFC, 0xFE, 0x00, 0x7F, 0xFF,
  0x1F, 0xC0, 0x07, 0xFF, 0xC7, 0xF0, 0x00, 0x7F, 0xE0, 0xFE, 0x00, 0x00,
  0xE0, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0x00,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00,
  0x7F, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00, 0x00,
  0x00, 0x3F, 0x80, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x01, 0xFC, 0x00,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xF8, 0x0F,
  0xF0, 0x1F, 0x83, 0xFE, 0x01, 0xF8, 0x7F, 0xE0, 0x1F, 0x8F, 0xFE, 0x01,
  0xF9, 0xFF, 0xE0, 0x3F, 0xBF, 0xFE, 0x03, 0xFF, 0xF8, 0x40, 0x3F, 0xFC,
  0x00, 0x03, 0xFF, 0x80, 0x00, 0x3F, 0xF0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x0F, 0xF0,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x0F, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x03, 0xF8, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F,
  0x80, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x01,
  0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0xFE, 0x03, 0xFF, 0xFF, 0xE0, 0x3F, 0xFF,
  0xFF, 0x01, 0xFF, 0xCF, 0xF8, 0x1F, 0xF0, 0x03, 0x80, 0xFF, 0x00, 0x04,
  0x07, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x03, 0xFE, 0x00, 0x00, 0x0F, 0xFC,
  0x00, 0x00, 0x7F, 0xF0, 0x00, 0x01, 0xFF, 0xE0, 0x00, 0x07, 0xFF, 0x80,
  0x00, 0x1F, 0xFF, 0x00, 0x00, 0x7F, 0xFC, 0x00, 0x00, 0xFF, 0xF0, 0x00,
  0x01, 0xFF, 0x80, 0x00, 0x07, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F,
  0x00, 0x00, 0x03, 0xF8, 0x40, 0x00, 0x3F, 0xC3, 0xC0, 0x03, 0xFE, 0x1F,
  0xC0, 0x7F, 0xE0, 0xFF, 0xFF, 0xFF, 0x07, 0xFF, 0xFF, 0xF0, 0x3F, 0xFF,
  0xFF, 0x00, 0xFF, 0xFF, 0xE0, 0x01, 0xFF, 0xFC, 0x00, 0x00, 0xFC, 0x00,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x3F, 0x00, 0x00, 0xFE, 0x00,
  0x07, 0xFF, 0xFE, 0x3F, 0xFF, 0xFD, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xEF,
  0xFF, 0xFF, 0xDF, 0xFF, 0xFF, 0x81, 0xFE, 0x00, 0x03, 0xF8, 0x00, 0x07,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0x7F, 0x80, 0x00, 0xFE,
  0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xC0,
  0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x03, 0xFC, 0x00,
  0x07, 0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x1F, 0xC0, 0x00, 0x3F, 0x80, 0x00,
  0xFF, 0x00, 0x01, 0xFC, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xF0, 0x00, 0x0F,
  0xE0, 0x00, 0x1F, 0xE0, 0x00, 0x3F, 0xE1, 0xC0, 0x7F, 0xFF, 0x80, 0x7F,
  0xFF, 0x00, 0xFF, 0xFE, 0x00, 0xFF, 0xFC, 0x00, 0xFF, 0xF0, 0x00, 0x1C,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07, 0xF0, 0x7F,
  0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFE, 0x0F, 0xE0, 0x00, 0x3F, 0x83,
  0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80, 0x01, 0xFE,
  0x1F, 0xE0, 0x00, 0x7F, 0x07, 0xF0, 0x00, 0x1F, 0xC1, 0xFC, 0x00, 0x07,
  0xF0, 0x7F, 0x00, 0x01, 0xFC, 0x3F, 0xC0, 0x00, 0xFF, 0x0F, 0xF0, 0x00,
  0x3F, 0x83, 0xF8, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x03, 0xF8, 0x3F, 0x80,
  0x00, 0xFE, 0x1F, 0xE0, 0x00, 0x7F, 0x87, 0xF0, 0x00, 0x1F, 0xC1, 0xFC,
  0x00, 0x07, 0xF0, 0x7F, 0x00, 0x03, 0xFC, 0x1F, 0xC0, 0x00, 0xFF, 0x0F,
  0xF0, 0x00, 0x3F, 0x83, 0xF8, 0x00, 0x1F, 0xE0, 0xFE, 0x00, 0x07, 0xF8,
  0x3F, 0x80, 0x03, 0xFE, 0x0F, 0xE0, 0x01, 0xFF, 0x83, 0xF8, 0x00, 0x7F,
  0xC0, 0xFE, 0x00, 0x3F, 0xF0, 0x3F, 0x80, 0x1F, 0xFC, 0x0F, 0xF0, 0x1F,
  0xFF, 0x03, 0xFF, 0x1F, 0xDF, 0xC0, 0xFF, 0xFF, 0xE7, 0xE0, 0x1F, 0xFF,
  0xF1, 0xF8, 0x03, 0xFF, 0xF8, 0x7E, 0x00, 0xFF, 0xFC, 0x1F, 0x80, 0x0F,
  0xFC, 0x07, 0xC0, 0x00, 0x78, 0x00, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x7F,
  0xFF, 0x80, 0x00, 0x3F, 0xDF, 0xC0, 0x00, 0x3F, 0xCF, 0xE0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x1F, 0xE3, 0xF8, 0x00, 0x0F, 0xE1, 0xFC, 0x00, 0x0F,
  0xF0, 0xFE, 0x00, 0x07, 0xF0, 0x7F, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x03,
  0xF8, 0x0F, 0xC0, 0x03, 0xFC, 0x07, 0xE0, 0x01, 0xFC, 0x03, 0xF8, 0x01,
  0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0xFE, 0x00, 0x7F, 0x00,
  0xFF, 0x00, 0x3F, 0x80, 0x7F, 0x00, 0x1F, 0xC0, 0x7F, 0x80, 0x0F, 0xE0,
  0x3F, 0x80, 0x03, 0xF0, 0x3F, 0xC0, 0x01, 0xF8, 0x1F, 0xC0, 0x00, 0xFC,
  0x1F, 0xE0, 0x00, 0x7E, 0x0F, 0xE0, 0x00, 0x3F, 0x8F, 0xF0, 0x00, 0x1F,
  0xC7, 0xF0, 0x00, 0x0F, 0xE7, 0xF8, 0x00, 0x07, 0xF3, 0xF8, 0x00, 0x03,
  0xF9, 0xF8, 0x00, 0x00, 0xFD, 0xFC, 0x00, 0x00, 0x7E, 0xFC, 0x00, 0x00,
  0x3F, 0xFE, 0x00, 0x00, 0x1F, 0xFE, 0x00, 0x00, 0x0F, 0xFF, 0x00, 0x00,
  0x07, 0xFF, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x01, 0xFF, 0x80, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x00, 0xFE, 0x00, 0x0F, 0xF0, 0x00, 0x3F, 0xFF,
  0x00, 0x07, 0xF8, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFC, 0x00, 0x1F, 0xDF,
  0xC0, 0x03, 0xFE, 0x00, 0x1F, 0xEF, 0xE0, 0x03, 0xFF, 0x00, 0x0F, 0xE7,
  0xF0, 0x01, 0xFF, 0x80, 0x07, 0xF3, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xF1,
  0xFC, 0x00, 0xFF, 0xE0, 0x03, 0xF8, 0xFE, 0x00, 0x7D, 0xF8, 0x03, 0xFC,
  0x7F, 0x00, 0x7E, 0xFC, 0x01, 0xFC, 0x3F, 0x80, 0x3F, 0x7E, 0x01, 0xFE,
  0x1F, 0xC0, 0x3F, 0x3F, 0x00, 0xFE, 0x0F, 0xE0, 0x1F, 0x9F, 0x80, 0xFF,
  0x03, 0xF0, 0x1F, 0x8F, 0xC0, 0x7F, 0x01, 0xF8, 0x0F, 0xC7, 0xE0, 0x3F,
  0x80, 0xFC, 0x0F, 0xE3, 0xF0, 0x3F, 0x80, 0x7E, 0x07, 0xE1, 0xF8, 0x1F,
  0xC0, 0x3F, 0x03, 0xF0, 0xFC, 0x1F, 0xC0, 0x1F, 0x83, 0xF0, 0x7E, 0x0F,
  0xE0, 0x0F, 0xC1, 0xF8, 0x3F, 0x0F, 0xE0, 0x07, 0xE1, 0xF8, 0x1F, 0x87,
  0xF0, 0x03, 0xF0, 0xFC, 0x0F, 0xC3, 0xF0, 0x01, 0xF8, 0xFC, 0x07, 0xE3,
  0xF8, 0x00, 0xFC, 0x7E, 0x03, 0xF1, 0xFC, 0x00, 0x7E, 0x7E, 0x01, 0xF9,
  0xFC, 0x00, 0x3F, 0x3F, 0x00, 0xFC, 0xFE, 0x00, 0x1F, 0x9F, 0x00, 0x3E,
  0x7E, 0x00, 0x0F, 0xDF, 0x80, 0x1F, 0x7F, 0x00, 0x07, 0xEF, 0xC0, 0x0F,
  0xBF, 0x00, 0x03, 0xF7, 0xC0, 0x07, 0xDF, 0x80, 0x01, 0xFF, 0xE0, 0x03,
  0xFF, 0x80, 0x00, 0xFF, 0xE0, 0x01, 0xFF, 0xC0, 0x00, 0x7F, 0xF0, 0x00,
  0xFF, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x7F, 0xE0, 0x00, 0x1F, 0xF8, 0x00,
  0x3F, 0xE0, 0x00, 0x0F, 0xF8, 0x00, 0x1F, 0xF0, 0x00, 0x07, 0xFC, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0xFE, 0x00,
  0x07, 0xF8, 0x01, 0xFE, 0x00, 0x1F, 0xE0, 0x01, 0xFC, 0x00, 0x7F, 0xC0,
  0x03, 0xF8, 0x00, 0xFF, 0x00, 0x03, 0xF8, 0x03, 0xFC, 0x00, 0x07, 0xF0,
  0x0F, 0xF0, 0x00, 0x0F, 0xF0, 0x3F, 0xC0, 0x00, 0x0F, 0xE0, 0x7F, 0x00,
  0x00, 0x1F, 0xC1, 0xFE, 0x00, 0x00, 0x1F, 0xC7, 0xF8, 0x00, 0x00, 0x3F,
  0x9F, 0xE0, 0x00, 0x00, 0x3F, 0xFF, 0x80, 0x00, 0x00, 0x7F, 0xFE, 0x00,
  0x00, 0x00, 0xFF, 0xF8, 0x00, 0x00, 0x00, 0xFF, 0xE0, 0x00, 0x00, 0x01,
  0xFF, 0xC0, 0x00, 0x00, 0x01, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00,
  0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x00, 0x3F, 0xF8, 0x00, 0x00, 0x00,
  0xFF, 0xF0, 0x00, 0x00, 0x03, 0xFF, 0xF0, 0x00, 0x00, 0x07, 0xFF, 0xE0,
  0x00, 0x00, 0x1F, 0xDF, 0xE0, 0x00, 0x00, 0x7F, 0x1F, 0xC0, 0x00, 0x01,
  0xFE, 0x3F, 0xC0, 0x00, 0x07, 0xF8, 0x3F, 0x80, 0x00, 0x1F, 0xE0, 0x7F,
  0x00, 0x00, 0x7F, 0x80, 0x7F, 0x00, 0x00, 0xFF, 0x00, 0xFE, 0x00, 0x03,
  0xFC, 0x01, 0xFE, 0x00, 0x0F, 0xF0, 0x01, 0xFC, 0x00, 0x3F, 0xC0, 0x03,
  0xFC, 0x00, 0xFF, 0x80, 0x03, 0xF8, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x0F,
  0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x3F, 0xC0, 0x1F,
  0xE0, 0x00, 0x0F, 0xF0, 0x03, 0xF8, 0x00, 0x07, 0xF8, 0x00, 0xFE, 0x00,
  0x01, 0xFC, 0x00, 0x3F, 0x80, 0x00, 0xFF, 0x00, 0x0F, 0xE0, 0x00, 0x3F,
  0x80, 0x03, 0xF8, 0x00, 0x1F, 0xE0, 0x00, 0xFE, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0x80, 0x03, 0xFC, 0x00, 0x07, 0xF0, 0x00, 0xFE, 0x00, 0x01, 0xFC,
  0x00, 0x7F, 0x80, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x00, 0x1F, 0xC0, 0x0F,
  0xF0, 0x00, 0x07, 0xF0, 0x03, 0xF8, 0x00, 0x01, 0xFC, 0x01, 0xFE, 0x00,
  0x00, 0x3F, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x3F, 0x80, 0x00, 0x03,
  0xF8, 0x0F, 0xE0, 0x00, 0x00, 0xFE, 0x07, 0xF0, 0x00, 0x00, 0x3F, 0x81,
  0xFC, 0x00, 0x00, 0x0F, 0xE0, 0xFE, 0x00, 0x00, 0x03, 0xF8, 0x7F, 0x80,
  0x00, 0x00, 0x7E, 0x1F, 0xC0, 0x00, 0x00, 0x1F, 0x87, 0xF0, 0x00, 0x00,
  0x07, 0xE3, 0xF8, 0x00, 0x00, 0x01, 0xF8, 0xFE, 0x00, 0x00, 0x00, 0x7E,
  0x7F, 0x00, 0x00, 0x00, 0x1F, 0x9F, 0xC0, 0x00, 0x00, 0x07, 0xEF, 0xE0,
  0x00, 0x00, 0x00, 0xFB, 0xF0, 0x00, 0x00, 0x00, 0x3E, 0xFC, 0x00, 0x00,
  0x00, 0x0F, 0xFE, 0x00, 0x00, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x00, 0x00,
  0xFF, 0xC0, 0x00, 0x00, 0x00, 0x3F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8,
  0x00, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x00, 0x00, 0x7F, 0x00, 0x00,
  0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x00, 0x00, 0x7F, 0x80, 0x00, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x00, 0x1F, 0xF0, 0x00, 0x00, 0x00, 0x0F, 0xF8, 0x00, 0x00, 0x03,
  0xFF, 0xFC, 0x00, 0x00, 0x00, 0xFF, 0xFE, 0x00, 0x00, 0x00, 0x3F, 0xFF,
  0x00, 0x00, 0x00, 0x0F, 0xFF, 0x80, 0x00, 0x00, 0x03, 0xFF, 0xC0, 0x00,
  0x00, 0x00, 0xFF, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7F, 0xFF, 0xFF,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE,
  0x00, 0xFF, 0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0xFE, 0x00, 0x00, 0x03, 0xFC,
  0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0,
  0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x7F, 0x80,
  0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x01, 0xFE, 0x00,
  0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x0F, 0xF0, 0x00,
  0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00, 0x3F, 0xC0, 0x00,
  0x00, 0x7F, 0x80, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0x03, 0xFC, 0x00, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x07, 0xF8, 0x00, 0x00,
  0x0F, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x00,
  0x3F, 0x80, 0x00, 0x00, 0x7F, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF, 0xFF, 0x80,
  0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xFF, 0x80,
  0x00, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xFF, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x01, 0xFF, 0x80,
  0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x01, 0xFC, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3F, 0x80, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x03, 0xF0,
  0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF0, 0x00, 0x00,
  0x7E, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0xF8, 0x00, 0x00, 0xFE, 0x00,
  0x00, 0x3F, 0xC0, 0x00, 0x3F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x0F, 0xFF,
  0x00, 0x01, 0xFF, 0x00, 0x00, 0x3F, 0xE0, 0x00, 0x07, 0xFE, 0x00, 0x00,
  0xFF, 0xE0, 0x00, 0x01, 0xFE, 0x00, 0x00, 0x1F, 0xC0, 0x00, 0x01, 0xF8,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF8, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F,
  0xE0, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7F, 0xF0, 0x00, 0x07, 0xFE, 0x00,
  0x00, 0x7F, 0xC0, 0x00, 0x07, 0xF8, 0x00, 0x00, 0x07, 0x00, 0x00, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0x00, 0x0C, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x0F, 0xFC, 0x00, 0x01, 0xFF, 0xC0, 0x00, 0x3F, 0xF8, 0x00, 0x09,
  0xFF, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x03,
  0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x01, 0xF8, 0x00,
  0x00, 0x7F, 0x00, 0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F,
  0x00, 0x00, 0x07, 0xE0, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x03, 0xF0, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0x00, 0xFF,
  0xC0, 0x00, 0x0F, 0xFE, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x0F, 0xF0, 0x00,
  0x0F, 0xFE, 0x00, 0x07, 0xFF, 0xC0, 0x01, 0xFF, 0xF0, 0x00, 0x3F, 0xC0,
  0x00, 0x0F, 0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x7F, 0x00, 0x00, 0x0F,
  0xE0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0xE0, 0x00,
  0x01, 0xFC, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xFC,
  0x00, 0x00, 0x3F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE, 0x00, 0x00, 0x3F, 0x80,
  0x00, 0x1F, 0xF0, 0x00, 0x3F, 0xFC, 0x00, 0x07, 0xFF, 0x80, 0x00, 0xFF,
  0xE0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFC, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x8F, 0xFF, 0x00, 0x00, 0xCF, 0xFF, 0xF0,
  0x00, 0xEF, 0xFF, 0xFF, 0x01, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xE0, 0x3F, 0xFF, 0xFD, 0xC0, 0x03, 0xFF, 0xFC, 0xC0, 0x00,
  0x3F, 0xFC, 0x40, 0x00, 0x01, 0xF0, 0x00,
};

const GFXglyph NotoSans_MediumItalic68pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 18, 0, -1 },
  { 1, 19, 50, 18, 1, -49 },
  { 120, 22, 18, 28, 7, -49 },
  { 170, 42, 49, 44, 2, -49 },
  { 428, 34, 56, 37, 2, -52 },
  { 666, 48, 50, 55, 5, -49 },
  { 966, 43, 50, 46, 2, -49 },
  { 1235, 10, 18, 16, 7, -49 },
  { 1258, 23, 60, 21, 3, -49 },
  { 1431, 23, 60, 21, -5, -49 },
  { 1604, 31, 32, 37, 7, -52 },
  { 1728, 33, 32, 39, 4, -40 },
  { 1860, 14, 17, 18, -3, -8 },
  { 1890, 17, 6, 21, 2, -21 },
  { 1903, 10, 10, 18, 1, -9 },
  { 1916, 34, 49, 26, -3, -49 },
  { 2125, 33, 50, 37, 3, -49 },
  { 2332, 22, 49, 37, 9, -49 },
  { 2467, 36, 49, 37, 0, -49 },
  { 2688, 35, 50, 37, 1, -49 },
  { 2907, 36, 49, 37, 0, -49 },
  { 3128, 35, 50, 37, 2, -49 },
  { 3347, 33, 50, 37, 4, -49 },
  { 3554, 34, 49, 37, 5, -49 },
  { 3763, 34, 50, 37, 3, -49 },
  { 3976, 33, 50, 37, 3, -49 },
  { 4183, 15, 39, 18, 1, -38 },
  { 4257, 19, 47, 18, -3, -38 },
  { 4369, 33, 34, 39, 4, -42 },
  { 4510, 31, 19, 39, 5, -33 },
  { 4584, 33, 34, 39, 4, -42 },
  { 4725, 27, 50, 30, 5, -49 },
  { 4894, 53, 54, 58, 3, -48 },
  { 5252, 40, 49, 40, -4, -49 },
  { 5497, 37, 49, 41, 3, -49 },
  { 5724, 38, 50, 40, 5, -49 },
  { 5962, 40, 49, 46, 3, -49 },
  { 6207, 35, 49, 36, 3, -49 },
  { 6422, 35, 49, 34, 3, -49 },
  { 6637, 40, 50, 46, 5, -49 },
  { 6887, 44, 49, 47, 3, -49 },
  { 7157, 29, 49, 23, -2, -49 },
  { 7335, 31, 62, 20, -11, -49 },
  { 7576, 42, 49, 39, 3, -49 },
  { 7834, 26, 49, 33, 3, -49 },
  { 7994, 56, 49, 58, 2, -49 },
  { 8337, 47, 49, 49, 2, -49 },
  { 8625, 42, 50, 49, 5, -49 },
  { 8888, 37, 49, 39, 3, -49 },
  { 9115, 42, 61, 49, 5, -49 },
  { 9436, 36, 49, 40, 3, -49 },
  { 9657, 35, 50, 35, 1, -49 },
  { 9876, 34, 49, 35, 6, -49 },
  { 10085, 42, 50, 46, 5, -49 },
  { 10348, 39, 49, 38, 6, -49 },
  { 10587, 58, 49, 59, 7, -49 },
  { 10943, 47, 49, 37, -4, -49 },
  { 11231, 36, 49, 36, 6, -49 },
  { 11452, 40, 49, 36, -1, -49 },
  { 11697, 27, 60, 21, -1, -49 },
  { 11900, 14, 49, 26, 7, -49 },
  { 11986, 27, 60, 21, -5, -49 },
  { 12189, 34, 31, 38, 2, -49 },
  { 12321, 28, 5, 27, -6, 6 },
  { 12339, 12, 11, 20, 10, -52 },
  { 12356, 35, 38, 39, 3, -37 },
  { 12523, 34, 53, 40, 2, -52 },
  { 12749, 29, 38, 31, 3, -37 },
  { 12887, 38, 53, 40, 3, -52 },
  { 13139, 30, 38, 35, 3, -37 },
  { 13282, 38, 68, 23, -7, -52 },
  { 13605, 36, 53, 40, 2, -37 },
  { 13844, 34, 52, 40, 2, -52 },
  { 14065, 17, 51, 18, 2, -51 },
  { 14174, 28, 67, 18, -9, -51 },
  { 14409, 36, 52, 35, 2, -52 },
  { 14643, 18, 52, 18, 2, -52 },
  { 14760, 54, 37, 60, 2, -37 },
  { 15010, 35, 37, 40, 1, -37 },
  { 15172, 33, 38, 39, 3, -37 },
  { 15329, 38, 53, 40, -2, -37 },
  { 15581, 35, 53, 40, 3, -37 },
  { 15813, 28, 37, 28, 2, -37 },
  { 15943, 29, 38, 30, 0, -37 },
  { 16081, 23, 46, 24, 3, -45 },
  { 16214, 34, 38, 40, 4, -37 },
  { 16376, 33, 37, 33, 3, -37 },
  { 16529, 49, 37, 50, 4, -37 },
  { 16756, 39, 37, 34, -3, -37 },
  { 16937, 42, 53, 33, -6, -37 },
  { 17216, 32, 37, 31, -1, -37 },
  { 17364, 27, 60, 24, 1, -49 },
  { 17567, 6, 68, 37, 17, -52 },
  { 17618, 27, 60, 24, -3, -49 },
  { 17821, 33, 10, 39, 4, -29 },
};

const GFXfont NotoSans_MediumItalic68pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic68pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic68pt7bGlyphs,
  0x20, 0x7E, 93
};

#endif // _NOTOSANS_MEDIUMITALIC68PT7B_H_
