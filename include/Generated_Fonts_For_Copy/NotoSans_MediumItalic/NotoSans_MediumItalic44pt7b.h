#ifndef _NOTOSANS_MEDIUMITALIC44PT7B_H_
#define _NOTOSANS_MEDIUMITALIC44PT7B_H_

#include <pgmspace.h>
#ifndef GFXfont
#  include <TFT_eSPI.h>  // provides GFXfont and GFXglyph
#endif

// FreeFont (1bpp) generated from TTF by fontMaker.py
// Source: NotoSans-MediumItalic.ttf
// Size: 44pt @ 72dpi, chars: 0x20-0x7E

const uint8_t NotoSans_MediumItalic44pt7bBitmaps[] PROGMEM = {
  0x00, 0x03, 0xF0, 0x3E, 0x03, 0xE0, 0x7E, 0x07, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x00, 0xF0, 0x0F, 0x01,
  0xF0, 0x1E, 0x01, 0xE0, 0x1E, 0x01, 0xE0, 0x3C, 0x03, 0xC0, 0x00, 0x00,
  0x00, 0x00, 0x03, 0x80, 0x7C, 0x0F, 0xC0, 0xFC, 0x0F, 0xC0, 0xF8, 0x02,
  0x00, 0x7C, 0x7D, 0xE1, 0xE7, 0x87, 0x9E, 0x1E, 0x78, 0xF3, 0xC3, 0xCF,
  0x0F, 0x3C, 0x3C, 0xE0, 0xE3, 0x83, 0x8E, 0x0E, 0x00, 0x00, 0x0F, 0x07,
  0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00,
  0x1C, 0x0E, 0x00, 0x03, 0xC0, 0xE0, 0x00, 0x3C, 0x1E, 0x00, 0x03, 0x81,
  0xE0, 0x00, 0x78, 0x1C, 0x01, 0xFF, 0xFF, 0xFF, 0x1F, 0xFF, 0xFF, 0xF1,
  0xFF, 0xFF, 0xFE, 0x00, 0xF0, 0x38, 0x00, 0x0F, 0x07, 0x80, 0x00, 0xE0,
  0x78, 0x00, 0x1E, 0x07, 0x00, 0x01, 0xE0, 0xF0, 0x00, 0x1C, 0x0F, 0x00,
  0x01, 0xC0, 0xE0, 0x0F, 0xFF, 0xFF, 0xF8, 0xFF, 0xFF, 0xFF, 0x8F, 0xFF,
  0xFF, 0xF8, 0x07, 0x81, 0xC0, 0x00, 0x78, 0x3C, 0x00, 0x07, 0x03, 0xC0,
  0x00, 0x70, 0x38, 0x00, 0x0F, 0x03, 0x80, 0x00, 0xF0, 0x78, 0x00, 0x0E,
  0x07, 0x80, 0x01, 0xE0, 0x70, 0x00, 0x1E, 0x0F, 0x00, 0x00, 0x00, 0x03,
  0x80, 0x00, 0x0E, 0x00, 0x00, 0x70, 0x00, 0x03, 0xF0, 0x00, 0xFF, 0xF8,
  0x07, 0xFF, 0xF0, 0x3F, 0xFF, 0xC1, 0xFB, 0x8E, 0x0F, 0x8E, 0x08, 0x3E,
  0x38, 0x00, 0xF0, 0xE0, 0x03, 0xC3, 0x00, 0x0F, 0x9C, 0x00, 0x3E, 0x70,
  0x00, 0x7F, 0xC0, 0x01, 0xFF, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xFF, 0x00,
  0x03, 0xFE, 0x00, 0x0F, 0xF8, 0x00, 0x3B, 0xF0, 0x01, 0xC7, 0xC0, 0x07,
  0x1F, 0x00, 0x1C, 0x7C, 0x00, 0x71, 0xF2, 0x01, 0x8F, 0x8F, 0x0E, 0x7E,
  0x3F, 0xFF, 0xF0, 0xFF, 0xFF, 0x81, 0xFF, 0xFC, 0x00, 0xFF, 0x80, 0x00,
  0x70, 0x00, 0x01, 0xC0, 0x00, 0x07, 0x00, 0x00, 0x1C, 0x00, 0x00, 0xE0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x0F, 0xF0, 0x00, 0xF0, 0x3F, 0xE0, 0x03,
  0xC0, 0xFF, 0xE0, 0x0F, 0x03, 0xC3, 0xC0, 0x3C, 0x07, 0x87, 0x80, 0x78,
  0x1E, 0x0F, 0x01, 0xE0, 0x3C, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x1E, 0x00,
  0xE0, 0x78, 0x3C, 0x03, 0xC0, 0xF0, 0xF0, 0x07, 0x81, 0xE3, 0xC0, 0x0F,
  0x07, 0x8F, 0x00, 0x1E, 0x0F, 0x1E, 0x7F, 0x3C, 0x1E, 0x79, 0xFF, 0x78,
  0x79, 0xE7, 0xFE, 0x7F, 0xE7, 0x9F, 0x3E, 0xFF, 0xCF, 0x3C, 0x3C, 0xFF,
  0x3C, 0xF0, 0x78, 0x78, 0xF1, 0xE0, 0xF0, 0x03, 0xC3, 0xC1, 0xE0, 0x07,
  0x8F, 0x03, 0xC0, 0x1E, 0x1E, 0x07, 0x80, 0x78, 0x3C, 0x0F, 0x00, 0xF0,
  0x78, 0x3C, 0x03, 0xC0, 0xF0, 0x78, 0x0F, 0x01, 0xE0, 0xF0, 0x3C, 0x03,
  0xC3, 0xC0, 0x78, 0x07, 0x8F, 0x81, 0xE0, 0x07, 0xFE, 0x07, 0x80, 0x0F,
  0xF8, 0x1E, 0x00, 0x0F, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xF8, 0x00, 0x0F, 0xFF, 0xC0, 0x01, 0xF8, 0x7C, 0x00, 0x1F,
  0x03, 0xC0, 0x01, 0xE0, 0x3E, 0x00, 0x1E, 0x03, 0xC0, 0x01, 0xE0, 0x3C,
  0x00, 0x1E, 0x07, 0xC0, 0x01, 0xE0, 0xF8, 0x00, 0x1F, 0x1F, 0x00, 0x01,
  0xF7, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x00, 0xFF, 0x00, 0x00, 0x1F, 0xC0,
  0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF, 0xF0, 0x1F, 0x1F, 0x9F, 0x01, 0xE3,
  0xE0, 0xF8, 0x3E, 0x7C, 0x07, 0xC7, 0xC7, 0xC0, 0x7C, 0x7C, 0x78, 0x03,
  0xEF, 0x8F, 0x80, 0x1F, 0xF0, 0xF8, 0x01, 0xFE, 0x0F, 0x80, 0x0F, 0xC0,
  0x7C, 0x00, 0xFC, 0x07, 0xE0, 0x3F, 0xE0, 0x7F, 0xBF, 0xFF, 0x03, 0xFF,
  0xFD, 0xF0, 0x1F, 0xFF, 0x0F, 0x80, 0xFF, 0xC0, 0xFC, 0x7D, 0xE7, 0x9E,
  0x7B, 0xCF, 0x3C, 0xE3, 0x8E, 0x00, 0x00, 0x3E, 0x00, 0xF0, 0x03, 0xC0,
  0x0F, 0x80, 0x3E, 0x00, 0x78, 0x01, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x3E,
  0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x07, 0x80, 0x1F, 0x00, 0x3C, 0x00,
  0x78, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C,
  0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x07, 0x80, 0x0F, 0x00,
  0x1E, 0x00, 0x3C, 0x00, 0x7C, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x01,
  0xE0, 0x03, 0xC0, 0x03, 0x80, 0x00, 0x00, 0xF0, 0x01, 0xE0, 0x01, 0xE0,
  0x03, 0xC0, 0x07, 0x80, 0x07, 0x80, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00,
  0x78, 0x00, 0xF8, 0x01, 0xF0, 0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F,
  0x00, 0x3E, 0x00, 0x78, 0x00, 0xF0, 0x01, 0xE0, 0x03, 0xC0, 0x0F, 0x80,
  0x1F, 0x00, 0x3C, 0x00, 0x78, 0x01, 0xF0, 0x03, 0xC0, 0x0F, 0x80, 0x1E,
  0x00, 0x7C, 0x00, 0xF0, 0x03, 0xE0, 0x07, 0x80, 0x1E, 0x00, 0x7C, 0x00,
  0xF0, 0x03, 0xC0, 0x0F, 0x00, 0x3C, 0x00, 0x00, 0x00, 0x20, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x30, 0x1C, 0x01,
  0xE0, 0xE0, 0x0F, 0xC7, 0x00, 0xFF, 0xF0, 0x00, 0xFF, 0xFF, 0xC0, 0xFF,
  0xFE, 0x03, 0xFF, 0xF0, 0x3F, 0x87, 0x83, 0xDC, 0x00, 0x3E, 0xF0, 0x03,
  0xE3, 0x80, 0x3E, 0x1E, 0x01, 0xE0, 0xF0, 0x07, 0x07, 0xC0, 0x10, 0x1E,
  0x00, 0x00, 0xC0, 0x00, 0x00, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E,
  0x00, 0x00, 0xF0, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xF0,
  0x0F, 0x00, 0x00, 0x78, 0x00, 0x03, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x00, 0x00,
  0x0F, 0x87, 0xC7, 0xC3, 0xE1, 0xE1, 0xF0, 0xF0, 0xF8, 0x78, 0x38, 0x3C,
  0x00, 0x7F, 0xF7, 0xFE, 0xFF, 0xEF, 0xFE, 0x39, 0xFF, 0xFF, 0xFF, 0xE2,
  0x00, 0x00, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x3E,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F,
  0x00, 0x00, 0xF8, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x78, 0x00,
  0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x00, 0x00, 0x7C, 0x00, 0x01, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00,
  0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0x00, 0x1F, 0x00, 0x03, 0xFF, 0x00, 0x1F,
  0xFE, 0x00, 0xFF, 0xFC, 0x07, 0xE1, 0xF8, 0x3F, 0x03, 0xE0, 0xF8, 0x0F,
  0x87, 0xC0, 0x1E, 0x1F, 0x00, 0x7C, 0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF,
  0x80, 0x1F, 0x7C, 0x00, 0x7D, 0xF0, 0x01, 0xE7, 0xC0, 0x07, 0x9F, 0x00,
  0x3E, 0x78, 0x00, 0xFB, 0xE0, 0x03, 0xEF, 0x80, 0x0F, 0xBE, 0x00, 0x3E,
  0xF8, 0x01, 0xF3, 0xE0, 0x07, 0xCF, 0x80, 0x1F, 0x3E, 0x00, 0xF8, 0xF8,
  0x03, 0xE1, 0xE0, 0x1F, 0x07, 0xC0, 0x7C, 0x1F, 0x03, 0xE0, 0x7F, 0xFF,
  0x00, 0xFF, 0xF8, 0x01, 0xFF, 0xC0, 0x03, 0xFE, 0x00, 0x00, 0x7C, 0x07,
  0xF0, 0x7F, 0x83, 0xFE, 0x3F, 0xF9, 0xFF, 0xEF, 0xEF, 0xBE, 0x3C, 0x60,
  0xF1, 0x07, 0xC0, 0x1F, 0x00, 0x7C, 0x01, 0xE0, 0x0F, 0x80, 0x3E, 0x00,
  0xF8, 0x03, 0xC0, 0x0F, 0x00, 0x7C, 0x01, 0xF0, 0x07, 0xC0, 0x1E, 0x00,
  0x78, 0x03, 0xE0, 0x0F, 0x80, 0x3E, 0x00, 0xF0, 0x07, 0xC0, 0x1F, 0x00,
  0x7C, 0x01, 0xE0, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0xFF, 0xE0, 0x07, 0xFF,
  0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0x0F, 0xE0, 0x38, 0x07, 0xC0, 0x40, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x3E, 0x00,
  0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF8, 0x00, 0x07, 0xE0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00, 0x01, 0xF8,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00,
  0x07, 0xFF, 0xFF, 0x1F, 0xFF, 0xFE, 0x3F, 0xFF, 0xFC, 0x7F, 0xFF, 0xF8,
  0x00, 0x3F, 0x80, 0x03, 0xFF, 0x80, 0x3F, 0xFF, 0x83, 0xFF, 0xFE, 0x07,
  0xC0, 0xFC, 0x0C, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x00, 0x00,
  0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x3E, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x1F, 0xFC, 0x00, 0x7F, 0xC0, 0x03, 0xFF, 0x00, 0x0F,
  0xFF, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x07,
  0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC8,
  0x00, 0x3E, 0x30, 0x01, 0xF8, 0xFE, 0xFF, 0xC3, 0xFF, 0xFE, 0x0F, 0xFF,
  0xF0, 0x0F, 0xFF, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xFC, 0x00, 0x03,
  0xF8, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xC0, 0x00, 0xF7, 0x80, 0x03, 0xEF,
  0x00, 0x0F, 0xBE, 0x00, 0x1E, 0x78, 0x00, 0x78, 0xF0, 0x01, 0xF1, 0xE0,
  0x07, 0xC7, 0xC0, 0x1F, 0x0F, 0x80, 0x7C, 0x1E, 0x00, 0xF0, 0x3C, 0x03,
  0xC0, 0xF8, 0x0F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0xF8, 0x07, 0x83, 0xE0,
  0x0F, 0x07, 0xFF, 0xFF, 0xEF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C,
  0x00, 0x00, 0x78, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x00, 0xFF,
  0xFE, 0x03, 0xFF, 0xF8, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xE0, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00,
  0x0F, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xFF, 0xF0, 0x01,
  0xFF, 0xF8, 0x07, 0xFF, 0xF8, 0x03, 0x87, 0xF8, 0x00, 0x03, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF1, 0x00, 0x07,
  0xC3, 0x80, 0x3F, 0x87, 0xF3, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0,
  0x0F, 0xFF, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x01, 0xFF, 0xC0, 0x3F, 0xFE,
  0x03, 0xFF, 0xF0, 0x3F, 0x80, 0x83, 0xF0, 0x00, 0x3F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x78, 0x00, 0x07,
  0xC7, 0xE0, 0x3C, 0xFF, 0xC1, 0xEF, 0xFF, 0x1F, 0xFF, 0xF8, 0xFF, 0x07,
  0xE7, 0xE0, 0x1F, 0x3E, 0x00, 0xF9, 0xF0, 0x03, 0xCF, 0x00, 0x1E, 0x78,
  0x00, 0xF3, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF0, 0x03, 0xC7, 0x80, 0x3E,
  0x3E, 0x01, 0xF1, 0xF8, 0x1F, 0x07, 0xF7, 0xF0, 0x3F, 0xFF, 0x80, 0xFF,
  0xF0, 0x01, 0xFF, 0x00, 0x3F, 0xFF, 0xFC, 0xFF, 0xFF, 0xF3, 0xFF, 0xFF,
  0xDF, 0xFF, 0xFE, 0x00, 0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1E, 0x00,
  0x00, 0xF8, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03,
  0xE0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03,
  0xE0, 0x00, 0x0F, 0x80, 0x00, 0x7C, 0x00, 0x03, 0xF0, 0x00, 0x0F, 0x80,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00, 0x7E, 0x00, 0x01,
  0xF0, 0x00, 0x0F, 0x80, 0x00, 0x00, 0x00, 0x1F, 0x80, 0x03, 0xFF, 0x80,
  0x1F, 0xFF, 0x00, 0xFF, 0xFE, 0x07, 0xE0, 0xFC, 0x1F, 0x01, 0xF0, 0xF8,
  0x07, 0xC3, 0xE0, 0x1F, 0x0F, 0x80, 0x7C, 0x3E, 0x01, 0xF0, 0xF8, 0x0F,
  0x81, 0xF0, 0x3E, 0x07, 0xC3, 0xF0, 0x0F, 0xFF, 0x80, 0x1F, 0xF8, 0x00,
  0x7F, 0x80, 0x07, 0xFF, 0x00, 0x7F, 0xFE, 0x03, 0xF0, 0xFC, 0x1F, 0x80,
  0xF8, 0x7C, 0x03, 0xE3, 0xE0, 0x07, 0x8F, 0x80, 0x1F, 0x3E, 0x00, 0x7C,
  0xF0, 0x01, 0xF3, 0xE0, 0x07, 0x8F, 0x80, 0x3E, 0x3F, 0x01, 0xF8, 0x7F,
  0x1F, 0xC1, 0xFF, 0xFE, 0x03, 0xFF, 0xF0, 0x03, 0xFF, 0x00, 0x00, 0x3E,
  0x00, 0x0F, 0xFE, 0x00, 0xFF, 0xF8, 0x0F, 0xFF, 0xE0, 0xFC, 0x3F, 0x0F,
  0xC0, 0xF8, 0x7C, 0x03, 0xE7, 0xC0, 0x1F, 0x3E, 0x00, 0xF9, 0xE0, 0x03,
  0xCF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x0F, 0x9E, 0x00, 0x7C, 0xF8,
  0x07, 0xE7, 0xC0, 0x7F, 0x3F, 0x0F, 0xF0, 0xFF, 0xF7, 0x83, 0xFF, 0x7C,
  0x0F, 0xF3, 0xE0, 0x0C, 0x1E, 0x00, 0x01, 0xF0, 0x00, 0x0F, 0x80, 0x00,
  0xF8, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xE0, 0x00, 0x7E, 0x0F,
  0xBF, 0xE0, 0x7F, 0xFE, 0x03, 0xFF, 0xE0, 0x1F, 0xFC, 0x00, 0x07, 0x83,
  0xE1, 0xFC, 0x7E, 0x1F, 0x83, 0xC0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x03, 0x81, 0xF0, 0xFC,
  0x3F, 0x0F, 0xC3, 0xE0, 0x20, 0x00, 0x00, 0xF0, 0x0F, 0x80, 0xFE, 0x07,
  0xE0, 0x3F, 0x00, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x1F, 0x01, 0xF8, 0x0F, 0x80, 0x7C, 0x07, 0xC0, 0x3C, 0x01, 0xE0,
  0x1E, 0x00, 0xF0, 0x0F, 0x00, 0x70, 0x00, 0x00, 0x00, 0x08, 0x00, 0x01,
  0xC0, 0x00, 0x3E, 0x00, 0x07, 0xF0, 0x00, 0xFF, 0x00, 0x1F, 0xC0, 0x03,
  0xF8, 0x00, 0x7F, 0x00, 0x0F, 0xE0, 0x01, 0xFC, 0x00, 0x3F, 0x80, 0x01,
  0xF0, 0x00, 0x0F, 0xE0, 0x00, 0x3F, 0xE0, 0x00, 0x7F, 0xC0, 0x00, 0x7F,
  0x80, 0x00, 0xFF, 0x80, 0x01, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x03, 0xF0,
  0x00, 0x07, 0x80, 0x00, 0x0C, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xF0, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x07, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0x80, 0x80, 0x00, 0x07, 0x00, 0x00, 0x3E, 0x00, 0x01,
  0xFC, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0, 0x00, 0x1F, 0xE0, 0x00, 0x3F,
  0xC0, 0x00, 0x3F, 0x80, 0x00, 0x7F, 0x00, 0x00, 0xFE, 0x00, 0x01, 0xF0,
  0x00, 0x3F, 0x80, 0x0F, 0xF0, 0x01, 0xFE, 0x00, 0x7F, 0xC0, 0x0F, 0xF8,
  0x01, 0xFE, 0x00, 0x3F, 0xC0, 0x01, 0xF8, 0x00, 0x0F, 0x00, 0x00, 0x40,
  0x00, 0x00, 0x03, 0xF8, 0x0F, 0xFF, 0x1F, 0xFF, 0xC7, 0xFF, 0xF3, 0xC1,
  0xF9, 0x80, 0x7C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x07, 0xC0,
  0x03, 0xE0, 0x03, 0xE0, 0x03, 0xF0, 0x03, 0xF0, 0x07, 0xF0, 0x07, 0xE0,
  0x07, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x70, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x06, 0x00, 0x0F,
  0x80, 0x07, 0xE0, 0x07, 0xF0, 0x03, 0xF0, 0x00, 0xF8, 0x00, 0x30, 0x00,
  0x00, 0x00, 0x03, 0xFF, 0xE0, 0x00, 0x03, 0xFF, 0xFE, 0x00, 0x03, 0xFF,
  0xFF, 0xC0, 0x03, 0xF8, 0x01, 0xF8, 0x01, 0xF8, 0x00, 0x1F, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x7C, 0x00, 0x00, 0x78, 0x3E, 0x00, 0x00, 0x0F, 0x0F,
  0x00, 0x7E, 0x03, 0xC7, 0x80, 0xFF, 0xF0, 0xF3, 0xC0, 0x7F, 0xFC, 0x1C,
  0xF0, 0x3E, 0x1E, 0x07, 0x38, 0x1F, 0x07, 0x81, 0xDE, 0x0F, 0x81, 0xE0,
  0x77, 0x83, 0xC0, 0x78, 0x1D, 0xC1, 0xE0, 0x1C, 0x07, 0x70, 0x78, 0x0F,
  0x03, 0xFC, 0x1E, 0x03, 0xC0, 0xFF, 0x07, 0x00, 0xF0, 0x3F, 0xC3, 0xC0,
  0x78, 0x1E, 0xF0, 0xF0, 0x1E, 0x07, 0xBC, 0x1C, 0x0F, 0x83, 0xCF, 0x07,
  0x87, 0xF1, 0xF1, 0xC1, 0xFF, 0xBF, 0xF8, 0x78, 0x3F, 0xC7, 0xFC, 0x1E,
  0x07, 0xE0, 0xFC, 0x07, 0x80, 0x00, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x00,
  0x3E, 0x00, 0x00, 0x00, 0x07, 0xC0, 0x00, 0x00, 0x00, 0xFC, 0x00, 0x18,
  0x00, 0x1F, 0xF0, 0xFE, 0x00, 0x03, 0xFF, 0xFF, 0x80, 0x00, 0x3F, 0xFF,
  0x80, 0x00, 0x03, 0xFF, 0x00, 0x00, 0x00, 0x00, 0x7E, 0x00, 0x00, 0x3F,
  0x80, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xF8, 0x00, 0x01, 0xFE, 0x00, 0x00,
  0xF7, 0x80, 0x00, 0x3D, 0xE0, 0x00, 0x1F, 0x7C, 0x00, 0x07, 0x9F, 0x00,
  0x03, 0xE3, 0xC0, 0x01, 0xF0, 0xF0, 0x00, 0x7C, 0x3C, 0x00, 0x3E, 0x0F,
  0x00, 0x0F, 0x83, 0xC0, 0x07, 0xC0, 0xF0, 0x01, 0xF0, 0x3C, 0x00, 0xF8,
  0x0F, 0x80, 0x3C, 0x03, 0xE0, 0x1F, 0xFF, 0xF8, 0x07, 0xFF, 0xFE, 0x03,
  0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xE0, 0x7C, 0x00, 0x78, 0x3E, 0x00, 0x1E,
  0x0F, 0x80, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x3C, 0x03,
  0xFF, 0xF0, 0x03, 0xFF, 0xFC, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xFF, 0x07,
  0xC0, 0x3F, 0x07, 0xC0, 0x1F, 0x07, 0x80, 0x1F, 0x07, 0x80, 0x1F, 0x0F,
  0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x3E, 0x0F, 0x00, 0x7E, 0x0F,
  0x01, 0xFC, 0x1F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x1F, 0xFF, 0xE0, 0x1F,
  0xFF, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E,
  0x00, 0x7C, 0x3C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C, 0x00, 0x7C, 0x7C,
  0x00, 0xFC, 0x78, 0x01, 0xF8, 0x78, 0x03, 0xF8, 0xFF, 0xFF, 0xF0, 0xFF,
  0xFF, 0xE0, 0xFF, 0xFF, 0x80, 0xFF, 0xFC, 0x00, 0x00, 0x07, 0xF0, 0x00,
  0x1F, 0xFF, 0x80, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xE0, 0x3F, 0xE1, 0xF0,
  0x3F, 0x80, 0x10, 0x3F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x1F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80,
  0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xFC,
  0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x07, 0xF0, 0x04, 0x03,
  0xFF, 0xFE, 0x00, 0xFF, 0xFF, 0x00, 0x3F, 0xFF, 0x80, 0x07, 0xFF, 0x80,
  0x03, 0xFF, 0xE0, 0x00, 0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0xE0, 0x1F, 0xFF,
  0xFC, 0x07, 0xC0, 0x3F, 0x01, 0xF0, 0x07, 0xE0, 0x7C, 0x00, 0xF8, 0x1E,
  0x00, 0x3F, 0x0F, 0x80, 0x07, 0xC3, 0xE0, 0x01, 0xF0, 0xF8, 0x00, 0x7C,
  0x3C, 0x00, 0x1F, 0x0F, 0x00, 0x07, 0xC7, 0xC0, 0x01, 0xF1, 0xF0, 0x00,
  0x7C, 0x7C, 0x00, 0x1F, 0x1E, 0x00, 0x07, 0xCF, 0x80, 0x03, 0xF3, 0xE0,
  0x00, 0xF8, 0xF8, 0x00, 0x3E, 0x3E, 0x00, 0x1F, 0x8F, 0x00, 0x07, 0xC7,
  0xC0, 0x03, 0xF1, 0xF0, 0x01, 0xF8, 0x7C, 0x00, 0xFC, 0x1F, 0x00, 0xFF,
  0x07, 0x80, 0xFF, 0x83, 0xFF, 0xFF, 0x80, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF,
  0xC0, 0x0F, 0xFF, 0x80, 0x00, 0x03, 0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F,
  0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0,
  0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x78, 0x00, 0x00, 0xF0, 0x00, 0x03, 0xFF, 0xFC, 0x07, 0xFF, 0xF8,
  0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0, 0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01,
  0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00, 0x01, 0xE0, 0x00, 0x07, 0xFF,
  0xFC, 0x0F, 0xFF, 0xF8, 0x1F, 0xFF, 0xE0, 0x3F, 0xFF, 0xC0, 0x00, 0x03,
  0xFF, 0xFE, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF, 0xE0, 0x7C,
  0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x0F, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xFF, 0xF8, 0x0F, 0xFF, 0xF0, 0x1F, 0xFF, 0xC0,
  0x7F, 0xFF, 0x80, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF8,
  0x00, 0x01, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00, 0x1F, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0x03, 0xF8, 0x00, 0x07, 0xFF, 0xE0,
  0x07, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x03, 0xFE, 0x0F, 0x81, 0xFC, 0x00,
  0x60, 0xFE, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x1F, 0x80, 0x00, 0x0F, 0xC0,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x0F, 0xFE, 0xF8, 0x03, 0xFF,
  0xBE, 0x00, 0xFF, 0xCF, 0x80, 0x7F, 0xF3, 0xE0, 0x00, 0x7C, 0xF8, 0x00,
  0x1F, 0x3E, 0x00, 0x07, 0x8F, 0x80, 0x03, 0xE3, 0xE0, 0x00, 0xF8, 0xFC,
  0x00, 0x3E, 0x1F, 0x00, 0x0F, 0x87, 0xE0, 0x03, 0xC0, 0xFE, 0x01, 0xF0,
  0x3F, 0xFF, 0xFC, 0x07, 0xFF, 0xFF, 0x00, 0x7F, 0xFF, 0xC0, 0x07, 0xFF,
  0x80, 0x03, 0xE0, 0x01, 0xF0, 0x3E, 0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0,
  0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01, 0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0,
  0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F, 0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C,
  0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00, 0x7C, 0x0F, 0x00, 0x07, 0xC1, 0xFF,
  0xFF, 0xF8, 0x1F, 0xFF, 0xFF, 0x81, 0xFF, 0xFF, 0xF8, 0x1F, 0xFF, 0xFF,
  0x83, 0xE0, 0x00, 0xF8, 0x3E, 0x00, 0x0F, 0x03, 0xE0, 0x01, 0xF0, 0x3E,
  0x00, 0x1F, 0x03, 0xC0, 0x01, 0xF0, 0x7C, 0x00, 0x1F, 0x07, 0xC0, 0x01,
  0xE0, 0x7C, 0x00, 0x3E, 0x07, 0xC0, 0x03, 0xE0, 0x78, 0x00, 0x3E, 0x0F,
  0x80, 0x03, 0xC0, 0xF8, 0x00, 0x3C, 0x0F, 0x80, 0x07, 0xC0, 0xF0, 0x00,
  0x7C, 0x00, 0x03, 0xFF, 0xE0, 0x7F, 0xF8, 0x07, 0xFE, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E, 0x00, 0x03, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x78, 0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00,
  0x7C, 0x00, 0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01,
  0xF0, 0x00, 0x3C, 0x00, 0x07, 0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0xC0, 0x00, 0xF0, 0x00, 0x3E, 0x00, 0x0F, 0xE0, 0x07, 0xFF, 0x01, 0xFF,
  0xE0, 0x3F, 0xFC, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3E,
  0x00, 0x03, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07,
  0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00,
  0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00,
  0x1E, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x00, 0x3C, 0x00,
  0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0x80,
  0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x0E, 0xFF, 0x00, 0xFF, 0xE0,
  0x0F, 0xFC, 0x00, 0xFF, 0x80, 0x03, 0x80, 0x00, 0x03, 0xE0, 0x07, 0xE0,
  0x7C, 0x01, 0xF8, 0x0F, 0x00, 0x7E, 0x03, 0xE0, 0x1F, 0x80, 0x7C, 0x07,
  0xE0, 0x0F, 0x81, 0xF8, 0x01, 0xE0, 0x7E, 0x00, 0x3C, 0x1F, 0x80, 0x0F,
  0x87, 0xE0, 0x01, 0xF1, 0xF8, 0x00, 0x3E, 0x7E, 0x00, 0x07, 0x8F, 0x80,
  0x00, 0xF3, 0xE0, 0x00, 0x3E, 0xF8, 0x00, 0x07, 0xFF, 0x00, 0x00, 0xFF,
  0xF0, 0x00, 0x1F, 0xFE, 0x00, 0x07, 0xF3, 0xE0, 0x00, 0xF8, 0x7C, 0x00,
  0x1F, 0x0F, 0x80, 0x03, 0xE0, 0xF8, 0x00, 0x78, 0x1F, 0x00, 0x1F, 0x01,
  0xF0, 0x03, 0xE0, 0x3E, 0x00, 0x7C, 0x07, 0xC0, 0x0F, 0x00, 0x7C, 0x01,
  0xE0, 0x0F, 0x80, 0x7C, 0x00, 0xF8, 0x0F, 0x80, 0x1F, 0x01, 0xF0, 0x03,
  0xE0, 0x3C, 0x00, 0x3E, 0x00, 0x03, 0xE0, 0x01, 0xF0, 0x00, 0xF0, 0x00,
  0xF8, 0x00, 0x7C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80,
  0x07, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00, 0x7C,
  0x00, 0x3E, 0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x80, 0x07, 0xC0, 0x03,
  0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x7C, 0x00, 0x3C, 0x00,
  0x1E, 0x00, 0x1F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFB, 0xFF, 0xFC, 0x03,
  0xF8, 0x00, 0x0F, 0xF0, 0x3F, 0x80, 0x00, 0xFE, 0x03, 0xF8, 0x00, 0x1F,
  0xE0, 0x7F, 0x80, 0x01, 0xFE, 0x07, 0xF8, 0x00, 0x3F, 0xE0, 0x7F, 0x80,
  0x03, 0xFC, 0x07, 0xB8, 0x00, 0x7B, 0xC0, 0x7B, 0xC0, 0x0F, 0xBC, 0x0F,
  0xBC, 0x00, 0xF7, 0xC0, 0xF3, 0xC0, 0x1F, 0x7C, 0x0F, 0x3C, 0x01, 0xE7,
  0x80, 0xF3, 0xC0, 0x3E, 0x78, 0x1F, 0x3C, 0x03, 0xCF, 0x81, 0xF3, 0xC0,
  0x78, 0xF8, 0x1E, 0x3C, 0x07, 0x8F, 0x81, 0xE3, 0xC0, 0xF0, 0xF0, 0x1E,
  0x1C, 0x0F, 0x0F, 0x03, 0xE1, 0xE1, 0xE1, 0xF0, 0x3E, 0x1E, 0x1E, 0x1F,
  0x03, 0xC1, 0xE3, 0xC1, 0xF0, 0x3C, 0x1E, 0x3C, 0x1E, 0x03, 0xC1, 0xE7,
  0x81, 0xE0, 0x7C, 0x1E, 0x78, 0x3E, 0x07, 0xC1, 0xEF, 0x03, 0xE0, 0x78,
  0x1F, 0xF0, 0x3C, 0x07, 0x80, 0xFE, 0x03, 0xC0, 0x78, 0x0F, 0xC0, 0x7C,
  0x0F, 0x80, 0xFC, 0x07, 0xC0, 0xF0, 0x0F, 0x80, 0x7C, 0x0F, 0x00, 0xF8,
  0x07, 0x80, 0xF0, 0x0F, 0x00, 0x78, 0x00, 0x03, 0xF0, 0x00, 0x7C, 0x0F,
  0xC0, 0x01, 0xF0, 0x3F, 0x00, 0x07, 0x81, 0xFE, 0x00, 0x1E, 0x07, 0xF8,
  0x00, 0x78, 0x1F, 0xF0, 0x03, 0xE0, 0x7F, 0xC0, 0x0F, 0x81, 0xEF, 0x00,
  0x3C, 0x0F, 0xBE, 0x00, 0xF0, 0x3C, 0xF8, 0x07, 0xC0, 0xF1, 0xE0, 0x1F,
  0x03, 0xC7, 0xC0, 0x78, 0x1F, 0x1F, 0x01, 0xE0, 0x7C, 0x3C, 0x07, 0x81,
  0xE0, 0xF8, 0x3E, 0x07, 0x81, 0xE0, 0xF8, 0x1E, 0x07, 0x83, 0xC0, 0xF8,
  0x1F, 0x0F, 0x03, 0xE0, 0x3C, 0x3C, 0x0F, 0x00, 0xF9, 0xF0, 0x3C, 0x03,
  0xE7, 0xC0, 0xF0, 0x07, 0x9E, 0x07, 0xC0, 0x1F, 0x78, 0x1F, 0x00, 0x7D,
  0xE0, 0x78, 0x00, 0xF7, 0x81, 0xE0, 0x03, 0xFE, 0x07, 0x80, 0x07, 0xF0,
  0x3E, 0x00, 0x1F, 0xC0, 0xF0, 0x00, 0x7F, 0x03, 0xC0, 0x00, 0xFC, 0x0F,
  0x00, 0x03, 0xE0, 0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03,
  0xFF, 0xFC, 0x00, 0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xC0, 0x1F,
  0x83, 0xF0, 0x01, 0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE7, 0xE0,
  0x00, 0x7C, 0xF8, 0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E,
  0xF8, 0x00, 0x07, 0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00,
  0x03, 0xFF, 0x00, 0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF,
  0x80, 0x00, 0x7D, 0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00,
  0x7C, 0xFC, 0x00, 0x1F, 0x8F, 0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F,
  0x80, 0x7F, 0x03, 0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xF0, 0x01, 0xFF, 0xF8,
  0x00, 0x1F, 0xFC, 0x00, 0x03, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x03, 0xFF,
  0xFC, 0x07, 0xFF, 0xFE, 0x07, 0xC0, 0x7E, 0x07, 0xC0, 0x3E, 0x07, 0xC0,
  0x1E, 0x07, 0x80, 0x1F, 0x0F, 0x80, 0x1F, 0x0F, 0x80, 0x1E, 0x0F, 0x80,
  0x3E, 0x0F, 0x00, 0x3E, 0x0F, 0x00, 0x7E, 0x1F, 0x00, 0xFC, 0x1F, 0x03,
  0xFC, 0x1F, 0xFF, 0xF8, 0x1F, 0xFF, 0xF0, 0x3F, 0xFF, 0xC0, 0x3F, 0xFE,
  0x00, 0x3E, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x7C, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x78, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF8, 0x00, 0x00, 0xF0, 0x00,
  0x00, 0x00, 0x07, 0xF0, 0x00, 0x07, 0xFF, 0x80, 0x03, 0xFF, 0xFC, 0x00,
  0xFF, 0xFF, 0xC0, 0x3F, 0xC3, 0xF8, 0x0F, 0xC0, 0x1F, 0x83, 0xF0, 0x01,
  0xF0, 0xFC, 0x00, 0x3F, 0x1F, 0x00, 0x03, 0xE7, 0xE0, 0x00, 0x7C, 0xF8,
  0x00, 0x0F, 0xBF, 0x00, 0x01, 0xF7, 0xC0, 0x00, 0x3E, 0xF8, 0x00, 0x07,
  0xDF, 0x00, 0x00, 0xFF, 0xC0, 0x00, 0x1F, 0xF8, 0x00, 0x03, 0xFF, 0x00,
  0x00, 0x7F, 0xE0, 0x00, 0x0F, 0xFC, 0x00, 0x03, 0xFF, 0x80, 0x00, 0x7D,
  0xF0, 0x00, 0x0F, 0xBE, 0x00, 0x03, 0xF7, 0xC0, 0x00, 0x7C, 0xFC, 0x00,
  0x1F, 0x8F, 0x80, 0x07, 0xE1, 0xF8, 0x01, 0xF8, 0x1F, 0x80, 0xFE, 0x03,
  0xFF, 0xFF, 0xC0, 0x3F, 0xFF, 0xE0, 0x03, 0xFF, 0xF8, 0x00, 0x1F, 0xFC,
  0x00, 0x00, 0x0F, 0xC0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x01, 0xF8, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3F,
  0x80, 0x03, 0xFF, 0xE0, 0x07, 0xFF, 0xF0, 0x0F, 0xFF, 0xF0, 0x3F, 0xFF,
  0xE0, 0x7C, 0x07, 0xE0, 0xF8, 0x07, 0xC1, 0xF0, 0x0F, 0x83, 0xC0, 0x0F,
  0x0F, 0x80, 0x1E, 0x1F, 0x00, 0x7C, 0x3E, 0x00, 0xF8, 0x78, 0x01, 0xF0,
  0xF0, 0x07, 0xC3, 0xE0, 0x3F, 0x87, 0xFF, 0xFE, 0x0F, 0xFF, 0xF8, 0x1F,
  0xFF, 0xC0, 0x7F, 0xFE, 0x00, 0xF8, 0x3C, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0xF8, 0x07, 0x80, 0xF0, 0x1F, 0x01, 0xF0, 0x3E, 0x03, 0xE0, 0x7C, 0x03,
  0xE0, 0xF8, 0x07, 0xC1, 0xE0, 0x0F, 0x87, 0xC0, 0x0F, 0x8F, 0x80, 0x1F,
  0x1F, 0x00, 0x3F, 0x3C, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0xC0, 0x03, 0xFF,
  0xE0, 0x1F, 0xFF, 0xC0, 0xFF, 0xFF, 0x07, 0xF0, 0xF8, 0x3F, 0x00, 0x60,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x7F, 0x80,
  0x00, 0xFF, 0x80, 0x00, 0xFF, 0x00, 0x01, 0xFE, 0x00, 0x01, 0xFC, 0x00,
  0x03, 0xF0, 0x00, 0x07, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x1F, 0x88, 0x00, 0x7C, 0x30, 0x07, 0xF0,
  0xFF, 0xFF, 0x83, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x1F, 0xFE, 0x00, 0x7F,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFE, 0x00, 0xF8,
  0x00, 0x03, 0xE0, 0x00, 0x0F, 0x00, 0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00,
  0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F,
  0x80, 0x00, 0x3E, 0x00, 0x00, 0xF0, 0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00,
  0x00, 0x7C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0x80, 0x00, 0x3E, 0x00, 0x00,
  0xF8, 0x00, 0x03, 0xE0, 0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0,
  0x00, 0x07, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x7C, 0x00, 0x03, 0xE0, 0x00,
  0x00, 0x07, 0xC0, 0x03, 0xE1, 0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x87,
  0xC0, 0x01, 0xF0, 0xF8, 0x00, 0x3C, 0x1E, 0x00, 0x0F, 0x87, 0xC0, 0x01,
  0xF0, 0xF8, 0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF0, 0x78,
  0x00, 0x3E, 0x1F, 0x00, 0x07, 0xC3, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1E,
  0x0F, 0x00, 0x03, 0xC1, 0xE0, 0x00, 0xF8, 0x7C, 0x00, 0x1F, 0x0F, 0x80,
  0x03, 0xE1, 0xF0, 0x00, 0x78, 0x3C, 0x00, 0x1F, 0x0F, 0x80, 0x03, 0xE1,
  0xF0, 0x00, 0x7C, 0x3E, 0x00, 0x0F, 0x07, 0xC0, 0x03, 0xE0, 0xF8, 0x00,
  0x7C, 0x0F, 0x80, 0x1F, 0x01, 0xF8, 0x0F, 0xE0, 0x3F, 0xFF, 0xF8, 0x03,
  0xFF, 0xFE, 0x00, 0x3F, 0xFF, 0x80, 0x01, 0xFF, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0xFC, 0x00, 0x0F, 0xBE, 0x00, 0x0F, 0x9F, 0x00, 0x07, 0xC7, 0x80,
  0x07, 0xC3, 0xC0, 0x03, 0xE1, 0xE0, 0x03, 0xE0, 0xF0, 0x01, 0xF0, 0x78,
  0x01, 0xF0, 0x3C, 0x00, 0xF8, 0x1F, 0x00, 0xF8, 0x0F, 0x80, 0x7C, 0x07,
  0xC0, 0x7C, 0x03, 0xE0, 0x3E, 0x00, 0xF0, 0x3E, 0x00, 0x78, 0x1E, 0x00,
  0x3C, 0x1F, 0x00, 0x1E, 0x0F, 0x00, 0x0F, 0x0F, 0x80, 0x07, 0x87, 0x80,
  0x03, 0xC7, 0xC0, 0x01, 0xF3, 0xC0, 0x00, 0xFB, 0xE0, 0x00, 0x7D, 0xE0,
  0x00, 0x1F, 0xF0, 0x00, 0x0F, 0xF0, 0x00, 0x07, 0xF8, 0x00, 0x03, 0xF8,
  0x00, 0x01, 0xFC, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x7E, 0x00, 0x00, 0xF8,
  0x00, 0x7C, 0x00, 0x7D, 0xE0, 0x03, 0xF0, 0x03, 0xE7, 0x80, 0x0F, 0xC0,
  0x0F, 0x9E, 0x00, 0x7F, 0x00, 0x7C, 0x78, 0x01, 0xFC, 0x01, 0xF1, 0xE0,
  0x0F, 0xF0, 0x07, 0x87, 0x80, 0x3F, 0xC0, 0x3E, 0x1E, 0x01, 0xEF, 0x00,
  0xF8, 0x78, 0x07, 0xBC, 0x07, 0xC1, 0xE0, 0x3E, 0xF0, 0x1F, 0x07, 0x80,
  0xF3, 0xC0, 0xF8, 0x1E, 0x07, 0xCF, 0x03, 0xE0, 0x78, 0x1E, 0x3C, 0x0F,
  0x01, 0xE0, 0x78, 0xF0, 0x7C, 0x07, 0x83, 0xC3, 0xC1, 0xE0, 0x1E, 0x0F,
  0x0F, 0x0F, 0x80, 0x78, 0x78, 0x3C, 0x3C, 0x01, 0xE1, 0xE0, 0xF1, 0xF0,
  0x07, 0xCF, 0x03, 0xC7, 0xC0, 0x1F, 0x3C, 0x0F, 0x1E, 0x00, 0x7D, 0xF0,
  0x3C, 0xF8, 0x01, 0xE7, 0x80, 0x73, 0xC0, 0x07, 0x9E, 0x01, 0xCF, 0x00,
  0x1E, 0xF0, 0x07, 0x78, 0x00, 0x7B, 0xC0, 0x1D, 0xE0, 0x00, 0xFE, 0x00,
  0x7F, 0x00, 0x03, 0xF8, 0x01, 0xFC, 0x00, 0x0F, 0xC0, 0x07, 0xF0, 0x00,
  0x3F, 0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x7E, 0x00, 0x03, 0xE0, 0x01,
  0xF0, 0x00, 0x00, 0x01, 0xF0, 0x00, 0xFC, 0x03, 0xC0, 0x07, 0xC0, 0x0F,
  0x80, 0x3F, 0x00, 0x3E, 0x00, 0xF8, 0x00, 0x78, 0x07, 0xC0, 0x01, 0xF0,
  0x3E, 0x00, 0x07, 0xC1, 0xF0, 0x00, 0x0F, 0x07, 0xC0, 0x00, 0x3E, 0x3E,
  0x00, 0x00, 0x79, 0xF0, 0x00, 0x01, 0xEF, 0x80, 0x00, 0x07, 0xFC, 0x00,
  0x00, 0x0F, 0xF0, 0x00, 0x00, 0x3F, 0x80, 0x00, 0x00, 0xFC, 0x00, 0x00,
  0x07, 0xF0, 0x00, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xFF, 0x80, 0x00, 0x07,
  0xDE, 0x00, 0x00, 0x3E, 0x7C, 0x00, 0x00, 0xF9, 0xF0, 0x00, 0x07, 0xC3,
  0xC0, 0x00, 0x3E, 0x0F, 0x80, 0x01, 0xF0, 0x3E, 0x00, 0x07, 0xC0, 0x7C,
  0x00, 0x3E, 0x01, 0xF0, 0x01, 0xF0, 0x07, 0xC0, 0x0F, 0xC0, 0x0F, 0x80,
  0x3E, 0x00, 0x3E, 0x01, 0xF0, 0x00, 0xF8, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0xF8, 0x00, 0x7E, 0xF0, 0x00, 0xF9, 0xE0, 0x03, 0xE3, 0xE0, 0x0F, 0x87,
  0xC0, 0x1F, 0x07, 0x80, 0x7C, 0x0F, 0x01, 0xF0, 0x1F, 0x03, 0xE0, 0x3E,
  0x0F, 0x80, 0x3C, 0x3E, 0x00, 0x78, 0x7C, 0x00, 0xF9, 0xF0, 0x01, 0xF7,
  0xC0, 0x01, 0xEF, 0x80, 0x03, 0xFE, 0x00, 0x07, 0xF8, 0x00, 0x0F, 0xF0,
  0x00, 0x0F, 0xC0, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x78, 0x00,
  0x00, 0xF0, 0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x00,
  0x1E, 0x00, 0x00, 0x3C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xF0, 0x00, 0x03,
  0xE0, 0x00, 0x07, 0x80, 0x00, 0x00, 0x01, 0xFF, 0xFF, 0xC0, 0x7F, 0xFF,
  0xF0, 0x1F, 0xFF, 0xFC, 0x0F, 0xFF, 0xFE, 0x00, 0x00, 0x1F, 0x80, 0x00,
  0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00,
  0x00, 0x7E, 0x00, 0x00, 0x3F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x03, 0xF0, 0x00, 0x01, 0xF8, 0x00, 0x00, 0xFC, 0x00, 0x00, 0x3E,
  0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0xC0, 0x00, 0x07, 0xE0, 0x00, 0x01,
  0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x3F, 0x00, 0x00,
  0x1F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0xFF,
  0xE0, 0x7F, 0xFF, 0xF8, 0x1F, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0x00, 0x00,
  0xFF, 0xC0, 0x3F, 0xE0, 0x0F, 0xF8, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00,
  0x0F, 0x00, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x07,
  0x80, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x0F, 0x00, 0x03, 0xC0,
  0x00, 0xF0, 0x00, 0x3C, 0x00, 0x1F, 0x00, 0x07, 0x80, 0x01, 0xE0, 0x00,
  0x78, 0x00, 0x3E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C,
  0x00, 0x1F, 0x00, 0x07, 0xFC, 0x01, 0xFF, 0x00, 0x7F, 0xC0, 0x3F, 0xF0,
  0x00, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x07, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1E, 0x0F, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x0F, 0x83, 0xC1,
  0xE0, 0xF0, 0x78, 0x3C, 0x1E, 0x07, 0x83, 0xC1, 0xE0, 0xF0, 0x78, 0x3C,
  0x1F, 0x00, 0xFF, 0x80, 0x7F, 0xC0, 0x7F, 0xC0, 0x01, 0xE0, 0x00, 0xF0,
  0x00, 0x78, 0x00, 0x7C, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F,
  0x80, 0x07, 0xC0, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0xF8, 0x00,
  0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07, 0x80,
  0x03, 0xC0, 0x01, 0xE0, 0x01, 0xF0, 0x00, 0xF8, 0x00, 0x78, 0x00, 0x3C,
  0x00, 0x1E, 0x00, 0x1F, 0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01,
  0xE0, 0x1F, 0xF0, 0x1F, 0xF0, 0x0F, 0xF8, 0x07, 0xFC, 0x00, 0x00, 0x18,
  0x00, 0x00, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x1F, 0x80, 0x00, 0x7E, 0x00,
  0x03, 0xFC, 0x00, 0x0E, 0xF0, 0x00, 0x79, 0xE0, 0x01, 0xC7, 0x80, 0x0F,
  0x0F, 0x00, 0x38, 0x3C, 0x01, 0xE0, 0x70, 0x07, 0x01, 0xE0, 0x3C, 0x07,
  0x81, 0xE0, 0x0F, 0x07, 0x80, 0x3C, 0x3C, 0x00, 0x78, 0xF0, 0x01, 0xE7,
  0x80, 0x03, 0xFE, 0x00, 0x0F, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFC,
  0xF8, 0x7C, 0x7C, 0x3E, 0x1E, 0x0F, 0x07, 0x00, 0xFC, 0x1E, 0x07, 0xFE,
  0x78, 0x1F, 0xFE, 0xF0, 0x7F, 0xFD, 0xE1, 0xFC, 0x3F, 0xC3, 0xE0, 0x3F,
  0x0F, 0xC0, 0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1,
  0xF0, 0x03, 0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E,
  0x00, 0x7C, 0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0,
  0x3F, 0x87, 0xE0, 0xFE, 0x07, 0xF7, 0xFC, 0x0F, 0xFF, 0x78, 0x0F, 0xFC,
  0xF0, 0x0F, 0xE1, 0xE0, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0x80,
  0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0, 0x00,
  0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x8F, 0xC0, 0x1E, 0x3F, 0xC0,
  0x3D, 0xFF, 0xC0, 0xFF, 0xFF, 0xC1, 0xFE, 0x0F, 0x83, 0xF8, 0x1F, 0x07,
  0xE0, 0x1E, 0x0F, 0x80, 0x3E, 0x3F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8,
  0x01, 0xE1, 0xE0, 0x03, 0xC3, 0xC0, 0x0F, 0x8F, 0x80, 0x1F, 0x1F, 0x00,
  0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF1, 0xF8, 0x07, 0xE3, 0xF0, 0x0F,
  0x87, 0xF0, 0x3F, 0x0F, 0xF9, 0xFC, 0x1E, 0xFF, 0xF0, 0x79, 0xFF, 0xC0,
  0xF0, 0xFE, 0x00, 0x00, 0x7F, 0x80, 0x3F, 0xFC, 0x1F, 0xFF, 0x07, 0xFF,
  0xE1, 0xFC, 0x04, 0x3E, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x7C, 0x00,
  0x0F, 0x80, 0x01, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xF0, 0x00,
  0x3E, 0x01, 0x07, 0xFB, 0xE0, 0x7F, 0xFC, 0x07, 0xFF, 0x80, 0x7F, 0xE0,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0x78, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0x3E, 0x00, 0x7E, 0x1E, 0x00, 0xFF, 0xCF, 0x00, 0xFF,
  0xF7, 0x80, 0xFF, 0xFB, 0xC0, 0xFC, 0x0F, 0xE0, 0x7C, 0x07, 0xE0, 0x7E,
  0x01, 0xF0, 0x3E, 0x00, 0xF8, 0x3E, 0x00, 0x7C, 0x1F, 0x00, 0x3E, 0x0F,
  0x80, 0x1E, 0x07, 0x80, 0x0F, 0x07, 0xC0, 0x0F, 0x83, 0xE0, 0x07, 0xC1,
  0xF0, 0x03, 0xE0, 0xF8, 0x03, 0xE0, 0x7C, 0x01, 0xF0, 0x3E, 0x01, 0xF8,
  0x1F, 0x01, 0xFC, 0x0F, 0xC1, 0xFC, 0x03, 0xFB, 0xFE, 0x01, 0xFF, 0xEF,
  0x00, 0x7F, 0xE7, 0x80, 0x1F, 0xC3, 0xC0, 0x00, 0x00, 0x7F, 0x00, 0x3F,
  0xF8, 0x1F, 0xFF, 0x87, 0xFF, 0xF1, 0xF8, 0x1E, 0x3E, 0x03, 0xCF, 0x80,
  0x79, 0xF0, 0x0F, 0x7C, 0x03, 0xEF, 0x81, 0xF9, 0xFF, 0xFE, 0x7F, 0xFF,
  0x8F, 0xFF, 0xE1, 0xFF, 0xC0, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00,
  0x1F, 0x00, 0x03, 0xE0, 0x00, 0x3E, 0x00, 0x87, 0xF1, 0xF0, 0x7F, 0xFE,
  0x07, 0xFF, 0xC0, 0x7F, 0xE0, 0x00, 0x00, 0x1C, 0x00, 0x00, 0x7F, 0xC0,
  0x00, 0x7F, 0xE0, 0x00, 0x7F, 0xE0, 0x00, 0x3E, 0x10, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0,
  0x00, 0x07, 0xFF, 0x00, 0x1F, 0xFF, 0x00, 0x1F, 0xFF, 0x80, 0x0F, 0xFF,
  0xC0, 0x00, 0x7C, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x1E, 0x00, 0x00, 0x1F,
  0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03,
  0xE0, 0x00, 0x01, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00, 0x00,
  0x3C, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00,
  0x07, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xE0, 0x00, 0x01, 0xF0, 0x00,
  0x00, 0xF8, 0x00, 0x00, 0x78, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x3E, 0x00,
  0x00, 0x1F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x0F, 0x80, 0x00, 0x8F, 0xC0,
  0x00, 0x7F, 0xC0, 0x00, 0x3F, 0xC0, 0x00, 0x1F, 0xC0, 0x00, 0x03, 0x00,
  0x00, 0x00, 0x00, 0x7E, 0x0F, 0x01, 0xFF, 0x9E, 0x03, 0xFF, 0xDE, 0x07,
  0xFF, 0xDE, 0x0F, 0xE0, 0xFE, 0x0F, 0x80, 0xFC, 0x1F, 0x80, 0x7C, 0x1F,
  0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x7C, 0x3E, 0x00, 0x78, 0x3C,
  0x00, 0x78, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C, 0x00, 0xF8, 0x7C,
  0x01, 0xF0, 0x7C, 0x01, 0xF0, 0x7C, 0x03, 0xF0, 0x7C, 0x07, 0xF0, 0x7E,
  0x0F, 0xE0, 0x3F, 0xBD, 0xE0, 0x3F, 0xF9, 0xE0, 0x1F, 0xF3, 0xE0, 0x0F,
  0xE3, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x03, 0xC0, 0x00, 0x07, 0xC0, 0x00,
  0x07, 0xC0, 0x00, 0x0F, 0x80, 0x80, 0x1F, 0x80, 0xF0, 0x7F, 0x00, 0xFF,
  0xFE, 0x00, 0xFF, 0xFC, 0x00, 0x7F, 0xF8, 0x00, 0x01, 0x00, 0x00, 0x01,
  0xF0, 0x00, 0x07, 0x80, 0x00, 0x1E, 0x00, 0x00, 0xF8, 0x00, 0x03, 0xE0,
  0x00, 0x0F, 0x80, 0x00, 0x3C, 0x00, 0x01, 0xF0, 0x00, 0x07, 0xC0, 0x00,
  0x1F, 0x1F, 0x80, 0x78, 0xFF, 0x81, 0xEF, 0xFF, 0x0F, 0xFF, 0xFC, 0x3F,
  0xC1, 0xF0, 0xFE, 0x03, 0xC3, 0xF0, 0x0F, 0x0F, 0x80, 0x3C, 0x7E, 0x01,
  0xF1, 0xF0, 0x07, 0xC7, 0xC0, 0x1F, 0x1E, 0x00, 0x7C, 0x78, 0x01, 0xE3,
  0xE0, 0x0F, 0x8F, 0x80, 0x3E, 0x3E, 0x00, 0xF8, 0xF0, 0x03, 0xE7, 0xC0,
  0x0F, 0x1F, 0x00, 0x7C, 0x7C, 0x01, 0xF1, 0xE0, 0x07, 0xC7, 0x80, 0x1E,
  0x3E, 0x00, 0x78, 0xF8, 0x03, 0xE0, 0x00, 0xC0, 0x1E, 0x03, 0xF0, 0x3E,
  0x03, 0xE0, 0x08, 0x00, 0x00, 0x00, 0x00, 0x00, 0x7C, 0x07, 0xC0, 0x78,
  0x0F, 0x80, 0xF8, 0x0F, 0x80, 0xF8, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0,
  0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0,
  0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80, 0xF8, 0x00, 0x00, 0x01, 0x80, 0x00,
  0x78, 0x00, 0x1F, 0x80, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x03, 0x00, 0x00,
  0x00, 0x00, 0x00, 0x00, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07,
  0x80, 0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1E,
  0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F, 0x00, 0x03, 0xC0, 0x00, 0x78,
  0x00, 0x1F, 0x00, 0x03, 0xE0, 0x00, 0x7C, 0x00, 0x0F, 0x00, 0x03, 0xE0,
  0x00, 0x7C, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x80,
  0x01, 0xF0, 0x00, 0x3E, 0x00, 0x07, 0x80, 0x00, 0xF0, 0x00, 0x3E, 0x00,
  0x07, 0xC0, 0x01, 0xF0, 0x04, 0x7E, 0x00, 0xFF, 0x80, 0x1F, 0xF0, 0x03,
  0xFC, 0x00, 0x08, 0x00, 0x00, 0x01, 0xF0, 0x00, 0x03, 0xC0, 0x00, 0x07,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3E, 0x00, 0x00, 0x7C, 0x00, 0x00, 0xF0,
  0x00, 0x03, 0xE0, 0x00, 0x07, 0xC0, 0x00, 0x0F, 0x80, 0x7C, 0x1E, 0x01,
  0xF0, 0x3C, 0x07, 0xC0, 0xF8, 0x1F, 0x01, 0xF0, 0x7C, 0x03, 0xE1, 0xF0,
  0x07, 0x87, 0xC0, 0x0F, 0x1F, 0x00, 0x3E, 0x7C, 0x00, 0x7D, 0xF0, 0x00,
  0xF7, 0xC0, 0x01, 0xFF, 0x80, 0x07, 0xFF, 0x80, 0x0F, 0xFF, 0x00, 0x1F,
  0x9F, 0x00, 0x3E, 0x3E, 0x00, 0x78, 0x3E, 0x01, 0xF0, 0x7C, 0x03, 0xE0,
  0x7C, 0x07, 0xC0, 0xF8, 0x0F, 0x00, 0xF8, 0x1E, 0x01, 0xF0, 0x7C, 0x03,
  0xF0, 0xF8, 0x03, 0xE0, 0x01, 0xF0, 0x1E, 0x01, 0xE0, 0x3E, 0x03, 0xE0,
  0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07, 0xC0, 0x78, 0x0F, 0x80,
  0xF8, 0x0F, 0x80, 0xF0, 0x0F, 0x01, 0xF0, 0x1F, 0x01, 0xF0, 0x1E, 0x01,
  0xE0, 0x3E, 0x03, 0xE0, 0x3E, 0x03, 0xC0, 0x7C, 0x07, 0xC0, 0x7C, 0x07,
  0x80, 0x78, 0x0F, 0x80, 0xF8, 0x00, 0x07, 0x87, 0xE0, 0x1F, 0x80, 0xF3,
  0xFE, 0x0F, 0xF8, 0x1E, 0xFF, 0xE3, 0xFF, 0x87, 0xFF, 0xFC, 0xFF, 0xF0,
  0xF7, 0x07, 0xBC, 0x3E, 0x1F, 0xC0, 0xFE, 0x03, 0xC3, 0xF0, 0x1F, 0x80,
  0x78, 0x7C, 0x03, 0xF0, 0x0F, 0x1F, 0x80, 0x7C, 0x01, 0xE3, 0xE0, 0x0F,
  0x80, 0x7C, 0x7C, 0x01, 0xE0, 0x0F, 0x8F, 0x80, 0x7C, 0x01, 0xF1, 0xE0,
  0x0F, 0x80, 0x3C, 0x7C, 0x01, 0xF0, 0x07, 0x8F, 0x80, 0x3C, 0x01, 0xF1,
  0xF0, 0x07, 0x80, 0x3E, 0x3C, 0x01, 0xF0, 0x07, 0xCF, 0x80, 0x3E, 0x00,
  0xF1, 0xF0, 0x07, 0xC0, 0x1E, 0x3E, 0x00, 0xF0, 0x07, 0xC7, 0x80, 0x3E,
  0x00, 0xF8, 0xF0, 0x07, 0xC0, 0x1F, 0x3E, 0x00, 0xF8, 0x03, 0xC7, 0xC0,
  0x1E, 0x00, 0xF8, 0x07, 0x87, 0xF0, 0x0F, 0x3F, 0xF0, 0x1E, 0xFF, 0xF0,
  0x7F, 0xFF, 0xE0, 0xF7, 0x07, 0xC1, 0xFC, 0x07, 0xC3, 0xF0, 0x0F, 0x0F,
  0xC0, 0x1E, 0x1F, 0x80, 0x7C, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0, 0xF8,
  0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E, 0x1F, 0x00,
  0x7C, 0x3C, 0x00, 0xF8, 0xF8, 0x01, 0xE1, 0xF0, 0x07, 0xC3, 0xE0, 0x0F,
  0x87, 0xC0, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0xF8, 0x7C, 0x01, 0xF0,
  0x00, 0x7F, 0x00, 0x1F, 0xFE, 0x01, 0xFF, 0xF8, 0x1F, 0xFF, 0xE1, 0xF8,
  0x1F, 0x0F, 0x80, 0xF8, 0xF8, 0x03, 0xE7, 0xC0, 0x1F, 0x7C, 0x00, 0xFB,
  0xE0, 0x07, 0xDE, 0x00, 0x3F, 0xF0, 0x01, 0xFF, 0x80, 0x0F, 0xFC, 0x00,
  0x7F, 0xE0, 0x07, 0xDF, 0x00, 0x3E, 0xF8, 0x01, 0xF7, 0xC0, 0x1F, 0x3E,
  0x01, 0xF8, 0xF8, 0x1F, 0x87, 0xFB, 0xF8, 0x1F, 0xFF, 0x80, 0x7F, 0xF8,
  0x00, 0xFF, 0x00, 0x01, 0xE1, 0xF8, 0x00, 0xF3, 0xFE, 0x00, 0x7B, 0xFF,
  0x80, 0x7B, 0xFF, 0xE0, 0x3F, 0xC1, 0xF0, 0x1F, 0xC0, 0xF8, 0x0F, 0xC0,
  0x3C, 0x07, 0xC0, 0x1F, 0x07, 0xE0, 0x0F, 0x83, 0xE0, 0x07, 0xC1, 0xF0,
  0x03, 0xC0, 0xF0, 0x01, 0xE0, 0x78, 0x01, 0xF0, 0x7C, 0x00, 0xF8, 0x3E,
  0x00, 0x7C, 0x1F, 0x00, 0x7C, 0x0F, 0x80, 0x3E, 0x07, 0xC0, 0x3F, 0x07,
  0xE0, 0x1F, 0x03, 0xF8, 0x1F, 0x81, 0xFF, 0x3F, 0x80, 0xF7, 0xFF, 0x80,
  0xF9, 0xFF, 0x80, 0x7C, 0x7F, 0x00, 0x3E, 0x00, 0x00, 0x1E, 0x00, 0x00,
  0x0F, 0x00, 0x00, 0x0F, 0x80, 0x00, 0x07, 0xC0, 0x00, 0x03, 0xE0, 0x00,
  0x01, 0xE0, 0x00, 0x00, 0xF0, 0x00, 0x00, 0xF8, 0x00, 0x00, 0x7C, 0x00,
  0x00, 0x3C, 0x00, 0x00, 0x00, 0x00, 0xFC, 0x1E, 0x07, 0xFE, 0x38, 0x1F,
  0xFE, 0xF0, 0x7F, 0xFD, 0xE1, 0xF8, 0x1F, 0xC3, 0xE0, 0x3F, 0x0F, 0xC0,
  0x3E, 0x1F, 0x00, 0x7C, 0x7C, 0x00, 0xF8, 0xF8, 0x01, 0xF1, 0xF0, 0x03,
  0xC3, 0xC0, 0x07, 0x8F, 0x80, 0x1F, 0x1F, 0x00, 0x3E, 0x3E, 0x00, 0x7C,
  0x7C, 0x01, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x0F, 0xC3, 0xE0, 0x3F, 0x87,
  0xE0, 0xFE, 0x07, 0xF7, 0xBC, 0x0F, 0xFF, 0x78, 0x0F, 0xFD, 0xF0, 0x0F,
  0xE3, 0xE0, 0x00, 0x07, 0x80, 0x00, 0x0F, 0x00, 0x00, 0x3E, 0x00, 0x00,
  0x7C, 0x00, 0x00, 0xF8, 0x00, 0x01, 0xE0, 0x00, 0x03, 0xC0, 0x00, 0x0F,
  0x80, 0x00, 0x1F, 0x00, 0x00, 0x3C, 0x00, 0x00, 0x78, 0x00, 0x07, 0x87,
  0xC1, 0xE7, 0xF0, 0x7B, 0xFC, 0x3F, 0xFE, 0x0F, 0x78, 0x03, 0xF8, 0x00,
  0xFC, 0x00, 0x3E, 0x00, 0x1F, 0x80, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xE0, 0x00, 0xF8, 0x00, 0x3C, 0x00,
  0x1F, 0x00, 0x07, 0xC0, 0x01, 0xF0, 0x00, 0x7C, 0x00, 0x1E, 0x00, 0x0F,
  0x80, 0x03, 0xE0, 0x00, 0x01, 0xFF, 0x00, 0x7F, 0xFC, 0x3F, 0xFF, 0x07,
  0xFF, 0xE1, 0xF8, 0x08, 0x3E, 0x00, 0x07, 0xC0, 0x00, 0xF8, 0x00, 0x1F,
  0x80, 0x01, 0xF8, 0x00, 0x3F, 0xC0, 0x03, 0xFC, 0x00, 0x1F, 0xE0, 0x01,
  0xFE, 0x00, 0x0F, 0xC0, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x01, 0xF0, 0x00,
  0x3C, 0x60, 0x0F, 0x8F, 0x87, 0xF1, 0xFF, 0xFC, 0x3F, 0xFF, 0x03, 0xFF,
  0x80, 0x01, 0xC0, 0x07, 0x80, 0x0E, 0x00, 0x3C, 0x00, 0x78, 0x03, 0xFF,
  0xDF, 0xFF, 0xFF, 0xFE, 0xFF, 0xFC, 0x3E, 0x00, 0x7C, 0x00, 0xF8, 0x01,
  0xE0, 0x07, 0xC0, 0x0F, 0x80, 0x1F, 0x00, 0x3E, 0x00, 0x78, 0x01, 0xF0,
  0x03, 0xE0, 0x07, 0xC0, 0x0F, 0x00, 0x1E, 0x00, 0x3C, 0x00, 0x78, 0x00,
  0xF8, 0xC1, 0xFF, 0x83, 0xFF, 0x03, 0xFE, 0x00, 0x0F, 0x80, 0x3E, 0x1E,
  0x00, 0x78, 0x7C, 0x00, 0xF0, 0xF8, 0x03, 0xE1, 0xF0, 0x07, 0xC3, 0xC0,
  0x0F, 0x87, 0x80, 0x1E, 0x1F, 0x00, 0x3C, 0x3E, 0x00, 0xF8, 0x7C, 0x01,
  0xF0, 0xF0, 0x03, 0xE3, 0xE0, 0x07, 0x87, 0xC0, 0x1F, 0x0F, 0x80, 0x3E,
  0x1F, 0x00, 0x7C, 0x3C, 0x01, 0xF0, 0x78, 0x03, 0xE1, 0xF0, 0x0F, 0xC3,
  0xE0, 0x3F, 0x87, 0xE0, 0xFF, 0x07, 0xE7, 0xFC, 0x0F, 0xFF, 0x78, 0x0F,
  0xFC, 0xF0, 0x0F, 0xE1, 0xE0, 0xF8, 0x00, 0xFF, 0xC0, 0x07, 0xFE, 0x00,
  0x7C, 0xF0, 0x03, 0xE7, 0x80, 0x3E, 0x3C, 0x01, 0xF1, 0xE0, 0x1F, 0x0F,
  0x00, 0xF0, 0x7C, 0x0F, 0x83, 0xE0, 0x78, 0x1F, 0x07, 0xC0, 0xF8, 0x7C,
  0x03, 0xC3, 0xE0, 0x1E, 0x3E, 0x00, 0xF1, 0xF0, 0x07, 0x9F, 0x00, 0x3C,
  0xF8, 0x01, 0xE7, 0x80, 0x0F, 0x7C, 0x00, 0x7B, 0xC0, 0x01, 0xFC, 0x00,
  0x0F, 0xE0, 0x00, 0x7E, 0x00, 0x03, 0xF0, 0x00, 0xF0, 0x07, 0xC0, 0x1F,
  0xF0, 0x0F, 0xC0, 0x3E, 0xF0, 0x0F, 0xC0, 0x3C, 0xF0, 0x1F, 0xC0, 0x7C,
  0xF0, 0x1F, 0xC0, 0x7C, 0xF0, 0x3D, 0xC0, 0xF8, 0xF0, 0x3D, 0xC0, 0xF8,
  0xF0, 0x79, 0xC1, 0xF0, 0xF0, 0x79, 0xC1, 0xF0, 0xF0, 0x71, 0xC1, 0xE0,
  0xF0, 0xF1, 0xC3, 0xE0, 0xF0, 0xF1, 0xC3, 0xC0, 0xF1, 0xE1, 0xC7, 0xC0,
  0xF1, 0xE1, 0xC7, 0x80, 0xF3, 0xC1, 0xCF, 0x80, 0xF3, 0xC1, 0xCF, 0x00,
  0xF7, 0x81, 0xCF, 0x00, 0xF7, 0x81, 0xDE, 0x00, 0xF7, 0x01, 0xDE, 0x00,
  0xFF, 0x01, 0xDE, 0x00, 0xFE, 0x01, 0xFC, 0x00, 0xFE, 0x01, 0xFC, 0x00,
  0x7E, 0x01, 0xF8, 0x00, 0x7C, 0x01, 0xF8, 0x00, 0x07, 0xC0, 0x0F, 0x81,
  0xF0, 0x0F, 0x80, 0xF8, 0x0F, 0xC0, 0x3E, 0x0F, 0xC0, 0x1F, 0x07, 0xC0,
  0x07, 0x87, 0xC0, 0x03, 0xE7, 0xC0, 0x00, 0xF7, 0xC0, 0x00, 0x7F, 0xE0,
  0x00, 0x3F, 0xE0, 0x00, 0x0F, 0xE0, 0x00, 0x07, 0xE0, 0x00, 0x03, 0xF0,
  0x00, 0x03, 0xF8, 0x00, 0x03, 0xFE, 0x00, 0x03, 0xFF, 0x00, 0x03, 0xE7,
  0xC0, 0x01, 0xF3, 0xE0, 0x01, 0xF0, 0xF0, 0x01, 0xF0, 0x7C, 0x01, 0xF0,
  0x1E, 0x01, 0xF8, 0x0F, 0x81, 0xF8, 0x07, 0xC1, 0xF8, 0x01, 0xF0, 0x03,
  0xE0, 0x03, 0xE0, 0x7C, 0x00, 0x7C, 0x0F, 0x80, 0x1F, 0x00, 0xF0, 0x03,
  0xE0, 0x1E, 0x00, 0xF8, 0x03, 0xC0, 0x1F, 0x00, 0x7C, 0x07, 0xC0, 0x0F,
  0x80, 0xF8, 0x01, 0xF0, 0x3E, 0x00, 0x1E, 0x07, 0x80, 0x03, 0xC1, 0xF0,
  0x00, 0x78, 0x3C, 0x00, 0x0F, 0x0F, 0x80, 0x01, 0xE1, 0xE0, 0x00, 0x3C,
  0x7C, 0x00, 0x07, 0x8F, 0x00, 0x00, 0x7B, 0xE0, 0x00, 0x0F, 0x78, 0x00,
  0x01, 0xFF, 0x00, 0x00, 0x3F, 0xC0, 0x00, 0x07, 0xF0, 0x00, 0x00, 0xFE,
  0x00, 0x00, 0x1F, 0x80, 0x00, 0x01, 0xF0, 0x00, 0x00, 0x3C, 0x00, 0x00,
  0x0F, 0x80, 0x00, 0x03, 0xE0, 0x00, 0x00, 0x7C, 0x00, 0x00, 0x1F, 0x00,
  0x00, 0x07, 0xE0, 0x00, 0x21, 0xF8, 0x00, 0x07, 0xFE, 0x00, 0x00, 0xFF,
  0x80, 0x00, 0x1F, 0xE0, 0x00, 0x00, 0xE0, 0x00, 0x00, 0x00, 0x03, 0xFF,
  0xF8, 0x1F, 0xFF, 0xC1, 0xFF, 0xFC, 0x0F, 0xFF, 0xE0, 0x00, 0x3F, 0x00,
  0x03, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0, 0x00, 0x1F, 0x00, 0x01, 0xF0,
  0x00, 0x1F, 0x80, 0x00, 0xF8, 0x00, 0x0F, 0x80, 0x00, 0xF8, 0x00, 0x0F,
  0x80, 0x00, 0xFC, 0x00, 0x07, 0xC0, 0x00, 0x7C, 0x00, 0x07, 0xC0, 0x00,
  0x7C, 0x00, 0x07, 0xFF, 0xF8, 0x3F, 0xFF, 0xC1, 0xFF, 0xFE, 0x1F, 0xFF,
  0xE0, 0x00, 0x0F, 0xC0, 0x07, 0xE0, 0x03, 0xF8, 0x01, 0xF8, 0x00, 0x7C,
  0x00, 0x1E, 0x00, 0x0F, 0x80, 0x03, 0xC0, 0x00, 0xF0, 0x00, 0x3C, 0x00,
  0x0F, 0x00, 0x07, 0xC0, 0x01, 0xE0, 0x00, 0x78, 0x00, 0x3E, 0x00, 0x1F,
  0x00, 0x3F, 0xC0, 0x1F, 0xE0, 0x07, 0xC0, 0x01, 0xF8, 0x00, 0xBF, 0x00,
  0x03, 0xE0, 0x00, 0x78, 0x00, 0x1E, 0x00, 0x07, 0x80, 0x03, 0xE0, 0x00,
  0xF0, 0x00, 0x3C, 0x00, 0x0F, 0x00, 0x03, 0xC0, 0x01, 0xF0, 0x00, 0x78,
  0x00, 0x1E, 0x00, 0x07, 0xC0, 0x01, 0xFC, 0x00, 0x3F, 0x00, 0x0F, 0xC0,
  0x00, 0xF0, 0x00, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF, 0xFF,
  0xF0, 0x01, 0xF0, 0x00, 0xFE, 0x00, 0x7F, 0x00, 0x1F, 0xC0, 0x03, 0xE0,
  0x01, 0xF0, 0x00, 0xF0, 0x00, 0x78, 0x00, 0x3C, 0x00, 0x1E, 0x00, 0x1F,
  0x00, 0x0F, 0x00, 0x07, 0x80, 0x03, 0xC0, 0x01, 0xE0, 0x00, 0xF0, 0x00,
  0x7C, 0x00, 0x1F, 0xC0, 0x07, 0xE0, 0x07, 0xF0, 0x07, 0xF8, 0x07, 0xC0,
  0x07, 0xC0, 0x03, 0xC0, 0x03, 0xE0, 0x01, 0xE0, 0x00, 0xF0, 0x00, 0x78,
  0x00, 0x3C, 0x00, 0x3E, 0x00, 0x1E, 0x00, 0x0F, 0x00, 0x0F, 0x80, 0x07,
  0xC0, 0x3F, 0xC0, 0x1F, 0xC0, 0x0F, 0xC0, 0x07, 0x80, 0x00, 0x0C, 0x00,
  0x0B, 0xFE, 0x00, 0xFF, 0xFE, 0x0F, 0xFF, 0xFF, 0xFE, 0x0F, 0xFF, 0x40,
  0x1F, 0xF2, 0x00, 0x04, 0x00,
};

const GFXglyph NotoSans_MediumItalic44pt7bGlyphs[] PROGMEM = {
  { 0, 1, 1, 11, 0, -1 },
  { 1, 12, 32, 12, 1, -31 },
  { 49, 14, 11, 18, 5, -31 },
  { 69, 28, 31, 28, 1, -31 },
  { 178, 22, 36, 24, 1, -33 },
  { 277, 31, 32, 36, 3, -32 },
  { 401, 28, 32, 30, 1, -32 },
  { 513, 6, 11, 10, 5, -31 },
  { 522, 15, 38, 13, 2, -31 },
  { 594, 15, 39, 13, -3, -32 },
  { 668, 21, 21, 24, 4, -34 },
  { 724, 21, 21, 25, 3, -26 },
  { 780, 9, 11, 12, -2, -5 },
  { 793, 12, 4, 14, 1, -14 },
  { 799, 6, 7, 12, 1, -6 },
  { 805, 22, 32, 17, -2, -32 },
  { 893, 22, 32, 24, 2, -32 },
  { 981, 14, 31, 24, 6, -31 },
  { 1036, 23, 32, 24, 0, -32 },
  { 1128, 22, 32, 24, 1, -32 },
  { 1216, 23, 31, 24, 0, -31 },
  { 1306, 23, 31, 24, 1, -31 },
  { 1396, 21, 32, 24, 3, -32 },
  { 1480, 22, 31, 24, 3, -31 },
  { 1566, 22, 32, 24, 2, -32 },
  { 1654, 21, 32, 24, 2, -32 },
  { 1738, 10, 25, 12, 1, -24 },
  { 1770, 13, 30, 12, -2, -24 },
  { 1819, 21, 22, 25, 3, -27 },
  { 1877, 21, 13, 25, 3, -22 },
  { 1912, 21, 22, 25, 3, -27 },
  { 1970, 17, 33, 19, 3, -32 },
  { 2041, 34, 35, 37, 2, -31 },
  { 2190, 26, 31, 26, -3, -31 },
  { 2291, 24, 31, 27, 2, -31 },
  { 2384, 25, 32, 26, 3, -32 },
  { 2484, 26, 31, 29, 2, -31 },
  { 2585, 23, 31, 23, 2, -31 },
  { 2675, 23, 31, 22, 2, -31 },
  { 2765, 26, 32, 30, 3, -32 },
  { 2869, 28, 31, 30, 2, -31 },
  { 2978, 19, 31, 15, -1, -31 },
  { 3052, 20, 40, 13, -7, -31 },
  { 3152, 27, 31, 25, 2, -31 },
  { 3257, 17, 31, 22, 2, -31 },
  { 3323, 36, 31, 38, 2, -31 },
  { 3463, 30, 31, 32, 2, -31 },
  { 3580, 27, 32, 32, 3, -32 },
  { 3688, 24, 31, 26, 2, -31 },
  { 3781, 27, 39, 32, 3, -32 },
  { 3913, 23, 31, 26, 2, -31 },
  { 4003, 22, 32, 23, 1, -32 },
  { 4091, 22, 31, 22, 4, -31 },
  { 4177, 27, 31, 30, 3, -31 },
  { 4282, 25, 31, 25, 4, -31 },
  { 4379, 38, 31, 38, 4, -31 },
  { 4527, 30, 31, 24, -2, -31 },
  { 4644, 23, 31, 23, 4, -31 },
  { 4734, 26, 31, 23, -1, -31 },
  { 4835, 18, 38, 13, -1, -31 },
  { 4921, 9, 32, 17, 5, -32 },
  { 4957, 17, 38, 13, -3, -31 },
  { 5038, 22, 20, 25, 1, -32 },
  { 5093, 18, 3, 17, -4, 4 },
  { 5100, 8, 7, 13, 6, -34 },
  { 5107, 23, 24, 25, 2, -24 },
  { 5176, 23, 33, 26, 1, -33 },
  { 5271, 19, 24, 20, 2, -24 },
  { 5328, 25, 33, 26, 2, -33 },
  { 5432, 19, 24, 23, 2, -24 },
  { 5489, 25, 45, 15, -5, -34 },
  { 5630, 24, 35, 26, 1, -24 },
  { 5735, 22, 33, 26, 1, -33 },
  { 5826, 12, 33, 12, 1, -33 },
  { 5876, 19, 44, 12, -6, -33 },
  { 5981, 23, 33, 23, 1, -33 },
  { 6076, 12, 33, 12, 1, -33 },
  { 6126, 35, 24, 39, 1, -24 },
  { 6231, 23, 24, 26, 1, -24 },
  { 6300, 21, 24, 25, 2, -24 },
  { 6363, 25, 35, 26, -1, -24 },
  { 6473, 23, 35, 26, 2, -24 },
  { 6574, 18, 24, 18, 1, -24 },
  { 6628, 19, 24, 20, 0, -24 },
  { 6685, 15, 29, 16, 2, -29 },
  { 6740, 23, 24, 26, 2, -24 },
  { 6809, 21, 24, 21, 2, -24 },
  { 6872, 32, 24, 33, 3, -24 },
  { 6968, 25, 24, 22, -2, -24 },
  { 7043, 27, 35, 21, -4, -24 },
  { 7162, 21, 24, 20, -1, -24 },
  { 7225, 18, 38, 15, 0, -31 },
  { 7311, 4, 43, 24, 11, -33 },
  { 7333, 17, 38, 15, -2, -31 },
  { 7414, 21, 7, 25, 3, -19 },
};

const GFXfont NotoSans_MediumItalic44pt7b PROGMEM = {
  (uint8_t  *)NotoSans_MediumItalic44pt7bBitmaps,
  (GFXglyph *)NotoSans_MediumItalic44pt7bGlyphs,
  0x20, 0x7E, 60
};

#endif // _NOTOSANS_MEDIUMITALIC44PT7B_H_
